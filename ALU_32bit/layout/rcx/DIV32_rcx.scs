    I_MXI1114_I111_XP_MP0 (VDD I1114_P15_14 I1114_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I1_MP1 (I1114_gn1 b12_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I1_MP0 (VDD p11_0 I1114_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I30_MP1 (I1022_gn30 b10_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I30_MP0 (VDD p9_29 I1022_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I29_MP1 (I1022_gn29 b10_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I29_MP0 (VDD p9_28 I1022_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I126_XP_MP1 (I976_P30_27n I976_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I126_XP_MP0 (VDD I976_P30_29 I976_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I182_XP_MP1 (I976_P31_16n I976_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I182_XP_MP0 (VDD I976_P31_24 I976_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I127_XP_MP1 (I976_P31_28n I976_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I127_XP_MP0 (VDD I976_P31_30 I976_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I28_MP1 (I976_gn28 b9_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I28_MP0 (VDD p8_27 I976_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I30_MP1 (I930_gn30 b8_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I30_MP0 (VDD p7_29 I930_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I29_MP1 (I930_gn29 b8_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I29_MP0 (VDD p7_28 I930_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I0_MP1 (I1344_gn0 b17_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I0_MP0 (VDD aa14 I1344_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I0_MP1 (I1390_gn0 b18_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I0_MP0 (VDD aa13 I1390_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I0_MP1 (I1436_gn0 b19_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I0_MP0 (VDD aa12 I1436_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I1_MP1 (I1436_gn1 b19_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I1_MP0 (VDD p18_0 I1436_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I0_MP1 (I1482_gn0 b20_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I0_MP0 (VDD aa11 I1482_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I1_MP1 (I1482_gn1 b20_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I1_MP0 (VDD p19_0 I1482_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I1_MP1 (I1528_gn1 b21_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I1_MP0 (VDD p20_0 I1528_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I2_MP1 (I1528_gn2 b21_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I2_MP0 (VDD p20_1 I1528_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I29_MP1 (I1574_gn29 b22_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I29_MP0 (VDD p21_28 I1574_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I26_MP1 (I1574_gn26 b22_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I26_MP0 (VDD p21_25 I1574_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I28_MP1 (I1574_gn28 b22_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I28_MP0 (VDD p21_27 I1574_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I180_XP_MP1 (I1114_P29_14n I1114_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I180_XP_MP0 (VDD I1114_P29_22 I1114_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I172_XP_MP1 (I1114_P21_6n I1114_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I172_XP_MP0 (VDD I1114_P21_14 I1114_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I176_XP_MP1 (I1114_P25_10n I1114_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I176_XP_MP0 (VDD I1114_P25_18 I1114_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I115_XP_MP1 (I1114_P19_16n I1114_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I115_XP_MP0 (VDD I1114_P19_18 I1114_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I113_XP_MP1 (I1114_P17_14n I1114_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I113_XP_MP0 (VDD I1114_P17_16 I1114_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I109_XP_MP1 (I1114_P13_10n I1114_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I109_XP_MP0 (VDD I1114_P13_12 I1114_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I107_XP_MP1 (I1114_P11_8n I1114_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I107_XP_MP0 (VDD I1114_P11_10 I1114_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I168_XP_MP1 (I1114_P17_2n I1114_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I168_XP_MP0 (VDD I1114_P17_10 I1114_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I105_XP_MP1 (I1114_P9_6n I1114_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I105_XP_MP0 (VDD I1114_P9_8 I1114_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I101_XP_MP1 (I1114_P5_2n I1114_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I101_XP_MP0 (VDD I1114_P5_4 I1114_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I0_MP1 (I1114_gn0 b12_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I0_MP0 (VDD aa19 I1114_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I0_MP1 (I1160_gn0 b13_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I0_MP0 (VDD aa18 I1160_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I0_MP1 (I1206_gn0 b14_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I0_MP0 (VDD aa17 I1206_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I0_MP1 (I1252_gn0 b15_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I0_MP0 (VDD aa16 I1252_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I31_MP1 (I976_gn31 b9_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I31_MP0 (VDD p8_30 I976_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I30_MP1 (I976_gn30 b9_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I30_MP0 (VDD p8_29 I976_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I0_MP1 (I1298_gn0 b16_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I0_MP0 (VDD aa15 I1298_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I29_MP1 (I976_gn29 b9_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I29_MP0 (VDD p8_28 I976_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I2_MP1 (I1344_gn2 b17_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I2_MP0 (VDD p16_1 I1344_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I1_MP1 (I1344_gn1 b17_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I1_MP0 (VDD p16_0 I1344_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I2_MP1 (I1390_gn2 b18_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I2_MP0 (VDD p17_1 I1390_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I1_MP1 (I1390_gn1 b18_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I1_MP0 (VDD p17_0 I1390_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I2_MP1 (I1436_gn2 b19_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I2_MP0 (VDD p18_1 I1436_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I3_MP1 (I1482_gn3 b20_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I3_MP0 (VDD p19_2 I1482_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I2_MP1 (I1482_gn2 b20_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I2_MP0 (VDD p19_1 I1482_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I3_MP1 (I1528_gn3 b21_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I3_MP0 (VDD p20_2 I1528_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I4_MP1 (I1528_gn4 b21_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I4_MP0 (VDD p20_3 I1528_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I100_XP_MP1 (I1528_P4_1n I1528_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I100_XP_MP0 (VDD I1528_P4_3 I1528_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I102_XP_MP1 (I1528_P6_3n I1528_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I102_XP_MP0 (VDD I1528_P6_5 I1528_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I167_XP_MP1 (I1528_P16_1n I1528_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I167_XP_MP0 (VDD I1528_P16_9 I1528_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I101_XP_MP1 (I1528_P5_2n I1528_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I101_XP_MP0 (VDD I1528_P5_4 I1528_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I182_XP_MP1 (I1114_P31_16n I1114_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I182_XP_MP0 (VDD I1114_P31_24 I1114_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I178_XP_MP1 (I1114_P27_12n I1114_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I178_XP_MP0 (VDD I1114_P27_20 I1114_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I174_XP_MP1 (I1114_P23_8n I1114_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I174_XP_MP0 (VDD I1114_P23_16 I1114_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I170_XP_MP1 (I1114_P19_4n I1114_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I170_XP_MP0 (VDD I1114_P19_12 I1114_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I103_XP_MP1 (I1114_P7_4n I1114_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I103_XP_MP0 (VDD I1114_P7_6 I1114_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I5_MP1 (I1160_gn5 b13_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I5_MP0 (VDD p12_4 I1160_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I4_MP1 (I1160_gn4 b13_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I4_MP0 (VDD p12_3 I1160_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I1_MP1 (I1160_gn1 b13_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I1_MP0 (VDD p12_0 I1160_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I1_MP1 (I1252_gn1 b15_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I1_MP0 (VDD p14_0 I1252_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I2_MP1 (I1298_gn2 b16_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I2_MP0 (VDD p15_1 I1298_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I1_MP1 (I1298_gn1 b16_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I1_MP0 (VDD p15_0 I1298_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I5_MP1 (I1344_gn5 b17_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I5_MP0 (VDD p16_4 I1344_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I4_MP1 (I1344_gn4 b17_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I4_MP0 (VDD p16_3 I1344_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I3_MP1 (I1344_gn3 b17_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I3_MP0 (VDD p16_2 I1344_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I4_MP1 (I1390_gn4 b18_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I4_MP0 (VDD p17_3 I1390_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I3_MP1 (I1390_gn3 b18_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I3_MP0 (VDD p17_2 I1390_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I4_MP1 (I1436_gn4 b19_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I4_MP0 (VDD p18_3 I1436_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I3_MP1 (I1436_gn3 b19_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I3_MP0 (VDD p18_2 I1436_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I4_MP1 (I1482_gn4 b20_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I4_MP0 (VDD p19_3 I1482_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I5_MP1 (I1528_gn5 b21_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I5_MP0 (VDD p20_4 I1528_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I6_MP1 (I1528_gn6 b21_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I6_MP0 (VDD p20_5 I1528_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I104_XP_MP1 (I1528_P8_5n I1528_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I104_XP_MP0 (VDD I1528_P8_7 I1528_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I175_XP_MP1 (I1528_P24_9n I1528_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I175_XP_MP0 (VDD I1528_P24_17 I1528_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I103_XP_MP1 (I1528_P7_4n I1528_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I103_XP_MP0 (VDD I1528_P7_6 I1528_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I168_XP_MP1 (I1528_P17_2n I1528_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I168_XP_MP0 (VDD I1528_P17_10 I1528_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I21_MP1 (I1160_gn21 b13_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I21_MP0 (VDD p12_20 I1160_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I13_MP1 (I1160_gn13 b13_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I13_MP0 (VDD p12_12 I1160_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I12_MP1 (I1160_gn12 b13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I12_MP0 (VDD p12_11 I1160_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I7_MP1 (I1160_gn7 b13_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I7_MP0 (VDD p12_6 I1160_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I6_MP1 (I1160_gn6 b13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I6_MP0 (VDD p12_5 I1160_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I3_MP1 (I1160_gn3 b13_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I3_MP0 (VDD p12_2 I1160_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I2_MP1 (I1206_gn2 b14_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I2_MP0 (VDD p13_1 I1206_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I1_MP1 (I1206_gn1 b14_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I1_MP0 (VDD p13_0 I1206_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I2_MP1 (I1252_gn2 b15_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I2_MP0 (VDD p14_1 I1252_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I4_MP1 (I1298_gn4 b16_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I4_MP0 (VDD p15_3 I1298_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I3_MP1 (I1298_gn3 b16_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I3_MP0 (VDD p15_2 I1298_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I100_XP_MP1 (I1298_P4_1n I1298_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I100_XP_MP0 (VDD I1298_P4_3 I1298_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I6_MP1 (I1344_gn6 b17_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I6_MP0 (VDD p16_5 I1344_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I102_XP_MP1 (I1344_P6_3n I1344_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I102_XP_MP0 (VDD I1344_P6_5 I1344_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I100_XP_MP1 (I1344_P4_1n I1344_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I100_XP_MP0 (VDD I1344_P4_3 I1344_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I101_XP_MP1 (I1344_P5_2n I1344_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I101_XP_MP0 (VDD I1344_P5_4 I1344_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I6_MP1 (I1390_gn6 b18_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I6_MP0 (VDD p17_5 I1390_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I7_MP1 (I1390_gn7 b18_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I7_MP0 (VDD p17_6 I1390_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I5_MP1 (I1390_gn5 b18_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I5_MP0 (VDD p17_4 I1390_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I100_XP_MP1 (I1390_P4_1n I1390_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I100_XP_MP0 (VDD I1390_P4_3 I1390_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I101_XP_MP1 (I1390_P5_2n I1390_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I101_XP_MP0 (VDD I1390_P5_4 I1390_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I6_MP1 (I1436_gn6 b19_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I6_MP0 (VDD p18_5 I1436_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I5_MP1 (I1436_gn5 b19_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I5_MP0 (VDD p18_4 I1436_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I102_XP_MP1 (I1436_P6_3n I1436_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I102_XP_MP0 (VDD I1436_P6_5 I1436_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I100_XP_MP1 (I1436_P4_1n I1436_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I100_XP_MP0 (VDD I1436_P4_3 I1436_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I5_MP1 (I1482_gn5 b20_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I5_MP0 (VDD p19_4 I1482_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I6_MP1 (I1482_gn6 b20_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I6_MP0 (VDD p19_5 I1482_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I101_XP_MP1 (I1482_P5_2n I1482_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I101_XP_MP0 (VDD I1482_P5_4 I1482_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I100_XP_MP1 (I1482_P4_1n I1482_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I100_XP_MP0 (VDD I1482_P4_3 I1482_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I102_XP_MP1 (I1482_P6_3n I1482_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I102_XP_MP0 (VDD I1482_P6_5 I1482_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I7_MP1 (I1528_gn7 b21_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I7_MP0 (VDD p20_6 I1528_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I8_MP1 (I1528_gn8 b21_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I8_MP0 (VDD p20_7 I1528_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I106_XP_MP1 (I1528_P10_7n I1528_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I106_XP_MP0 (VDD I1528_P10_9 I1528_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I108_XP_MP1 (I1528_P12_9n I1528_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I108_XP_MP0 (VDD I1528_P12_11 I1528_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I171_XP_MP1 (I1528_P20_5n I1528_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I171_XP_MP0 (VDD I1528_P20_13 I1528_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I107_XP_MP1 (I1528_P11_8n I1528_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I107_XP_MP0 (VDD I1528_P11_10 I1528_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I105_XP_MP1 (I1528_P9_6n I1528_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I105_XP_MP0 (VDD I1528_P9_8 I1528_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I176_XP_MP1 (I1528_P25_10n I1528_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I176_XP_MP0 (VDD I1528_P25_18 I1528_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I23_MP1 (I1160_gn23 b13_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I23_MP0 (VDD p12_22 I1160_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I20_MP1 (I1160_gn20 b13_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I20_MP0 (VDD p12_19 I1160_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I19_MP1 (I1160_gn19 b13_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I19_MP0 (VDD p12_18 I1160_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I16_MP1 (I1160_gn16 b13_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I16_MP0 (VDD p12_15 I1160_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I17_MP1 (I1160_gn17 b13_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I17_MP0 (VDD p12_16 I1160_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I15_MP1 (I1160_gn15 b13_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I15_MP0 (VDD p12_14 I1160_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I14_MP1 (I1160_gn14 b13_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I14_MP0 (VDD p12_13 I1160_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I11_MP1 (I1160_gn11 b13_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I11_MP0 (VDD p12_10 I1160_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I2_MP1 (I1160_gn2 b13_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I2_MP0 (VDD p12_1 I1160_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I3_MP1 (I1206_gn3 b14_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I3_MP0 (VDD p13_2 I1206_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I4_MP1 (I1252_gn4 b15_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I4_MP0 (VDD p14_3 I1252_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I3_MP1 (I1252_gn3 b15_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I3_MP0 (VDD p14_2 I1252_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I100_XP_MP1 (I1252_P4_1n I1252_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I100_XP_MP0 (VDD I1252_P4_3 I1252_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I101_XP_MP1 (I1252_P5_2n I1252_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I101_XP_MP0 (VDD I1252_P5_4 I1252_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I5_MP1 (I1298_gn5 b16_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I5_MP0 (VDD p15_4 I1298_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I6_MP1 (I1298_gn6 b16_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I6_MP0 (VDD p15_5 I1298_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I102_XP_MP1 (I1298_P6_3n I1298_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I102_XP_MP0 (VDD I1298_P6_5 I1298_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I103_XP_MP1 (I1298_P7_4n I1298_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I103_XP_MP0 (VDD I1298_P7_6 I1298_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I101_XP_MP1 (I1298_P5_2n I1298_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I101_XP_MP0 (VDD I1298_P5_4 I1298_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I7_MP1 (I1344_gn7 b17_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I7_MP0 (VDD p16_6 I1344_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I104_XP_MP1 (I1344_P8_5n I1344_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I104_XP_MP0 (VDD I1344_P8_7 I1344_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I9_MP1 (I1344_gn9 b17_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I9_MP0 (VDD p16_8 I1344_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I103_XP_MP1 (I1344_P7_4n I1344_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I103_XP_MP0 (VDD I1344_P7_6 I1344_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I105_XP_MP1 (I1344_P9_6n I1344_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I105_XP_MP0 (VDD I1344_P9_8 I1344_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I8_MP1 (I1390_gn8 b18_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I8_MP0 (VDD p17_7 I1390_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I104_XP_MP1 (I1390_P8_5n I1390_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I104_XP_MP0 (VDD I1390_P8_7 I1390_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I102_XP_MP1 (I1390_P6_3n I1390_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I102_XP_MP0 (VDD I1390_P6_5 I1390_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I105_XP_MP1 (I1390_P9_6n I1390_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I105_XP_MP0 (VDD I1390_P9_8 I1390_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I103_XP_MP1 (I1390_P7_4n I1390_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I103_XP_MP0 (VDD I1390_P7_6 I1390_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I8_MP1 (I1436_gn8 b19_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I8_MP0 (VDD p18_7 I1436_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I7_MP1 (I1436_gn7 b19_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I7_MP0 (VDD p18_6 I1436_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I104_XP_MP1 (I1436_P8_5n I1436_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I104_XP_MP0 (VDD I1436_P8_7 I1436_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I101_XP_MP1 (I1436_P5_2n I1436_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I101_XP_MP0 (VDD I1436_P5_4 I1436_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I8_MP1 (I1482_gn8 b20_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I8_MP0 (VDD p19_7 I1482_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I7_MP1 (I1482_gn7 b20_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I7_MP0 (VDD p19_6 I1482_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I103_XP_MP1 (I1482_P7_4n I1482_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I103_XP_MP0 (VDD I1482_P7_6 I1482_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I104_XP_MP1 (I1482_P8_5n I1482_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I104_XP_MP0 (VDD I1482_P8_7 I1482_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I9_MP1 (I1528_gn9 b21_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I9_MP0 (VDD p20_8 I1528_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I10_MP1 (I1528_gn10 b21_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I10_MP0 (VDD p20_9 I1528_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I11_MP1 (I1528_gn11 b21_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I11_MP0 (VDD p20_10 I1528_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I170_XP_MP1 (I1528_P19_4n I1528_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I170_XP_MP0 (VDD I1528_P19_12 I1528_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I31_MP1 (I1160_gn31 b13_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I31_MP0 (VDD p12_30 I1160_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I30_MP1 (I1160_gn30 b13_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I30_MP0 (VDD p12_29 I1160_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I119_XP_MP1 (I1160_P23_20n I1160_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I119_XP_MP0 (VDD I1160_P23_22 I1160_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I22_MP1 (I1160_gn22 b13_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I22_MP0 (VDD p12_21 I1160_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I18_MP1 (I1160_gn18 b13_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I18_MP0 (VDD p12_17 I1160_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I10_MP1 (I1160_gn10 b13_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I10_MP0 (VDD p12_9 I1160_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I9_MP1 (I1160_gn9 b13_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I9_MP0 (VDD p12_8 I1160_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I8_MP1 (I1160_gn8 b13_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I8_MP0 (VDD p12_7 I1160_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I5_MP1 (I1252_gn5 b15_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I5_MP0 (VDD p14_4 I1252_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I6_MP1 (I1252_gn6 b15_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I6_MP0 (VDD p14_5 I1252_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I104_XP_MP1 (I1252_P8_5n I1252_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I104_XP_MP0 (VDD I1252_P8_7 I1252_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I102_XP_MP1 (I1252_P6_3n I1252_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I102_XP_MP0 (VDD I1252_P6_5 I1252_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I103_XP_MP1 (I1252_P7_4n I1252_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I103_XP_MP0 (VDD I1252_P7_6 I1252_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I8_MP1 (I1298_gn8 b16_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I8_MP0 (VDD p15_7 I1298_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I7_MP1 (I1298_gn7 b16_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I7_MP0 (VDD p15_6 I1298_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I104_XP_MP1 (I1298_P8_5n I1298_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I104_XP_MP0 (VDD I1298_P8_7 I1298_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I105_XP_MP1 (I1298_P9_6n I1298_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I105_XP_MP0 (VDD I1298_P9_8 I1298_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I8_MP1 (I1344_gn8 b17_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I8_MP0 (VDD p16_7 I1344_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I106_XP_MP1 (I1344_P10_7n I1344_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I106_XP_MP0 (VDD I1344_P10_9 I1344_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I167_XP_MP1 (I1344_P16_1n I1344_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I167_XP_MP0 (VDD I1344_P16_9 I1344_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I10_MP1 (I1344_gn10 b17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I10_MP0 (VDD p16_9 I1344_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I168_XP_MP1 (I1344_P17_2n I1344_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I168_XP_MP0 (VDD I1344_P17_10 I1344_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I10_MP1 (I1390_gn10 b18_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I10_MP0 (VDD p17_9 I1390_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I9_MP1 (I1390_gn9 b18_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I9_MP0 (VDD p17_8 I1390_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I106_XP_MP1 (I1390_P10_7n I1390_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I106_XP_MP0 (VDD I1390_P10_9 I1390_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I167_XP_MP1 (I1390_P16_1n I1390_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I167_XP_MP0 (VDD I1390_P16_9 I1390_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I9_MP1 (I1436_gn9 b19_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I9_MP0 (VDD p18_8 I1436_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I106_XP_MP1 (I1436_P10_7n I1436_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I106_XP_MP0 (VDD I1436_P10_9 I1436_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I167_XP_MP1 (I1436_P16_1n I1436_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I167_XP_MP0 (VDD I1436_P16_9 I1436_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I103_XP_MP1 (I1436_P7_4n I1436_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I103_XP_MP0 (VDD I1436_P7_6 I1436_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I105_XP_MP1 (I1436_P9_6n I1436_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I105_XP_MP0 (VDD I1436_P9_8 I1436_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I10_MP1 (I1482_gn10 b20_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I10_MP0 (VDD p19_9 I1482_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I9_MP1 (I1482_gn9 b20_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I9_MP0 (VDD p19_8 I1482_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I105_XP_MP1 (I1482_P9_6n I1482_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I105_XP_MP0 (VDD I1482_P9_8 I1482_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I167_XP_MP1 (I1482_P16_1n I1482_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I167_XP_MP0 (VDD I1482_P16_9 I1482_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I12_MP1 (I1528_gn12 b21_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I12_MP0 (VDD p20_11 I1528_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I110_XP_MP1 (I1528_P14_11n I1528_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I110_XP_MP0 (VDD I1528_P14_13 I1528_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I169_XP_MP1 (I1528_P18_3n I1528_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I169_XP_MP0 (VDD I1528_P18_11 I1528_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I179_XP_MP1 (I1528_P28_13n I1528_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I179_XP_MP0 (VDD I1528_P28_21 I1528_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I109_XP_MP1 (I1528_P13_10n I1528_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I109_XP_MP0 (VDD I1528_P13_12 I1528_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I182_XP_MP1 (I1160_P31_16n I1160_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I182_XP_MP0 (VDD I1160_P31_24 I1160_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I174_XP_MP1 (I1160_P23_8n I1160_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I174_XP_MP0 (VDD I1160_P23_16 I1160_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I117_XP_MP1 (I1160_P21_18n I1160_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I117_XP_MP0 (VDD I1160_P21_20 I1160_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I115_XP_MP1 (I1160_P19_16n I1160_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I115_XP_MP0 (VDD I1160_P19_18 I1160_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I113_XP_MP1 (I1160_P17_14n I1160_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I113_XP_MP0 (VDD I1160_P17_16 I1160_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I111_XP_MP1 (I1160_P15_12n I1160_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I111_XP_MP0 (VDD I1160_P15_14 I1160_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I109_XP_MP1 (I1160_P13_10n I1160_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I109_XP_MP0 (VDD I1160_P13_12 I1160_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I107_XP_MP1 (I1160_P11_8n I1160_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I107_XP_MP0 (VDD I1160_P11_10 I1160_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I105_XP_MP1 (I1160_P9_6n I1160_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I105_XP_MP0 (VDD I1160_P9_8 I1160_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I103_XP_MP1 (I1160_P7_4n I1160_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I103_XP_MP0 (VDD I1160_P7_6 I1160_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I101_XP_MP1 (I1160_P5_2n I1160_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I101_XP_MP0 (VDD I1160_P5_4 I1160_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I4_MP1 (I1206_gn4 b14_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I4_MP0 (VDD p13_3 I1206_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I100_XP_MP1 (I1206_P4_1n I1206_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I100_XP_MP0 (VDD I1206_P4_3 I1206_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I8_MP1 (I1252_gn8 b15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I8_MP0 (VDD p14_7 I1252_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I7_MP1 (I1252_gn7 b15_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I7_MP0 (VDD p14_6 I1252_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I106_XP_MP1 (I1252_P10_7n I1252_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I106_XP_MP0 (VDD I1252_P10_9 I1252_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I167_XP_MP1 (I1252_P16_1n I1252_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I167_XP_MP0 (VDD I1252_P16_9 I1252_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I105_XP_MP1 (I1252_P9_6n I1252_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I105_XP_MP0 (VDD I1252_P9_8 I1252_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I9_MP1 (I1298_gn9 b16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I9_MP0 (VDD p15_8 I1298_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I106_XP_MP1 (I1298_P10_7n I1298_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I106_XP_MP0 (VDD I1298_P10_9 I1298_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I167_XP_MP1 (I1298_P16_1n I1298_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I167_XP_MP0 (VDD I1298_P16_9 I1298_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I107_XP_MP1 (I1298_P11_8n I1298_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I107_XP_MP0 (VDD I1298_P11_10 I1298_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I108_XP_MP1 (I1344_P12_9n I1344_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I108_XP_MP0 (VDD I1344_P12_11 I1344_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I11_MP1 (I1344_gn11 b17_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I11_MP0 (VDD p16_10 I1344_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I107_XP_MP1 (I1344_P11_8n I1344_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I107_XP_MP0 (VDD I1344_P11_10 I1344_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I12_MP1 (I1390_gn12 b18_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I12_MP0 (VDD p17_11 I1390_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I11_MP1 (I1390_gn11 b18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I11_MP0 (VDD p17_10 I1390_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I108_XP_MP1 (I1390_P12_9n I1390_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I108_XP_MP0 (VDD I1390_P12_11 I1390_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I107_XP_MP1 (I1390_P11_8n I1390_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I107_XP_MP0 (VDD I1390_P11_10 I1390_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I168_XP_MP1 (I1390_P17_2n I1390_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I168_XP_MP0 (VDD I1390_P17_10 I1390_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I11_MP1 (I1436_gn11 b19_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I11_MP0 (VDD p18_10 I1436_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I10_MP1 (I1436_gn10 b19_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I10_MP0 (VDD p18_9 I1436_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I108_XP_MP1 (I1436_P12_9n I1436_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I108_XP_MP0 (VDD I1436_P12_11 I1436_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I107_XP_MP1 (I1436_P11_8n I1436_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I107_XP_MP0 (VDD I1436_P11_10 I1436_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I168_XP_MP1 (I1436_P17_2n I1436_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I168_XP_MP0 (VDD I1436_P17_10 I1436_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I11_MP1 (I1482_gn11 b20_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I11_MP0 (VDD p19_10 I1482_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I106_XP_MP1 (I1482_P10_7n I1482_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I106_XP_MP0 (VDD I1482_P10_9 I1482_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I13_MP1 (I1528_gn13 b21_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I13_MP0 (VDD p20_12 I1528_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I112_XP_MP1 (I1528_P16_13n I1528_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I112_XP_MP0 (VDD I1528_P16_15 I1528_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I177_XP_MP1 (I1528_P26_11n I1528_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I177_XP_MP0 (VDD I1528_P26_19 I1528_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I111_XP_MP1 (I1528_P15_12n I1528_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I111_XP_MP0 (VDD I1528_P15_14 I1528_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I178_XP_MP1 (I1528_P27_12n I1528_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I178_XP_MP0 (VDD I1528_P27_20 I1528_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I172_XP_MP1 (I1528_P21_6n I1528_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I172_XP_MP0 (VDD I1528_P21_14 I1528_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I178_XP_MP1 (I1160_P27_12n I1160_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I178_XP_MP0 (VDD I1160_P27_20 I1160_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I176_XP_MP1 (I1160_P25_10n I1160_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I176_XP_MP0 (VDD I1160_P25_18 I1160_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I170_XP_MP1 (I1160_P19_4n I1160_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I170_XP_MP0 (VDD I1160_P19_12 I1160_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I168_XP_MP1 (I1160_P17_2n I1160_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I168_XP_MP0 (VDD I1160_P17_10 I1160_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I100_XP_MP1 (I1160_P4_1n I1160_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I100_XP_MP0 (VDD I1160_P4_3 I1160_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I9_MP1 (I1206_gn9 b14_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I9_MP0 (VDD p13_8 I1206_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I7_MP1 (I1206_gn7 b14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I7_MP0 (VDD p13_6 I1206_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I5_MP1 (I1206_gn5 b14_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I5_MP0 (VDD p13_4 I1206_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I101_XP_MP1 (I1206_P5_2n I1206_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I101_XP_MP0 (VDD I1206_P5_4 I1206_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I11_MP1 (I1252_gn11 b15_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I11_MP0 (VDD p14_10 I1252_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I9_MP1 (I1252_gn9 b15_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I9_MP0 (VDD p14_8 I1252_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I10_MP1 (I1252_gn10 b15_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I10_MP0 (VDD p14_9 I1252_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I169_XP_MP1 (I1252_P18_3n I1252_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I169_XP_MP0 (VDD I1252_P18_11 I1252_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I107_XP_MP1 (I1252_P11_8n I1252_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I107_XP_MP0 (VDD I1252_P11_10 I1252_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I168_XP_MP1 (I1252_P17_2n I1252_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I168_XP_MP0 (VDD I1252_P17_10 I1252_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I11_MP1 (I1298_gn11 b16_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I11_MP0 (VDD p15_10 I1298_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I10_MP1 (I1298_gn10 b16_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I10_MP0 (VDD p15_9 I1298_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I108_XP_MP1 (I1298_P12_9n I1298_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I108_XP_MP0 (VDD I1298_P12_11 I1298_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I169_XP_MP1 (I1298_P18_3n I1298_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I169_XP_MP0 (VDD I1298_P18_11 I1298_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I168_XP_MP1 (I1298_P17_2n I1298_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I168_XP_MP0 (VDD I1298_P17_10 I1298_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I169_XP_MP1 (I1344_P18_3n I1344_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I169_XP_MP0 (VDD I1344_P18_11 I1344_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I175_XP_MP1 (I1344_P24_9n I1344_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I175_XP_MP0 (VDD I1344_P24_17 I1344_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I13_MP1 (I1344_gn13 b17_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I13_MP0 (VDD p16_12 I1344_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I12_MP1 (I1344_gn12 b17_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I12_MP0 (VDD p16_11 I1344_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I109_XP_MP1 (I1344_P13_10n I1344_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I109_XP_MP0 (VDD I1344_P13_12 I1344_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I170_XP_MP1 (I1344_P19_4n I1344_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I170_XP_MP0 (VDD I1344_P19_12 I1344_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I13_MP1 (I1390_gn13 b18_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I13_MP0 (VDD p17_12 I1390_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I169_XP_MP1 (I1390_P18_3n I1390_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I169_XP_MP0 (VDD I1390_P18_11 I1390_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I175_XP_MP1 (I1390_P24_9n I1390_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I175_XP_MP0 (VDD I1390_P24_17 I1390_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I109_XP_MP1 (I1390_P13_10n I1390_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I109_XP_MP0 (VDD I1390_P13_12 I1390_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I12_MP1 (I1436_gn12 b19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I12_MP0 (VDD p18_11 I1436_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I169_XP_MP1 (I1436_P18_3n I1436_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I169_XP_MP0 (VDD I1436_P18_11 I1436_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I13_MP1 (I1482_gn13 b20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I13_MP0 (VDD p19_12 I1482_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I12_MP1 (I1482_gn12 b20_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I12_MP0 (VDD p19_11 I1482_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I107_XP_MP1 (I1482_P11_8n I1482_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I107_XP_MP0 (VDD I1482_P11_10 I1482_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I168_XP_MP1 (I1482_P17_2n I1482_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I168_XP_MP0 (VDD I1482_P17_10 I1482_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I108_XP_MP1 (I1482_P12_9n I1482_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I108_XP_MP0 (VDD I1482_P12_11 I1482_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I14_MP1 (I1528_gn14 b21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I14_MP0 (VDD p20_13 I1528_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I15_MP1 (I1528_gn15 b21_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I15_MP0 (VDD p20_14 I1528_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I114_XP_MP1 (I1528_P18_15n I1528_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I114_XP_MP0 (VDD I1528_P18_17 I1528_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I116_XP_MP1 (I1528_P20_17n I1528_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I116_XP_MP0 (VDD I1528_P20_19 I1528_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I113_XP_MP1 (I1528_P17_14n I1528_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I113_XP_MP0 (VDD I1528_P17_16 I1528_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I127_XP_MP1 (I1160_P31_28n I1160_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I127_XP_MP0 (VDD I1160_P31_30 I1160_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I125_XP_MP1 (I1160_P29_26n I1160_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I125_XP_MP0 (VDD I1160_P29_28 I1160_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I123_XP_MP1 (I1160_P27_24n I1160_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I123_XP_MP0 (VDD I1160_P27_26 I1160_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I121_XP_MP1 (I1160_P25_22n I1160_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I121_XP_MP0 (VDD I1160_P25_24 I1160_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I180_XP_MP1 (I1160_P29_14n I1160_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I180_XP_MP0 (VDD I1160_P29_22 I1160_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I172_XP_MP1 (I1160_P21_6n I1160_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I172_XP_MP0 (VDD I1160_P21_14 I1160_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I104_XP_MP1 (I1160_P8_5n I1160_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I104_XP_MP0 (VDD I1160_P8_7 I1160_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I102_XP_MP1 (I1160_P6_3n I1160_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I102_XP_MP0 (VDD I1160_P6_5 I1160_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I11_MP1 (I1206_gn11 b14_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I11_MP0 (VDD p13_10 I1206_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I8_MP1 (I1206_gn8 b14_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I8_MP0 (VDD p13_7 I1206_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I6_MP1 (I1206_gn6 b14_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I6_MP0 (VDD p13_5 I1206_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I104_XP_MP1 (I1206_P8_5n I1206_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I104_XP_MP0 (VDD I1206_P8_7 I1206_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I102_XP_MP1 (I1206_P6_3n I1206_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I102_XP_MP0 (VDD I1206_P6_5 I1206_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I12_MP1 (I1252_gn12 b15_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I12_MP0 (VDD p14_11 I1252_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I108_XP_MP1 (I1252_P12_9n I1252_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I108_XP_MP0 (VDD I1252_P12_11 I1252_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I109_XP_MP1 (I1252_P13_10n I1252_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I109_XP_MP0 (VDD I1252_P13_12 I1252_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I13_MP1 (I1298_gn13 b16_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I13_MP0 (VDD p15_12 I1298_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I12_MP1 (I1298_gn12 b16_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I12_MP0 (VDD p15_11 I1298_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I110_XP_MP1 (I1298_P14_11n I1298_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I110_XP_MP0 (VDD I1298_P14_13 I1298_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I175_XP_MP1 (I1298_P24_9n I1298_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I175_XP_MP0 (VDD I1298_P24_17 I1298_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I109_XP_MP1 (I1298_P13_10n I1298_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I109_XP_MP0 (VDD I1298_P13_12 I1298_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I170_XP_MP1 (I1298_P19_4n I1298_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I170_XP_MP0 (VDD I1298_P19_12 I1298_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I171_XP_MP1 (I1344_P20_5n I1344_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I171_XP_MP0 (VDD I1344_P20_13 I1344_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I112_XP_MP1 (I1344_P16_13n I1344_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I112_XP_MP0 (VDD I1344_P16_15 I1344_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I110_XP_MP1 (I1344_P14_11n I1344_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I110_XP_MP0 (VDD I1344_P14_13 I1344_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I14_MP1 (I1344_gn14 b17_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I14_MP0 (VDD p16_13 I1344_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I176_XP_MP1 (I1344_P25_10n I1344_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I176_XP_MP0 (VDD I1344_P25_18 I1344_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I14_MP1 (I1390_gn14 b18_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I14_MP0 (VDD p17_13 I1390_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I112_XP_MP1 (I1390_P16_13n I1390_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I112_XP_MP0 (VDD I1390_P16_15 I1390_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I110_XP_MP1 (I1390_P14_11n I1390_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I110_XP_MP0 (VDD I1390_P14_13 I1390_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I170_XP_MP1 (I1390_P19_4n I1390_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I170_XP_MP0 (VDD I1390_P19_12 I1390_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I14_MP1 (I1436_gn14 b19_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I14_MP0 (VDD p18_13 I1436_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I13_MP1 (I1436_gn13 b19_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I13_MP0 (VDD p18_12 I1436_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I110_XP_MP1 (I1436_P14_11n I1436_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I110_XP_MP0 (VDD I1436_P14_13 I1436_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I175_XP_MP1 (I1436_P24_9n I1436_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I175_XP_MP0 (VDD I1436_P24_17 I1436_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I109_XP_MP1 (I1436_P13_10n I1436_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I109_XP_MP0 (VDD I1436_P13_12 I1436_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I170_XP_MP1 (I1436_P19_4n I1436_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I170_XP_MP0 (VDD I1436_P19_12 I1436_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I14_MP1 (I1482_gn14 b20_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I14_MP0 (VDD p19_13 I1482_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I109_XP_MP1 (I1482_P13_10n I1482_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I109_XP_MP0 (VDD I1482_P13_12 I1482_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I110_XP_MP1 (I1482_P14_11n I1482_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I110_XP_MP0 (VDD I1482_P14_13 I1482_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I16_MP1 (I1528_gn16 b21_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I16_MP0 (VDD p20_15 I1528_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I173_XP_MP1 (I1528_P22_7n I1528_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I173_XP_MP0 (VDD I1528_P22_15 I1528_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I115_XP_MP1 (I1528_P19_16n I1528_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I115_XP_MP0 (VDD I1528_P19_18 I1528_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I180_XP_MP1 (I1528_P29_14n I1528_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I180_XP_MP0 (VDD I1528_P29_22 I1528_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I24_MP1 (I1160_gn24 b13_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I24_MP0 (VDD p12_23 I1160_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I118_XP_MP1 (I1160_P22_19n I1160_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I118_XP_MP0 (VDD I1160_P22_21 I1160_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I116_XP_MP1 (I1160_P20_17n I1160_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I116_XP_MP0 (VDD I1160_P20_19 I1160_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I114_XP_MP1 (I1160_P18_15n I1160_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I114_XP_MP0 (VDD I1160_P18_17 I1160_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I112_XP_MP1 (I1160_P16_13n I1160_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I112_XP_MP0 (VDD I1160_P16_15 I1160_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I110_XP_MP1 (I1160_P14_11n I1160_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I110_XP_MP0 (VDD I1160_P14_13 I1160_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I108_XP_MP1 (I1160_P12_9n I1160_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I108_XP_MP0 (VDD I1160_P12_11 I1160_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I106_XP_MP1 (I1160_P10_7n I1160_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I106_XP_MP0 (VDD I1160_P10_9 I1160_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I167_XP_MP1 (I1160_P16_1n I1160_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I167_XP_MP0 (VDD I1160_P16_9 I1160_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I10_MP1 (I1206_gn10 b14_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I10_MP0 (VDD p13_9 I1206_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I103_XP_MP1 (I1206_P7_4n I1206_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I103_XP_MP0 (VDD I1206_P7_6 I1206_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I106_XP_MP1 (I1206_P10_7n I1206_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I106_XP_MP0 (VDD I1206_P10_9 I1206_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I167_XP_MP1 (I1206_P16_1n I1206_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I167_XP_MP0 (VDD I1206_P16_9 I1206_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I13_MP1 (I1252_gn13 b15_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I13_MP0 (VDD p14_12 I1252_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I110_XP_MP1 (I1252_P14_11n I1252_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I110_XP_MP0 (VDD I1252_P14_13 I1252_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I171_XP_MP1 (I1252_P20_5n I1252_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I171_XP_MP0 (VDD I1252_P20_13 I1252_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I175_XP_MP1 (I1252_P24_9n I1252_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I175_XP_MP0 (VDD I1252_P24_17 I1252_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I170_XP_MP1 (I1252_P19_4n I1252_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I170_XP_MP0 (VDD I1252_P19_12 I1252_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I14_MP1 (I1298_gn14 b16_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I14_MP0 (VDD p15_13 I1298_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I15_MP1 (I1298_gn15 b16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I15_MP0 (VDD p15_14 I1298_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I112_XP_MP1 (I1298_P16_13n I1298_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I112_XP_MP0 (VDD I1298_P16_15 I1298_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I171_XP_MP1 (I1298_P20_5n I1298_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I171_XP_MP0 (VDD I1298_P20_13 I1298_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I111_XP_MP1 (I1298_P15_12n I1298_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I111_XP_MP0 (VDD I1298_P15_14 I1298_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I177_XP_MP1 (I1344_P26_11n I1344_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I177_XP_MP0 (VDD I1344_P26_19 I1344_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I15_MP1 (I1344_gn15 b17_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I15_MP0 (VDD p16_14 I1344_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I113_XP_MP1 (I1344_P17_14n I1344_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I113_XP_MP0 (VDD I1344_P17_16 I1344_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I111_XP_MP1 (I1344_P15_12n I1344_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I111_XP_MP0 (VDD I1344_P15_14 I1344_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I15_MP1 (I1390_gn15 b18_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I15_MP0 (VDD p17_14 I1390_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I114_XP_MP1 (I1390_P18_15n I1390_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I114_XP_MP0 (VDD I1390_P18_17 I1390_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I171_XP_MP1 (I1390_P20_5n I1390_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I171_XP_MP0 (VDD I1390_P20_13 I1390_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I111_XP_MP1 (I1390_P15_12n I1390_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I111_XP_MP0 (VDD I1390_P15_14 I1390_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I176_XP_MP1 (I1390_P25_10n I1390_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I176_XP_MP0 (VDD I1390_P25_18 I1390_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I15_MP1 (I1436_gn15 b19_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I15_MP0 (VDD p18_14 I1436_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I112_XP_MP1 (I1436_P16_13n I1436_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I112_XP_MP0 (VDD I1436_P16_15 I1436_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I171_XP_MP1 (I1436_P20_5n I1436_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I171_XP_MP0 (VDD I1436_P20_13 I1436_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I111_XP_MP1 (I1436_P15_12n I1436_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I111_XP_MP0 (VDD I1436_P15_14 I1436_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I111_XP_MP1 (I1482_P15_12n I1482_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I111_XP_MP0 (VDD I1482_P15_14 I1482_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I112_XP_MP1 (I1482_P16_13n I1482_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I112_XP_MP0 (VDD I1482_P16_15 I1482_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I171_XP_MP1 (I1482_P20_5n I1482_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I171_XP_MP0 (VDD I1482_P20_13 I1482_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I169_XP_MP1 (I1482_P18_3n I1482_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I169_XP_MP0 (VDD I1482_P18_11 I1482_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I17_MP1 (I1528_gn17 b21_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I17_MP0 (VDD p20_16 I1528_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I18_MP1 (I1528_gn18 b21_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I18_MP0 (VDD p20_17 I1528_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I118_XP_MP1 (I1528_P22_19n I1528_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I118_XP_MP0 (VDD I1528_P22_21 I1528_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I174_XP_MP1 (I1528_P23_8n I1528_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I174_XP_MP0 (VDD I1528_P23_16 I1528_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I117_XP_MP1 (I1528_P21_18n I1528_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I117_XP_MP0 (VDD I1528_P21_20 I1528_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I29_MP1 (I1160_gn29 b13_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I29_MP0 (VDD p12_28 I1160_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I25_MP1 (I1160_gn25 b13_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I25_MP0 (VDD p12_24 I1160_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I120_XP_MP1 (I1160_P24_21n I1160_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I120_XP_MP0 (VDD I1160_P24_23 I1160_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I179_XP_MP1 (I1160_P28_13n I1160_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I179_XP_MP0 (VDD I1160_P28_21 I1160_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I175_XP_MP1 (I1160_P24_9n I1160_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I175_XP_MP0 (VDD I1160_P24_17 I1160_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I171_XP_MP1 (I1160_P20_5n I1160_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I171_XP_MP0 (VDD I1160_P20_13 I1160_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I13_MP1 (I1206_gn13 b14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I13_MP0 (VDD p13_12 I1206_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I107_XP_MP1 (I1206_P11_8n I1206_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I107_XP_MP0 (VDD I1206_P11_10 I1206_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I105_XP_MP1 (I1206_P9_6n I1206_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I105_XP_MP0 (VDD I1206_P9_8 I1206_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I108_XP_MP1 (I1206_P12_9n I1206_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I108_XP_MP0 (VDD I1206_P12_11 I1206_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I14_MP1 (I1252_gn14 b15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I14_MP0 (VDD p14_13 I1252_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I112_XP_MP1 (I1252_P16_13n I1252_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I112_XP_MP0 (VDD I1252_P16_15 I1252_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I111_XP_MP1 (I1252_P15_12n I1252_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I111_XP_MP0 (VDD I1252_P15_14 I1252_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I176_XP_MP1 (I1252_P25_10n I1252_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I176_XP_MP0 (VDD I1252_P25_18 I1252_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I16_MP1 (I1298_gn16 b16_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I16_MP0 (VDD p15_15 I1298_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I114_XP_MP1 (I1298_P18_15n I1298_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I114_XP_MP0 (VDD I1298_P18_17 I1298_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I177_XP_MP1 (I1298_P26_11n I1298_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I177_XP_MP0 (VDD I1298_P26_19 I1298_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I113_XP_MP1 (I1298_P17_14n I1298_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I113_XP_MP0 (VDD I1298_P17_16 I1298_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I114_XP_MP1 (I1344_P18_15n I1344_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I114_XP_MP0 (VDD I1344_P18_17 I1344_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I16_MP1 (I1344_gn16 b17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I16_MP0 (VDD p16_15 I1344_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I17_MP1 (I1344_gn17 b17_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I17_MP0 (VDD p16_16 I1344_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I115_XP_MP1 (I1344_P19_16n I1344_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I115_XP_MP0 (VDD I1344_P19_18 I1344_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I17_MP1 (I1390_gn17 b18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I17_MP0 (VDD p17_16 I1390_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I16_MP1 (I1390_gn16 b18_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I16_MP0 (VDD p17_15 I1390_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I116_XP_MP1 (I1390_P20_17n I1390_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I116_XP_MP0 (VDD I1390_P20_19 I1390_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I177_XP_MP1 (I1390_P26_11n I1390_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I177_XP_MP0 (VDD I1390_P26_19 I1390_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I113_XP_MP1 (I1390_P17_14n I1390_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I113_XP_MP0 (VDD I1390_P17_16 I1390_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I16_MP1 (I1436_gn16 b19_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I16_MP0 (VDD p18_15 I1436_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I114_XP_MP1 (I1436_P18_15n I1436_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I114_XP_MP0 (VDD I1436_P18_17 I1436_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I177_XP_MP1 (I1436_P26_11n I1436_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I177_XP_MP0 (VDD I1436_P26_19 I1436_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I113_XP_MP1 (I1436_P17_14n I1436_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I113_XP_MP0 (VDD I1436_P17_16 I1436_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I16_MP1 (I1482_gn16 b20_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I16_MP0 (VDD p19_15 I1482_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I15_MP1 (I1482_gn15 b20_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I15_MP0 (VDD p19_14 I1482_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I17_MP1 (I1482_gn17 b20_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I17_MP0 (VDD p19_16 I1482_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I113_XP_MP1 (I1482_P17_14n I1482_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I113_XP_MP0 (VDD I1482_P17_16 I1482_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I114_XP_MP1 (I1482_P18_15n I1482_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I114_XP_MP0 (VDD I1482_P18_17 I1482_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I19_MP1 (I1528_gn19 b21_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I19_MP0 (VDD p20_18 I1528_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I20_MP1 (I1528_gn20 b21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I20_MP0 (VDD p20_19 I1528_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I120_XP_MP1 (I1528_P24_21n I1528_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I120_XP_MP0 (VDD I1528_P24_23 I1528_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I181_XP_MP1 (I1528_P30_15n I1528_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I181_XP_MP0 (VDD I1528_P30_23 I1528_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I119_XP_MP1 (I1528_P23_20n I1528_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I119_XP_MP0 (VDD I1528_P23_22 I1528_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I28_MP1 (I1160_gn28 b13_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I28_MP0 (VDD p12_27 I1160_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I124_XP_MP1 (I1160_P28_25n I1160_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I124_XP_MP0 (VDD I1160_P28_27 I1160_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I122_XP_MP1 (I1160_P26_23n I1160_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I122_XP_MP0 (VDD I1160_P26_25 I1160_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I17_MP1 (I1206_gn17 b14_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I17_MP0 (VDD p13_16 I1206_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I14_MP1 (I1206_gn14 b14_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I14_MP0 (VDD p13_13 I1206_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I12_MP1 (I1206_gn12 b14_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I12_MP0 (VDD p13_11 I1206_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I109_XP_MP1 (I1206_P13_10n I1206_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I109_XP_MP0 (VDD I1206_P13_12 I1206_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I168_XP_MP1 (I1206_P17_2n I1206_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I168_XP_MP0 (VDD I1206_P17_10 I1206_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I110_XP_MP1 (I1206_P14_11n I1206_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I110_XP_MP0 (VDD I1206_P14_13 I1206_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I16_MP1 (I1252_gn16 b15_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I16_MP0 (VDD p14_15 I1252_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I15_MP1 (I1252_gn15 b15_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I15_MP0 (VDD p14_14 I1252_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I116_XP_MP1 (I1252_P20_17n I1252_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I116_XP_MP0 (VDD I1252_P20_19 I1252_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I114_XP_MP1 (I1252_P18_15n I1252_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I114_XP_MP0 (VDD I1252_P18_17 I1252_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I177_XP_MP1 (I1252_P26_11n I1252_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I177_XP_MP0 (VDD I1252_P26_19 I1252_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I113_XP_MP1 (I1252_P17_14n I1252_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I113_XP_MP0 (VDD I1252_P17_16 I1252_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I17_MP1 (I1298_gn17 b16_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I17_MP0 (VDD p15_16 I1298_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I18_MP1 (I1298_gn18 b16_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I18_MP0 (VDD p15_17 I1298_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I116_XP_MP1 (I1298_P20_17n I1298_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I116_XP_MP0 (VDD I1298_P20_19 I1298_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I173_XP_MP1 (I1298_P22_7n I1298_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I173_XP_MP0 (VDD I1298_P22_15 I1298_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I115_XP_MP1 (I1298_P19_16n I1298_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I115_XP_MP0 (VDD I1298_P19_18 I1298_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I172_XP_MP1 (I1298_P21_6n I1298_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I172_XP_MP0 (VDD I1298_P21_14 I1298_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I173_XP_MP1 (I1344_P22_7n I1344_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I173_XP_MP0 (VDD I1344_P22_15 I1344_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I116_XP_MP1 (I1344_P20_17n I1344_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I116_XP_MP0 (VDD I1344_P20_19 I1344_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I18_MP1 (I1344_gn18 b17_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I18_MP0 (VDD p16_17 I1344_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I172_XP_MP1 (I1344_P21_6n I1344_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I172_XP_MP0 (VDD I1344_P21_14 I1344_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I18_MP1 (I1390_gn18 b18_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I18_MP0 (VDD p17_17 I1390_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I19_MP1 (I1390_gn19 b18_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I19_MP0 (VDD p17_18 I1390_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I173_XP_MP1 (I1390_P22_7n I1390_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I173_XP_MP0 (VDD I1390_P22_15 I1390_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I117_XP_MP1 (I1390_P21_18n I1390_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I117_XP_MP0 (VDD I1390_P21_20 I1390_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I115_XP_MP1 (I1390_P19_16n I1390_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I115_XP_MP0 (VDD I1390_P19_18 I1390_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I172_XP_MP1 (I1390_P21_6n I1390_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I172_XP_MP0 (VDD I1390_P21_14 I1390_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I17_MP1 (I1436_gn17 b19_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I17_MP0 (VDD p18_16 I1436_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I18_MP1 (I1436_gn18 b19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I18_MP0 (VDD p18_17 I1436_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I19_MP1 (I1436_gn19 b19_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I19_MP0 (VDD p18_18 I1436_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I116_XP_MP1 (I1436_P20_17n I1436_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I116_XP_MP0 (VDD I1436_P20_19 I1436_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I173_XP_MP1 (I1436_P22_7n I1436_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I173_XP_MP0 (VDD I1436_P22_15 I1436_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I115_XP_MP1 (I1436_P19_16n I1436_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I115_XP_MP0 (VDD I1436_P19_18 I1436_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I172_XP_MP1 (I1436_P21_6n I1436_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I172_XP_MP0 (VDD I1436_P21_14 I1436_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I18_MP1 (I1482_gn18 b20_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I18_MP0 (VDD p19_17 I1482_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I115_XP_MP1 (I1482_P19_16n I1482_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I115_XP_MP0 (VDD I1482_P19_18 I1482_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I170_XP_MP1 (I1482_P19_4n I1482_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I170_XP_MP0 (VDD I1482_P19_12 I1482_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I172_XP_MP1 (I1482_P21_6n I1482_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I172_XP_MP0 (VDD I1482_P21_14 I1482_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I116_XP_MP1 (I1482_P20_17n I1482_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I116_XP_MP0 (VDD I1482_P20_19 I1482_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I175_XP_MP1 (I1482_P24_9n I1482_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I175_XP_MP0 (VDD I1482_P24_17 I1482_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I177_XP_MP1 (I1482_P26_11n I1482_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I177_XP_MP0 (VDD I1482_P26_19 I1482_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I21_MP1 (I1528_gn21 b21_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I21_MP0 (VDD p20_20 I1528_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I122_XP_MP1 (I1528_P26_23n I1528_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I122_XP_MP0 (VDD I1528_P26_25 I1528_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I182_XP_MP1 (I1528_P31_16n I1528_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I182_XP_MP0 (VDD I1528_P31_24 I1528_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I121_XP_MP1 (I1528_P25_22n I1528_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I121_XP_MP0 (VDD I1528_P25_24 I1528_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I126_XP_MP1 (I1160_P30_27n I1160_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I126_XP_MP0 (VDD I1160_P30_29 I1160_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I26_MP1 (I1160_gn26 b13_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I26_MP0 (VDD p12_25 I1160_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I181_XP_MP1 (I1160_P30_15n I1160_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I181_XP_MP0 (VDD I1160_P30_23 I1160_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I173_XP_MP1 (I1160_P22_7n I1160_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I173_XP_MP0 (VDD I1160_P22_15 I1160_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I177_XP_MP1 (I1160_P26_11n I1160_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I177_XP_MP0 (VDD I1160_P26_19 I1160_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I169_XP_MP1 (I1160_P18_3n I1160_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I169_XP_MP0 (VDD I1160_P18_11 I1160_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I15_MP1 (I1206_gn15 b14_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I15_MP0 (VDD p13_14 I1206_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I111_XP_MP1 (I1206_P15_12n I1206_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I111_XP_MP0 (VDD I1206_P15_14 I1206_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I112_XP_MP1 (I1206_P16_13n I1206_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I112_XP_MP0 (VDD I1206_P16_15 I1206_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I169_XP_MP1 (I1206_P18_3n I1206_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I169_XP_MP0 (VDD I1206_P18_11 I1206_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I17_MP1 (I1252_gn17 b15_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I17_MP0 (VDD p14_16 I1252_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I19_MP1 (I1252_gn19 b15_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I19_MP0 (VDD p14_18 I1252_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I18_MP1 (I1252_gn18 b15_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I18_MP0 (VDD p14_17 I1252_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I173_XP_MP1 (I1252_P22_7n I1252_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I173_XP_MP0 (VDD I1252_P22_15 I1252_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I117_XP_MP1 (I1252_P21_18n I1252_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I117_XP_MP0 (VDD I1252_P21_20 I1252_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I115_XP_MP1 (I1252_P19_16n I1252_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I115_XP_MP0 (VDD I1252_P19_18 I1252_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I172_XP_MP1 (I1252_P21_6n I1252_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I172_XP_MP0 (VDD I1252_P21_14 I1252_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I19_MP1 (I1298_gn19 b16_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I19_MP0 (VDD p15_18 I1298_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I118_XP_MP1 (I1298_P22_19n I1298_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I118_XP_MP0 (VDD I1298_P22_21 I1298_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I117_XP_MP1 (I1298_P21_18n I1298_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I117_XP_MP0 (VDD I1298_P21_20 I1298_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I176_XP_MP1 (I1298_P25_10n I1298_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I176_XP_MP0 (VDD I1298_P25_18 I1298_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I179_XP_MP1 (I1344_P28_13n I1344_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I179_XP_MP0 (VDD I1344_P28_21 I1344_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I118_XP_MP1 (I1344_P22_19n I1344_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I118_XP_MP0 (VDD I1344_P22_21 I1344_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I19_MP1 (I1344_gn19 b17_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I19_MP0 (VDD p16_18 I1344_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I20_MP1 (I1344_gn20 b17_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I20_MP0 (VDD p16_19 I1344_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I117_XP_MP1 (I1344_P21_18n I1344_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I117_XP_MP0 (VDD I1344_P21_20 I1344_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I178_XP_MP1 (I1344_P27_12n I1344_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I178_XP_MP0 (VDD I1344_P27_20 I1344_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I20_MP1 (I1390_gn20 b18_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I20_MP0 (VDD p17_19 I1390_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I118_XP_MP1 (I1390_P22_19n I1390_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I118_XP_MP0 (VDD I1390_P22_21 I1390_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I179_XP_MP1 (I1390_P28_13n I1390_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I179_XP_MP0 (VDD I1390_P28_21 I1390_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I178_XP_MP1 (I1390_P27_12n I1390_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I178_XP_MP0 (VDD I1390_P27_20 I1390_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I20_MP1 (I1436_gn20 b19_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I20_MP0 (VDD p18_19 I1436_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I118_XP_MP1 (I1436_P22_19n I1436_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I118_XP_MP0 (VDD I1436_P22_21 I1436_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I117_XP_MP1 (I1436_P21_18n I1436_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I117_XP_MP0 (VDD I1436_P21_20 I1436_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I176_XP_MP1 (I1436_P25_10n I1436_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I176_XP_MP0 (VDD I1436_P25_18 I1436_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I20_MP1 (I1482_gn20 b20_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I20_MP0 (VDD p19_19 I1482_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I19_MP1 (I1482_gn19 b20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I19_MP0 (VDD p19_18 I1482_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I117_XP_MP1 (I1482_P21_18n I1482_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I117_XP_MP0 (VDD I1482_P21_20 I1482_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I118_XP_MP1 (I1482_P22_19n I1482_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I118_XP_MP0 (VDD I1482_P22_21 I1482_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I173_XP_MP1 (I1482_P22_7n I1482_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I173_XP_MP0 (VDD I1482_P22_15 I1482_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I22_MP1 (I1528_gn22 b21_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I22_MP0 (VDD p20_21 I1528_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I124_XP_MP1 (I1528_P28_25n I1528_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I124_XP_MP0 (VDD I1528_P28_27 I1528_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I123_XP_MP1 (I1528_P27_24n I1528_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I123_XP_MP0 (VDD I1528_P27_26 I1528_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1160_I27_MP1 (I1160_gn27 b13_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1160_I27_MP0 (VDD p12_26 I1160_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I18_MP1 (I1206_gn18 b14_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I18_MP0 (VDD p13_17 I1206_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I16_MP1 (I1206_gn16 b14_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I16_MP0 (VDD p13_15 I1206_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I113_XP_MP1 (I1206_P17_14n I1206_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I113_XP_MP0 (VDD I1206_P17_16 I1206_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I170_XP_MP1 (I1206_P19_4n I1206_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I170_XP_MP0 (VDD I1206_P19_12 I1206_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I114_XP_MP1 (I1206_P18_15n I1206_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I114_XP_MP0 (VDD I1206_P18_17 I1206_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I171_XP_MP1 (I1206_P20_5n I1206_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I171_XP_MP0 (VDD I1206_P20_13 I1206_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I20_MP1 (I1252_gn20 b15_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I20_MP0 (VDD p14_19 I1252_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I118_XP_MP1 (I1252_P22_19n I1252_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I118_XP_MP0 (VDD I1252_P22_21 I1252_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I179_XP_MP1 (I1252_P28_13n I1252_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I179_XP_MP0 (VDD I1252_P28_21 I1252_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I178_XP_MP1 (I1252_P27_12n I1252_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I178_XP_MP0 (VDD I1252_P27_20 I1252_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I21_MP1 (I1298_gn21 b16_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I21_MP0 (VDD p15_20 I1298_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I20_MP1 (I1298_gn20 b16_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I20_MP0 (VDD p15_19 I1298_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I120_XP_MP1 (I1298_P24_21n I1298_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I120_XP_MP0 (VDD I1298_P24_23 I1298_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I179_XP_MP1 (I1298_P28_13n I1298_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I179_XP_MP0 (VDD I1298_P28_21 I1298_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I181_XP_MP1 (I1298_P30_15n I1298_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I181_XP_MP0 (VDD I1298_P30_23 I1298_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I119_XP_MP1 (I1298_P23_20n I1298_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I119_XP_MP0 (VDD I1298_P23_22 I1298_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I174_XP_MP1 (I1298_P23_8n I1298_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I174_XP_MP0 (VDD I1298_P23_16 I1298_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I181_XP_MP1 (I1344_P30_15n I1344_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I181_XP_MP0 (VDD I1344_P30_23 I1344_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I120_XP_MP1 (I1344_P24_21n I1344_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I120_XP_MP0 (VDD I1344_P24_23 I1344_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I22_MP1 (I1344_gn22 b17_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I22_MP0 (VDD p16_21 I1344_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I21_MP1 (I1344_gn21 b17_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I21_MP0 (VDD p16_20 I1344_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I119_XP_MP1 (I1344_P23_20n I1344_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I119_XP_MP0 (VDD I1344_P23_22 I1344_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I174_XP_MP1 (I1344_P23_8n I1344_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I174_XP_MP0 (VDD I1344_P23_16 I1344_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I21_MP1 (I1390_gn21 b18_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I21_MP0 (VDD p17_20 I1390_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I120_XP_MP1 (I1390_P24_21n I1390_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I120_XP_MP0 (VDD I1390_P24_23 I1390_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I181_XP_MP1 (I1390_P30_15n I1390_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I181_XP_MP0 (VDD I1390_P30_23 I1390_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I119_XP_MP1 (I1390_P23_20n I1390_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I119_XP_MP0 (VDD I1390_P23_22 I1390_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I174_XP_MP1 (I1390_P23_8n I1390_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I174_XP_MP0 (VDD I1390_P23_16 I1390_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I21_MP1 (I1436_gn21 b19_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I21_MP0 (VDD p18_20 I1436_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I120_XP_MP1 (I1436_P24_21n I1436_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I120_XP_MP0 (VDD I1436_P24_23 I1436_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I179_XP_MP1 (I1436_P28_13n I1436_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I179_XP_MP0 (VDD I1436_P28_21 I1436_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I119_XP_MP1 (I1436_P23_20n I1436_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I119_XP_MP0 (VDD I1436_P23_22 I1436_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I174_XP_MP1 (I1436_P23_8n I1436_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I174_XP_MP0 (VDD I1436_P23_16 I1436_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I22_MP1 (I1482_gn22 b20_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I22_MP0 (VDD p19_21 I1482_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I21_MP1 (I1482_gn21 b20_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I21_MP0 (VDD p19_20 I1482_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I176_XP_MP1 (I1482_P25_10n I1482_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I176_XP_MP0 (VDD I1482_P25_18 I1482_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I120_XP_MP1 (I1482_P24_21n I1482_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I120_XP_MP0 (VDD I1482_P24_23 I1482_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I179_XP_MP1 (I1482_P28_13n I1482_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I179_XP_MP0 (VDD I1482_P28_21 I1482_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I181_XP_MP1 (I1482_P30_15n I1482_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I181_XP_MP0 (VDD I1482_P30_23 I1482_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I24_MP1 (I1528_gn24 b21_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I24_MP0 (VDD p20_23 I1528_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I23_MP1 (I1528_gn23 b21_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I23_MP0 (VDD p20_22 I1528_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I126_XP_MP1 (I1528_P30_27n I1528_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I126_XP_MP0 (VDD I1528_P30_29 I1528_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I127_XP_MP1 (I1528_P31_28n I1528_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I127_XP_MP0 (VDD I1528_P31_30 I1528_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I125_XP_MP1 (I1528_P29_26n I1528_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I125_XP_MP0 (VDD I1528_P29_28 I1528_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I22_MP1 (I1206_gn22 b14_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I22_MP0 (VDD p13_21 I1206_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I21_MP1 (I1206_gn21 b14_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I21_MP0 (VDD p13_20 I1206_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I20_MP1 (I1206_gn20 b14_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I20_MP0 (VDD p13_19 I1206_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I19_MP1 (I1206_gn19 b14_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I19_MP0 (VDD p13_18 I1206_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I117_XP_MP1 (I1206_P21_18n I1206_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I117_XP_MP0 (VDD I1206_P21_20 I1206_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I115_XP_MP1 (I1206_P19_16n I1206_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I115_XP_MP0 (VDD I1206_P19_18 I1206_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I172_XP_MP1 (I1206_P21_6n I1206_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I172_XP_MP0 (VDD I1206_P21_14 I1206_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I116_XP_MP1 (I1206_P20_17n I1206_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I116_XP_MP0 (VDD I1206_P20_19 I1206_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I175_XP_MP1 (I1206_P24_9n I1206_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I175_XP_MP0 (VDD I1206_P24_17 I1206_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I22_MP1 (I1252_gn22 b15_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I22_MP0 (VDD p14_21 I1252_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I21_MP1 (I1252_gn21 b15_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I21_MP0 (VDD p14_20 I1252_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I120_XP_MP1 (I1252_P24_21n I1252_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I120_XP_MP0 (VDD I1252_P24_23 I1252_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I119_XP_MP1 (I1252_P23_20n I1252_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I119_XP_MP0 (VDD I1252_P23_22 I1252_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I174_XP_MP1 (I1252_P23_8n I1252_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I174_XP_MP0 (VDD I1252_P23_16 I1252_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I23_MP1 (I1298_gn23 b16_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I23_MP0 (VDD p15_22 I1298_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I22_MP1 (I1298_gn22 b16_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I22_MP0 (VDD p15_21 I1298_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I122_XP_MP1 (I1298_P26_23n I1298_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I122_XP_MP0 (VDD I1298_P26_25 I1298_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I178_XP_MP1 (I1298_P27_12n I1298_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I178_XP_MP0 (VDD I1298_P27_20 I1298_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I122_XP_MP1 (I1344_P26_23n I1344_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I122_XP_MP0 (VDD I1344_P26_25 I1344_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I124_XP_MP1 (I1344_P28_25n I1344_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I124_XP_MP0 (VDD I1344_P28_27 I1344_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I23_MP1 (I1344_gn23 b17_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I23_MP0 (VDD p16_22 I1344_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I121_XP_MP1 (I1344_P25_22n I1344_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I121_XP_MP0 (VDD I1344_P25_24 I1344_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I180_XP_MP1 (I1344_P29_14n I1344_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I180_XP_MP0 (VDD I1344_P29_22 I1344_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I22_MP1 (I1390_gn22 b18_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I22_MP0 (VDD p17_21 I1390_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I23_MP1 (I1390_gn23 b18_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I23_MP0 (VDD p17_22 I1390_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I122_XP_MP1 (I1390_P26_23n I1390_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I122_XP_MP0 (VDD I1390_P26_25 I1390_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I121_XP_MP1 (I1390_P25_22n I1390_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I121_XP_MP0 (VDD I1390_P25_24 I1390_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I180_XP_MP1 (I1390_P29_14n I1390_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I180_XP_MP0 (VDD I1390_P29_22 I1390_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I23_MP1 (I1436_gn23 b19_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I23_MP0 (VDD p18_22 I1436_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I22_MP1 (I1436_gn22 b19_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I22_MP0 (VDD p18_21 I1436_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I122_XP_MP1 (I1436_P26_23n I1436_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I122_XP_MP0 (VDD I1436_P26_25 I1436_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I181_XP_MP1 (I1436_P30_15n I1436_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I181_XP_MP0 (VDD I1436_P30_23 I1436_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I180_XP_MP1 (I1436_P29_14n I1436_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I180_XP_MP0 (VDD I1436_P29_22 I1436_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I23_MP1 (I1482_gn23 b20_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I23_MP0 (VDD p19_22 I1482_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I174_XP_MP1 (I1482_P23_8n I1482_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I174_XP_MP0 (VDD I1482_P23_16 I1482_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I178_XP_MP1 (I1482_P27_12n I1482_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I178_XP_MP0 (VDD I1482_P27_20 I1482_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I180_XP_MP1 (I1482_P29_14n I1482_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I180_XP_MP0 (VDD I1482_P29_22 I1482_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I122_XP_MP1 (I1482_P26_23n I1482_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I122_XP_MP0 (VDD I1482_P26_25 I1482_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I25_MP1 (I1528_gn25 b21_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I25_MP0 (VDD p20_24 I1528_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I26_MP1 (I1528_gn26 b21_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I26_MP0 (VDD p20_25 I1528_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I27_MP1 (I1528_gn27 b21_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I27_MP0 (VDD p20_26 I1528_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I23_MP1 (I1206_gn23 b14_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I23_MP0 (VDD p13_22 I1206_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I24_MP1 (I1206_gn24 b14_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I24_MP0 (VDD p13_23 I1206_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I182_XP_MP1 (I1206_P31_16n I1206_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I182_XP_MP0 (VDD I1206_P31_24 I1206_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I119_XP_MP1 (I1206_P23_20n I1206_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I119_XP_MP0 (VDD I1206_P23_22 I1206_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I176_XP_MP1 (I1206_P25_10n I1206_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I176_XP_MP0 (VDD I1206_P25_18 I1206_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I120_XP_MP1 (I1206_P24_21n I1206_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I120_XP_MP0 (VDD I1206_P24_23 I1206_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I118_XP_MP1 (I1206_P22_19n I1206_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I118_XP_MP0 (VDD I1206_P22_21 I1206_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I173_XP_MP1 (I1206_P22_7n I1206_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I173_XP_MP0 (VDD I1206_P22_15 I1206_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I23_MP1 (I1252_gn23 b15_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I23_MP0 (VDD p14_22 I1252_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I122_XP_MP1 (I1252_P26_23n I1252_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I122_XP_MP0 (VDD I1252_P26_25 I1252_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I124_XP_MP1 (I1252_P28_25n I1252_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I124_XP_MP0 (VDD I1252_P28_27 I1252_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I181_XP_MP1 (I1252_P30_15n I1252_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I181_XP_MP0 (VDD I1252_P30_23 I1252_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I121_XP_MP1 (I1252_P25_22n I1252_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I121_XP_MP0 (VDD I1252_P25_24 I1252_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I180_XP_MP1 (I1252_P29_14n I1252_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I180_XP_MP0 (VDD I1252_P29_22 I1252_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I24_MP1 (I1298_gn24 b16_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I24_MP0 (VDD p15_23 I1298_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I124_XP_MP1 (I1298_P28_25n I1298_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I124_XP_MP0 (VDD I1298_P28_27 I1298_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I121_XP_MP1 (I1298_P25_22n I1298_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I121_XP_MP0 (VDD I1298_P25_24 I1298_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I123_XP_MP1 (I1298_P27_24n I1298_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I123_XP_MP0 (VDD I1298_P27_26 I1298_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I180_XP_MP1 (I1298_P29_14n I1298_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I180_XP_MP0 (VDD I1298_P29_22 I1298_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I126_XP_MP1 (I1344_P30_27n I1344_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I126_XP_MP0 (VDD I1344_P30_29 I1344_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I24_MP1 (I1344_gn24 b17_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I24_MP0 (VDD p16_23 I1344_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I123_XP_MP1 (I1344_P27_24n I1344_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I123_XP_MP0 (VDD I1344_P27_26 I1344_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I182_XP_MP1 (I1344_P31_16n I1344_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I182_XP_MP0 (VDD I1344_P31_24 I1344_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I24_MP1 (I1390_gn24 b18_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I24_MP0 (VDD p17_23 I1390_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I124_XP_MP1 (I1390_P28_25n I1390_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I124_XP_MP0 (VDD I1390_P28_27 I1390_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I123_XP_MP1 (I1390_P27_24n I1390_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I123_XP_MP0 (VDD I1390_P27_26 I1390_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I182_XP_MP1 (I1390_P31_16n I1390_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I182_XP_MP0 (VDD I1390_P31_24 I1390_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I24_MP1 (I1436_gn24 b19_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I24_MP0 (VDD p18_23 I1436_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I124_XP_MP1 (I1436_P28_25n I1436_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I124_XP_MP0 (VDD I1436_P28_27 I1436_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I126_XP_MP1 (I1436_P30_27n I1436_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I126_XP_MP0 (VDD I1436_P30_29 I1436_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I121_XP_MP1 (I1436_P25_22n I1436_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I121_XP_MP0 (VDD I1436_P25_24 I1436_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I178_XP_MP1 (I1436_P27_12n I1436_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I178_XP_MP0 (VDD I1436_P27_20 I1436_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I119_XP_MP1 (I1482_P23_20n I1482_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I119_XP_MP0 (VDD I1482_P23_22 I1482_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I121_XP_MP1 (I1482_P25_22n I1482_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I121_XP_MP0 (VDD I1482_P25_24 I1482_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I24_MP1 (I1482_gn24 b20_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I24_MP0 (VDD p19_23 I1482_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I25_MP1 (I1482_gn25 b20_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I25_MP0 (VDD p19_24 I1482_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I124_XP_MP1 (I1482_P28_25n I1482_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I124_XP_MP0 (VDD I1482_P28_27 I1482_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I126_XP_MP1 (I1482_P30_27n I1482_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I126_XP_MP0 (VDD I1482_P30_29 I1482_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I29_MP1 (I1528_gn29 b21_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I29_MP0 (VDD p20_28 I1528_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I28_MP1 (I1528_gn28 b21_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I28_MP0 (VDD p20_27 I1528_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I30_MP1 (I1206_gn30 b14_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I30_MP0 (VDD p13_29 I1206_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I25_MP1 (I1206_gn25 b14_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I25_MP0 (VDD p13_24 I1206_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I123_XP_MP1 (I1206_P27_24n I1206_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I123_XP_MP0 (VDD I1206_P27_26 I1206_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I121_XP_MP1 (I1206_P25_22n I1206_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I121_XP_MP0 (VDD I1206_P25_24 I1206_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I178_XP_MP1 (I1206_P27_12n I1206_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I178_XP_MP0 (VDD I1206_P27_20 I1206_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I174_XP_MP1 (I1206_P23_8n I1206_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I174_XP_MP0 (VDD I1206_P23_16 I1206_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I122_XP_MP1 (I1206_P26_23n I1206_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I122_XP_MP0 (VDD I1206_P26_25 I1206_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I177_XP_MP1 (I1206_P26_11n I1206_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I177_XP_MP0 (VDD I1206_P26_19 I1206_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I26_MP1 (I1252_gn26 b15_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I26_MP0 (VDD p14_25 I1252_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I25_MP1 (I1252_gn25 b15_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I25_MP0 (VDD p14_24 I1252_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I24_MP1 (I1252_gn24 b15_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I24_MP0 (VDD p14_23 I1252_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I123_XP_MP1 (I1252_P27_24n I1252_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I123_XP_MP0 (VDD I1252_P27_26 I1252_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I125_XP_MP1 (I1252_P29_26n I1252_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I125_XP_MP0 (VDD I1252_P29_28 I1252_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I182_XP_MP1 (I1252_P31_16n I1252_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I182_XP_MP0 (VDD I1252_P31_24 I1252_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I25_MP1 (I1298_gn25 b16_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I25_MP0 (VDD p15_24 I1298_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I26_MP1 (I1298_gn26 b16_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I26_MP0 (VDD p15_25 I1298_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I126_XP_MP1 (I1298_P30_27n I1298_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I126_XP_MP0 (VDD I1298_P30_29 I1298_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I125_XP_MP1 (I1298_P29_26n I1298_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I125_XP_MP0 (VDD I1298_P29_28 I1298_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I182_XP_MP1 (I1298_P31_16n I1298_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I182_XP_MP0 (VDD I1298_P31_24 I1298_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I26_MP1 (I1344_gn26 b17_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I26_MP0 (VDD p16_25 I1344_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I25_MP1 (I1344_gn25 b17_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I25_MP0 (VDD p16_24 I1344_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I125_XP_MP1 (I1344_P29_26n I1344_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I125_XP_MP0 (VDD I1344_P29_28 I1344_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I127_XP_MP1 (I1344_P31_28n I1344_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I127_XP_MP0 (VDD I1344_P31_30 I1344_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I25_MP1 (I1390_gn25 b18_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I25_MP0 (VDD p17_24 I1390_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I26_MP1 (I1390_gn26 b18_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I26_MP0 (VDD p17_25 I1390_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I126_XP_MP1 (I1390_P30_27n I1390_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I126_XP_MP0 (VDD I1390_P30_29 I1390_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I125_XP_MP1 (I1390_P29_26n I1390_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I125_XP_MP0 (VDD I1390_P29_28 I1390_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I127_XP_MP1 (I1390_P31_28n I1390_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I127_XP_MP0 (VDD I1390_P31_30 I1390_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I25_MP1 (I1436_gn25 b19_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I25_MP0 (VDD p18_24 I1436_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I27_MP1 (I1436_gn27 b19_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I27_MP0 (VDD p18_26 I1436_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I26_MP1 (I1436_gn26 b19_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I26_MP0 (VDD p18_25 I1436_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I123_XP_MP1 (I1436_P27_24n I1436_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I123_XP_MP0 (VDD I1436_P27_26 I1436_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I125_XP_MP1 (I1436_P29_26n I1436_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I125_XP_MP0 (VDD I1436_P29_28 I1436_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I182_XP_MP1 (I1436_P31_16n I1436_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I182_XP_MP0 (VDD I1436_P31_24 I1436_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I182_XP_MP1 (I1482_P31_16n I1482_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I182_XP_MP0 (VDD I1482_P31_24 I1482_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I123_XP_MP1 (I1482_P27_24n I1482_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I123_XP_MP0 (VDD I1482_P27_26 I1482_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I125_XP_MP1 (I1482_P29_26n I1482_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I125_XP_MP0 (VDD I1482_P29_28 I1482_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I26_MP1 (I1482_gn26 b20_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I26_MP0 (VDD p19_25 I1482_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I31_MP1 (I1528_gn31 b21_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I31_MP0 (VDD p20_30 I1528_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I30_MP1 (I1528_gn30 b21_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I30_MP0 (VDD p20_29 I1528_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I31_MP1 (I1206_gn31 b14_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I31_MP0 (VDD p13_30 I1206_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I27_MP1 (I1206_gn27 b14_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I27_MP0 (VDD p13_26 I1206_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I29_MP1 (I1206_gn29 b14_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I29_MP0 (VDD p13_28 I1206_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I26_MP1 (I1206_gn26 b14_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I26_MP0 (VDD p13_25 I1206_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I127_XP_MP1 (I1206_P31_28n I1206_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I127_XP_MP0 (VDD I1206_P31_30 I1206_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I125_XP_MP1 (I1206_P29_26n I1206_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I125_XP_MP0 (VDD I1206_P29_28 I1206_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I180_XP_MP1 (I1206_P29_14n I1206_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I180_XP_MP0 (VDD I1206_P29_22 I1206_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I124_XP_MP1 (I1206_P28_25n I1206_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I124_XP_MP0 (VDD I1206_P28_27 I1206_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I181_XP_MP1 (I1206_P30_15n I1206_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I181_XP_MP0 (VDD I1206_P30_23 I1206_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I179_XP_MP1 (I1206_P28_13n I1206_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I179_XP_MP0 (VDD I1206_P28_21 I1206_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I27_MP1 (I1252_gn27 b15_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I27_MP0 (VDD p14_26 I1252_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I126_XP_MP1 (I1252_P30_27n I1252_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I126_XP_MP0 (VDD I1252_P30_29 I1252_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I127_XP_MP1 (I1252_P31_28n I1252_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I127_XP_MP0 (VDD I1252_P31_30 I1252_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I27_MP1 (I1298_gn27 b16_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I27_MP0 (VDD p15_26 I1298_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I29_MP1 (I1298_gn29 b16_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I29_MP0 (VDD p15_28 I1298_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I28_MP1 (I1298_gn28 b16_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I28_MP0 (VDD p15_27 I1298_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I127_XP_MP1 (I1298_P31_28n I1298_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I127_XP_MP0 (VDD I1298_P31_30 I1298_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I27_MP1 (I1344_gn27 b17_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I27_MP0 (VDD p16_26 I1344_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I28_MP1 (I1344_gn28 b17_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I28_MP0 (VDD p16_27 I1344_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I29_MP1 (I1344_gn29 b17_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I29_MP0 (VDD p16_28 I1344_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I27_MP1 (I1390_gn27 b18_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I27_MP0 (VDD p17_26 I1390_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I28_MP1 (I1390_gn28 b18_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I28_MP0 (VDD p17_27 I1390_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I29_MP1 (I1390_gn29 b18_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I29_MP0 (VDD p17_28 I1390_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I28_MP1 (I1436_gn28 b19_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I28_MP0 (VDD p18_27 I1436_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I29_MP1 (I1436_gn29 b19_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I29_MP0 (VDD p18_28 I1436_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I127_XP_MP1 (I1436_P31_28n I1436_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I127_XP_MP0 (VDD I1436_P31_30 I1436_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I31_MP1 (I1482_gn31 b20_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I31_MP0 (VDD p19_30 I1482_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I127_XP_MP1 (I1482_P31_28n I1482_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I127_XP_MP0 (VDD I1482_P31_30 I1482_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I27_MP1 (I1482_gn27 b20_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I27_MP0 (VDD p19_26 I1482_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I28_MP1 (I1206_gn28 b14_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I28_MP0 (VDD p13_27 I1206_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1206_I126_XP_MP1 (I1206_P30_27n I1206_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1206_I126_XP_MP0 (VDD I1206_P30_29 I1206_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I29_MP1 (I1252_gn29 b15_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I29_MP0 (VDD p14_28 I1252_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I28_MP1 (I1252_gn28 b15_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I28_MP0 (VDD p14_27 I1252_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I30_MP1 (I1252_gn30 b15_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I30_MP0 (VDD p14_29 I1252_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1252_I31_MP1 (I1252_gn31 b15_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1252_I31_MP0 (VDD p14_30 I1252_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I31_MP1 (I1298_gn31 b16_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I31_MP0 (VDD p15_30 I1298_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1298_I30_MP1 (I1298_gn30 b16_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1298_I30_MP0 (VDD p15_29 I1298_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I30_MP1 (I1344_gn30 b17_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I30_MP0 (VDD p16_29 I1344_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1344_I31_MP1 (I1344_gn31 b17_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1344_I31_MP0 (VDD p16_30 I1344_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I30_MP1 (I1390_gn30 b18_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I30_MP0 (VDD p17_29 I1390_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1390_I31_MP1 (I1390_gn31 b18_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1390_I31_MP0 (VDD p17_30 I1390_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I30_MP1 (I1436_gn30 b19_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I30_MP0 (VDD p18_29 I1436_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1436_I31_MP1 (I1436_gn31 b19_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1436_I31_MP0 (VDD p18_30 I1436_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I30_MP1 (I1482_gn30 b20_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I30_MP0 (VDD p19_29 I1482_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I29_MP1 (I1482_gn29 b20_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I29_MP0 (VDD p19_28 I1482_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1482_I28_MP1 (I1482_gn28 b20_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1482_I28_MP0 (VDD p19_27 I1482_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I97_XP_MP0 (XI654_I97_XP_p1 I654_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I97_XP_MP1 (I654_P31_30 I654_pn30 XI654_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I97_XP_MP0 (XI1942_I97_XP_p1 I1942_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I97_XP_MP1 (I1942_P31_30 I1942_pn30 XI1942_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I95_XP_MP0 (XI654_I95_XP_p1 I654_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I95_XP_MP1 (I654_P29_28 I654_pn28 XI654_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I96_XP_MP0 (XI654_I96_XP_p1 I654_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I96_XP_MP1 (I654_P30_29 I654_pn29 XI654_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I97_XP_MP0 (XI608_I97_XP_p1 I608_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I97_XP_MP1 (I608_P31_30 I608_pn30 XI608_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I96_XP_MP0 (XI608_I96_XP_p1 I608_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I96_XP_MP1 (I608_P30_29 I608_pn29 XI608_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I97_XP_MP0 (XI562_I97_XP_p1 I562_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I97_XP_MP1 (I562_P31_30 I562_pn30 XI562_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I97_XP_MP0 (XI2066_I97_XP_p1 I2066_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I97_XP_MP1 (I2066_P31_30 I2066_pn30 XI2066_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I96_XP_MP0 (XI1988_I96_XP_p1 I1988_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I96_XP_MP1 (I1988_P30_29 I1988_pn29 XI1988_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I97_XP_MP0 (XI1988_I97_XP_p1 I1988_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I97_XP_MP1 (I1988_P31_30 I1988_pn30 XI1988_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I95_XP_MP0 (XI1988_I95_XP_p1 I1988_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I95_XP_MP1 (I1988_P29_28 I1988_pn28 XI1988_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I96_XP_MP0 (XI1942_I96_XP_p1 I1942_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I96_XP_MP1 (I1942_P30_29 I1942_pn29 XI1942_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I94_XP_MP0 (XI1942_I94_XP_p1 I1942_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I94_XP_MP1 (I1942_P28_27 I1942_pn27 XI1942_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I95_XP_MP0 (XI1942_I95_XP_p1 I1942_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I95_XP_MP1 (I1942_P29_28 I1942_pn28 XI1942_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I155_XP_MP0 (XI1896_I155_XP_p1 I1896_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I155_XP_MP1 (I1896_P30_23 I1896_P26_23n XI1896_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I96_XP_MP0 (XI1896_I96_XP_p1 I1896_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I96_XP_MP1 (I1896_P30_29 I1896_pn29 XI1896_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I94_XP_MP0 (XI1896_I94_XP_p1 I1896_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I94_XP_MP1 (I1896_P28_27 I1896_pn27 XI1896_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I156_XP_MP0 (XI654_I156_XP_p1 I654_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I156_XP_MP1 (I654_P31_24 I654_P27_24n XI654_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I93_XP_MP0 (XI654_I93_XP_p1 I654_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I93_XP_MP1 (I654_P27_26 I654_pn26 XI654_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I94_XP_MP0 (XI654_I94_XP_p1 I654_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I94_XP_MP1 (I654_P28_27 I654_pn27 XI654_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I156_XP_MP0 (XI608_I156_XP_p1 I608_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I156_XP_MP1 (I608_P31_24 I608_P27_24n XI608_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I95_XP_MP0 (XI608_I95_XP_p1 I608_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I95_XP_MP1 (I608_P29_28 I608_pn28 XI608_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I93_XP_MP0 (XI608_I93_XP_p1 I608_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I93_XP_MP1 (I608_P27_26 I608_pn26 XI608_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I94_XP_MP0 (XI608_I94_XP_p1 I608_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I94_XP_MP1 (I608_P28_27 I608_pn27 XI608_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I92_XP_MP0 (XI608_I92_XP_p1 I608_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I92_XP_MP1 (I608_P26_25 I608_pn25 XI608_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I96_XP_MP0 (XI562_I96_XP_p1 I562_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I96_XP_MP1 (I562_P30_29 I562_pn29 XI562_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I94_XP_MP0 (XI562_I94_XP_p1 I562_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I94_XP_MP1 (I562_P28_27 I562_pn27 XI562_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I95_XP_MP0 (XI562_I95_XP_p1 I562_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I95_XP_MP1 (I562_P29_28 I562_pn28 XI562_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I93_XP_MP0 (XI2066_I93_XP_p1 I2066_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I93_XP_MP1 (I2066_P27_26 I2066_pn26 XI2066_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I95_XP_MP0 (XI2066_I95_XP_p1 I2066_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I95_XP_MP1 (I2066_P29_28 I2066_pn28 XI2066_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I94_XP_MP0 (XI2066_I94_XP_p1 I2066_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I94_XP_MP1 (I2066_P28_27 I2066_pn27 XI2066_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I96_XP_MP0 (XI2066_I96_XP_p1 I2066_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I96_XP_MP1 (I2066_P30_29 I2066_pn29 XI2066_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I94_XP_MP0 (XI1988_I94_XP_p1 I1988_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I94_XP_MP1 (I1988_P28_27 I1988_pn27 XI1988_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I93_XP_MP0 (XI1988_I93_XP_p1 I1988_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I93_XP_MP1 (I1988_P27_26 I1988_pn26 XI1988_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I155_XP_MP0 (XI1942_I155_XP_p1 I1942_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I155_XP_MP1 (I1942_P30_23 I1942_P26_23n XI1942_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I92_XP_MP0 (XI1942_I92_XP_p1 I1942_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I92_XP_MP1 (I1942_P26_25 I1942_pn25 XI1942_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I156_XP_MP0 (XI1942_I156_XP_p1 I1942_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I156_XP_MP1 (I1942_P31_24 I1942_P27_24n XI1942_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I93_XP_MP0 (XI1942_I93_XP_p1 I1942_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I93_XP_MP1 (I1942_P27_26 I1942_pn26 XI1942_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I151_XP_MP0 (XI1896_I151_XP_p1 I1896_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I151_XP_MP1 (I1896_P26_19 I1896_P22_19n XI1896_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I153_XP_MP0 (XI1896_I153_XP_p1 I1896_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I153_XP_MP1 (I1896_P28_21 I1896_P24_21n XI1896_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I92_XP_MP0 (XI1896_I92_XP_p1 I1896_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I92_XP_MP1 (I1896_P26_25 I1896_pn25 XI1896_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I93_XP_MP0 (XI1896_I93_XP_p1 I1896_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I93_XP_MP1 (I1896_P27_26 I1896_pn26 XI1896_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I95_XP_MP0 (XI1896_I95_XP_p1 I1896_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I95_XP_MP1 (I1896_P29_28 I1896_pn28 XI1896_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I152_XP_MP0 (XI654_I152_XP_p1 I654_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I152_XP_MP1 (I654_P27_20 I654_P23_20n XI654_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I91_XP_MP0 (XI654_I91_XP_p1 I654_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I91_XP_MP1 (I654_P25_24 I654_pn24 XI654_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I155_XP_MP0 (XI654_I155_XP_p1 I654_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I155_XP_MP1 (I654_P30_23 I654_P26_23n XI654_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I92_XP_MP0 (XI654_I92_XP_p1 I654_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I92_XP_MP1 (I654_P26_25 I654_pn25 XI654_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I152_XP_MP0 (XI608_I152_XP_p1 I608_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I152_XP_MP1 (I608_P27_20 I608_P23_20n XI608_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I91_XP_MP0 (XI608_I91_XP_p1 I608_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I91_XP_MP1 (I608_P25_24 I608_pn24 XI608_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I155_XP_MP0 (XI608_I155_XP_p1 I608_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I155_XP_MP1 (I608_P30_23 I608_P26_23n XI608_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I90_XP_MP0 (XI608_I90_XP_p1 I608_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I90_XP_MP1 (I608_P24_23 I608_pn23 XI608_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I92_XP_MP0 (XI562_I92_XP_p1 I562_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I92_XP_MP1 (I562_P26_25 I562_pn25 XI562_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I93_XP_MP0 (XI562_I93_XP_p1 I562_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I93_XP_MP1 (I562_P27_26 I562_pn26 XI562_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I156_XP_MP0 (XI2066_I156_XP_p1 I2066_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I156_XP_MP1 (I2066_P31_24 I2066_P27_24n XI2066_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I91_XP_MP0 (XI2066_I91_XP_p1 I2066_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I91_XP_MP1 (I2066_P25_24 I2066_pn24 XI2066_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I92_XP_MP0 (XI2066_I92_XP_p1 I2066_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I92_XP_MP1 (I2066_P26_25 I2066_pn25 XI2066_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I92_XP_MP0 (XI1988_I92_XP_p1 I1988_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I92_XP_MP1 (I1988_P26_25 I1988_pn25 XI1988_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I156_XP_MP0 (XI1988_I156_XP_p1 I1988_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I156_XP_MP1 (I1988_P31_24 I1988_P27_24n XI1988_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I91_XP_MP0 (XI1988_I91_XP_p1 I1988_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I91_XP_MP1 (I1988_P25_24 I1988_pn24 XI1988_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I153_XP_MP0 (XI1942_I153_XP_p1 I1942_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I153_XP_MP1 (I1942_P28_21 I1942_P24_21n XI1942_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I90_XP_MP0 (XI1942_I90_XP_p1 I1942_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I90_XP_MP1 (I1942_P24_23 I1942_pn23 XI1942_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I154_XP_MP0 (XI1942_I154_XP_p1 I1942_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I154_XP_MP1 (I1942_P29_22 I1942_P25_22n XI1942_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I89_XP_MP0 (XI1942_I89_XP_p1 I1942_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I89_XP_MP1 (I1942_P23_22 I1942_pn22 XI1942_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I91_XP_MP0 (XI1942_I91_XP_p1 I1942_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I91_XP_MP1 (I1942_P25_24 I1942_pn24 XI1942_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I147_XP_MP0 (XI1896_I147_XP_p1 I1896_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I147_XP_MP1 (I1896_P22_15 I1896_P18_15n XI1896_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I149_XP_MP0 (XI1896_I149_XP_p1 I1896_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I149_XP_MP1 (I1896_P24_17 I1896_P20_17n XI1896_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I90_XP_MP0 (XI1896_I90_XP_p1 I1896_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I90_XP_MP1 (I1896_P24_23 I1896_pn23 XI1896_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I154_XP_MP0 (XI1896_I154_XP_p1 I1896_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I154_XP_MP1 (I1896_P29_22 I1896_P25_22n XI1896_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I91_XP_MP0 (XI1896_I91_XP_p1 I1896_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I91_XP_MP1 (I1896_P25_24 I1896_pn24 XI1896_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I97_XP_MP0 (XI1896_I97_XP_p1 I1896_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I97_XP_MP1 (I1896_P31_30 I1896_pn30 XI1896_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I148_XP_MP0 (XI654_I148_XP_p1 I654_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I148_XP_MP1 (I654_P23_16 I654_P19_16n XI654_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I154_XP_MP0 (XI654_I154_XP_p1 I654_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I154_XP_MP1 (I654_P29_22 I654_P25_22n XI654_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I89_XP_MP0 (XI654_I89_XP_p1 I654_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I89_XP_MP1 (I654_P23_22 I654_pn22 XI654_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I153_XP_MP0 (XI654_I153_XP_p1 I654_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I153_XP_MP1 (I654_P28_21 I654_P24_21n XI654_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I90_XP_MP0 (XI654_I90_XP_p1 I654_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I90_XP_MP1 (I654_P24_23 I654_pn23 XI654_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I148_XP_MP0 (XI608_I148_XP_p1 I608_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I148_XP_MP1 (I608_P23_16 I608_P19_16n XI608_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I154_XP_MP0 (XI608_I154_XP_p1 I608_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I154_XP_MP1 (I608_P29_22 I608_P25_22n XI608_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I89_XP_MP0 (XI608_I89_XP_p1 I608_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I89_XP_MP1 (I608_P23_22 I608_pn22 XI608_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I153_XP_MP0 (XI608_I153_XP_p1 I608_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I153_XP_MP1 (I608_P28_21 I608_P24_21n XI608_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I89_XP_MP0 (XI562_I89_XP_p1 I562_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I89_XP_MP1 (I562_P23_22 I562_pn22 XI562_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I90_XP_MP0 (XI562_I90_XP_p1 I562_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I90_XP_MP1 (I562_P24_23 I562_pn23 XI562_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I155_XP_MP0 (XI562_I155_XP_p1 I562_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I155_XP_MP1 (I562_P30_23 I562_P26_23n XI562_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I91_XP_MP0 (XI562_I91_XP_p1 I562_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I91_XP_MP1 (I562_P25_24 I562_pn24 XI562_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I154_XP_MP0 (XI562_I154_XP_p1 I562_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I154_XP_MP1 (I562_P29_22 I562_P25_22n XI562_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I156_XP_MP0 (XI562_I156_XP_p1 I562_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I156_XP_MP1 (I562_P31_24 I562_P27_24n XI562_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I154_XP_MP0 (XI2066_I154_XP_p1 I2066_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I154_XP_MP1 (I2066_P29_22 I2066_P25_22n XI2066_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I90_XP_MP0 (XI2066_I90_XP_p1 I2066_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I90_XP_MP1 (I2066_P24_23 I2066_pn23 XI2066_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I155_XP_MP0 (XI2066_I155_XP_p1 I2066_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I155_XP_MP1 (I2066_P30_23 I2066_P26_23n XI2066_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I155_XP_MP0 (XI1988_I155_XP_p1 I1988_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I155_XP_MP1 (I1988_P30_23 I1988_P26_23n XI1988_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I90_XP_MP0 (XI1988_I90_XP_p1 I1988_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I90_XP_MP1 (I1988_P24_23 I1988_pn23 XI1988_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I154_XP_MP0 (XI1988_I154_XP_p1 I1988_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I154_XP_MP1 (I1988_P29_22 I1988_P25_22n XI1988_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I89_XP_MP0 (XI1988_I89_XP_p1 I1988_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I89_XP_MP1 (I1988_P23_22 I1988_pn22 XI1988_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I151_XP_MP0 (XI1942_I151_XP_p1 I1942_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I151_XP_MP1 (I1942_P26_19 I1942_P22_19n XI1942_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I152_XP_MP0 (XI1942_I152_XP_p1 I1942_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I152_XP_MP1 (I1942_P27_20 I1942_P23_20n XI1942_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I145_XP_MP0 (XI1896_I145_XP_p1 I1896_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I145_XP_MP1 (I1896_P20_13 I1896_P16_13n XI1896_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I88_XP_MP0 (XI1896_I88_XP_p1 I1896_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I88_XP_MP1 (I1896_P22_21 I1896_pn21 XI1896_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I150_XP_MP0 (XI1896_I150_XP_p1 I1896_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I150_XP_MP1 (I1896_P25_18 I1896_P21_18n XI1896_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I89_XP_MP0 (XI1896_I89_XP_p1 I1896_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I89_XP_MP1 (I1896_P23_22 I1896_pn22 XI1896_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I150_XP_MP0 (XI654_I150_XP_p1 I654_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I150_XP_MP1 (I654_P25_18 I654_P21_18n XI654_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I87_XP_MP0 (XI654_I87_XP_p1 I654_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I87_XP_MP1 (I654_P21_20 I654_pn20 XI654_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I147_XP_MP0 (XI654_I147_XP_p1 I654_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I147_XP_MP1 (I654_P22_15 I654_P18_15n XI654_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I151_XP_MP0 (XI654_I151_XP_p1 I654_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I151_XP_MP1 (I654_P26_19 I654_P22_19n XI654_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I88_XP_MP0 (XI654_I88_XP_p1 I654_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I88_XP_MP1 (I654_P22_21 I654_pn21 XI654_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I87_XP_MP0 (XI608_I87_XP_p1 I608_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I87_XP_MP1 (I608_P21_20 I608_pn20 XI608_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I151_XP_MP0 (XI608_I151_XP_p1 I608_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I151_XP_MP1 (I608_P26_19 I608_P22_19n XI608_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I88_XP_MP0 (XI608_I88_XP_p1 I608_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I88_XP_MP1 (I608_P22_21 I608_pn21 XI608_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I88_XP_MP0 (XI562_I88_XP_p1 I562_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I88_XP_MP1 (I562_P22_21 I562_pn21 XI562_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I87_XP_MP0 (XI562_I87_XP_p1 I562_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I87_XP_MP1 (I562_P21_20 I562_pn20 XI562_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I148_XP_MP0 (XI2066_I148_XP_p1 I2066_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I148_XP_MP1 (I2066_P23_16 I2066_P19_16n XI2066_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I152_XP_MP0 (XI2066_I152_XP_p1 I2066_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I152_XP_MP1 (I2066_P27_20 I2066_P23_20n XI2066_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I87_XP_MP0 (XI2066_I87_XP_p1 I2066_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I87_XP_MP1 (I2066_P21_20 I2066_pn20 XI2066_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I89_XP_MP0 (XI2066_I89_XP_p1 I2066_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I89_XP_MP1 (I2066_P23_22 I2066_pn22 XI2066_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I88_XP_MP0 (XI2066_I88_XP_p1 I2066_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I88_XP_MP1 (I2066_P22_21 I2066_pn21 XI2066_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I153_XP_MP0 (XI1988_I153_XP_p1 I1988_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I153_XP_MP1 (I1988_P28_21 I1988_P24_21n XI1988_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I88_XP_MP0 (XI1988_I88_XP_p1 I1988_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I88_XP_MP1 (I1988_P22_21 I1988_pn21 XI1988_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I87_XP_MP0 (XI1988_I87_XP_p1 I1988_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I87_XP_MP1 (I1988_P21_20 I1988_pn20 XI1988_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I147_XP_MP0 (XI1942_I147_XP_p1 I1942_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I147_XP_MP1 (I1942_P22_15 I1942_P18_15n XI1942_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I86_XP_MP0 (XI1942_I86_XP_p1 I1942_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I86_XP_MP1 (I1942_P20_19 I1942_pn19 XI1942_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I88_XP_MP0 (XI1942_I88_XP_p1 I1942_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I88_XP_MP1 (I1942_P22_21 I1942_pn21 XI1942_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I148_XP_MP0 (XI1942_I148_XP_p1 I1942_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I148_XP_MP1 (I1942_P23_16 I1942_P19_16n XI1942_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I150_XP_MP0 (XI1942_I150_XP_p1 I1942_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I150_XP_MP1 (I1942_P25_18 I1942_P21_18n XI1942_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I87_XP_MP0 (XI1942_I87_XP_p1 I1942_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I87_XP_MP1 (I1942_P21_20 I1942_pn20 XI1942_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I143_XP_MP0 (XI1896_I143_XP_p1 I1896_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I143_XP_MP1 (I1896_P18_11 I1896_P14_11n XI1896_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I85_XP_MP0 (XI1896_I85_XP_p1 I1896_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I85_XP_MP1 (I1896_P19_18 I1896_pn18 XI1896_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I146_XP_MP0 (XI1896_I146_XP_p1 I1896_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I146_XP_MP1 (I1896_P21_14 I1896_P17_14n XI1896_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I86_XP_MP0 (XI1896_I86_XP_p1 I1896_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I86_XP_MP1 (I1896_P20_19 I1896_pn19 XI1896_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I87_XP_MP0 (XI1896_I87_XP_p1 I1896_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I87_XP_MP1 (I1896_P21_20 I1896_pn20 XI1896_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I97_XP_MP0 (XI700_I97_XP_p1 I700_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I97_XP_MP1 (I700_P31_30 I700_pn30 XI700_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I144_XP_MP0 (XI654_I144_XP_p1 I654_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I144_XP_MP1 (I654_P19_12 I654_P15_12n XI654_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I146_XP_MP0 (XI654_I146_XP_p1 I654_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I146_XP_MP1 (I654_P21_14 I654_P17_14n XI654_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I85_XP_MP0 (XI654_I85_XP_p1 I654_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I85_XP_MP1 (I654_P19_18 I654_pn18 XI654_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I149_XP_MP0 (XI654_I149_XP_p1 I654_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I149_XP_MP1 (I654_P24_17 I654_P20_17n XI654_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I86_XP_MP0 (XI654_I86_XP_p1 I654_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I86_XP_MP1 (I654_P20_19 I654_pn19 XI654_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I146_XP_MP0 (XI608_I146_XP_p1 I608_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I146_XP_MP1 (I608_P21_14 I608_P17_14n XI608_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I150_XP_MP0 (XI608_I150_XP_p1 I608_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I150_XP_MP1 (I608_P25_18 I608_P21_18n XI608_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I85_XP_MP0 (XI608_I85_XP_p1 I608_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I85_XP_MP1 (I608_P19_18 I608_pn18 XI608_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I147_XP_MP0 (XI608_I147_XP_p1 I608_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I147_XP_MP1 (I608_P22_15 I608_P18_15n XI608_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I86_XP_MP0 (XI608_I86_XP_p1 I608_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I86_XP_MP1 (I608_P20_19 I608_pn19 XI608_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I86_XP_MP0 (XI562_I86_XP_p1 I562_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I86_XP_MP1 (I562_P20_19 I562_pn19 XI562_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I153_XP_MP0 (XI562_I153_XP_p1 I562_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I153_XP_MP1 (I562_P28_21 I562_P24_21n XI562_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I151_XP_MP0 (XI562_I151_XP_p1 I562_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I151_XP_MP1 (I562_P26_19 I562_P22_19n XI562_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I147_XP_MP0 (XI562_I147_XP_p1 I562_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I147_XP_MP1 (I562_P22_15 I562_P18_15n XI562_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I146_XP_MP0 (XI562_I146_XP_p1 I562_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I146_XP_MP1 (I562_P21_14 I562_P17_14n XI562_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I150_XP_MP0 (XI562_I150_XP_p1 I562_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I150_XP_MP1 (I562_P25_18 I562_P21_18n XI562_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I152_XP_MP0 (XI562_I152_XP_p1 I562_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I152_XP_MP1 (I562_P27_20 I562_P23_20n XI562_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I148_XP_MP0 (XI562_I148_XP_p1 I562_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I148_XP_MP1 (I562_P23_16 I562_P19_16n XI562_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I146_XP_MP0 (XI2066_I146_XP_p1 I2066_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I146_XP_MP1 (I2066_P21_14 I2066_P17_14n XI2066_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I150_XP_MP0 (XI2066_I150_XP_p1 I2066_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I150_XP_MP1 (I2066_P25_18 I2066_P21_18n XI2066_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I85_XP_MP0 (XI2066_I85_XP_p1 I2066_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I85_XP_MP1 (I2066_P19_18 I2066_pn18 XI2066_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I147_XP_MP0 (XI2066_I147_XP_p1 I2066_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I147_XP_MP1 (I2066_P22_15 I2066_P18_15n XI2066_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I151_XP_MP0 (XI2066_I151_XP_p1 I2066_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I151_XP_MP1 (I2066_P26_19 I2066_P22_19n XI2066_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I153_XP_MP0 (XI2066_I153_XP_p1 I2066_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I153_XP_MP1 (I2066_P28_21 I2066_P24_21n XI2066_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I86_XP_MP0 (XI2066_I86_XP_p1 I2066_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I86_XP_MP1 (I2066_P20_19 I2066_pn19 XI2066_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I147_XP_MP0 (XI1988_I147_XP_p1 I1988_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I147_XP_MP1 (I1988_P22_15 I1988_P18_15n XI1988_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I151_XP_MP0 (XI1988_I151_XP_p1 I1988_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I151_XP_MP1 (I1988_P26_19 I1988_P22_19n XI1988_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I86_XP_MP0 (XI1988_I86_XP_p1 I1988_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I86_XP_MP1 (I1988_P20_19 I1988_pn19 XI1988_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I148_XP_MP0 (XI1988_I148_XP_p1 I1988_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I148_XP_MP1 (I1988_P23_16 I1988_P19_16n XI1988_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I152_XP_MP0 (XI1988_I152_XP_p1 I1988_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I152_XP_MP1 (I1988_P27_20 I1988_P23_20n XI1988_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I149_XP_MP0 (XI1942_I149_XP_p1 I1942_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I149_XP_MP1 (I1942_P24_17 I1942_P20_17n XI1942_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I144_XP_MP0 (XI1942_I144_XP_p1 I1942_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I144_XP_MP1 (I1942_P19_12 I1942_P15_12n XI1942_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I146_XP_MP0 (XI1942_I146_XP_p1 I1942_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I146_XP_MP1 (I1942_P21_14 I1942_P17_14n XI1942_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I85_XP_MP0 (XI1942_I85_XP_p1 I1942_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I85_XP_MP1 (I1942_P19_18 I1942_pn18 XI1942_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I135_XP_MP0 (XI1896_I135_XP_p1 I1896_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I135_XP_MP1 (I1896_P10_3 I1896_P6_3n XI1896_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I137_XP_MP0 (XI1896_I137_XP_p1 I1896_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I137_XP_MP1 (I1896_P12_5 I1896_P8_5n XI1896_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I141_XP_MP0 (XI1896_I141_XP_p1 I1896_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I141_XP_MP1 (I1896_P16_9 I1896_P12_9n XI1896_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I139_XP_MP0 (XI1896_I139_XP_p1 I1896_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I139_XP_MP1 (I1896_P14_7 I1896_P10_7n XI1896_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I84_XP_MP0 (XI1896_I84_XP_p1 I1896_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I84_XP_MP1 (I1896_P18_17 I1896_pn17 XI1896_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I152_XP_MP0 (XI1896_I152_XP_p1 I1896_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I152_XP_MP1 (I1896_P27_20 I1896_P23_20n XI1896_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I156_XP_MP0 (XI1896_I156_XP_p1 I1896_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I156_XP_MP1 (I1896_P31_24 I1896_P27_24n XI1896_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I95_XP_MP0 (XI700_I95_XP_p1 I700_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I95_XP_MP1 (I700_P29_28 I700_pn28 XI700_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I156_XP_MP0 (XI700_I156_XP_p1 I700_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I156_XP_MP1 (I700_P31_24 I700_P27_24n XI700_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I93_XP_MP0 (XI700_I93_XP_p1 I700_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I93_XP_MP1 (I700_P27_26 I700_pn26 XI700_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I91_XP_MP0 (XI700_I91_XP_p1 I700_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I91_XP_MP1 (I700_P25_24 I700_pn24 XI700_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I140_XP_MP0 (XI654_I140_XP_p1 I654_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I140_XP_MP1 (I654_P15_8 I654_P11_8n XI654_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I136_XP_MP0 (XI654_I136_XP_p1 I654_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I136_XP_MP1 (I654_P11_4 I654_P7_4n XI654_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I83_XP_MP0 (XI654_I83_XP_p1 I654_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I83_XP_MP1 (I654_P17_16 I654_pn16 XI654_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I145_XP_MP0 (XI654_I145_XP_p1 I654_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I145_XP_MP1 (I654_P20_13 I654_P16_13n XI654_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I84_XP_MP0 (XI654_I84_XP_p1 I654_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I84_XP_MP1 (I654_P18_17 I654_pn17 XI654_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I140_XP_MP0 (XI608_I140_XP_p1 I608_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I140_XP_MP1 (I608_P15_8 I608_P11_8n XI608_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I144_XP_MP0 (XI608_I144_XP_p1 I608_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I144_XP_MP1 (I608_P19_12 I608_P15_12n XI608_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I83_XP_MP0 (XI608_I83_XP_p1 I608_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I83_XP_MP1 (I608_P17_16 I608_pn16 XI608_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I149_XP_MP0 (XI608_I149_XP_p1 I608_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I149_XP_MP1 (I608_P24_17 I608_P20_17n XI608_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I145_XP_MP0 (XI608_I145_XP_p1 I608_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I145_XP_MP1 (I608_P20_13 I608_P16_13n XI608_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I84_XP_MP0 (XI608_I84_XP_p1 I608_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I84_XP_MP1 (I608_P18_17 I608_pn17 XI608_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I85_XP_MP0 (XI562_I85_XP_p1 I562_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I85_XP_MP1 (I562_P19_18 I562_pn18 XI562_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I144_XP_MP0 (XI562_I144_XP_p1 I562_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I144_XP_MP1 (I562_P19_12 I562_P15_12n XI562_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I140_XP_MP0 (XI2066_I140_XP_p1 I2066_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I140_XP_MP1 (I2066_P15_8 I2066_P11_8n XI2066_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I144_XP_MP0 (XI2066_I144_XP_p1 I2066_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I144_XP_MP1 (I2066_P19_12 I2066_P15_12n XI2066_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I83_XP_MP0 (XI2066_I83_XP_p1 I2066_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I83_XP_MP1 (I2066_P17_16 I2066_pn16 XI2066_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I84_XP_MP0 (XI2066_I84_XP_p1 I2066_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I84_XP_MP1 (I2066_P18_17 I2066_pn17 XI2066_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I149_XP_MP0 (XI1988_I149_XP_p1 I1988_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I149_XP_MP1 (I1988_P24_17 I1988_P20_17n XI1988_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I84_XP_MP0 (XI1988_I84_XP_p1 I1988_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I84_XP_MP1 (I1988_P18_17 I1988_pn17 XI1988_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I150_XP_MP0 (XI1988_I150_XP_p1 I1988_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I150_XP_MP1 (I1988_P25_18 I1988_P21_18n XI1988_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I85_XP_MP0 (XI1988_I85_XP_p1 I1988_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I85_XP_MP1 (I1988_P19_18 I1988_pn18 XI1988_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I83_XP_MP0 (XI1988_I83_XP_p1 I1988_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I83_XP_MP1 (I1988_P17_16 I1988_pn16 XI1988_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I143_XP_MP0 (XI1942_I143_XP_p1 I1942_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I143_XP_MP1 (I1942_P18_11 I1942_P14_11n XI1942_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I145_XP_MP0 (XI1942_I145_XP_p1 I1942_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I145_XP_MP1 (I1942_P20_13 I1942_P16_13n XI1942_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I84_XP_MP0 (XI1942_I84_XP_p1 I1942_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I84_XP_MP1 (I1942_P18_17 I1942_pn17 XI1942_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I82_XP_MP0 (XI1942_I82_XP_p1 I1942_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I82_XP_MP1 (I1942_P16_15 I1942_pn15 XI1942_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I140_XP_MP0 (XI1942_I140_XP_p1 I1942_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I140_XP_MP1 (I1942_P15_8 I1942_P11_8n XI1942_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I142_XP_MP0 (XI1942_I142_XP_p1 I1942_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I142_XP_MP1 (I1942_P17_10 I1942_P13_10n XI1942_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I83_XP_MP0 (XI1942_I83_XP_p1 I1942_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I83_XP_MP1 (I1942_P17_16 I1942_pn16 XI1942_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I80_XP_MP0 (XI1896_I80_XP_p1 I1896_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I80_XP_MP1 (I1896_P14_13 I1896_pn13 XI1896_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I138_XP_MP0 (XI1896_I138_XP_p1 I1896_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I138_XP_MP1 (I1896_P13_6 I1896_P9_6n XI1896_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I142_XP_MP0 (XI1896_I142_XP_p1 I1896_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I142_XP_MP1 (I1896_P17_10 I1896_P13_10n XI1896_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I81_XP_MP0 (XI1896_I81_XP_p1 I1896_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I81_XP_MP1 (I1896_P15_14 I1896_pn14 XI1896_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I82_XP_MP0 (XI1896_I82_XP_p1 I1896_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I82_XP_MP1 (I1896_P16_15 I1896_pn15 XI1896_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I83_XP_MP0 (XI1896_I83_XP_p1 I1896_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I83_XP_MP1 (I1896_P17_16 I1896_pn16 XI1896_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I148_XP_MP0 (XI1896_I148_XP_p1 I1896_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I148_XP_MP1 (I1896_P23_16 I1896_P19_16n XI1896_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I144_XP_MP0 (XI1896_I144_XP_p1 I1896_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I144_XP_MP1 (I1896_P19_12 I1896_P15_12n XI1896_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I154_XP_MP0 (XI700_I154_XP_p1 I700_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I154_XP_MP1 (I700_P29_22 I700_P25_22n XI700_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I89_XP_MP0 (XI700_I89_XP_p1 I700_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I89_XP_MP1 (I700_P23_22 I700_pn22 XI700_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I87_XP_MP0 (XI700_I87_XP_p1 I700_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I87_XP_MP1 (I700_P21_20 I700_pn20 XI700_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I142_XP_MP0 (XI654_I142_XP_p1 I654_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I142_XP_MP1 (I654_P17_10 I654_P13_10n XI654_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I138_XP_MP0 (XI654_I138_XP_p1 I654_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I138_XP_MP1 (I654_P13_6 I654_P9_6n XI654_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I81_XP_MP0 (XI654_I81_XP_p1 I654_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I81_XP_MP1 (I654_P15_14 I654_pn14 XI654_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I139_XP_MP0 (XI654_I139_XP_p1 I654_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I139_XP_MP1 (I654_P14_7 I654_P10_7n XI654_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I143_XP_MP0 (XI654_I143_XP_p1 I654_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I143_XP_MP1 (I654_P18_11 I654_P14_11n XI654_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I82_XP_MP0 (XI654_I82_XP_p1 I654_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I82_XP_MP1 (I654_P16_15 I654_pn15 XI654_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I81_XP_MP0 (XI608_I81_XP_p1 I608_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I81_XP_MP1 (I608_P15_14 I608_pn14 XI608_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I139_XP_MP0 (XI608_I139_XP_p1 I608_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I139_XP_MP1 (I608_P14_7 I608_P10_7n XI608_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I143_XP_MP0 (XI608_I143_XP_p1 I608_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I143_XP_MP1 (I608_P18_11 I608_P14_11n XI608_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I82_XP_MP0 (XI608_I82_XP_p1 I608_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I82_XP_MP1 (I608_P16_15 I608_pn15 XI608_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I84_XP_MP0 (XI562_I84_XP_p1 I562_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I84_XP_MP1 (I562_P18_17 I562_pn17 XI562_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I83_XP_MP0 (XI562_I83_XP_p1 I562_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I83_XP_MP1 (I562_P17_16 I562_pn16 XI562_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I81_XP_MP0 (XI562_I81_XP_p1 I562_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I81_XP_MP1 (I562_P15_14 I562_pn14 XI562_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I140_XP_MP0 (XI562_I140_XP_p1 I562_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I140_XP_MP1 (I562_P15_8 I562_P11_8n XI562_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I136_XP_MP0 (XI2066_I136_XP_p1 I2066_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I136_XP_MP1 (I2066_P11_4 I2066_P7_4n XI2066_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I142_XP_MP0 (XI2066_I142_XP_p1 I2066_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I142_XP_MP1 (I2066_P17_10 I2066_P13_10n XI2066_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I81_XP_MP0 (XI2066_I81_XP_p1 I2066_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I81_XP_MP1 (I2066_P15_14 I2066_pn14 XI2066_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I143_XP_MP0 (XI2066_I143_XP_p1 I2066_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I143_XP_MP1 (I2066_P18_11 I2066_P14_11n XI2066_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I145_XP_MP0 (XI2066_I145_XP_p1 I2066_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I145_XP_MP1 (I2066_P20_13 I2066_P16_13n XI2066_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I149_XP_MP0 (XI2066_I149_XP_p1 I2066_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I149_XP_MP1 (I2066_P24_17 I2066_P20_17n XI2066_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I82_XP_MP0 (XI2066_I82_XP_p1 I2066_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I82_XP_MP1 (I2066_P16_15 I2066_pn15 XI2066_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I82_XP_MP0 (XI1988_I82_XP_p1 I1988_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I82_XP_MP1 (I1988_P16_15 I1988_pn15 XI1988_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I140_XP_MP0 (XI1988_I140_XP_p1 I1988_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I140_XP_MP1 (I1988_P15_8 I1988_P11_8n XI1988_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I144_XP_MP0 (XI1988_I144_XP_p1 I1988_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I144_XP_MP1 (I1988_P19_12 I1988_P15_12n XI1988_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I146_XP_MP0 (XI1988_I146_XP_p1 I1988_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I146_XP_MP1 (I1988_P21_14 I1988_P17_14n XI1988_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I139_XP_MP0 (XI1942_I139_XP_p1 I1942_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I139_XP_MP1 (I1942_P14_7 I1942_P10_7n XI1942_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I141_XP_MP0 (XI1942_I141_XP_p1 I1942_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I141_XP_MP1 (I1942_P16_9 I1942_P12_9n XI1942_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I80_XP_MP0 (XI1942_I80_XP_p1 I1942_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I80_XP_MP1 (I1942_P14_13 I1942_pn13 XI1942_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I138_XP_MP0 (XI1942_I138_XP_p1 I1942_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I138_XP_MP1 (I1942_P13_6 I1942_P9_6n XI1942_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I81_XP_MP0 (XI1942_I81_XP_p1 I1942_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I81_XP_MP1 (I1942_P15_14 I1942_pn14 XI1942_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I134_XP_MP0 (XI1896_I134_XP_p1 I1896_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I134_XP_MP1 (I1896_P9_2 I1896_P5_2n XI1896_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I78_XP_MP0 (XI1896_I78_XP_p1 I1896_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I78_XP_MP1 (I1896_P12_11 I1896_pn11 XI1896_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I79_XP_MP0 (XI1896_I79_XP_p1 I1896_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I79_XP_MP1 (I1896_P13_12 I1896_pn12 XI1896_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I140_XP_MP0 (XI1896_I140_XP_p1 I1896_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I140_XP_MP1 (I1896_P15_8 I1896_P11_8n XI1896_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I152_XP_MP0 (XI700_I152_XP_p1 I700_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I152_XP_MP1 (I700_P27_20 I700_P23_20n XI700_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I148_XP_MP0 (XI700_I148_XP_p1 I700_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I148_XP_MP1 (I700_P23_16 I700_P19_16n XI700_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I85_XP_MP0 (XI700_I85_XP_p1 I700_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I85_XP_MP1 (I700_P19_18 I700_pn18 XI700_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I83_XP_MP0 (XI700_I83_XP_p1 I700_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I83_XP_MP1 (I700_P17_16 I700_pn16 XI700_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I79_XP_MP0 (XI654_I79_XP_p1 I654_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I79_XP_MP1 (I654_P13_12 I654_pn12 XI654_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I137_XP_MP0 (XI654_I137_XP_p1 I654_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I137_XP_MP1 (I654_P12_5 I654_P8_5n XI654_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I141_XP_MP0 (XI654_I141_XP_p1 I654_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I141_XP_MP1 (I654_P16_9 I654_P12_9n XI654_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I80_XP_MP0 (XI654_I80_XP_p1 I654_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I80_XP_MP1 (I654_P14_13 I654_pn13 XI654_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I142_XP_MP0 (XI608_I142_XP_p1 I608_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I142_XP_MP1 (I608_P17_10 I608_P13_10n XI608_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I138_XP_MP0 (XI608_I138_XP_p1 I608_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I138_XP_MP1 (I608_P13_6 I608_P9_6n XI608_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I79_XP_MP0 (XI608_I79_XP_p1 I608_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I79_XP_MP1 (I608_P13_12 I608_pn12 XI608_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I80_XP_MP0 (XI608_I80_XP_p1 I608_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I80_XP_MP1 (I608_P14_13 I608_pn13 XI608_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I149_XP_MP0 (XI562_I149_XP_p1 I562_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I149_XP_MP1 (I562_P24_17 I562_P20_17n XI562_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I82_XP_MP0 (XI562_I82_XP_p1 I562_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I82_XP_MP1 (I562_P16_15 I562_pn15 XI562_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I138_XP_MP0 (XI562_I138_XP_p1 I562_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I138_XP_MP1 (I562_P13_6 I562_P9_6n XI562_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I142_XP_MP0 (XI562_I142_XP_p1 I562_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I142_XP_MP1 (I562_P17_10 I562_P13_10n XI562_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I79_XP_MP0 (XI562_I79_XP_p1 I562_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I79_XP_MP1 (I562_P13_12 I562_pn12 XI562_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I138_XP_MP0 (XI2066_I138_XP_p1 I2066_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I138_XP_MP1 (I2066_P13_6 I2066_P9_6n XI2066_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I79_XP_MP0 (XI2066_I79_XP_p1 I2066_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I79_XP_MP1 (I2066_P13_12 I2066_pn12 XI2066_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I139_XP_MP0 (XI2066_I139_XP_p1 I2066_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I139_XP_MP1 (I2066_P14_7 I2066_P10_7n XI2066_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I80_XP_MP0 (XI2066_I80_XP_p1 I2066_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I80_XP_MP1 (I2066_P14_13 I2066_pn13 XI2066_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I139_XP_MP0 (XI1988_I139_XP_p1 I1988_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I139_XP_MP1 (I1988_P14_7 I1988_P10_7n XI1988_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I143_XP_MP0 (XI1988_I143_XP_p1 I1988_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I143_XP_MP1 (I1988_P18_11 I1988_P14_11n XI1988_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I145_XP_MP0 (XI1988_I145_XP_p1 I1988_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I145_XP_MP1 (I1988_P20_13 I1988_P16_13n XI1988_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I142_XP_MP0 (XI1988_I142_XP_p1 I1988_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I142_XP_MP1 (I1988_P17_10 I1988_P13_10n XI1988_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I81_XP_MP0 (XI1988_I81_XP_p1 I1988_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I81_XP_MP1 (I1988_P15_14 I1988_pn14 XI1988_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I137_XP_MP0 (XI1942_I137_XP_p1 I1942_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I137_XP_MP1 (I1942_P12_5 I1942_P8_5n XI1942_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I78_XP_MP0 (XI1942_I78_XP_p1 I1942_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I78_XP_MP1 (I1942_P12_11 I1942_pn11 XI1942_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I79_XP_MP0 (XI1942_I79_XP_p1 I1942_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I79_XP_MP1 (I1942_P13_12 I1942_pn12 XI1942_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I133_XP_MP0 (XI1896_I133_XP_p1 I1896_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I133_XP_MP1 (I1896_P8_1 I1896_P4_1n XI1896_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I76_XP_MP0 (XI1896_I76_XP_p1 I1896_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I76_XP_MP1 (I1896_P10_9 I1896_pn9 XI1896_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I77_XP_MP0 (XI1896_I77_XP_p1 I1896_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I77_XP_MP1 (I1896_P11_10 I1896_pn10 XI1896_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I136_XP_MP0 (XI1896_I136_XP_p1 I1896_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I136_XP_MP1 (I1896_P11_4 I1896_P7_4n XI1896_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I150_XP_MP0 (XI700_I150_XP_p1 I700_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I150_XP_MP1 (I700_P25_18 I700_P21_18n XI700_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I146_XP_MP0 (XI700_I146_XP_p1 I700_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I146_XP_MP1 (I700_P21_14 I700_P17_14n XI700_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I144_XP_MP0 (XI700_I144_XP_p1 I700_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I144_XP_MP1 (I700_P19_12 I700_P15_12n XI700_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I140_XP_MP0 (XI700_I140_XP_p1 I700_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I140_XP_MP1 (I700_P15_8 I700_P11_8n XI700_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I81_XP_MP0 (XI700_I81_XP_p1 I700_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I81_XP_MP1 (I700_P15_14 I700_pn14 XI700_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I134_XP_MP0 (XI654_I134_XP_p1 I654_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I134_XP_MP1 (I654_P9_2 I654_P5_2n XI654_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I77_XP_MP0 (XI654_I77_XP_p1 I654_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I77_XP_MP1 (I654_P11_10 I654_pn10 XI654_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I135_XP_MP0 (XI654_I135_XP_p1 I654_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I135_XP_MP1 (I654_P10_3 I654_P6_3n XI654_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I78_XP_MP0 (XI654_I78_XP_p1 I654_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I78_XP_MP1 (I654_P12_11 I654_pn11 XI654_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I136_XP_MP0 (XI608_I136_XP_p1 I608_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I136_XP_MP1 (I608_P11_4 I608_P7_4n XI608_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I77_XP_MP0 (XI608_I77_XP_p1 I608_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I77_XP_MP1 (I608_P11_10 I608_pn10 XI608_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I135_XP_MP0 (XI608_I135_XP_p1 I608_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I135_XP_MP1 (I608_P10_3 I608_P6_3n XI608_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I141_XP_MP0 (XI608_I141_XP_p1 I608_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I141_XP_MP1 (I608_P16_9 I608_P12_9n XI608_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I137_XP_MP0 (XI608_I137_XP_p1 I608_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I137_XP_MP1 (I608_P12_5 I608_P8_5n XI608_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I78_XP_MP0 (XI608_I78_XP_p1 I608_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I78_XP_MP1 (I608_P12_11 I608_pn11 XI608_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I145_XP_MP0 (XI562_I145_XP_p1 I562_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I145_XP_MP1 (I562_P20_13 I562_P16_13n XI562_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I143_XP_MP0 (XI562_I143_XP_p1 I562_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I143_XP_MP1 (I562_P18_11 I562_P14_11n XI562_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I139_XP_MP0 (XI562_I139_XP_p1 I562_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I139_XP_MP1 (I562_P14_7 I562_P10_7n XI562_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I80_XP_MP0 (XI562_I80_XP_p1 I562_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I80_XP_MP1 (I562_P14_13 I562_pn13 XI562_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I78_XP_MP0 (XI562_I78_XP_p1 I562_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I78_XP_MP1 (I562_P12_11 I562_pn11 XI562_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I77_XP_MP0 (XI2066_I77_XP_p1 I2066_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I77_XP_MP1 (I2066_P11_10 I2066_pn10 XI2066_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I135_XP_MP0 (XI2066_I135_XP_p1 I2066_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I135_XP_MP1 (I2066_P10_3 I2066_P6_3n XI2066_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I137_XP_MP0 (XI2066_I137_XP_p1 I2066_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I137_XP_MP1 (I2066_P12_5 I2066_P8_5n XI2066_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I141_XP_MP0 (XI2066_I141_XP_p1 I2066_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I141_XP_MP1 (I2066_P16_9 I2066_P12_9n XI2066_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I78_XP_MP0 (XI2066_I78_XP_p1 I2066_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I78_XP_MP1 (I2066_P12_11 I2066_pn11 XI2066_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I141_XP_MP0 (XI1988_I141_XP_p1 I1988_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I141_XP_MP1 (I1988_P16_9 I1988_P12_9n XI1988_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I80_XP_MP0 (XI1988_I80_XP_p1 I1988_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I80_XP_MP1 (I1988_P14_13 I1988_pn13 XI1988_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I138_XP_MP0 (XI1988_I138_XP_p1 I1988_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I138_XP_MP1 (I1988_P13_6 I1988_P9_6n XI1988_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I79_XP_MP0 (XI1988_I79_XP_p1 I1988_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I79_XP_MP1 (I1988_P13_12 I1988_pn12 XI1988_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I135_XP_MP0 (XI1942_I135_XP_p1 I1942_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I135_XP_MP1 (I1942_P10_3 I1942_P6_3n XI1942_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I76_XP_MP0 (XI1942_I76_XP_p1 I1942_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I76_XP_MP1 (I1942_P10_9 I1942_pn9 XI1942_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I136_XP_MP0 (XI1942_I136_XP_p1 I1942_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I136_XP_MP1 (I1942_P11_4 I1942_P7_4n XI1942_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I77_XP_MP0 (XI1942_I77_XP_p1 I1942_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I77_XP_MP1 (I1942_P11_10 I1942_pn10 XI1942_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I74_XP_MP0 (XI1896_I74_XP_p1 I1896_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I74_XP_MP1 (I1896_P8_7 I1896_pn7 XI1896_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I75_XP_MP0 (XI1896_I75_XP_p1 I1896_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I75_XP_MP1 (I1896_P9_8 I1896_pn8 XI1896_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I96_XP_MP0 (XI700_I96_XP_p1 I700_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I96_XP_MP1 (I700_P30_29 I700_pn29 XI700_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I94_XP_MP0 (XI700_I94_XP_p1 I700_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I94_XP_MP1 (I700_P28_27 I700_pn27 XI700_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I142_XP_MP0 (XI700_I142_XP_p1 I700_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I142_XP_MP1 (I700_P17_10 I700_P13_10n XI700_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I82_XP_MP0 (XI700_I82_XP_p1 I700_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I82_XP_MP1 (I700_P16_15 I700_pn15 XI700_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I79_XP_MP0 (XI700_I79_XP_p1 I700_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I79_XP_MP1 (I700_P13_12 I700_pn12 XI700_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I75_XP_MP0 (XI654_I75_XP_p1 I654_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I75_XP_MP1 (I654_P9_8 I654_pn8 XI654_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I76_XP_MP0 (XI654_I76_XP_p1 I654_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I76_XP_MP1 (I654_P10_9 I654_pn9 XI654_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I134_XP_MP0 (XI608_I134_XP_p1 I608_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I134_XP_MP1 (I608_P9_2 I608_P5_2n XI608_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I75_XP_MP0 (XI608_I75_XP_p1 I608_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I75_XP_MP1 (I608_P9_8 I608_pn8 XI608_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I76_XP_MP0 (XI608_I76_XP_p1 I608_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I76_XP_MP1 (I608_P10_9 I608_pn9 XI608_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I137_XP_MP0 (XI562_I137_XP_p1 I562_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I137_XP_MP1 (I562_P12_5 I562_P8_5n XI562_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I141_XP_MP0 (XI562_I141_XP_p1 I562_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I141_XP_MP1 (I562_P16_9 I562_P12_9n XI562_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I134_XP_MP0 (XI562_I134_XP_p1 I562_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I134_XP_MP1 (I562_P9_2 I562_P5_2n XI562_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I77_XP_MP0 (XI562_I77_XP_p1 I562_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I77_XP_MP1 (I562_P11_10 I562_pn10 XI562_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I136_XP_MP0 (XI562_I136_XP_p1 I562_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I136_XP_MP1 (I562_P11_4 I562_P7_4n XI562_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I134_XP_MP0 (XI2066_I134_XP_p1 I2066_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I134_XP_MP1 (I2066_P9_2 I2066_P5_2n XI2066_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I75_XP_MP0 (XI2066_I75_XP_p1 I2066_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I75_XP_MP1 (I2066_P9_8 I2066_pn8 XI2066_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I73_XP_MP0 (XI2066_I73_XP_p1 I2066_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I73_XP_MP1 (I2066_P7_6 I2066_pn6 XI2066_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I76_XP_MP0 (XI2066_I76_XP_p1 I2066_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I76_XP_MP1 (I2066_P10_9 I2066_pn9 XI2066_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I137_XP_MP0 (XI1988_I137_XP_p1 I1988_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I137_XP_MP1 (I1988_P12_5 I1988_P8_5n XI1988_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I78_XP_MP0 (XI1988_I78_XP_p1 I1988_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I78_XP_MP1 (I1988_P12_11 I1988_pn11 XI1988_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I136_XP_MP0 (XI1988_I136_XP_p1 I1988_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I136_XP_MP1 (I1988_P11_4 I1988_P7_4n XI1988_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I77_XP_MP0 (XI1988_I77_XP_p1 I1988_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I77_XP_MP1 (I1988_P11_10 I1988_pn10 XI1988_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I134_XP_MP0 (XI1942_I134_XP_p1 I1942_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I134_XP_MP1 (I1942_P9_2 I1942_P5_2n XI1942_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I75_XP_MP0 (XI1942_I75_XP_p1 I1942_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I75_XP_MP1 (I1942_P9_8 I1942_pn8 XI1942_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I71_XP_MP0 (XI1896_I71_XP_p1 I1896_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I71_XP_MP1 (I1896_P5_4 I1896_pn4 XI1896_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I72_XP_MP0 (XI1896_I72_XP_p1 I1896_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I72_XP_MP1 (I1896_P6_5 I1896_pn5 XI1896_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I73_XP_MP0 (XI1896_I73_XP_p1 I1896_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I73_XP_MP1 (I1896_P7_6 I1896_pn6 XI1896_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I136_XP_MP0 (XI1850_I136_XP_p1 I1850_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I136_XP_MP1 (I1850_P11_4 I1850_P7_4n XI1850_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I140_XP_MP0 (XI1850_I140_XP_p1 I1850_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I140_XP_MP1 (I1850_P15_8 I1850_P11_8n XI1850_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I144_XP_MP0 (XI1850_I144_XP_p1 I1850_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I144_XP_MP1 (I1850_P19_12 I1850_P15_12n XI1850_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I148_XP_MP0 (XI1850_I148_XP_p1 I1850_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I148_XP_MP1 (I1850_P23_16 I1850_P19_16n XI1850_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I152_XP_MP0 (XI1850_I152_XP_p1 I1850_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I152_XP_MP1 (I1850_P27_20 I1850_P23_20n XI1850_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I156_XP_MP0 (XI1850_I156_XP_p1 I1850_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I156_XP_MP1 (I1850_P31_24 I1850_P27_24n XI1850_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I92_XP_MP0 (XI700_I92_XP_p1 I700_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I92_XP_MP1 (I700_P26_25 I700_pn25 XI700_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I90_XP_MP0 (XI700_I90_XP_p1 I700_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I90_XP_MP1 (I700_P24_23 I700_pn23 XI700_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I138_XP_MP0 (XI700_I138_XP_p1 I700_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I138_XP_MP1 (I700_P13_6 I700_P9_6n XI700_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I80_XP_MP0 (XI700_I80_XP_p1 I700_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I80_XP_MP1 (I700_P14_13 I700_pn13 XI700_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I77_XP_MP0 (XI700_I77_XP_p1 I700_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I77_XP_MP1 (I700_P11_10 I700_pn10 XI700_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I73_XP_MP0 (XI654_I73_XP_p1 I654_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I73_XP_MP1 (I654_P7_6 I654_pn6 XI654_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I71_XP_MP0 (XI654_I71_XP_p1 I654_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I71_XP_MP1 (I654_P5_4 I654_pn4 XI654_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I133_XP_MP0 (XI654_I133_XP_p1 I654_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I133_XP_MP1 (I654_P8_1 I654_P4_1n XI654_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I72_XP_MP0 (XI654_I72_XP_p1 I654_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I72_XP_MP1 (I654_P6_5 I654_pn5 XI654_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I74_XP_MP0 (XI654_I74_XP_p1 I654_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I74_XP_MP1 (I654_P8_7 I654_pn7 XI654_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I73_XP_MP0 (XI608_I73_XP_p1 I608_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I73_XP_MP1 (I608_P7_6 I608_pn6 XI608_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I133_XP_MP0 (XI608_I133_XP_p1 I608_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I133_XP_MP1 (I608_P8_1 I608_P4_1n XI608_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I74_XP_MP0 (XI608_I74_XP_p1 I608_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I74_XP_MP1 (I608_P8_7 I608_pn7 XI608_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I133_XP_MP0 (XI562_I133_XP_p1 I562_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I133_XP_MP1 (I562_P8_1 I562_P4_1n XI562_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I135_XP_MP0 (XI562_I135_XP_p1 I562_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I135_XP_MP1 (I562_P10_3 I562_P6_3n XI562_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I74_XP_MP0 (XI562_I74_XP_p1 I562_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I74_XP_MP1 (I562_P8_7 I562_pn7 XI562_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I76_XP_MP0 (XI562_I76_XP_p1 I562_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I76_XP_MP1 (I562_P10_9 I562_pn9 XI562_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I75_XP_MP0 (XI562_I75_XP_p1 I562_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I75_XP_MP1 (I562_P9_8 I562_pn8 XI562_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I71_XP_MP0 (XI2066_I71_XP_p1 I2066_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I71_XP_MP1 (I2066_P5_4 I2066_pn4 XI2066_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I133_XP_MP0 (XI2066_I133_XP_p1 I2066_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I133_XP_MP1 (I2066_P8_1 I2066_P4_1n XI2066_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I74_XP_MP0 (XI2066_I74_XP_p1 I2066_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I74_XP_MP1 (I2066_P8_7 I2066_pn7 XI2066_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I135_XP_MP0 (XI1988_I135_XP_p1 I1988_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I135_XP_MP1 (I1988_P10_3 I1988_P6_3n XI1988_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I76_XP_MP0 (XI1988_I76_XP_p1 I1988_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I76_XP_MP1 (I1988_P10_9 I1988_pn9 XI1988_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I134_XP_MP0 (XI1988_I134_XP_p1 I1988_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I134_XP_MP1 (I1988_P9_2 I1988_P5_2n XI1988_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I75_XP_MP0 (XI1988_I75_XP_p1 I1988_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I75_XP_MP1 (I1988_P9_8 I1988_pn8 XI1988_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I133_XP_MP0 (XI1942_I133_XP_p1 I1942_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I133_XP_MP1 (I1942_P8_1 I1942_P4_1n XI1942_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I74_XP_MP0 (XI1942_I74_XP_p1 I1942_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I74_XP_MP1 (I1942_P8_7 I1942_pn7 XI1942_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I73_XP_MP0 (XI1942_I73_XP_p1 I1942_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I73_XP_MP1 (I1942_P7_6 I1942_pn6 XI1942_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I69_XP_MP0 (XI1896_I69_XP_p1 I1896_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I69_XP_MP1 (I1896_P3_2 I1896_pn2 XI1896_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I70_XP_MP0 (XI1896_I70_XP_p1 I1896_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I70_XP_MP1 (I1896_P4_3 I1896_pn3 XI1896_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I134_XP_MP0 (XI1850_I134_XP_p1 I1850_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I134_XP_MP1 (I1850_P9_2 I1850_P5_2n XI1850_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I138_XP_MP0 (XI1850_I138_XP_p1 I1850_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I138_XP_MP1 (I1850_P13_6 I1850_P9_6n XI1850_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I142_XP_MP0 (XI1850_I142_XP_p1 I1850_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I142_XP_MP1 (I1850_P17_10 I1850_P13_10n XI1850_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I146_XP_MP0 (XI1850_I146_XP_p1 I1850_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I146_XP_MP1 (I1850_P21_14 I1850_P17_14n XI1850_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I150_XP_MP0 (XI1850_I150_XP_p1 I1850_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I150_XP_MP1 (I1850_P25_18 I1850_P21_18n XI1850_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I154_XP_MP0 (XI1850_I154_XP_p1 I1850_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I154_XP_MP1 (I1850_P29_22 I1850_P25_22n XI1850_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I88_XP_MP0 (XI700_I88_XP_p1 I700_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I88_XP_MP1 (I700_P22_21 I700_pn21 XI700_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I136_XP_MP0 (XI700_I136_XP_p1 I700_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I136_XP_MP1 (I700_P11_4 I700_P7_4n XI700_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I78_XP_MP0 (XI700_I78_XP_p1 I700_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I78_XP_MP1 (I700_P12_11 I700_pn11 XI700_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I75_XP_MP0 (XI700_I75_XP_p1 I700_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I75_XP_MP1 (I700_P9_8 I700_pn8 XI700_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I70_XP_MP0 (XI654_I70_XP_p1 I654_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I70_XP_MP1 (I654_P4_3 I654_pn3 XI654_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I69_XP_MP0 (XI654_I69_XP_p1 I654_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I69_XP_MP1 (I654_P3_2 I654_pn2 XI654_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I69_XP_MP0 (XI608_I69_XP_p1 I608_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I69_XP_MP1 (I608_P3_2 I608_pn2 XI608_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I71_XP_MP0 (XI608_I71_XP_p1 I608_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I71_XP_MP1 (I608_P5_4 I608_pn4 XI608_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I70_XP_MP0 (XI608_I70_XP_p1 I608_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I70_XP_MP1 (I608_P4_3 I608_pn3 XI608_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I72_XP_MP0 (XI608_I72_XP_p1 I608_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I72_XP_MP1 (I608_P6_5 I608_pn5 XI608_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I70_XP_MP0 (XI562_I70_XP_p1 I562_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I70_XP_MP1 (I562_P4_3 I562_pn3 XI562_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I72_XP_MP0 (XI562_I72_XP_p1 I562_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I72_XP_MP1 (I562_P6_5 I562_pn5 XI562_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I73_XP_MP0 (XI562_I73_XP_p1 I562_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I73_XP_MP1 (I562_P7_6 I562_pn6 XI562_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2295_MP0 (XI2295_p1 vn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2295_MP1 (V DZ XI2295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2286_MP0 (XI2286_p1 z1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2286_MP1 (z2_0 z1_1 XI2286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2265_MP0 (XI2265_p1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2265_MP1 (z0_3 B_7 XI2265_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2292_MP0 (XI2292_p1 z3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2292_MP1 (DZ z3_1 XI2292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2287_MP0 (XI2287_p1 z1_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2287_MP1 (z2_1 z1_3 XI2287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I69_XP_MP0 (XI2066_I69_XP_p1 I2066_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I69_XP_MP1 (I2066_P3_2 I2066_pn2 XI2066_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I72_XP_MP0 (XI2066_I72_XP_p1 I2066_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I72_XP_MP1 (I2066_P6_5 I2066_pn5 XI2066_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I70_XP_MP0 (XI2066_I70_XP_p1 I2066_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I70_XP_MP1 (I2066_P4_3 I2066_pn3 XI2066_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I133_XP_MP0 (XI1988_I133_XP_p1 I1988_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I133_XP_MP1 (I1988_P8_1 I1988_P4_1n XI1988_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I74_XP_MP0 (XI1988_I74_XP_p1 I1988_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I74_XP_MP1 (I1988_P8_7 I1988_pn7 XI1988_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I73_XP_MP0 (XI1988_I73_XP_p1 I1988_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I73_XP_MP1 (I1988_P7_6 I1988_pn6 XI1988_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I72_XP_MP0 (XI1942_I72_XP_p1 I1942_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I72_XP_MP1 (I1942_P6_5 I1942_pn5 XI1942_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I71_XP_MP0 (XI1942_I71_XP_p1 I1942_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I71_XP_MP1 (I1942_P5_4 I1942_pn4 XI1942_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I68_XP_MP0 (XI1896_I68_XP_p1 I1896_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I68_XP_MP1 (I1896_P2_1 I1896_pn1 XI1896_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I75_XP_MP0 (XI1850_I75_XP_p1 I1850_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I75_XP_MP1 (I1850_P9_8 I1850_pn8 XI1850_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I77_XP_MP0 (XI1850_I77_XP_p1 I1850_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I77_XP_MP1 (I1850_P11_10 I1850_pn10 XI1850_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I79_XP_MP0 (XI1850_I79_XP_p1 I1850_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I79_XP_MP1 (I1850_P13_12 I1850_pn12 XI1850_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I81_XP_MP0 (XI1850_I81_XP_p1 I1850_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I81_XP_MP1 (I1850_P15_14 I1850_pn14 XI1850_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I83_XP_MP0 (XI1850_I83_XP_p1 I1850_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I83_XP_MP1 (I1850_P17_16 I1850_pn16 XI1850_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I85_XP_MP0 (XI1850_I85_XP_p1 I1850_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I85_XP_MP1 (I1850_P19_18 I1850_pn18 XI1850_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I87_XP_MP0 (XI1850_I87_XP_p1 I1850_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I87_XP_MP1 (I1850_P21_20 I1850_pn20 XI1850_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I89_XP_MP0 (XI1850_I89_XP_p1 I1850_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I89_XP_MP1 (I1850_P23_22 I1850_pn22 XI1850_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I93_XP_MP0 (XI1850_I93_XP_p1 I1850_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I93_XP_MP1 (I1850_P27_26 I1850_pn26 XI1850_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I155_XP_MP0 (XI700_I155_XP_p1 I700_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I155_XP_MP1 (I700_P30_23 I700_P26_23n XI700_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I86_XP_MP0 (XI700_I86_XP_p1 I700_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I86_XP_MP1 (I700_P20_19 I700_pn19 XI700_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I84_XP_MP0 (XI700_I84_XP_p1 I700_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I84_XP_MP1 (I700_P18_17 I700_pn17 XI700_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I134_XP_MP0 (XI700_I134_XP_p1 I700_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I134_XP_MP1 (I700_P9_2 I700_P5_2n XI700_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I73_XP_MP0 (XI700_I73_XP_p1 I700_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I73_XP_MP1 (I700_P7_6 I700_pn6 XI700_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I68_XP_MP0 (XI654_I68_XP_p1 I654_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I68_XP_MP1 (I654_P2_1 I654_pn1 XI654_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I68_XP_MP0 (XI608_I68_XP_p1 I608_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I68_XP_MP1 (I608_P2_1 I608_pn1 XI608_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I68_XP_MP0 (XI562_I68_XP_p1 I562_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I68_XP_MP1 (I562_P2_1 I562_pn1 XI562_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I69_XP_MP0 (XI562_I69_XP_p1 I562_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I69_XP_MP1 (I562_P3_2 I562_pn2 XI562_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I71_XP_MP0 (XI562_I71_XP_p1 I562_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I71_XP_MP1 (I562_P5_4 I562_pn4 XI562_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2264_MP0 (XI2264_p1 B_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2264_MP1 (z0_2 B_5 XI2264_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2263_MP0 (XI2263_p1 B_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2263_MP1 (z0_1 B_3 XI2263_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2266_MP0 (XI2266_p1 B_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2266_MP1 (z0_4 B_9 XI2266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I68_XP_MP0 (XI2066_I68_XP_p1 I2066_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I68_XP_MP1 (I2066_P2_1 I2066_pn1 XI2066_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I72_XP_MP0 (XI1988_I72_XP_p1 I1988_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I72_XP_MP1 (I1988_P6_5 I1988_pn5 XI1988_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I71_XP_MP0 (XI1988_I71_XP_p1 I1988_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I71_XP_MP1 (I1988_P5_4 I1988_pn4 XI1988_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I70_XP_MP0 (XI1942_I70_XP_p1 I1942_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I70_XP_MP1 (I1942_P4_3 I1942_pn3 XI1942_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I69_XP_MP0 (XI1942_I69_XP_p1 I1942_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I69_XP_MP1 (I1942_P3_2 I1942_pn2 XI1942_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I69_XP_MP0 (XI1850_I69_XP_p1 I1850_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I69_XP_MP1 (I1850_P3_2 I1850_pn2 XI1850_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I71_XP_MP0 (XI1850_I71_XP_p1 I1850_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I71_XP_MP1 (I1850_P5_4 I1850_pn4 XI1850_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I73_XP_MP0 (XI1850_I73_XP_p1 I1850_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I73_XP_MP1 (I1850_P7_6 I1850_pn6 XI1850_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I91_XP_MP0 (XI1850_I91_XP_p1 I1850_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I91_XP_MP1 (I1850_P25_24 I1850_pn24 XI1850_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I95_XP_MP0 (XI1850_I95_XP_p1 I1850_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I95_XP_MP1 (I1850_P29_28 I1850_pn28 XI1850_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I97_XP_MP0 (XI1850_I97_XP_p1 I1850_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I97_XP_MP1 (I1850_P31_30 I1850_pn30 XI1850_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I153_XP_MP0 (XI700_I153_XP_p1 I700_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I153_XP_MP1 (I700_P28_21 I700_P24_21n XI700_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I151_XP_MP0 (XI700_I151_XP_p1 I700_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I151_XP_MP1 (I700_P26_19 I700_P22_19n XI700_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I147_XP_MP0 (XI700_I147_XP_p1 I700_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I147_XP_MP1 (I700_P22_15 I700_P18_15n XI700_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I76_XP_MP0 (XI700_I76_XP_p1 I700_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I76_XP_MP1 (I700_P10_9 I700_pn9 XI700_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I74_XP_MP0 (XI700_I74_XP_p1 I700_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I74_XP_MP1 (I700_P8_7 I700_pn7 XI700_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I72_XP_MP0 (XI700_I72_XP_p1 I700_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I72_XP_MP1 (I700_P6_5 I700_pn5 XI700_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2267_MP0 (XI2267_p1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2267_MP1 (z0_5 B_11 XI2267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2268_MP0 (XI2268_p1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2268_MP1 (z0_6 B_13 XI2268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2269_MP0 (XI2269_p1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2269_MP1 (z0_7 B_15 XI2269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2289_MP0 (XI2289_p1 z1_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2289_MP1 (z2_3 z1_7 XI2289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2288_MP0 (XI2288_p1 z1_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2288_MP1 (z2_2 z1_5 XI2288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2272_MP0 (XI2272_p1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2272_MP1 (z0_10 B_21 XI2272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I68_XP_MP0 (XI1988_I68_XP_p1 I1988_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I68_XP_MP1 (I1988_P2_1 I1988_pn1 XI1988_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I70_XP_MP0 (XI1988_I70_XP_p1 I1988_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I70_XP_MP1 (I1988_P4_3 I1988_pn3 XI1988_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I69_XP_MP0 (XI1988_I69_XP_p1 I1988_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I69_XP_MP1 (I1988_P3_2 I1988_pn2 XI1988_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I68_XP_MP0 (XI1942_I68_XP_p1 I1942_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I68_XP_MP1 (I1942_P2_1 I1942_pn1 XI1942_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I68_XP_MP0 (XI1850_I68_XP_p1 I1850_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I68_XP_MP1 (I1850_P2_1 I1850_pn1 XI1850_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I70_XP_MP0 (XI1850_I70_XP_p1 I1850_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I70_XP_MP1 (I1850_P4_3 I1850_pn3 XI1850_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I72_XP_MP0 (XI1850_I72_XP_p1 I1850_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I72_XP_MP1 (I1850_P6_5 I1850_pn5 XI1850_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I133_XP_MP0 (XI1850_I133_XP_p1 I1850_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I133_XP_MP1 (I1850_P8_1 I1850_P4_1n XI1850_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I135_XP_MP0 (XI1850_I135_XP_p1 I1850_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I135_XP_MP1 (I1850_P10_3 I1850_P6_3n XI1850_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I137_XP_MP0 (XI1850_I137_XP_p1 I1850_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I137_XP_MP1 (I1850_P12_5 I1850_P8_5n XI1850_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I141_XP_MP0 (XI1850_I141_XP_p1 I1850_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I141_XP_MP1 (I1850_P16_9 I1850_P12_9n XI1850_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I139_XP_MP0 (XI1850_I139_XP_p1 I1850_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I139_XP_MP1 (I1850_P14_7 I1850_P10_7n XI1850_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I143_XP_MP0 (XI1850_I143_XP_p1 I1850_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I143_XP_MP1 (I1850_P18_11 I1850_P14_11n XI1850_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I145_XP_MP0 (XI1850_I145_XP_p1 I1850_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I145_XP_MP1 (I1850_P20_13 I1850_P16_13n XI1850_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I149_XP_MP0 (XI1850_I149_XP_p1 I1850_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I149_XP_MP1 (I1850_P24_17 I1850_P20_17n XI1850_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I147_XP_MP0 (XI1850_I147_XP_p1 I1850_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I147_XP_MP1 (I1850_P22_15 I1850_P18_15n XI1850_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I151_XP_MP0 (XI1850_I151_XP_p1 I1850_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I151_XP_MP1 (I1850_P26_19 I1850_P22_19n XI1850_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I149_XP_MP0 (XI700_I149_XP_p1 I700_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I149_XP_MP1 (I700_P24_17 I700_P20_17n XI700_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I145_XP_MP0 (XI700_I145_XP_p1 I700_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I145_XP_MP1 (I700_P20_13 I700_P16_13n XI700_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I139_XP_MP0 (XI700_I139_XP_p1 I700_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I139_XP_MP1 (I700_P14_7 I700_P10_7n XI700_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I143_XP_MP0 (XI700_I143_XP_p1 I700_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I143_XP_MP1 (I700_P18_11 I700_P14_11n XI700_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I141_XP_MP0 (XI700_I141_XP_p1 I700_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I141_XP_MP1 (I700_P16_9 I700_P12_9n XI700_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I135_XP_MP0 (XI700_I135_XP_p1 I700_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I135_XP_MP1 (I700_P10_3 I700_P6_3n XI700_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I71_XP_MP0 (XI700_I71_XP_p1 I700_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I71_XP_MP1 (I700_P5_4 I700_pn4 XI700_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I70_XP_MP0 (XI700_I70_XP_p1 I700_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I70_XP_MP1 (I700_P4_3 I700_pn3 XI700_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I69_XP_MP0 (XI700_I69_XP_p1 I700_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I69_XP_MP1 (I700_P3_2 I700_pn2 XI700_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2262_MP0 (XI2262_p1 B_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2262_MP1 (z0_0 B_1 XI2262_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2270_MP0 (XI2270_p1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2270_MP1 (z0_8 B_17 XI2270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2271_MP0 (XI2271_p1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2271_MP1 (z0_9 B_19 XI2271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I74_XP_MP0 (XI1850_I74_XP_p1 I1850_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I74_XP_MP1 (I1850_P8_7 I1850_pn7 XI1850_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I76_XP_MP0 (XI1850_I76_XP_p1 I1850_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I76_XP_MP1 (I1850_P10_9 I1850_pn9 XI1850_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I78_XP_MP0 (XI1850_I78_XP_p1 I1850_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I78_XP_MP1 (I1850_P12_11 I1850_pn11 XI1850_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I80_XP_MP0 (XI1850_I80_XP_p1 I1850_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I80_XP_MP1 (I1850_P14_13 I1850_pn13 XI1850_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I84_XP_MP0 (XI1850_I84_XP_p1 I1850_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I84_XP_MP1 (I1850_P18_17 I1850_pn17 XI1850_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I82_XP_MP0 (XI1850_I82_XP_p1 I1850_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I82_XP_MP1 (I1850_P16_15 I1850_pn15 XI1850_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I88_XP_MP0 (XI1850_I88_XP_p1 I1850_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I88_XP_MP1 (I1850_P22_21 I1850_pn21 XI1850_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I92_XP_MP0 (XI1850_I92_XP_p1 I1850_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I92_XP_MP1 (I1850_P26_25 I1850_pn25 XI1850_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I153_XP_MP0 (XI1850_I153_XP_p1 I1850_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I153_XP_MP1 (I1850_P28_21 I1850_P24_21n XI1850_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I155_XP_MP0 (XI1850_I155_XP_p1 I1850_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I155_XP_MP1 (I1850_P30_23 I1850_P26_23n XI1850_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I94_XP_MP0 (XI1850_I94_XP_p1 I1850_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I94_XP_MP1 (I1850_P28_27 I1850_pn27 XI1850_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I137_XP_MP0 (XI700_I137_XP_p1 I700_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I137_XP_MP1 (I700_P12_5 I700_P8_5n XI700_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I133_XP_MP0 (XI700_I133_XP_p1 I700_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I133_XP_MP1 (I700_P8_1 I700_P4_1n XI700_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I68_XP_MP0 (XI700_I68_XP_p1 I700_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I68_XP_MP1 (I700_P2_1 I700_pn1 XI700_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2277_MP0 (XI2277_p1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2277_MP1 (z0_15 B_31_b3_5 XI2277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2273_MP0 (XI2273_p1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2273_MP1 (z0_11 B_23 XI2273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I86_XP_MP0 (XI1850_I86_XP_p1 I1850_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I86_XP_MP1 (I1850_P20_19 I1850_pn19 XI1850_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I90_XP_MP0 (XI1850_I90_XP_p1 I1850_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I90_XP_MP1 (I1850_P24_23 I1850_pn23 XI1850_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I96_XP_MP0 (XI1850_I96_XP_p1 I1850_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I96_XP_MP1 (I1850_P30_29 I1850_pn29 XI1850_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2276_MP0 (XI2276_p1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2276_MP1 (z0_14 B_29 XI2276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2274_MP0 (XI2274_p1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2274_MP1 (z0_12 B_25 XI2274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2275_MP0 (XI2275_p1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2275_MP1 (z0_13 B_27 XI2275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I72_XP_MP0 (XI746_I72_XP_p1 I746_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I72_XP_MP1 (I746_P6_5 I746_pn5 XI746_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I71_XP_MP0 (XI746_I71_XP_p1 I746_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I71_XP_MP1 (I746_P5_4 I746_pn4 XI746_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I70_XP_MP0 (XI746_I70_XP_p1 I746_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I70_XP_MP1 (I746_P4_3 I746_pn3 XI746_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I69_XP_MP0 (XI746_I69_XP_p1 I746_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I69_XP_MP1 (I746_P3_2 I746_pn2 XI746_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I71_XP_MP0 (XI792_I71_XP_p1 I792_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I71_XP_MP1 (I792_P5_4 I792_pn4 XI792_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I72_XP_MP0 (XI792_I72_XP_p1 I792_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I72_XP_MP1 (I792_P6_5 I792_pn5 XI792_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I70_XP_MP0 (XI792_I70_XP_p1 I792_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I70_XP_MP1 (I792_P4_3 I792_pn3 XI792_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I69_XP_MP0 (XI792_I69_XP_p1 I792_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I69_XP_MP1 (I792_P3_2 I792_pn2 XI792_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I68_XP_MP0 (XI792_I68_XP_p1 I792_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I68_XP_MP1 (I792_P2_1 I792_pn1 XI792_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I69_XP_MP0 (XI838_I69_XP_p1 I838_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I69_XP_MP1 (I838_P3_2 I838_pn2 XI838_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I70_XP_MP0 (XI838_I70_XP_p1 I838_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I70_XP_MP1 (I838_P4_3 I838_pn3 XI838_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I68_XP_MP0 (XI838_I68_XP_p1 I838_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I68_XP_MP1 (I838_P2_1 I838_pn1 XI838_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I68_XP_MP0 (XI884_I68_XP_p1 I884_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I68_XP_MP1 (I884_P2_1 I884_pn1 XI884_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I69_XP_MP0 (XI884_I69_XP_p1 I884_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I69_XP_MP1 (I884_P3_2 I884_pn2 XI884_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I68_XP_MP0 (XI1712_I68_XP_p1 I1712_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I68_XP_MP1 (I1712_P2_1 I1712_pn1 XI1712_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I68_XP_MP0 (XI1758_I68_XP_p1 I1758_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I68_XP_MP1 (I1758_P2_1 I1758_pn1 XI1758_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I69_XP_MP0 (XI1758_I69_XP_p1 I1758_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I69_XP_MP1 (I1758_P3_2 I1758_pn2 XI1758_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I68_XP_MP0 (XI1804_I68_XP_p1 I1804_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I68_XP_MP1 (I1804_P2_1 I1804_pn1 XI1804_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I69_XP_MP0 (XI1804_I69_XP_p1 I1804_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I69_XP_MP1 (I1804_P3_2 I1804_pn2 XI1804_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I70_XP_MP0 (XI1804_I70_XP_p1 I1804_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I70_XP_MP1 (I1804_P4_3 I1804_pn3 XI1804_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I75_XP_MP0 (XI746_I75_XP_p1 I746_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I75_XP_MP1 (I746_P9_8 I746_pn8 XI746_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I74_XP_MP0 (XI746_I74_XP_p1 I746_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I74_XP_MP1 (I746_P8_7 I746_pn7 XI746_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I73_XP_MP0 (XI746_I73_XP_p1 I746_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I73_XP_MP1 (I746_P7_6 I746_pn6 XI746_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I68_XP_MP0 (XI746_I68_XP_p1 I746_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I68_XP_MP1 (I746_P2_1 I746_pn1 XI746_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I73_XP_MP0 (XI792_I73_XP_p1 I792_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I73_XP_MP1 (I792_P7_6 I792_pn6 XI792_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I74_XP_MP0 (XI792_I74_XP_p1 I792_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I74_XP_MP1 (I792_P8_7 I792_pn7 XI792_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I133_XP_MP0 (XI792_I133_XP_p1 I792_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I133_XP_MP1 (I792_P8_1 I792_P4_1n XI792_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I73_XP_MP0 (XI838_I73_XP_p1 I838_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I73_XP_MP1 (I838_P7_6 I838_pn6 XI838_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I71_XP_MP0 (XI838_I71_XP_p1 I838_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I71_XP_MP1 (I838_P5_4 I838_pn4 XI838_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I72_XP_MP0 (XI838_I72_XP_p1 I838_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I72_XP_MP1 (I838_P6_5 I838_pn5 XI838_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I133_XP_MP0 (XI838_I133_XP_p1 I838_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I133_XP_MP1 (I838_P8_1 I838_P4_1n XI838_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I72_XP_MP0 (XI884_I72_XP_p1 I884_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I72_XP_MP1 (I884_P6_5 I884_pn5 XI884_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I70_XP_MP0 (XI884_I70_XP_p1 I884_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I70_XP_MP1 (I884_P4_3 I884_pn3 XI884_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I71_XP_MP0 (XI884_I71_XP_p1 I884_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I71_XP_MP1 (I884_P5_4 I884_pn4 XI884_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I133_XP_MP0 (XI1712_I133_XP_p1 I1712_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I133_XP_MP1 (I1712_P8_1 I1712_P4_1n XI1712_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I70_XP_MP0 (XI1712_I70_XP_p1 I1712_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I70_XP_MP1 (I1712_P4_3 I1712_pn3 XI1712_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I71_XP_MP0 (XI1712_I71_XP_p1 I1712_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I71_XP_MP1 (I1712_P5_4 I1712_pn4 XI1712_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I69_XP_MP0 (XI1712_I69_XP_p1 I1712_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I69_XP_MP1 (I1712_P3_2 I1712_pn2 XI1712_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I72_XP_MP0 (XI1758_I72_XP_p1 I1758_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I72_XP_MP1 (I1758_P6_5 I1758_pn5 XI1758_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I70_XP_MP0 (XI1758_I70_XP_p1 I1758_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I70_XP_MP1 (I1758_P4_3 I1758_pn3 XI1758_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I71_XP_MP0 (XI1758_I71_XP_p1 I1758_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I71_XP_MP1 (I1758_P5_4 I1758_pn4 XI1758_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I72_XP_MP0 (XI1804_I72_XP_p1 I1804_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I72_XP_MP1 (I1804_P6_5 I1804_pn5 XI1804_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I71_XP_MP0 (XI1804_I71_XP_p1 I1804_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I71_XP_MP1 (I1804_P5_4 I1804_pn4 XI1804_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I133_XP_MP0 (XI1804_I133_XP_p1 I1804_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I133_XP_MP1 (I1804_P8_1 I1804_P4_1n XI1804_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I135_XP_MP0 (XI1804_I135_XP_p1 I1804_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I135_XP_MP1 (I1804_P10_3 I1804_P6_3n XI1804_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I140_XP_MP0 (XI746_I140_XP_p1 I746_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I140_XP_MP1 (I746_P15_8 I746_P11_8n XI746_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I136_XP_MP0 (XI746_I136_XP_p1 I746_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I136_XP_MP1 (I746_P11_4 I746_P7_4n XI746_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I81_XP_MP0 (XI746_I81_XP_p1 I746_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I81_XP_MP1 (I746_P15_14 I746_pn14 XI746_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I79_XP_MP0 (XI746_I79_XP_p1 I746_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I79_XP_MP1 (I746_P13_12 I746_pn12 XI746_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I77_XP_MP0 (XI746_I77_XP_p1 I746_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I77_XP_MP1 (I746_P11_10 I746_pn10 XI746_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I134_XP_MP0 (XI746_I134_XP_p1 I746_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I134_XP_MP1 (I746_P9_2 I746_P5_2n XI746_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I76_XP_MP0 (XI746_I76_XP_p1 I746_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I76_XP_MP1 (I746_P10_9 I746_pn9 XI746_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I75_XP_MP0 (XI792_I75_XP_p1 I792_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I75_XP_MP1 (I792_P9_8 I792_pn8 XI792_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I134_XP_MP0 (XI792_I134_XP_p1 I792_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I134_XP_MP1 (I792_P9_2 I792_P5_2n XI792_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I76_XP_MP0 (XI792_I76_XP_p1 I792_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I76_XP_MP1 (I792_P10_9 I792_pn9 XI792_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I75_XP_MP0 (XI838_I75_XP_p1 I838_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I75_XP_MP1 (I838_P9_8 I838_pn8 XI838_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I134_XP_MP0 (XI838_I134_XP_p1 I838_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I134_XP_MP1 (I838_P9_2 I838_P5_2n XI838_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I74_XP_MP0 (XI838_I74_XP_p1 I838_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I74_XP_MP1 (I838_P8_7 I838_pn7 XI838_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I76_XP_MP0 (XI838_I76_XP_p1 I838_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I76_XP_MP1 (I838_P10_9 I838_pn9 XI838_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I74_XP_MP0 (XI884_I74_XP_p1 I884_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I74_XP_MP1 (I884_P8_7 I884_pn7 XI884_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I133_XP_MP0 (XI884_I133_XP_p1 I884_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I133_XP_MP1 (I884_P8_1 I884_P4_1n XI884_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I73_XP_MP0 (XI884_I73_XP_p1 I884_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I73_XP_MP1 (I884_P7_6 I884_pn6 XI884_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I74_XP_MP0 (XI1712_I74_XP_p1 I1712_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I74_XP_MP1 (I1712_P8_7 I1712_pn7 XI1712_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I72_XP_MP0 (XI1712_I72_XP_p1 I1712_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I72_XP_MP1 (I1712_P6_5 I1712_pn5 XI1712_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I73_XP_MP0 (XI1712_I73_XP_p1 I1712_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I73_XP_MP1 (I1712_P7_6 I1712_pn6 XI1712_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I133_XP_MP0 (XI1758_I133_XP_p1 I1758_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I133_XP_MP1 (I1758_P8_1 I1758_P4_1n XI1758_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I73_XP_MP0 (XI1758_I73_XP_p1 I1758_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I73_XP_MP1 (I1758_P7_6 I1758_pn6 XI1758_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I73_XP_MP0 (XI1804_I73_XP_p1 I1804_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I73_XP_MP1 (I1804_P7_6 I1804_pn6 XI1804_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I76_XP_MP0 (XI1804_I76_XP_p1 I1804_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I76_XP_MP1 (I1804_P10_9 I1804_pn9 XI1804_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I74_XP_MP0 (XI1804_I74_XP_p1 I1804_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I74_XP_MP1 (I1804_P8_7 I1804_pn7 XI1804_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I137_XP_MP0 (XI1804_I137_XP_p1 I1804_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I137_XP_MP1 (I1804_P12_5 I1804_P8_5n XI1804_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I141_XP_MP0 (XI1804_I141_XP_p1 I1804_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I141_XP_MP1 (I1804_P16_9 I1804_P12_9n XI1804_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I148_XP_MP0 (XI746_I148_XP_p1 I746_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I148_XP_MP1 (I746_P23_16 I746_P19_16n XI746_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I144_XP_MP0 (XI746_I144_XP_p1 I746_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I144_XP_MP1 (I746_P19_12 I746_P15_12n XI746_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I87_XP_MP0 (XI746_I87_XP_p1 I746_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I87_XP_MP1 (I746_P21_20 I746_pn20 XI746_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I85_XP_MP0 (XI746_I85_XP_p1 I746_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I85_XP_MP1 (I746_P19_18 I746_pn18 XI746_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I83_XP_MP0 (XI746_I83_XP_p1 I746_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I83_XP_MP1 (I746_P17_16 I746_pn16 XI746_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I142_XP_MP0 (XI746_I142_XP_p1 I746_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I142_XP_MP1 (I746_P17_10 I746_P13_10n XI746_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I138_XP_MP0 (XI746_I138_XP_p1 I746_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I138_XP_MP1 (I746_P13_6 I746_P9_6n XI746_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I78_XP_MP0 (XI746_I78_XP_p1 I746_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I78_XP_MP1 (I746_P12_11 I746_pn11 XI746_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I133_XP_MP0 (XI746_I133_XP_p1 I746_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I133_XP_MP1 (I746_P8_1 I746_P4_1n XI746_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I77_XP_MP0 (XI792_I77_XP_p1 I792_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I77_XP_MP1 (I792_P11_10 I792_pn10 XI792_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I135_XP_MP0 (XI792_I135_XP_p1 I792_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I135_XP_MP1 (I792_P10_3 I792_P6_3n XI792_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I77_XP_MP0 (XI838_I77_XP_p1 I838_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I77_XP_MP1 (I838_P11_10 I838_pn10 XI838_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I138_XP_MP0 (XI838_I138_XP_p1 I838_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I138_XP_MP1 (I838_P13_6 I838_P9_6n XI838_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I141_XP_MP0 (XI838_I141_XP_p1 I838_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I141_XP_MP1 (I838_P16_9 I838_P12_9n XI838_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I137_XP_MP0 (XI838_I137_XP_p1 I838_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I137_XP_MP1 (I838_P12_5 I838_P8_5n XI838_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I135_XP_MP0 (XI838_I135_XP_p1 I838_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I135_XP_MP1 (I838_P10_3 I838_P6_3n XI838_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I76_XP_MP0 (XI884_I76_XP_p1 I884_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I76_XP_MP1 (I884_P10_9 I884_pn9 XI884_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I135_XP_MP0 (XI884_I135_XP_p1 I884_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I135_XP_MP1 (I884_P10_3 I884_P6_3n XI884_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I75_XP_MP0 (XI884_I75_XP_p1 I884_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I75_XP_MP1 (I884_P9_8 I884_pn8 XI884_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I134_XP_MP0 (XI884_I134_XP_p1 I884_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I134_XP_MP1 (I884_P9_2 I884_P5_2n XI884_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I137_XP_MP0 (XI1712_I137_XP_p1 I1712_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I137_XP_MP1 (I1712_P12_5 I1712_P8_5n XI1712_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I75_XP_MP0 (XI1712_I75_XP_p1 I1712_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I75_XP_MP1 (I1712_P9_8 I1712_pn8 XI1712_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I134_XP_MP0 (XI1712_I134_XP_p1 I1712_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I134_XP_MP1 (I1712_P9_2 I1712_P5_2n XI1712_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I74_XP_MP0 (XI1758_I74_XP_p1 I1758_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I74_XP_MP1 (I1758_P8_7 I1758_pn7 XI1758_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I135_XP_MP0 (XI1758_I135_XP_p1 I1758_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I135_XP_MP1 (I1758_P10_3 I1758_P6_3n XI1758_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I75_XP_MP0 (XI1758_I75_XP_p1 I1758_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I75_XP_MP1 (I1758_P9_8 I1758_pn8 XI1758_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I134_XP_MP0 (XI1758_I134_XP_p1 I1758_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I134_XP_MP1 (I1758_P9_2 I1758_P5_2n XI1758_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I75_XP_MP0 (XI1804_I75_XP_p1 I1804_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I75_XP_MP1 (I1804_P9_8 I1804_pn8 XI1804_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I77_XP_MP0 (XI1804_I77_XP_p1 I1804_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I77_XP_MP1 (I1804_P11_10 I1804_pn10 XI1804_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I134_XP_MP0 (XI1804_I134_XP_p1 I1804_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I134_XP_MP1 (I1804_P9_2 I1804_P5_2n XI1804_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I139_XP_MP0 (XI1804_I139_XP_p1 I1804_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I139_XP_MP1 (I1804_P14_7 I1804_P10_7n XI1804_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I143_XP_MP0 (XI1804_I143_XP_p1 I1804_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I143_XP_MP1 (I1804_P18_11 I1804_P14_11n XI1804_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I152_XP_MP0 (XI746_I152_XP_p1 I746_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I152_XP_MP1 (I746_P27_20 I746_P23_20n XI746_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I89_XP_MP0 (XI746_I89_XP_p1 I746_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I89_XP_MP1 (I746_P23_22 I746_pn22 XI746_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I150_XP_MP0 (XI746_I150_XP_p1 I746_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I150_XP_MP1 (I746_P25_18 I746_P21_18n XI746_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I146_XP_MP0 (XI746_I146_XP_p1 I746_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I146_XP_MP1 (I746_P21_14 I746_P17_14n XI746_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I80_XP_MP0 (XI746_I80_XP_p1 I746_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I80_XP_MP1 (I746_P14_13 I746_pn13 XI746_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I84_XP_MP0 (XI746_I84_XP_p1 I746_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I84_XP_MP1 (I746_P18_17 I746_pn17 XI746_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I137_XP_MP0 (XI746_I137_XP_p1 I746_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I137_XP_MP1 (I746_P12_5 I746_P8_5n XI746_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I136_XP_MP0 (XI792_I136_XP_p1 I792_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I136_XP_MP1 (I792_P11_4 I792_P7_4n XI792_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I79_XP_MP0 (XI792_I79_XP_p1 I792_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I79_XP_MP1 (I792_P13_12 I792_pn12 XI792_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I78_XP_MP0 (XI792_I78_XP_p1 I792_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I78_XP_MP1 (I792_P12_11 I792_pn11 XI792_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I141_XP_MP0 (XI792_I141_XP_p1 I792_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I141_XP_MP1 (I792_P16_9 I792_P12_9n XI792_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I137_XP_MP0 (XI792_I137_XP_p1 I792_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I137_XP_MP1 (I792_P12_5 I792_P8_5n XI792_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I79_XP_MP0 (XI838_I79_XP_p1 I838_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I79_XP_MP1 (I838_P13_12 I838_pn12 XI838_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I136_XP_MP0 (XI838_I136_XP_p1 I838_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I136_XP_MP1 (I838_P11_4 I838_P7_4n XI838_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I142_XP_MP0 (XI838_I142_XP_p1 I838_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I142_XP_MP1 (I838_P17_10 I838_P13_10n XI838_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I78_XP_MP0 (XI838_I78_XP_p1 I838_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I78_XP_MP1 (I838_P12_11 I838_pn11 XI838_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I139_XP_MP0 (XI838_I139_XP_p1 I838_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I139_XP_MP1 (I838_P14_7 I838_P10_7n XI838_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I78_XP_MP0 (XI884_I78_XP_p1 I884_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I78_XP_MP1 (I884_P12_11 I884_pn11 XI884_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I141_XP_MP0 (XI884_I141_XP_p1 I884_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I141_XP_MP1 (I884_P16_9 I884_P12_9n XI884_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I137_XP_MP0 (XI884_I137_XP_p1 I884_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I137_XP_MP1 (I884_P12_5 I884_P8_5n XI884_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I77_XP_MP0 (XI884_I77_XP_p1 I884_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I77_XP_MP1 (I884_P11_10 I884_pn10 XI884_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I135_XP_MP0 (XI1712_I135_XP_p1 I1712_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I135_XP_MP1 (I1712_P10_3 I1712_P6_3n XI1712_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I141_XP_MP0 (XI1712_I141_XP_p1 I1712_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I141_XP_MP1 (I1712_P16_9 I1712_P12_9n XI1712_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I76_XP_MP0 (XI1712_I76_XP_p1 I1712_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I76_XP_MP1 (I1712_P10_9 I1712_pn9 XI1712_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I76_XP_MP0 (XI1758_I76_XP_p1 I1758_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I76_XP_MP1 (I1758_P10_9 I1758_pn9 XI1758_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I137_XP_MP0 (XI1758_I137_XP_p1 I1758_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I137_XP_MP1 (I1758_P12_5 I1758_P8_5n XI1758_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I141_XP_MP0 (XI1758_I141_XP_p1 I1758_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I141_XP_MP1 (I1758_P16_9 I1758_P12_9n XI1758_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I77_XP_MP0 (XI1758_I77_XP_p1 I1758_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I77_XP_MP1 (I1758_P11_10 I1758_pn10 XI1758_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I136_XP_MP0 (XI1758_I136_XP_p1 I1758_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I136_XP_MP1 (I1758_P11_4 I1758_P7_4n XI1758_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I78_XP_MP0 (XI1804_I78_XP_p1 I1804_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I78_XP_MP1 (I1804_P12_11 I1804_pn11 XI1804_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I136_XP_MP0 (XI1804_I136_XP_p1 I1804_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I136_XP_MP1 (I1804_P11_4 I1804_P7_4n XI1804_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I145_XP_MP0 (XI1804_I145_XP_p1 I1804_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I145_XP_MP1 (I1804_P20_13 I1804_P16_13n XI1804_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I156_XP_MP0 (XI746_I156_XP_p1 I746_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I156_XP_MP1 (I746_P31_24 I746_P27_24n XI746_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I154_XP_MP0 (XI746_I154_XP_p1 I746_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I154_XP_MP1 (I746_P29_22 I746_P25_22n XI746_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I86_XP_MP0 (XI746_I86_XP_p1 I746_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I86_XP_MP1 (I746_P20_19 I746_pn19 XI746_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I82_XP_MP0 (XI746_I82_XP_p1 I746_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I82_XP_MP1 (I746_P16_15 I746_pn15 XI746_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I141_XP_MP0 (XI746_I141_XP_p1 I746_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I141_XP_MP1 (I746_P16_9 I746_P12_9n XI746_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I135_XP_MP0 (XI746_I135_XP_p1 I746_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I135_XP_MP1 (I746_P10_3 I746_P6_3n XI746_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I83_XP_MP0 (XI792_I83_XP_p1 I792_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I83_XP_MP1 (I792_P17_16 I792_pn16 XI792_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I81_XP_MP0 (XI792_I81_XP_p1 I792_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I81_XP_MP1 (I792_P15_14 I792_pn14 XI792_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I142_XP_MP0 (XI792_I142_XP_p1 I792_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I142_XP_MP1 (I792_P17_10 I792_P13_10n XI792_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I138_XP_MP0 (XI792_I138_XP_p1 I792_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I138_XP_MP1 (I792_P13_6 I792_P9_6n XI792_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I82_XP_MP0 (XI792_I82_XP_p1 I792_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I82_XP_MP1 (I792_P16_15 I792_pn15 XI792_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I80_XP_MP0 (XI792_I80_XP_p1 I792_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I80_XP_MP1 (I792_P14_13 I792_pn13 XI792_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I84_XP_MP0 (XI792_I84_XP_p1 I792_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I84_XP_MP1 (I792_P18_17 I792_pn17 XI792_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I143_XP_MP0 (XI792_I143_XP_p1 I792_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I143_XP_MP1 (I792_P18_11 I792_P14_11n XI792_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I139_XP_MP0 (XI792_I139_XP_p1 I792_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I139_XP_MP1 (I792_P14_7 I792_P10_7n XI792_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I140_XP_MP0 (XI838_I140_XP_p1 I838_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I140_XP_MP1 (I838_P15_8 I838_P11_8n XI838_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I150_XP_MP0 (XI838_I150_XP_p1 I838_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I150_XP_MP1 (I838_P25_18 I838_P21_18n XI838_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I80_XP_MP0 (XI838_I80_XP_p1 I838_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I80_XP_MP1 (I838_P14_13 I838_pn13 XI838_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I145_XP_MP0 (XI838_I145_XP_p1 I838_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I145_XP_MP1 (I838_P20_13 I838_P16_13n XI838_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I149_XP_MP0 (XI838_I149_XP_p1 I838_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I149_XP_MP1 (I838_P24_17 I838_P20_17n XI838_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I143_XP_MP0 (XI838_I143_XP_p1 I838_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I143_XP_MP1 (I838_P18_11 I838_P14_11n XI838_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I80_XP_MP0 (XI884_I80_XP_p1 I884_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I80_XP_MP1 (I884_P14_13 I884_pn13 XI884_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I143_XP_MP0 (XI884_I143_XP_p1 I884_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I143_XP_MP1 (I884_P18_11 I884_P14_11n XI884_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I139_XP_MP0 (XI884_I139_XP_p1 I884_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I139_XP_MP1 (I884_P14_7 I884_P10_7n XI884_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I79_XP_MP0 (XI884_I79_XP_p1 I884_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I79_XP_MP1 (I884_P13_12 I884_pn12 XI884_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I138_XP_MP0 (XI884_I138_XP_p1 I884_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I138_XP_MP1 (I884_P13_6 I884_P9_6n XI884_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I142_XP_MP0 (XI884_I142_XP_p1 I884_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I142_XP_MP1 (I884_P17_10 I884_P13_10n XI884_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I149_XP_MP0 (XI1712_I149_XP_p1 I1712_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I149_XP_MP1 (I1712_P24_17 I1712_P20_17n XI1712_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I145_XP_MP0 (XI1712_I145_XP_p1 I1712_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I145_XP_MP1 (I1712_P20_13 I1712_P16_13n XI1712_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I80_XP_MP0 (XI1712_I80_XP_p1 I1712_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I80_XP_MP1 (I1712_P14_13 I1712_pn13 XI1712_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I78_XP_MP0 (XI1712_I78_XP_p1 I1712_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I78_XP_MP1 (I1712_P12_11 I1712_pn11 XI1712_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I77_XP_MP0 (XI1712_I77_XP_p1 I1712_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I77_XP_MP1 (I1712_P11_10 I1712_pn10 XI1712_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I138_XP_MP0 (XI1712_I138_XP_p1 I1712_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I138_XP_MP1 (I1712_P13_6 I1712_P9_6n XI1712_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I136_XP_MP0 (XI1712_I136_XP_p1 I1712_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I136_XP_MP1 (I1712_P11_4 I1712_P7_4n XI1712_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I78_XP_MP0 (XI1758_I78_XP_p1 I1758_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I78_XP_MP1 (I1758_P12_11 I1758_pn11 XI1758_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I143_XP_MP0 (XI1758_I143_XP_p1 I1758_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I143_XP_MP1 (I1758_P18_11 I1758_P14_11n XI1758_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I139_XP_MP0 (XI1758_I139_XP_p1 I1758_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I139_XP_MP1 (I1758_P14_7 I1758_P10_7n XI1758_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I79_XP_MP0 (XI1758_I79_XP_p1 I1758_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I79_XP_MP1 (I1758_P13_12 I1758_pn12 XI1758_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I138_XP_MP0 (XI1758_I138_XP_p1 I1758_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I138_XP_MP1 (I1758_P13_6 I1758_P9_6n XI1758_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I142_XP_MP0 (XI1758_I142_XP_p1 I1758_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I142_XP_MP1 (I1758_P17_10 I1758_P13_10n XI1758_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I79_XP_MP0 (XI1804_I79_XP_p1 I1804_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I79_XP_MP1 (I1804_P13_12 I1804_pn12 XI1804_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I138_XP_MP0 (XI1804_I138_XP_p1 I1804_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I138_XP_MP1 (I1804_P13_6 I1804_P9_6n XI1804_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I142_XP_MP0 (XI1804_I142_XP_p1 I1804_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I142_XP_MP1 (I1804_P17_10 I1804_P13_10n XI1804_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I80_XP_MP0 (XI1804_I80_XP_p1 I1804_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I80_XP_MP1 (I1804_P14_13 I1804_pn13 XI1804_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I84_XP_MP0 (XI1804_I84_XP_p1 I1804_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I84_XP_MP1 (I1804_P18_17 I1804_pn17 XI1804_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I149_XP_MP0 (XI1804_I149_XP_p1 I1804_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I149_XP_MP1 (I1804_P24_17 I1804_P20_17n XI1804_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I147_XP_MP0 (XI1804_I147_XP_p1 I1804_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I147_XP_MP1 (I1804_P22_15 I1804_P18_15n XI1804_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I91_XP_MP0 (XI746_I91_XP_p1 I746_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I91_XP_MP1 (I746_P25_24 I746_pn24 XI746_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I88_XP_MP0 (XI746_I88_XP_p1 I746_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I88_XP_MP1 (I746_P22_21 I746_pn21 XI746_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I149_XP_MP0 (XI746_I149_XP_p1 I746_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I149_XP_MP1 (I746_P24_17 I746_P20_17n XI746_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I145_XP_MP0 (XI746_I145_XP_p1 I746_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I145_XP_MP1 (I746_P20_13 I746_P16_13n XI746_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I143_XP_MP0 (XI746_I143_XP_p1 I746_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I143_XP_MP1 (I746_P18_11 I746_P14_11n XI746_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I139_XP_MP0 (XI746_I139_XP_p1 I746_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I139_XP_MP1 (I746_P14_7 I746_P10_7n XI746_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I85_XP_MP0 (XI792_I85_XP_p1 I792_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I85_XP_MP1 (I792_P19_18 I792_pn18 XI792_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I144_XP_MP0 (XI792_I144_XP_p1 I792_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I144_XP_MP1 (I792_P19_12 I792_P15_12n XI792_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I140_XP_MP0 (XI792_I140_XP_p1 I792_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I140_XP_MP1 (I792_P15_8 I792_P11_8n XI792_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I149_XP_MP0 (XI792_I149_XP_p1 I792_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I149_XP_MP1 (I792_P24_17 I792_P20_17n XI792_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I145_XP_MP0 (XI792_I145_XP_p1 I792_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I145_XP_MP1 (I792_P20_13 I792_P16_13n XI792_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I81_XP_MP0 (XI838_I81_XP_p1 I838_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I81_XP_MP1 (I838_P15_14 I838_pn14 XI838_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I144_XP_MP0 (XI838_I144_XP_p1 I838_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I144_XP_MP1 (I838_P19_12 I838_P15_12n XI838_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I146_XP_MP0 (XI838_I146_XP_p1 I838_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I146_XP_MP1 (I838_P21_14 I838_P17_14n XI838_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I82_XP_MP0 (XI838_I82_XP_p1 I838_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I82_XP_MP1 (I838_P16_15 I838_pn15 XI838_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I82_XP_MP0 (XI884_I82_XP_p1 I884_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I82_XP_MP1 (I884_P16_15 I884_pn15 XI884_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I81_XP_MP0 (XI884_I81_XP_p1 I884_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I81_XP_MP1 (I884_P15_14 I884_pn14 XI884_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I145_XP_MP0 (XI884_I145_XP_p1 I884_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I145_XP_MP1 (I884_P20_13 I884_P16_13n XI884_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I143_XP_MP0 (XI1712_I143_XP_p1 I1712_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I143_XP_MP1 (I1712_P18_11 I1712_P14_11n XI1712_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I139_XP_MP0 (XI1712_I139_XP_p1 I1712_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I139_XP_MP1 (I1712_P14_7 I1712_P10_7n XI1712_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I79_XP_MP0 (XI1712_I79_XP_p1 I1712_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I79_XP_MP1 (I1712_P13_12 I1712_pn12 XI1712_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I142_XP_MP0 (XI1712_I142_XP_p1 I1712_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I142_XP_MP1 (I1712_P17_10 I1712_P13_10n XI1712_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I80_XP_MP0 (XI1758_I80_XP_p1 I1758_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I80_XP_MP1 (I1758_P14_13 I1758_pn13 XI1758_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I145_XP_MP0 (XI1758_I145_XP_p1 I1758_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I145_XP_MP1 (I1758_P20_13 I1758_P16_13n XI1758_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I81_XP_MP0 (XI1758_I81_XP_p1 I1758_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I81_XP_MP1 (I1758_P15_14 I1758_pn14 XI1758_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I140_XP_MP0 (XI1758_I140_XP_p1 I1758_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I140_XP_MP1 (I1758_P15_8 I1758_P11_8n XI1758_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I81_XP_MP0 (XI1804_I81_XP_p1 I1804_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I81_XP_MP1 (I1804_P15_14 I1804_pn14 XI1804_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I82_XP_MP0 (XI1804_I82_XP_p1 I1804_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I82_XP_MP1 (I1804_P16_15 I1804_pn15 XI1804_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I83_XP_MP0 (XI1804_I83_XP_p1 I1804_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I83_XP_MP1 (I1804_P17_16 I1804_pn16 XI1804_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I86_XP_MP0 (XI1804_I86_XP_p1 I1804_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I86_XP_MP1 (I1804_P20_19 I1804_pn19 XI1804_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I153_XP_MP0 (XI1804_I153_XP_p1 I1804_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I153_XP_MP1 (I1804_P28_21 I1804_P24_21n XI1804_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I155_XP_MP0 (XI1804_I155_XP_p1 I1804_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I155_XP_MP1 (I1804_P30_23 I1804_P26_23n XI1804_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I151_XP_MP0 (XI1804_I151_XP_p1 I1804_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I151_XP_MP1 (I1804_P26_19 I1804_P22_19n XI1804_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I93_XP_MP0 (XI746_I93_XP_p1 I746_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I93_XP_MP1 (I746_P27_26 I746_pn26 XI746_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I90_XP_MP0 (XI746_I90_XP_p1 I746_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I90_XP_MP1 (I746_P24_23 I746_pn23 XI746_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I92_XP_MP0 (XI746_I92_XP_p1 I746_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I92_XP_MP1 (I746_P26_25 I746_pn25 XI746_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I153_XP_MP0 (XI746_I153_XP_p1 I746_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I153_XP_MP1 (I746_P28_21 I746_P24_21n XI746_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I87_XP_MP0 (XI792_I87_XP_p1 I792_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I87_XP_MP1 (I792_P21_20 I792_pn20 XI792_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I150_XP_MP0 (XI792_I150_XP_p1 I792_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I150_XP_MP1 (I792_P25_18 I792_P21_18n XI792_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I146_XP_MP0 (XI792_I146_XP_p1 I792_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I146_XP_MP1 (I792_P21_14 I792_P17_14n XI792_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I86_XP_MP0 (XI792_I86_XP_p1 I792_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I86_XP_MP1 (I792_P20_19 I792_pn19 XI792_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I153_XP_MP0 (XI792_I153_XP_p1 I792_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I153_XP_MP1 (I792_P28_21 I792_P24_21n XI792_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I83_XP_MP0 (XI838_I83_XP_p1 I838_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I83_XP_MP1 (I838_P17_16 I838_pn16 XI838_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I85_XP_MP0 (XI838_I85_XP_p1 I838_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I85_XP_MP1 (I838_P19_18 I838_pn18 XI838_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I84_XP_MP0 (XI838_I84_XP_p1 I838_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I84_XP_MP1 (I838_P18_17 I838_pn17 XI838_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I147_XP_MP0 (XI838_I147_XP_p1 I838_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I147_XP_MP1 (I838_P22_15 I838_P18_15n XI838_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I151_XP_MP0 (XI838_I151_XP_p1 I838_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I151_XP_MP1 (I838_P26_19 I838_P22_19n XI838_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I83_XP_MP0 (XI884_I83_XP_p1 I884_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I83_XP_MP1 (I884_P17_16 I884_pn16 XI884_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I84_XP_MP0 (XI884_I84_XP_p1 I884_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I84_XP_MP1 (I884_P18_17 I884_pn17 XI884_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I147_XP_MP0 (XI884_I147_XP_p1 I884_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I147_XP_MP1 (I884_P22_15 I884_P18_15n XI884_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I149_XP_MP0 (XI884_I149_XP_p1 I884_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I149_XP_MP1 (I884_P24_17 I884_P20_17n XI884_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I146_XP_MP0 (XI884_I146_XP_p1 I884_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I146_XP_MP1 (I884_P21_14 I884_P17_14n XI884_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I150_XP_MP0 (XI884_I150_XP_p1 I884_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I150_XP_MP1 (I884_P25_18 I884_P21_18n XI884_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I136_XP_MP0 (XI884_I136_XP_p1 I884_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I136_XP_MP1 (I884_P11_4 I884_P7_4n XI884_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I144_XP_MP0 (XI884_I144_XP_p1 I884_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I144_XP_MP1 (I884_P19_12 I884_P15_12n XI884_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I140_XP_MP0 (XI884_I140_XP_p1 I884_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I140_XP_MP1 (I884_P15_8 I884_P11_8n XI884_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I147_XP_MP0 (XI1712_I147_XP_p1 I1712_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I147_XP_MP1 (I1712_P22_15 I1712_P18_15n XI1712_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I82_XP_MP0 (XI1712_I82_XP_p1 I1712_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I82_XP_MP1 (I1712_P16_15 I1712_pn15 XI1712_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I81_XP_MP0 (XI1712_I81_XP_p1 I1712_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I81_XP_MP1 (I1712_P15_14 I1712_pn14 XI1712_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I146_XP_MP0 (XI1712_I146_XP_p1 I1712_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I146_XP_MP1 (I1712_P21_14 I1712_P17_14n XI1712_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I144_XP_MP0 (XI1712_I144_XP_p1 I1712_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I144_XP_MP1 (I1712_P19_12 I1712_P15_12n XI1712_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I140_XP_MP0 (XI1712_I140_XP_p1 I1712_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I140_XP_MP1 (I1712_P15_8 I1712_P11_8n XI1712_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I82_XP_MP0 (XI1758_I82_XP_p1 I1758_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I82_XP_MP1 (I1758_P16_15 I1758_pn15 XI1758_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I84_XP_MP0 (XI1758_I84_XP_p1 I1758_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I84_XP_MP1 (I1758_P18_17 I1758_pn17 XI1758_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I149_XP_MP0 (XI1758_I149_XP_p1 I1758_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I149_XP_MP1 (I1758_P24_17 I1758_P20_17n XI1758_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I153_XP_MP0 (XI1758_I153_XP_p1 I1758_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I153_XP_MP1 (I1758_P28_21 I1758_P24_21n XI1758_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I83_XP_MP0 (XI1758_I83_XP_p1 I1758_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I83_XP_MP1 (I1758_P17_16 I1758_pn16 XI1758_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I146_XP_MP0 (XI1758_I146_XP_p1 I1758_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I146_XP_MP1 (I1758_P21_14 I1758_P17_14n XI1758_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I150_XP_MP0 (XI1758_I150_XP_p1 I1758_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I150_XP_MP1 (I1758_P25_18 I1758_P21_18n XI1758_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I144_XP_MP0 (XI1758_I144_XP_p1 I1758_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I144_XP_MP1 (I1758_P19_12 I1758_P15_12n XI1758_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I140_XP_MP0 (XI1804_I140_XP_p1 I1804_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I140_XP_MP1 (I1804_P15_8 I1804_P11_8n XI1804_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I144_XP_MP0 (XI1804_I144_XP_p1 I1804_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I144_XP_MP1 (I1804_P19_12 I1804_P15_12n XI1804_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I146_XP_MP0 (XI1804_I146_XP_p1 I1804_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I146_XP_MP1 (I1804_P21_14 I1804_P17_14n XI1804_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I88_XP_MP0 (XI1804_I88_XP_p1 I1804_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I88_XP_MP1 (I1804_P22_21 I1804_pn21 XI1804_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I92_XP_MP0 (XI1804_I92_XP_p1 I1804_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I92_XP_MP1 (I1804_P26_25 I1804_pn25 XI1804_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I151_XP_MP0 (XI746_I151_XP_p1 I746_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I151_XP_MP1 (I746_P26_19 I746_P22_19n XI746_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I147_XP_MP0 (XI746_I147_XP_p1 I746_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I147_XP_MP1 (I746_P22_15 I746_P18_15n XI746_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I89_XP_MP0 (XI792_I89_XP_p1 I792_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I89_XP_MP1 (I792_P23_22 I792_pn22 XI792_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I154_XP_MP0 (XI792_I154_XP_p1 I792_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I154_XP_MP1 (I792_P29_22 I792_P25_22n XI792_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I88_XP_MP0 (XI792_I88_XP_p1 I792_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I88_XP_MP1 (I792_P22_21 I792_pn21 XI792_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I90_XP_MP0 (XI792_I90_XP_p1 I792_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I90_XP_MP1 (I792_P24_23 I792_pn23 XI792_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I147_XP_MP0 (XI792_I147_XP_p1 I792_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I147_XP_MP1 (I792_P22_15 I792_P18_15n XI792_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I152_XP_MP0 (XI838_I152_XP_p1 I838_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I152_XP_MP1 (I838_P27_20 I838_P23_20n XI838_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I148_XP_MP0 (XI838_I148_XP_p1 I838_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I148_XP_MP1 (I838_P23_16 I838_P19_16n XI838_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I154_XP_MP0 (XI838_I154_XP_p1 I838_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I154_XP_MP1 (I838_P29_22 I838_P25_22n XI838_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I86_XP_MP0 (XI838_I86_XP_p1 I838_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I86_XP_MP1 (I838_P20_19 I838_pn19 XI838_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I153_XP_MP0 (XI838_I153_XP_p1 I838_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I153_XP_MP1 (I838_P28_21 I838_P24_21n XI838_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I86_XP_MP0 (XI884_I86_XP_p1 I884_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I86_XP_MP1 (I884_P20_19 I884_pn19 XI884_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I85_XP_MP0 (XI884_I85_XP_p1 I884_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I85_XP_MP1 (I884_P19_18 I884_pn18 XI884_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
