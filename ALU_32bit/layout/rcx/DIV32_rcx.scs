    I_MXI1758_I145_XG_MN0 (I1758_G20_13 I1758_P20_17n XI1758_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I145_XG_MN1 (XI1758_I145_XG_n1 I1758_G16_13n I1758_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I143_XG_MN2 (XI1758_I143_XG_n1 I1758_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I143_XG_MN0 (I1758_G18_11 I1758_P18_15n XI1758_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I143_XG_MN1 (XI1758_I143_XG_n1 I1758_G14_11n I1758_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I197_XG_MN2 (XI1758_I197_XG_n1 I1758_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I197_XG_MN0 (I1758_G26_0 I1758_P26_11n XI1758_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I197_XG_MN1 (XI1758_I197_XG_n1 I1758_G10_0n I1758_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I142_XG_MN2 (XI1758_I142_XG_n1 I1758_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I142_XG_MN0 (I1758_G17_10 I1758_P17_14n XI1758_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I142_XG_MN1 (XI1758_I142_XG_n1 I1758_G13_10n I1758_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I186_XG_MN2 (XI1758_I186_XG_n1 I1758_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I186_XG_MN0 (I1758_G19_0 I1758_P19_4n XI1758_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I186_XG_MN1 (XI1758_I186_XG_n1 I1758_G3_0n I1758_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I81_XG_MN2 (XI1804_I81_XG_n1 I1804_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I81_XG_MN0 (I1804_G15_14 I1804_pn15 XI1804_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I81_XG_MN1 (XI1804_I81_XG_n1 I1804_gn14 I1804_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I82_XG_MN2 (XI1804_I82_XG_n1 I1804_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I82_XG_MN0 (I1804_G16_15 I1804_pn16 XI1804_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I82_XG_MN1 (XI1804_I82_XG_n1 I1804_gn15 I1804_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I142_XG_MN2 (XI1804_I142_XG_n1 I1804_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I142_XG_MN0 (I1804_G17_10 I1804_P17_14n XI1804_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I142_XG_MN1 (XI1804_I142_XG_n1 I1804_G13_10n I1804_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I196_XG_MN2 (XI1804_I196_XG_n1 I1804_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I196_XG_MN0 (I1804_G25_0 I1804_P25_10n XI1804_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I196_XG_MN1 (XI1804_I196_XG_n1 I1804_G9_0n I1804_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I190_XG_MN2 (XI1804_I190_XG_n1 I1804_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I190_XG_MN0 (I1804_G21_0 I1804_P21_6n XI1804_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I190_XG_MN1 (XI1804_I190_XG_n1 I1804_G5_0n I1804_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I147_XG_MN2 (XI1804_I147_XG_n1 I1804_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I147_XG_MN0 (I1804_G22_15 I1804_P22_19n XI1804_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I147_XG_MN1 (XI1804_I147_XG_n1 I1804_G18_15n I1804_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I90_XG_MN2 (XI746_I90_XG_n1 I746_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I90_XG_MN0 (I746_G24_23 I746_pn24 XI746_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I90_XG_MN1 (XI746_I90_XG_n1 I746_gn23 I746_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I92_XG_MN2 (XI746_I92_XG_n1 I746_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I92_XG_MN0 (I746_G26_25 I746_pn26 XI746_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I92_XG_MN1 (XI746_I92_XG_n1 I746_gn25 I746_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I153_XG_MN2 (XI746_I153_XG_n1 I746_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I153_XG_MN0 (I746_G28_21 I746_P28_25n XI746_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I153_XG_MN1 (XI746_I153_XG_n1 I746_G24_21n I746_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I147_XG_MN2 (XI746_I147_XG_n1 I746_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I147_XG_MN0 (I746_G22_15 I746_P22_19n XI746_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I147_XG_MN1 (XI746_I147_XG_n1 I746_G18_15n I746_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I199_XG_MN2 (XI746_I199_XG_n1 I746_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I199_XG_MN0 (I746_G28_0 I746_P28_13n XI746_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I199_XG_MN1 (XI746_I199_XG_n1 I746_G12_0n I746_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I192_XG_MN2 (XI746_I192_XG_n1 I746_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I192_XG_MN0 (I746_G22_0 I746_P22_7n XI746_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I192_XG_MN1 (XI746_I192_XG_n1 I746_G6_0n I746_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I87_XG_MN2 (XI792_I87_XG_n1 I792_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I87_XG_MN0 (I792_G21_20 I792_pn21 XI792_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I87_XG_MN1 (XI792_I87_XG_n1 I792_gn20 I792_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I86_XG_MN2 (XI792_I86_XG_n1 I792_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I86_XG_MN0 (I792_G20_19 I792_pn20 XI792_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I86_XG_MN1 (XI792_I86_XG_n1 I792_gn19 I792_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I146_XG_MN2 (XI792_I146_XG_n1 I792_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I146_XG_MN0 (I792_G21_14 I792_P21_18n XI792_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I146_XG_MN1 (XI792_I146_XG_n1 I792_G17_14n I792_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I190_XG_MN2 (XI792_I190_XG_n1 I792_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I190_XG_MN0 (I792_G21_0 I792_P21_6n XI792_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I190_XG_MN1 (XI792_I190_XG_n1 I792_G5_0n I792_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I196_XG_MN2 (XI792_I196_XG_n1 I792_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I196_XG_MN0 (I792_G25_0 I792_P25_10n XI792_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I196_XG_MN1 (XI792_I196_XG_n1 I792_G9_0n I792_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I149_XG_MN2 (XI792_I149_XG_n1 I792_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I149_XG_MN0 (I792_G24_17 I792_P24_21n XI792_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I149_XG_MN1 (XI792_I149_XG_n1 I792_G20_17n I792_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I199_XG_MN2 (XI792_I199_XG_n1 I792_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I199_XG_MN0 (I792_G28_0 I792_P28_13n XI792_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I199_XG_MN1 (XI792_I199_XG_n1 I792_G12_0n I792_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I82_XG_MN2 (XI838_I82_XG_n1 I838_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I82_XG_MN0 (I838_G16_15 I838_pn16 XI838_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I82_XG_MN1 (XI838_I82_XG_n1 I838_gn15 I838_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I83_XG_MN2 (XI838_I83_XG_n1 I838_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I83_XG_MN0 (I838_G17_16 I838_pn17 XI838_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I83_XG_MN1 (XI838_I83_XG_n1 I838_gn16 I838_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I198_XG_MN2 (XI838_I198_XG_n1 I838_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I198_XG_MN0 (I838_G27_0 I838_P27_12n XI838_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I198_XG_MN1 (XI838_I198_XG_n1 I838_G11_0n I838_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I84_XG_MN2 (XI838_I84_XG_n1 I838_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I84_XG_MN0 (I838_G18_17 I838_pn18 XI838_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I84_XG_MN1 (XI838_I84_XG_n1 I838_gn17 I838_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I199_XG_MN2 (XI838_I199_XG_n1 I838_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I199_XG_MN0 (I838_G28_0 I838_P28_13n XI838_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I199_XG_MN1 (XI838_I199_XG_n1 I838_G12_0n I838_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I83_XG_MN2 (XI884_I83_XG_n1 I884_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I83_XG_MN0 (I884_G17_16 I884_pn17 XI884_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I83_XG_MN1 (XI884_I83_XG_n1 I884_gn16 I884_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I192_XG_MN2 (XI884_I192_XG_n1 I884_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I192_XG_MN0 (I884_G22_0 I884_P22_7n XI884_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I192_XG_MN1 (XI884_I192_XG_n1 I884_G6_0n I884_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I145_XG_MN2 (XI884_I145_XG_n1 I884_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I145_XG_MN0 (I884_G20_13 I884_P20_17n XI884_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I145_XG_MN1 (XI884_I145_XG_n1 I884_G16_13n I884_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I149_XG_MN2 (XI884_I149_XG_n1 I884_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I149_XG_MN0 (I884_G24_17 I884_P24_21n XI884_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I149_XG_MN1 (XI884_I149_XG_n1 I884_G20_17n I884_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I146_XG_MN2 (XI884_I146_XG_n1 I884_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I146_XG_MN0 (I884_G21_14 I884_P21_18n XI884_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I146_XG_MN1 (XI884_I146_XG_n1 I884_G17_14n I884_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I140_XG_MN2 (XI884_I140_XG_n1 I884_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I140_XG_MN0 (I884_G15_8 I884_P15_12n XI884_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I140_XG_MN1 (XI884_I140_XG_n1 I884_G11_8n I884_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I197_XG_MN2 (XI1712_I197_XG_n1 I1712_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I197_XG_MN0 (I1712_G26_0 I1712_P26_11n XI1712_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I197_XG_MN1 (XI1712_I197_XG_n1 I1712_G10_0n I1712_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I149_XG_MN2 (XI1712_I149_XG_n1 I1712_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I149_XG_MN0 (I1712_G24_17 I1712_P24_21n XI1712_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I149_XG_MN1 (XI1712_I149_XG_n1 I1712_G20_17n I1712_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I81_XG_MN2 (XI1712_I81_XG_n1 I1712_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I81_XG_MN0 (I1712_G15_14 I1712_pn15 XI1712_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I81_XG_MN1 (XI1712_I81_XG_n1 I1712_gn14 I1712_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I140_XG_MN2 (XI1712_I140_XG_n1 I1712_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I140_XG_MN0 (I1712_G15_8 I1712_P15_12n XI1712_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I140_XG_MN1 (XI1712_I140_XG_n1 I1712_G11_8n I1712_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I82_XG_MN2 (XI1758_I82_XG_n1 I1758_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I82_XG_MN0 (I1758_G16_15 I1758_pn16 XI1758_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I82_XG_MN1 (XI1758_I82_XG_n1 I1758_gn15 I1758_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I83_XG_MN2 (XI1758_I83_XG_n1 I1758_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I83_XG_MN0 (I1758_G17_16 I1758_pn17 XI1758_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I83_XG_MN1 (XI1758_I83_XG_n1 I1758_gn16 I1758_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I149_XG_MN2 (XI1758_I149_XG_n1 I1758_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I149_XG_MN0 (I1758_G24_17 I1758_P24_21n XI1758_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I149_XG_MN1 (XI1758_I149_XG_n1 I1758_G20_17n I1758_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I199_XG_MN2 (XI1758_I199_XG_n1 I1758_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I199_XG_MN0 (I1758_G28_0 I1758_P28_13n XI1758_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I199_XG_MN1 (XI1758_I199_XG_n1 I1758_G12_0n I1758_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I146_XG_MN2 (XI1758_I146_XG_n1 I1758_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I146_XG_MN0 (I1758_G21_14 I1758_P21_18n XI1758_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I146_XG_MN1 (XI1758_I146_XG_n1 I1758_G17_14n I1758_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I190_XG_MN2 (XI1758_I190_XG_n1 I1758_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I190_XG_MN0 (I1758_G21_0 I1758_P21_6n XI1758_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I190_XG_MN1 (XI1758_I190_XG_n1 I1758_G5_0n I1758_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I140_XG_MN2 (XI1758_I140_XG_n1 I1758_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I140_XG_MN0 (I1758_G15_8 I1758_P15_12n XI1758_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I140_XG_MN1 (XI1758_I140_XG_n1 I1758_G11_8n I1758_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I144_XG_MN2 (XI1758_I144_XG_n1 I1758_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I144_XG_MN0 (I1758_G19_12 I1758_P19_16n XI1758_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I144_XG_MN1 (XI1758_I144_XG_n1 I1758_G15_12n I1758_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I83_XG_MN2 (XI1804_I83_XG_n1 I1804_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I83_XG_MN0 (I1804_G17_16 I1804_pn17 XI1804_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I83_XG_MN1 (XI1804_I83_XG_n1 I1804_gn16 I1804_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I84_XG_MN2 (XI1804_I84_XG_n1 I1804_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I84_XG_MN0 (I1804_G18_17 I1804_pn18 XI1804_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I84_XG_MN1 (XI1804_I84_XG_n1 I1804_gn17 I1804_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I140_XG_MN2 (XI1804_I140_XG_n1 I1804_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I140_XG_MN0 (I1804_G15_8 I1804_P15_12n XI1804_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I140_XG_MN1 (XI1804_I140_XG_n1 I1804_G11_8n I1804_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I144_XG_MN2 (XI1804_I144_XG_n1 I1804_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I144_XG_MN0 (I1804_G19_12 I1804_P19_16n XI1804_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I144_XG_MN1 (XI1804_I144_XG_n1 I1804_G15_12n I1804_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I198_XG_MN2 (XI1804_I198_XG_n1 I1804_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I198_XG_MN0 (I1804_G27_0 I1804_P27_12n XI1804_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I198_XG_MN1 (XI1804_I198_XG_n1 I1804_G11_0n I1804_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I146_XG_MN2 (XI1804_I146_XG_n1 I1804_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I146_XG_MN0 (I1804_G21_14 I1804_P21_18n XI1804_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I146_XG_MN1 (XI1804_I146_XG_n1 I1804_G17_14n I1804_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I200_XG_MN2 (XI1804_I200_XG_n1 I1804_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I200_XG_MN0 (I1804_G29_0 I1804_P29_14n XI1804_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I200_XG_MN1 (XI1804_I200_XG_n1 I1804_G13_0n I1804_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I153_XG_MN2 (XI1804_I153_XG_n1 I1804_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I153_XG_MN0 (I1804_G28_21 I1804_P28_25n XI1804_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I153_XG_MN1 (XI1804_I153_XG_n1 I1804_G24_21n I1804_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I151_XG_MN2 (XI1804_I151_XG_n1 I1804_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I151_XG_MN0 (I1804_G26_19 I1804_P26_23n XI1804_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I151_XG_MN1 (XI1804_I151_XG_n1 I1804_G22_19n I1804_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I97_XG_MN2 (XI746_I97_XG_n1 I746_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I97_XG_MN0 (I746_G31_30 I746_pn31 XI746_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I97_XG_MN1 (XI746_I97_XG_n1 I746_gn30 I746_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I93_XG_MN2 (XI746_I93_XG_n1 I746_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I93_XG_MN0 (I746_G27_26 I746_pn27 XI746_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I93_XG_MN1 (XI746_I93_XG_n1 I746_gn26 I746_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I151_XG_MN2 (XI746_I151_XG_n1 I746_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I151_XG_MN0 (I746_G26_19 I746_P26_23n XI746_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I151_XG_MN1 (XI746_I151_XG_n1 I746_G22_19n I746_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I197_XG_MN2 (XI746_I197_XG_n1 I746_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I197_XG_MN0 (I746_G26_0 I746_P26_11n XI746_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I197_XG_MN1 (XI746_I197_XG_n1 I746_G10_0n I746_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I90_XG_MN2 (XI792_I90_XG_n1 I792_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I90_XG_MN0 (I792_G24_23 I792_pn24 XI792_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I90_XG_MN1 (XI792_I90_XG_n1 I792_gn23 I792_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I89_XG_MN2 (XI792_I89_XG_n1 I792_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I89_XG_MN0 (I792_G23_22 I792_pn23 XI792_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I89_XG_MN1 (XI792_I89_XG_n1 I792_gn22 I792_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I88_XG_MN2 (XI792_I88_XG_n1 I792_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I88_XG_MN0 (I792_G22_21 I792_pn22 XI792_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I88_XG_MN1 (XI792_I88_XG_n1 I792_gn21 I792_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I154_XG_MN2 (XI792_I154_XG_n1 I792_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I154_XG_MN0 (I792_G29_22 I792_P29_26n XI792_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I154_XG_MN1 (XI792_I154_XG_n1 I792_G25_22n I792_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I150_XG_MN2 (XI792_I150_XG_n1 I792_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I150_XG_MN0 (I792_G25_18 I792_P25_22n XI792_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I150_XG_MN1 (XI792_I150_XG_n1 I792_G21_18n I792_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I200_XG_MN2 (XI792_I200_XG_n1 I792_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I200_XG_MN0 (I792_G29_0 I792_P29_14n XI792_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I200_XG_MN1 (XI792_I200_XG_n1 I792_G13_0n I792_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I153_XG_MN2 (XI792_I153_XG_n1 I792_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I153_XG_MN0 (I792_G28_21 I792_P28_25n XI792_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I153_XG_MN1 (XI792_I153_XG_n1 I792_G24_21n I792_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I147_XG_MN2 (XI792_I147_XG_n1 I792_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I147_XG_MN0 (I792_G22_15 I792_P22_19n XI792_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I147_XG_MN1 (XI792_I147_XG_n1 I792_G18_15n I792_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I192_XG_MN2 (XI792_I192_XG_n1 I792_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I192_XG_MN0 (I792_G22_0 I792_P22_7n XI792_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I192_XG_MN1 (XI792_I192_XG_n1 I792_G6_0n I792_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I202_XG_MN2 (XI838_I202_XG_n1 I838_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I202_XG_MN0 (c6_o I838_P31_16n XI838_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I202_XG_MN1 (XI838_I202_XG_n1 I838_G15_0n c6_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I194_XG_MN2 (XI838_I194_XG_n1 I838_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I194_XG_MN0 (I838_G23_0 I838_P23_8n XI838_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I194_XG_MN1 (XI838_I194_XG_n1 I838_G7_0n I838_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I154_XG_MN2 (XI838_I154_XG_n1 I838_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I154_XG_MN0 (I838_G29_22 I838_P29_26n XI838_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I154_XG_MN1 (XI838_I154_XG_n1 I838_G25_22n I838_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I85_XG_MN2 (XI838_I85_XG_n1 I838_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I85_XG_MN0 (I838_G19_18 I838_pn19 XI838_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I85_XG_MN1 (XI838_I85_XG_n1 I838_gn18 I838_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I86_XG_MN2 (XI838_I86_XG_n1 I838_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I86_XG_MN0 (I838_G20_19 I838_pn20 XI838_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I86_XG_MN1 (XI838_I86_XG_n1 I838_gn19 I838_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I147_XG_MN2 (XI838_I147_XG_n1 I838_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I147_XG_MN0 (I838_G22_15 I838_P22_19n XI838_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I147_XG_MN1 (XI838_I147_XG_n1 I838_G18_15n I838_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I151_XG_MN2 (XI838_I151_XG_n1 I838_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I151_XG_MN0 (I838_G26_19 I838_P26_23n XI838_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I151_XG_MN1 (XI838_I151_XG_n1 I838_G22_19n I838_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I192_XG_MN2 (XI838_I192_XG_n1 I838_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I192_XG_MN0 (I838_G22_0 I838_P22_7n XI838_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I192_XG_MN1 (XI838_I192_XG_n1 I838_G6_0n I838_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I85_XG_MN2 (XI884_I85_XG_n1 I884_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I85_XG_MN0 (I884_G19_18 I884_pn19 XI884_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I85_XG_MN1 (XI884_I85_XG_n1 I884_gn18 I884_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I84_XG_MN2 (XI884_I84_XG_n1 I884_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I84_XG_MN0 (I884_G18_17 I884_pn18 XI884_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I84_XG_MN1 (XI884_I84_XG_n1 I884_gn17 I884_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I147_XG_MN2 (XI884_I147_XG_n1 I884_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I147_XG_MN0 (I884_G22_15 I884_P22_19n XI884_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I147_XG_MN1 (XI884_I147_XG_n1 I884_G18_15n I884_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I151_XG_MN2 (XI884_I151_XG_n1 I884_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I151_XG_MN0 (I884_G26_19 I884_P26_23n XI884_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I151_XG_MN1 (XI884_I151_XG_n1 I884_G22_19n I884_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I199_XG_MN2 (XI884_I199_XG_n1 I884_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I199_XG_MN0 (I884_G28_0 I884_P28_13n XI884_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I199_XG_MN1 (XI884_I199_XG_n1 I884_G12_0n I884_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I150_XG_MN2 (XI884_I150_XG_n1 I884_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I150_XG_MN0 (I884_G25_18 I884_P25_22n XI884_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I150_XG_MN1 (XI884_I150_XG_n1 I884_G21_18n I884_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I144_XG_MN2 (XI884_I144_XG_n1 I884_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I144_XG_MN0 (I884_G19_12 I884_P19_16n XI884_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I144_XG_MN1 (XI884_I144_XG_n1 I884_G15_12n I884_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I186_XG_MN2 (XI884_I186_XG_n1 I884_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I186_XG_MN0 (I884_G19_0 I884_P19_4n XI884_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I186_XG_MN1 (XI884_I186_XG_n1 I884_G3_0n I884_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I147_XG_MN2 (XI1712_I147_XG_n1 I1712_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I147_XG_MN0 (I1712_G22_15 I1712_P22_19n XI1712_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I147_XG_MN1 (XI1712_I147_XG_n1 I1712_G18_15n I1712_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I153_XG_MN2 (XI1712_I153_XG_n1 I1712_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I153_XG_MN0 (I1712_G28_21 I1712_P28_25n XI1712_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I153_XG_MN1 (XI1712_I153_XG_n1 I1712_G24_21n I1712_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I82_XG_MN2 (XI1712_I82_XG_n1 I1712_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I82_XG_MN0 (I1712_G16_15 I1712_pn16 XI1712_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I82_XG_MN1 (XI1712_I82_XG_n1 I1712_gn15 I1712_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I83_XG_MN2 (XI1712_I83_XG_n1 I1712_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I83_XG_MN0 (I1712_G17_16 I1712_pn17 XI1712_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I83_XG_MN1 (XI1712_I83_XG_n1 I1712_gn16 I1712_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I146_XG_MN2 (XI1712_I146_XG_n1 I1712_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I146_XG_MN0 (I1712_G21_14 I1712_P21_18n XI1712_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I146_XG_MN1 (XI1712_I146_XG_n1 I1712_G17_14n I1712_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I190_XG_MN2 (XI1712_I190_XG_n1 I1712_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I190_XG_MN0 (I1712_G21_0 I1712_P21_6n XI1712_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I190_XG_MN1 (XI1712_I190_XG_n1 I1712_G5_0n I1712_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I144_XG_MN2 (XI1712_I144_XG_n1 I1712_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I144_XG_MN0 (I1712_G19_12 I1712_P19_16n XI1712_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I144_XG_MN1 (XI1712_I144_XG_n1 I1712_G15_12n I1712_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I198_XG_MN2 (XI1712_I198_XG_n1 I1712_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I198_XG_MN0 (I1712_G27_0 I1712_P27_12n XI1712_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I198_XG_MN1 (XI1712_I198_XG_n1 I1712_G11_0n I1712_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I85_XG_MN2 (XI1758_I85_XG_n1 I1758_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I85_XG_MN0 (I1758_G19_18 I1758_pn19 XI1758_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I85_XG_MN1 (XI1758_I85_XG_n1 I1758_gn18 I1758_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I84_XG_MN2 (XI1758_I84_XG_n1 I1758_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I84_XG_MN0 (I1758_G18_17 I1758_pn18 XI1758_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I84_XG_MN1 (XI1758_I84_XG_n1 I1758_gn17 I1758_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I147_XG_MN2 (XI1758_I147_XG_n1 I1758_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I147_XG_MN0 (I1758_G22_15 I1758_P22_19n XI1758_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I147_XG_MN1 (XI1758_I147_XG_n1 I1758_G18_15n I1758_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I192_XG_MN2 (XI1758_I192_XG_n1 I1758_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I192_XG_MN0 (I1758_G22_0 I1758_P22_7n XI1758_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I192_XG_MN1 (XI1758_I192_XG_n1 I1758_G6_0n I1758_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I150_XG_MN2 (XI1758_I150_XG_n1 I1758_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I150_XG_MN0 (I1758_G25_18 I1758_P25_22n XI1758_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I150_XG_MN1 (XI1758_I150_XG_n1 I1758_G21_18n I1758_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I198_XG_MN2 (XI1758_I198_XG_n1 I1758_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I198_XG_MN0 (I1758_G27_0 I1758_P27_12n XI1758_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I198_XG_MN1 (XI1758_I198_XG_n1 I1758_G11_0n I1758_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I85_XG_MN2 (XI1804_I85_XG_n1 I1804_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I85_XG_MN0 (I1804_G19_18 I1804_pn19 XI1804_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I85_XG_MN1 (XI1804_I85_XG_n1 I1804_gn18 I1804_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I86_XG_MN2 (XI1804_I86_XG_n1 I1804_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I86_XG_MN0 (I1804_G20_19 I1804_pn20 XI1804_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I86_XG_MN1 (XI1804_I86_XG_n1 I1804_gn19 I1804_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I194_XG_MN2 (XI1804_I194_XG_n1 I1804_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I194_XG_MN0 (I1804_G23_0 I1804_P23_8n XI1804_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I194_XG_MN1 (XI1804_I194_XG_n1 I1804_G7_0n I1804_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I150_XG_MN2 (XI1804_I150_XG_n1 I1804_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I150_XG_MN0 (I1804_G25_18 I1804_P25_22n XI1804_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I150_XG_MN1 (XI1804_I150_XG_n1 I1804_G21_18n I1804_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I155_XG_MN2 (XI1804_I155_XG_n1 I1804_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I155_XG_MN0 (I1804_G30_23 I1804_P30_27n XI1804_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I155_XG_MN1 (XI1804_I155_XG_n1 I1804_G26_23n I1804_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I96_XG_MN2 (XI746_I96_XG_n1 I746_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I96_XG_MN0 (I746_G30_29 I746_pn30 XI746_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I96_XG_MN1 (XI746_I96_XG_n1 I746_gn29 I746_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I95_XG_MN2 (XI746_I95_XG_n1 I746_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I95_XG_MN0 (I746_G29_28 I746_pn29 XI746_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I95_XG_MN1 (XI746_I95_XG_n1 I746_gn28 I746_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I94_XG_MN2 (XI746_I94_XG_n1 I746_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I94_XG_MN0 (I746_G28_27 I746_pn28 XI746_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I94_XG_MN1 (XI746_I94_XG_n1 I746_gn27 I746_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I155_XG_MN2 (XI746_I155_XG_n1 I746_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I155_XG_MN0 (I746_G30_23 I746_P30_27n XI746_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I155_XG_MN1 (XI746_I155_XG_n1 I746_G26_23n I746_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I201_XG_MN2 (XI746_I201_XG_n1 I746_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I201_XG_MN0 (c4_m I746_P30_15n XI746_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I201_XG_MN1 (XI746_I201_XG_n1 I746_G14_0n c4_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I92_XG_MN2 (XI792_I92_XG_n1 I792_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I92_XG_MN0 (I792_G26_25 I792_pn26 XI792_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I92_XG_MN1 (XI792_I92_XG_n1 I792_gn25 I792_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I91_XG_MN2 (XI792_I91_XG_n1 I792_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I91_XG_MN0 (I792_G25_24 I792_pn25 XI792_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I91_XG_MN1 (XI792_I91_XG_n1 I792_gn24 I792_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I93_XG_MN2 (XI792_I93_XG_n1 I792_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I93_XG_MN0 (I792_G27_26 I792_pn27 XI792_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I93_XG_MN1 (XI792_I93_XG_n1 I792_gn26 I792_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I152_XG_MN2 (XI792_I152_XG_n1 I792_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I152_XG_MN0 (I792_G27_20 I792_P27_24n XI792_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I152_XG_MN1 (XI792_I152_XG_n1 I792_G23_20n I792_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I148_XG_MN2 (XI792_I148_XG_n1 I792_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I148_XG_MN0 (I792_G23_16 I792_P23_20n XI792_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I148_XG_MN1 (XI792_I148_XG_n1 I792_G19_16n I792_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I198_XG_MN2 (XI792_I198_XG_n1 I792_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I198_XG_MN0 (I792_G27_0 I792_P27_12n XI792_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I198_XG_MN1 (XI792_I198_XG_n1 I792_G11_0n I792_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I151_XG_MN2 (XI792_I151_XG_n1 I792_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I151_XG_MN0 (I792_G26_19 I792_P26_23n XI792_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I151_XG_MN1 (XI792_I151_XG_n1 I792_G22_19n I792_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I197_XG_MN2 (XI792_I197_XG_n1 I792_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I197_XG_MN0 (I792_G26_0 I792_P26_11n XI792_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I197_XG_MN1 (XI792_I197_XG_n1 I792_G10_0n I792_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I156_XG_MN2 (XI838_I156_XG_n1 I838_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I156_XG_MN0 (I838_G31_24 I838_P31_28n XI838_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I156_XG_MN1 (XI838_I156_XG_n1 I838_G27_24n I838_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I152_XG_MN2 (XI838_I152_XG_n1 I838_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I152_XG_MN0 (I838_G27_20 I838_P27_24n XI838_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I152_XG_MN1 (XI838_I152_XG_n1 I838_G23_20n I838_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I148_XG_MN2 (XI838_I148_XG_n1 I838_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I148_XG_MN0 (I838_G23_16 I838_P23_20n XI838_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I148_XG_MN1 (XI838_I148_XG_n1 I838_G19_16n I838_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I87_XG_MN2 (XI838_I87_XG_n1 I838_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I87_XG_MN0 (I838_G21_20 I838_pn21 XI838_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I87_XG_MN1 (XI838_I87_XG_n1 I838_gn20 I838_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I153_XG_MN2 (XI838_I153_XG_n1 I838_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I153_XG_MN0 (I838_G28_21 I838_P28_25n XI838_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I153_XG_MN1 (XI838_I153_XG_n1 I838_G24_21n I838_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I201_XG_MN2 (XI838_I201_XG_n1 I838_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I201_XG_MN0 (c6_m I838_P30_15n XI838_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I201_XG_MN1 (XI838_I201_XG_n1 I838_G14_0n c6_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I87_XG_MN2 (XI884_I87_XG_n1 I884_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I87_XG_MN0 (I884_G21_20 I884_pn21 XI884_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I87_XG_MN1 (XI884_I87_XG_n1 I884_gn20 I884_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I86_XG_MN2 (XI884_I86_XG_n1 I884_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I86_XG_MN0 (I884_G20_19 I884_pn20 XI884_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I86_XG_MN1 (XI884_I86_XG_n1 I884_gn19 I884_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I88_XG_MN2 (XI884_I88_XG_n1 I884_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I88_XG_MN0 (I884_G22_21 I884_pn22 XI884_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I88_XG_MN1 (XI884_I88_XG_n1 I884_gn21 I884_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I201_XG_MN2 (XI884_I201_XG_n1 I884_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I201_XG_MN0 (c7_m I884_P30_15n XI884_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I201_XG_MN1 (XI884_I201_XG_n1 I884_G14_0n c7_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I153_XG_MN2 (XI884_I153_XG_n1 I884_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I153_XG_MN0 (I884_G28_21 I884_P28_25n XI884_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I153_XG_MN1 (XI884_I153_XG_n1 I884_G24_21n I884_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I200_XG_MN2 (XI884_I200_XG_n1 I884_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I200_XG_MN0 (I884_G29_0 I884_P29_14n XI884_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I200_XG_MN1 (XI884_I200_XG_n1 I884_G13_0n I884_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I198_XG_MN2 (XI884_I198_XG_n1 I884_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I198_XG_MN0 (I884_G27_0 I884_P27_12n XI884_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I198_XG_MN1 (XI884_I198_XG_n1 I884_G11_0n I884_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I151_XG_MN2 (XI1712_I151_XG_n1 I1712_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I151_XG_MN0 (I1712_G26_19 I1712_P26_23n XI1712_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I151_XG_MN1 (XI1712_I151_XG_n1 I1712_G22_19n I1712_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I201_XG_MN2 (XI1712_I201_XG_n1 I1712_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I201_XG_MN0 (c25_m I1712_P30_15n XI1712_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I201_XG_MN1 (XI1712_I201_XG_n1 I1712_G14_0n c25_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I84_XG_MN2 (XI1712_I84_XG_n1 I1712_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I84_XG_MN0 (I1712_G18_17 I1712_pn18 XI1712_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I84_XG_MN1 (XI1712_I84_XG_n1 I1712_gn17 I1712_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I85_XG_MN2 (XI1712_I85_XG_n1 I1712_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I85_XG_MN0 (I1712_G19_18 I1712_pn19 XI1712_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I85_XG_MN1 (XI1712_I85_XG_n1 I1712_gn18 I1712_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I200_XG_MN2 (XI1712_I200_XG_n1 I1712_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I200_XG_MN0 (I1712_G29_0 I1712_P29_14n XI1712_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I200_XG_MN1 (XI1712_I200_XG_n1 I1712_G13_0n I1712_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I86_XG_MN2 (XI1758_I86_XG_n1 I1758_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I86_XG_MN0 (I1758_G20_19 I1758_pn20 XI1758_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I86_XG_MN1 (XI1758_I86_XG_n1 I1758_gn19 I1758_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I87_XG_MN2 (XI1758_I87_XG_n1 I1758_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I87_XG_MN0 (I1758_G21_20 I1758_pn21 XI1758_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I87_XG_MN1 (XI1758_I87_XG_n1 I1758_gn20 I1758_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I151_XG_MN2 (XI1758_I151_XG_n1 I1758_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I151_XG_MN0 (I1758_G26_19 I1758_P26_23n XI1758_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I151_XG_MN1 (XI1758_I151_XG_n1 I1758_G22_19n I1758_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I153_XG_MN2 (XI1758_I153_XG_n1 I1758_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I153_XG_MN0 (I1758_G28_21 I1758_P28_25n XI1758_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I153_XG_MN1 (XI1758_I153_XG_n1 I1758_G24_21n I1758_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I201_XG_MN2 (XI1758_I201_XG_n1 I1758_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I201_XG_MN0 (c26_m I1758_P30_15n XI1758_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I201_XG_MN1 (XI1758_I201_XG_n1 I1758_G14_0n c26_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I200_XG_MN2 (XI1758_I200_XG_n1 I1758_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I200_XG_MN0 (I1758_G29_0 I1758_P29_14n XI1758_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I200_XG_MN1 (XI1758_I200_XG_n1 I1758_G13_0n I1758_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I148_XG_MN2 (XI1758_I148_XG_n1 I1758_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I148_XG_MN0 (I1758_G23_16 I1758_P23_20n XI1758_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I148_XG_MN1 (XI1758_I148_XG_n1 I1758_G19_16n I1758_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I152_XG_MN2 (XI1758_I152_XG_n1 I1758_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I152_XG_MN0 (I1758_G27_20 I1758_P27_24n XI1758_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I152_XG_MN1 (XI1758_I152_XG_n1 I1758_G23_20n I1758_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I194_XG_MN2 (XI1758_I194_XG_n1 I1758_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I194_XG_MN0 (I1758_G23_0 I1758_P23_8n XI1758_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I194_XG_MN1 (XI1758_I194_XG_n1 I1758_G7_0n I1758_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I87_XG_MN2 (XI1804_I87_XG_n1 I1804_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I87_XG_MN0 (I1804_G21_20 I1804_pn21 XI1804_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I87_XG_MN1 (XI1804_I87_XG_n1 I1804_gn20 I1804_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I148_XG_MN2 (XI1804_I148_XG_n1 I1804_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I148_XG_MN0 (I1804_G23_16 I1804_P23_20n XI1804_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I148_XG_MN1 (XI1804_I148_XG_n1 I1804_G19_16n I1804_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I88_XG_MN2 (XI1804_I88_XG_n1 I1804_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I88_XG_MN0 (I1804_G22_21 I1804_pn22 XI1804_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I88_XG_MN1 (XI1804_I88_XG_n1 I1804_gn21 I1804_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I152_XG_MN2 (XI1804_I152_XG_n1 I1804_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I152_XG_MN0 (I1804_G27_20 I1804_P27_24n XI1804_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I152_XG_MN1 (XI1804_I152_XG_n1 I1804_G23_20n I1804_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I154_XG_MN2 (XI1804_I154_XG_n1 I1804_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I154_XG_MN0 (I1804_G29_22 I1804_P29_26n XI1804_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I154_XG_MN1 (XI1804_I154_XG_n1 I1804_G25_22n I1804_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I92_XG_MN2 (XI1804_I92_XG_n1 I1804_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I92_XG_MN0 (I1804_G26_25 I1804_pn26 XI1804_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I92_XG_MN1 (XI1804_I92_XG_n1 I1804_gn25 I1804_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I94_XG_MN2 (XI792_I94_XG_n1 I792_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I94_XG_MN0 (I792_G28_27 I792_pn28 XI792_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I94_XG_MN1 (XI792_I94_XG_n1 I792_gn27 I792_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I156_XG_MN2 (XI792_I156_XG_n1 I792_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I156_XG_MN0 (I792_G31_24 I792_P31_28n XI792_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I156_XG_MN1 (XI792_I156_XG_n1 I792_G27_24n I792_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I202_XG_MN2 (XI792_I202_XG_n1 I792_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I202_XG_MN0 (c5_o I792_P31_16n XI792_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I202_XG_MN1 (XI792_I202_XG_n1 I792_G15_0n c5_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I194_XG_MN2 (XI792_I194_XG_n1 I792_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I194_XG_MN0 (I792_G23_0 I792_P23_8n XI792_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I194_XG_MN1 (XI792_I194_XG_n1 I792_G7_0n I792_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I155_XG_MN2 (XI792_I155_XG_n1 I792_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I155_XG_MN0 (I792_G30_23 I792_P30_27n XI792_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I155_XG_MN1 (XI792_I155_XG_n1 I792_G26_23n I792_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I201_XG_MN2 (XI792_I201_XG_n1 I792_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I201_XG_MN0 (c5_m I792_P30_15n XI792_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I201_XG_MN1 (XI792_I201_XG_n1 I792_G14_0n c5_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I97_XG_MN2 (XI838_I97_XG_n1 I838_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I97_XG_MN0 (I838_G31_30 I838_pn31 XI838_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I97_XG_MN1 (XI838_I97_XG_n1 I838_gn30 I838_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I89_XG_MN2 (XI838_I89_XG_n1 I838_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I89_XG_MN0 (I838_G23_22 I838_pn23 XI838_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I89_XG_MN1 (XI838_I89_XG_n1 I838_gn22 I838_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I90_XG_MN2 (XI838_I90_XG_n1 I838_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I90_XG_MN0 (I838_G24_23 I838_pn24 XI838_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I90_XG_MN1 (XI838_I90_XG_n1 I838_gn23 I838_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I88_XG_MN2 (XI838_I88_XG_n1 I838_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I88_XG_MN0 (I838_G22_21 I838_pn22 XI838_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I88_XG_MN1 (XI838_I88_XG_n1 I838_gn21 I838_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I155_XG_MN2 (XI838_I155_XG_n1 I838_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I155_XG_MN0 (I838_G30_23 I838_P30_27n XI838_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I155_XG_MN1 (XI838_I155_XG_n1 I838_G26_23n I838_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I90_XG_MN2 (XI884_I90_XG_n1 I884_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I90_XG_MN0 (I884_G24_23 I884_pn24 XI884_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I90_XG_MN1 (XI884_I90_XG_n1 I884_gn23 I884_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I89_XG_MN2 (XI884_I89_XG_n1 I884_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I89_XG_MN0 (I884_G23_22 I884_pn23 XI884_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I89_XG_MN1 (XI884_I89_XG_n1 I884_gn22 I884_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I155_XG_MN2 (XI884_I155_XG_n1 I884_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I155_XG_MN0 (I884_G30_23 I884_P30_27n XI884_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I155_XG_MN1 (XI884_I155_XG_n1 I884_G26_23n I884_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I154_XG_MN2 (XI884_I154_XG_n1 I884_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I154_XG_MN0 (I884_G29_22 I884_P29_26n XI884_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I154_XG_MN1 (XI884_I154_XG_n1 I884_G25_22n I884_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I152_XG_MN2 (XI884_I152_XG_n1 I884_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I152_XG_MN0 (I884_G27_20 I884_P27_24n XI884_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I152_XG_MN1 (XI884_I152_XG_n1 I884_G23_20n I884_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I148_XG_MN2 (XI884_I148_XG_n1 I884_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I148_XG_MN0 (I884_G23_16 I884_P23_20n XI884_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I148_XG_MN1 (XI884_I148_XG_n1 I884_G19_16n I884_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I155_XG_MN2 (XI1712_I155_XG_n1 I1712_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I155_XG_MN0 (I1712_G30_23 I1712_P30_27n XI1712_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I155_XG_MN1 (XI1712_I155_XG_n1 I1712_G26_23n I1712_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I86_XG_MN2 (XI1712_I86_XG_n1 I1712_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I86_XG_MN0 (I1712_G20_19 I1712_pn20 XI1712_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I86_XG_MN1 (XI1712_I86_XG_n1 I1712_gn19 I1712_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I87_XG_MN2 (XI1712_I87_XG_n1 I1712_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I87_XG_MN0 (I1712_G21_20 I1712_pn21 XI1712_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I87_XG_MN1 (XI1712_I87_XG_n1 I1712_gn20 I1712_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I154_XG_MN2 (XI1712_I154_XG_n1 I1712_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I154_XG_MN0 (I1712_G29_22 I1712_P29_26n XI1712_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I154_XG_MN1 (XI1712_I154_XG_n1 I1712_G25_22n I1712_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I150_XG_MN2 (XI1712_I150_XG_n1 I1712_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I150_XG_MN0 (I1712_G25_18 I1712_P25_22n XI1712_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I150_XG_MN1 (XI1712_I150_XG_n1 I1712_G21_18n I1712_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I152_XG_MN2 (XI1712_I152_XG_n1 I1712_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I152_XG_MN0 (I1712_G27_20 I1712_P27_24n XI1712_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I152_XG_MN1 (XI1712_I152_XG_n1 I1712_G23_20n I1712_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I148_XG_MN2 (XI1712_I148_XG_n1 I1712_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I148_XG_MN0 (I1712_G23_16 I1712_P23_20n XI1712_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I148_XG_MN1 (XI1712_I148_XG_n1 I1712_G19_16n I1712_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I202_XG_MN2 (XI1712_I202_XG_n1 I1712_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I202_XG_MN0 (c25_o I1712_P31_16n XI1712_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I202_XG_MN1 (XI1712_I202_XG_n1 I1712_G15_0n c25_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I194_XG_MN2 (XI1712_I194_XG_n1 I1712_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I194_XG_MN0 (I1712_G23_0 I1712_P23_8n XI1712_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I194_XG_MN1 (XI1712_I194_XG_n1 I1712_G7_0n I1712_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I88_XG_MN2 (XI1758_I88_XG_n1 I1758_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I88_XG_MN0 (I1758_G22_21 I1758_pn22 XI1758_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I88_XG_MN1 (XI1758_I88_XG_n1 I1758_gn21 I1758_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I89_XG_MN2 (XI1758_I89_XG_n1 I1758_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I89_XG_MN0 (I1758_G23_22 I1758_pn23 XI1758_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I89_XG_MN1 (XI1758_I89_XG_n1 I1758_gn22 I1758_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I90_XG_MN2 (XI1758_I90_XG_n1 I1758_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I90_XG_MN0 (I1758_G24_23 I1758_pn24 XI1758_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I90_XG_MN1 (XI1758_I90_XG_n1 I1758_gn23 I1758_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I155_XG_MN2 (XI1758_I155_XG_n1 I1758_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I155_XG_MN0 (I1758_G30_23 I1758_P30_27n XI1758_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I155_XG_MN1 (XI1758_I155_XG_n1 I1758_G26_23n I1758_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I154_XG_MN2 (XI1758_I154_XG_n1 I1758_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I154_XG_MN0 (I1758_G29_22 I1758_P29_26n XI1758_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I154_XG_MN1 (XI1758_I154_XG_n1 I1758_G25_22n I1758_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I156_XG_MN2 (XI1758_I156_XG_n1 I1758_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I156_XG_MN0 (I1758_G31_24 I1758_P31_28n XI1758_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I156_XG_MN1 (XI1758_I156_XG_n1 I1758_G27_24n I1758_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I202_XG_MN2 (XI1758_I202_XG_n1 I1758_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I202_XG_MN0 (c26_o I1758_P31_16n XI1758_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I202_XG_MN1 (XI1758_I202_XG_n1 I1758_G15_0n c26_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I202_XG_MN2 (XI1804_I202_XG_n1 I1804_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I202_XG_MN0 (c27_o I1804_P31_16n XI1804_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I202_XG_MN1 (XI1804_I202_XG_n1 I1804_G15_0n c27_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I89_XG_MN2 (XI1804_I89_XG_n1 I1804_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I89_XG_MN0 (I1804_G23_22 I1804_pn23 XI1804_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I89_XG_MN1 (XI1804_I89_XG_n1 I1804_gn22 I1804_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I156_XG_MN2 (XI1804_I156_XG_n1 I1804_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I156_XG_MN0 (I1804_G31_24 I1804_P31_28n XI1804_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I156_XG_MN1 (XI1804_I156_XG_n1 I1804_G27_24n I1804_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I90_XG_MN2 (XI1804_I90_XG_n1 I1804_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I90_XG_MN0 (I1804_G24_23 I1804_pn24 XI1804_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I90_XG_MN1 (XI1804_I90_XG_n1 I1804_gn23 I1804_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I91_XG_MN2 (XI1804_I91_XG_n1 I1804_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I91_XG_MN0 (I1804_G25_24 I1804_pn25 XI1804_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I91_XG_MN1 (XI1804_I91_XG_n1 I1804_gn24 I1804_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I93_XG_MN2 (XI1804_I93_XG_n1 I1804_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I93_XG_MN0 (I1804_G27_26 I1804_pn27 XI1804_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I93_XG_MN1 (XI1804_I93_XG_n1 I1804_gn26 I1804_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I97_XG_MN2 (XI792_I97_XG_n1 I792_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I97_XG_MN0 (I792_G31_30 I792_pn31 XI792_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I97_XG_MN1 (XI792_I97_XG_n1 I792_gn30 I792_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I96_XG_MN2 (XI792_I96_XG_n1 I792_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I96_XG_MN0 (I792_G30_29 I792_pn30 XI792_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I96_XG_MN1 (XI792_I96_XG_n1 I792_gn29 I792_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I95_XG_MN2 (XI792_I95_XG_n1 I792_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I95_XG_MN0 (I792_G29_28 I792_pn29 XI792_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I95_XG_MN1 (XI792_I95_XG_n1 I792_gn28 I792_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I96_XG_MN2 (XI838_I96_XG_n1 I838_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I96_XG_MN0 (I838_G30_29 I838_pn30 XI838_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I96_XG_MN1 (XI838_I96_XG_n1 I838_gn29 I838_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I95_XG_MN2 (XI838_I95_XG_n1 I838_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I95_XG_MN0 (I838_G29_28 I838_pn29 XI838_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I95_XG_MN1 (XI838_I95_XG_n1 I838_gn28 I838_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I93_XG_MN2 (XI838_I93_XG_n1 I838_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I93_XG_MN0 (I838_G27_26 I838_pn27 XI838_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I93_XG_MN1 (XI838_I93_XG_n1 I838_gn26 I838_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I94_XG_MN2 (XI838_I94_XG_n1 I838_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I94_XG_MN0 (I838_G28_27 I838_pn28 XI838_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I94_XG_MN1 (XI838_I94_XG_n1 I838_gn27 I838_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I91_XG_MN2 (XI838_I91_XG_n1 I838_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I91_XG_MN0 (I838_G25_24 I838_pn25 XI838_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I91_XG_MN1 (XI838_I91_XG_n1 I838_gn24 I838_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I92_XG_MN2 (XI838_I92_XG_n1 I838_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I92_XG_MN0 (I838_G26_25 I838_pn26 XI838_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I92_XG_MN1 (XI838_I92_XG_n1 I838_gn25 I838_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I91_XG_MN2 (XI884_I91_XG_n1 I884_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I91_XG_MN0 (I884_G25_24 I884_pn25 XI884_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I91_XG_MN1 (XI884_I91_XG_n1 I884_gn24 I884_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I92_XG_MN2 (XI884_I92_XG_n1 I884_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I92_XG_MN0 (I884_G26_25 I884_pn26 XI884_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I92_XG_MN1 (XI884_I92_XG_n1 I884_gn25 I884_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I156_XG_MN2 (XI884_I156_XG_n1 I884_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I156_XG_MN0 (I884_G31_24 I884_P31_28n XI884_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I156_XG_MN1 (XI884_I156_XG_n1 I884_G27_24n I884_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I202_XG_MN2 (XI884_I202_XG_n1 I884_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I202_XG_MN0 (c7_o I884_P31_16n XI884_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I202_XG_MN1 (XI884_I202_XG_n1 I884_G15_0n c7_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I90_XG_MN2 (XI1712_I90_XG_n1 I1712_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I90_XG_MN0 (I1712_G24_23 I1712_pn24 XI1712_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I90_XG_MN1 (XI1712_I90_XG_n1 I1712_gn23 I1712_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I88_XG_MN2 (XI1712_I88_XG_n1 I1712_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I88_XG_MN0 (I1712_G22_21 I1712_pn22 XI1712_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I88_XG_MN1 (XI1712_I88_XG_n1 I1712_gn21 I1712_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I89_XG_MN2 (XI1712_I89_XG_n1 I1712_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I89_XG_MN0 (I1712_G23_22 I1712_pn23 XI1712_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I89_XG_MN1 (XI1712_I89_XG_n1 I1712_gn22 I1712_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I156_XG_MN2 (XI1712_I156_XG_n1 I1712_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I156_XG_MN0 (I1712_G31_24 I1712_P31_28n XI1712_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I156_XG_MN1 (XI1712_I156_XG_n1 I1712_G27_24n I1712_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I91_XG_MN2 (XI1758_I91_XG_n1 I1758_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I91_XG_MN0 (I1758_G25_24 I1758_pn25 XI1758_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I91_XG_MN1 (XI1758_I91_XG_n1 I1758_gn24 I1758_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I92_XG_MN2 (XI1758_I92_XG_n1 I1758_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I92_XG_MN0 (I1758_G26_25 I1758_pn26 XI1758_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I92_XG_MN1 (XI1758_I92_XG_n1 I1758_gn25 I1758_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I93_XG_MN2 (XI1758_I93_XG_n1 I1758_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I93_XG_MN0 (I1758_G27_26 I1758_pn27 XI1758_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I93_XG_MN1 (XI1758_I93_XG_n1 I1758_gn26 I1758_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I94_XG_MN2 (XI1758_I94_XG_n1 I1758_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I94_XG_MN0 (I1758_G28_27 I1758_pn28 XI1758_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I94_XG_MN1 (XI1758_I94_XG_n1 I1758_gn27 I1758_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I97_XG_MN2 (XI1804_I97_XG_n1 I1804_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I97_XG_MN0 (I1804_G31_30 I1804_pn31 XI1804_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I97_XG_MN1 (XI1804_I97_XG_n1 I1804_gn30 I1804_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I95_XG_MN2 (XI1804_I95_XG_n1 I1804_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I95_XG_MN0 (I1804_G29_28 I1804_pn29 XI1804_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I95_XG_MN1 (XI1804_I95_XG_n1 I1804_gn28 I1804_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I96_XG_MN2 (XI1804_I96_XG_n1 I1804_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I96_XG_MN0 (I1804_G30_29 I1804_pn30 XI1804_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I96_XG_MN1 (XI1804_I96_XG_n1 I1804_gn29 I1804_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I94_XG_MN2 (XI1804_I94_XG_n1 I1804_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I94_XG_MN0 (I1804_G28_27 I1804_pn28 XI1804_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I94_XG_MN1 (XI1804_I94_XG_n1 I1804_gn27 I1804_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I200_XG_MN2 (XI1068_I200_XG_n1 I1068_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I200_XG_MN0 (I1068_G29_0 I1068_P29_14n XI1068_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I200_XG_MN1 (XI1068_I200_XG_n1 I1068_G13_0n I1068_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I196_XG_MN2 (XI1068_I196_XG_n1 I1068_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I196_XG_MN0 (I1068_G25_0 I1068_P25_10n XI1068_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I196_XG_MN1 (XI1068_I196_XG_n1 I1068_G9_0n I1068_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I190_XG_MN2 (XI1068_I190_XG_n1 I1068_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I190_XG_MN0 (I1068_G21_0 I1068_P21_6n XI1068_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I190_XG_MN1 (XI1068_I190_XG_n1 I1068_G5_0n I1068_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I142_XG_MN2 (XI1068_I142_XG_n1 I1068_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I142_XG_MN0 (I1068_G17_10 I1068_P17_14n XI1068_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I142_XG_MN1 (XI1068_I142_XG_n1 I1068_G13_10n I1068_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I184_XG_MN2 (XI1068_I184_XG_n1 I1068_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I184_XG_MN0 (I1068_G17_0 I1068_P17_2n XI1068_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I184_XG_MN1 (XI1068_I184_XG_n1 I1068_G1_0n I1068_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I138_XG_MN2 (XI1068_I138_XG_n1 I1068_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I138_XG_MN0 (I1068_G13_6 I1068_P13_10n XI1068_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I138_XG_MN1 (XI1068_I138_XG_n1 I1068_G9_6n I1068_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I134_XG_MN2 (XI1068_I134_XG_n1 I1068_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I134_XG_MN0 (I1068_G9_2 I1068_P9_6n XI1068_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I134_XG_MN1 (XI1068_I134_XG_n1 I1068_G5_2n I1068_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I130_XG_MN2 (XI1068_I130_XG_n1 I1068_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I130_XG_MN0 (I1068_G5_0 I1068_P5_2n XI1068_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I130_XG_MN1 (XI1068_I130_XG_n1 I1068_G1_0n I1068_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I71_XG_MN2 (XI1068_I71_XG_n1 I1068_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I71_XG_MN0 (I1068_G5_4 I1068_pn5 XI1068_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I71_XG_MN1 (XI1068_I71_XG_n1 I1068_gn4 I1068_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I70_XG_MN2 (XI1068_I70_XG_n1 I1068_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I70_XG_MN0 (I1068_G4_3 I1068_pn4 XI1068_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I70_XG_MN1 (XI1068_I70_XG_n1 I1068_gn3 I1068_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I97_XG_MN2 (XI884_I97_XG_n1 I884_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I97_XG_MN0 (I884_G31_30 I884_pn31 XI884_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I97_XG_MN1 (XI884_I97_XG_n1 I884_gn30 I884_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I96_XG_MN2 (XI884_I96_XG_n1 I884_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I96_XG_MN0 (I884_G30_29 I884_pn30 XI884_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I96_XG_MN1 (XI884_I96_XG_n1 I884_gn29 I884_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I94_XG_MN2 (XI884_I94_XG_n1 I884_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I94_XG_MN0 (I884_G28_27 I884_pn28 XI884_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I94_XG_MN1 (XI884_I94_XG_n1 I884_gn27 I884_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I93_XG_MN2 (XI884_I93_XG_n1 I884_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I93_XG_MN0 (I884_G27_26 I884_pn27 XI884_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I93_XG_MN1 (XI884_I93_XG_n1 I884_gn26 I884_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I194_XG_MN2 (XI884_I194_XG_n1 I884_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I194_XG_MN0 (I884_G23_0 I884_P23_8n XI884_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I194_XG_MN1 (XI884_I194_XG_n1 I884_G7_0n I884_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I92_XG_MN2 (XI1712_I92_XG_n1 I1712_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I92_XG_MN0 (I1712_G26_25 I1712_pn26 XI1712_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I92_XG_MN1 (XI1712_I92_XG_n1 I1712_gn25 I1712_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I91_XG_MN2 (XI1712_I91_XG_n1 I1712_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I91_XG_MN0 (I1712_G25_24 I1712_pn25 XI1712_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I91_XG_MN1 (XI1712_I91_XG_n1 I1712_gn24 I1712_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I93_XG_MN2 (XI1712_I93_XG_n1 I1712_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I93_XG_MN0 (I1712_G27_26 I1712_pn27 XI1712_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I93_XG_MN1 (XI1712_I93_XG_n1 I1712_gn26 I1712_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I95_XG_MN2 (XI1712_I95_XG_n1 I1712_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I95_XG_MN0 (I1712_G29_28 I1712_pn29 XI1712_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I95_XG_MN1 (XI1712_I95_XG_n1 I1712_gn28 I1712_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I96_XG_MN2 (XI1712_I96_XG_n1 I1712_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I96_XG_MN0 (I1712_G30_29 I1712_pn30 XI1712_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I96_XG_MN1 (XI1712_I96_XG_n1 I1712_gn29 I1712_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I97_XG_MN2 (XI1712_I97_XG_n1 I1712_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I97_XG_MN0 (I1712_G31_30 I1712_pn31 XI1712_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I97_XG_MN1 (XI1712_I97_XG_n1 I1712_gn30 I1712_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I95_XG_MN2 (XI1758_I95_XG_n1 I1758_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I95_XG_MN0 (I1758_G29_28 I1758_pn29 XI1758_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I95_XG_MN1 (XI1758_I95_XG_n1 I1758_gn28 I1758_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I96_XG_MN2 (XI1758_I96_XG_n1 I1758_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I96_XG_MN0 (I1758_G30_29 I1758_pn30 XI1758_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I96_XG_MN1 (XI1758_I96_XG_n1 I1758_gn29 I1758_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I97_XG_MN2 (XI1758_I97_XG_n1 I1758_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I97_XG_MN0 (I1758_G31_30 I1758_pn31 XI1758_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I97_XG_MN1 (XI1758_I97_XG_n1 I1758_gn30 I1758_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I154_XG_MN2 (XI1068_I154_XG_n1 I1068_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I154_XG_MN0 (I1068_G29_22 I1068_P29_26n XI1068_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I154_XG_MN1 (XI1068_I154_XG_n1 I1068_G25_22n I1068_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I150_XG_MN2 (XI1068_I150_XG_n1 I1068_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I150_XG_MN0 (I1068_G25_18 I1068_P25_22n XI1068_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I150_XG_MN1 (XI1068_I150_XG_n1 I1068_G21_18n I1068_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I198_XG_MN2 (XI1068_I198_XG_n1 I1068_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I198_XG_MN0 (I1068_G27_0 I1068_P27_12n XI1068_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I198_XG_MN1 (XI1068_I198_XG_n1 I1068_G11_0n I1068_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I146_XG_MN2 (XI1068_I146_XG_n1 I1068_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I146_XG_MN0 (I1068_G21_14 I1068_P21_18n XI1068_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I146_XG_MN1 (XI1068_I146_XG_n1 I1068_G17_14n I1068_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I194_XG_MN2 (XI1068_I194_XG_n1 I1068_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I194_XG_MN0 (I1068_G23_0 I1068_P23_8n XI1068_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I194_XG_MN1 (XI1068_I194_XG_n1 I1068_G7_0n I1068_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I186_XG_MN2 (XI1068_I186_XG_n1 I1068_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I186_XG_MN0 (I1068_G19_0 I1068_P19_4n XI1068_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I186_XG_MN1 (XI1068_I186_XG_n1 I1068_G3_0n I1068_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I136_XG_MN2 (XI1068_I136_XG_n1 I1068_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I136_XG_MN0 (I1068_G11_4 I1068_P11_8n XI1068_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I136_XG_MN1 (XI1068_I136_XG_n1 I1068_G7_4n I1068_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I132_XG_MN2 (XI1068_I132_XG_n1 I1068_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I132_XG_MN0 (I1068_G7_0 I1068_P7_4n XI1068_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I132_XG_MN1 (XI1068_I132_XG_n1 I1068_G3_0n I1068_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I73_XG_MN2 (XI1068_I73_XG_n1 I1068_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I73_XG_MN0 (I1068_G7_6 I1068_pn7 XI1068_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I73_XG_MN1 (XI1068_I73_XG_n1 I1068_gn6 I1068_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I72_XG_MN2 (XI1068_I72_XG_n1 I1068_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I72_XG_MN0 (I1068_G6_5 I1068_pn6 XI1068_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I72_XG_MN1 (XI1068_I72_XG_n1 I1068_gn5 I1068_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I69_XG_MN2 (XI1068_I69_XG_n1 I1068_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I69_XG_MN0 (I1068_G3_2 I1068_pn3 XI1068_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I69_XG_MN1 (XI1068_I69_XG_n1 I1068_gn2 I1068_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I65_XG_MN2 (XI976_I65_XG_n1 I976_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I65_XG_MN0 (I976_G0_0 I976_pn0 XI976_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I65_XG_MN1 (XI976_I65_XG_n1 I976_cinn I976_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I95_XG_MN2 (XI884_I95_XG_n1 I884_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I95_XG_MN0 (I884_G29_28 I884_pn29 XI884_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I95_XG_MN1 (XI884_I95_XG_n1 I884_gn28 I884_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I94_XG_MN2 (XI1712_I94_XG_n1 I1712_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I94_XG_MN0 (I1712_G28_27 I1712_pn28 XI1712_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I94_XG_MN1 (XI1712_I94_XG_n1 I1712_gn27 I1712_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I65_XG_MN2 (XI1666_I65_XG_n1 I1666_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I65_XG_MN0 (I1666_G0_0 I1666_pn0 XI1666_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I65_XG_MN1 (XI1666_I65_XG_n1 I1666_cinn I1666_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I68_XG_MN2 (XI1574_I68_XG_n1 I1574_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I68_XG_MN0 (I1574_G2_1 I1574_pn2 XI1574_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I68_XG_MN1 (XI1574_I68_XG_n1 I1574_gn1 I1574_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I156_XG_MN2 (XI1068_I156_XG_n1 I1068_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I156_XG_MN0 (I1068_G31_24 I1068_P31_28n XI1068_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I156_XG_MN1 (XI1068_I156_XG_n1 I1068_G27_24n I1068_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I152_XG_MN2 (XI1068_I152_XG_n1 I1068_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I152_XG_MN0 (I1068_G27_20 I1068_P27_24n XI1068_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I152_XG_MN1 (XI1068_I152_XG_n1 I1068_G23_20n I1068_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I148_XG_MN2 (XI1068_I148_XG_n1 I1068_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I148_XG_MN0 (I1068_G23_16 I1068_P23_20n XI1068_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I148_XG_MN1 (XI1068_I148_XG_n1 I1068_G19_16n I1068_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I144_XG_MN2 (XI1068_I144_XG_n1 I1068_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I144_XG_MN0 (I1068_G19_12 I1068_P19_16n XI1068_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I144_XG_MN1 (XI1068_I144_XG_n1 I1068_G15_12n I1068_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I140_XG_MN2 (XI1068_I140_XG_n1 I1068_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I140_XG_MN0 (I1068_G15_8 I1068_P15_12n XI1068_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I140_XG_MN1 (XI1068_I140_XG_n1 I1068_G11_8n I1068_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I74_XG_MN2 (XI1068_I74_XG_n1 I1068_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I74_XG_MN0 (I1068_G8_7 I1068_pn8 XI1068_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I74_XG_MN1 (XI1068_I74_XG_n1 I1068_gn7 I1068_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I75_XG_MN2 (XI1068_I75_XG_n1 I1068_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I75_XG_MN0 (I1068_G9_8 I1068_pn9 XI1068_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I75_XG_MN1 (XI1068_I75_XG_n1 I1068_gn8 I1068_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I68_XG_MN2 (XI1068_I68_XG_n1 I1068_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I68_XG_MN0 (I1068_G2_1 I1068_pn2 XI1068_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I68_XG_MN1 (XI1068_I68_XG_n1 I1068_gn1 I1068_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I65_XG_MN2 (XI1022_I65_XG_n1 I1022_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I65_XG_MN0 (I1022_G0_0 I1022_pn0 XI1022_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I65_XG_MN1 (XI1022_I65_XG_n1 I1022_cinn I1022_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I67_XG_MN2 (XI1022_I67_XG_n1 I1022_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I67_XG_MN0 (I1022_G1_0 I1022_pn1 XI1022_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I67_XG_MN1 (XI1022_I67_XG_n1 I1022_G0_0n I1022_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I68_XG_MN2 (XI1022_I68_XG_n1 I1022_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I68_XG_MN0 (I1022_G2_1 I1022_pn2 XI1022_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I68_XG_MN1 (XI1022_I68_XG_n1 I1022_gn1 I1022_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I65_XG_MN2 (XI930_I65_XG_n1 I930_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I65_XG_MN0 (I930_G0_0 I930_pn0 XI930_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I65_XG_MN1 (XI930_I65_XG_n1 I930_cinn I930_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I70_XG_MN2 (XI930_I70_XG_n1 I930_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I70_XG_MN0 (I930_G4_3 I930_pn4 XI930_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I70_XG_MN1 (XI930_I70_XG_n1 I930_gn3 I930_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I71_XG_MN2 (XI930_I71_XG_n1 I930_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I71_XG_MN0 (I930_G5_4 I930_pn5 XI930_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I71_XG_MN1 (XI930_I71_XG_n1 I930_gn4 I930_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I67_XG_MN2 (XI1666_I67_XG_n1 I1666_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I67_XG_MN0 (I1666_G1_0 I1666_pn1 XI1666_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I67_XG_MN1 (XI1666_I67_XG_n1 I1666_G0_0n I1666_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I68_XG_MN2 (XI1666_I68_XG_n1 I1666_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I68_XG_MN0 (I1666_G2_1 I1666_pn2 XI1666_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I68_XG_MN1 (XI1666_I68_XG_n1 I1666_gn1 I1666_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I69_XG_MN2 (XI1666_I69_XG_n1 I1666_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I69_XG_MN0 (I1666_G3_2 I1666_pn3 XI1666_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I69_XG_MN1 (XI1666_I69_XG_n1 I1666_gn2 I1666_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I65_XG_MN2 (XI1620_I65_XG_n1 I1620_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I65_XG_MN0 (I1620_G0_0 I1620_pn0 XI1620_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I65_XG_MN1 (XI1620_I65_XG_n1 I1620_cinn I1620_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I65_XG_MN2 (XI1574_I65_XG_n1 I1574_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I65_XG_MN0 (I1574_G0_0 I1574_pn0 XI1574_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I65_XG_MN1 (XI1574_I65_XG_n1 I1574_cinn I1574_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I69_XG_MN2 (XI1574_I69_XG_n1 I1574_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I69_XG_MN0 (I1574_G3_2 I1574_pn3 XI1574_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I69_XG_MN1 (XI1574_I69_XG_n1 I1574_gn2 I1574_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I67_XG_MN2 (XI1574_I67_XG_n1 I1574_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I67_XG_MN0 (I1574_G1_0 I1574_pn1 XI1574_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I67_XG_MN1 (XI1574_I67_XG_n1 I1574_G0_0n I1574_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I70_XG_MN2 (XI1574_I70_XG_n1 I1574_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I70_XG_MN0 (I1574_G4_3 I1574_pn4 XI1574_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I70_XG_MN1 (XI1574_I70_XG_n1 I1574_gn3 I1574_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I128_XG_MN2 (XI1574_I128_XG_n1 I1574_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I128_XG_MN0 (I1574_G4_0 I1574_P4_1n XI1574_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I128_XG_MN1 (XI1574_I128_XG_n1 I1574_G0_0n I1574_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I93_XG_MN2 (XI1068_I93_XG_n1 I1068_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I93_XG_MN0 (I1068_G27_26 I1068_pn27 XI1068_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I93_XG_MN1 (XI1068_I93_XG_n1 I1068_gn26 I1068_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I197_XG_MN2 (XI1068_I197_XG_n1 I1068_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I197_XG_MN0 (I1068_G26_0 I1068_P26_11n XI1068_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I197_XG_MN1 (XI1068_I197_XG_n1 I1068_G10_0n I1068_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I202_XG_MN2 (XI1068_I202_XG_n1 I1068_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I202_XG_MN0 (c11_o I1068_P31_16n XI1068_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I202_XG_MN1 (XI1068_I202_XG_n1 I1068_G15_0n c11_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I185_XG_MN2 (XI1068_I185_XG_n1 I1068_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I185_XG_MN0 (I1068_G18_0 I1068_P18_3n XI1068_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I185_XG_MN1 (XI1068_I185_XG_n1 I1068_G2_0n I1068_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I135_XG_MN2 (XI1068_I135_XG_n1 I1068_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I135_XG_MN0 (I1068_G10_3 I1068_P10_7n XI1068_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I135_XG_MN1 (XI1068_I135_XG_n1 I1068_G6_3n I1068_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I131_XG_MN2 (XI1068_I131_XG_n1 I1068_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I131_XG_MN0 (I1068_G6_0 I1068_P6_3n XI1068_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I131_XG_MN1 (XI1068_I131_XG_n1 I1068_G2_0n I1068_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I67_XG_MN2 (XI1068_I67_XG_n1 I1068_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I67_XG_MN0 (I1068_G1_0 I1068_pn1 XI1068_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I67_XG_MN1 (XI1068_I67_XG_n1 I1068_G0_0n I1068_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I69_XG_MN2 (XI1022_I69_XG_n1 I1022_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I69_XG_MN0 (I1022_G3_2 I1022_pn3 XI1022_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I69_XG_MN1 (XI1022_I69_XG_n1 I1022_gn2 I1022_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I70_XG_MN2 (XI1022_I70_XG_n1 I1022_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I70_XG_MN0 (I1022_G4_3 I1022_pn4 XI1022_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I70_XG_MN1 (XI1022_I70_XG_n1 I1022_gn3 I1022_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I67_XG_MN2 (XI976_I67_XG_n1 I976_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I67_XG_MN0 (I976_G1_0 I976_pn1 XI976_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I67_XG_MN1 (XI976_I67_XG_n1 I976_G0_0n I976_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I68_XG_MN2 (XI976_I68_XG_n1 I976_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I68_XG_MN0 (I976_G2_1 I976_pn2 XI976_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I68_XG_MN1 (XI976_I68_XG_n1 I976_gn1 I976_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I69_XG_MN2 (XI976_I69_XG_n1 I976_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I69_XG_MN0 (I976_G3_2 I976_pn3 XI976_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I69_XG_MN1 (XI976_I69_XG_n1 I976_gn2 I976_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I70_XG_MN2 (XI976_I70_XG_n1 I976_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I70_XG_MN0 (I976_G4_3 I976_pn4 XI976_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I70_XG_MN1 (XI976_I70_XG_n1 I976_gn3 I976_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I67_XG_MN2 (XI930_I67_XG_n1 I930_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I67_XG_MN0 (I930_G1_0 I930_pn1 XI930_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I67_XG_MN1 (XI930_I67_XG_n1 I930_G0_0n I930_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I68_XG_MN2 (XI930_I68_XG_n1 I930_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I68_XG_MN0 (I930_G2_1 I930_pn2 XI930_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I68_XG_MN1 (XI930_I68_XG_n1 I930_gn1 I930_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I69_XG_MN2 (XI930_I69_XG_n1 I930_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I69_XG_MN0 (I930_G3_2 I930_pn3 XI930_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I69_XG_MN1 (XI930_I69_XG_n1 I930_gn2 I930_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I72_XG_MN2 (XI930_I72_XG_n1 I930_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I72_XG_MN0 (I930_G6_5 I930_pn6 XI930_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I72_XG_MN1 (XI930_I72_XG_n1 I930_gn5 I930_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I74_XG_MN2 (XI930_I74_XG_n1 I930_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I74_XG_MN0 (I930_G8_7 I930_pn8 XI930_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I74_XG_MN1 (XI930_I74_XG_n1 I930_gn7 I930_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I73_XG_MN2 (XI930_I73_XG_n1 I930_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I73_XG_MN0 (I930_G7_6 I930_pn7 XI930_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I73_XG_MN1 (XI930_I73_XG_n1 I930_gn6 I930_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I183_XG_MN2 (XI1666_I183_XG_n1 I1666_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I183_XG_MN0 (I1666_G16_0 I1666_P16_1n XI1666_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I183_XG_MN1 (XI1666_I183_XG_n1 I1666_G0_0n I1666_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I128_XG_MN2 (XI1666_I128_XG_n1 I1666_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I128_XG_MN0 (I1666_G4_0 I1666_P4_1n XI1666_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I128_XG_MN1 (XI1666_I128_XG_n1 I1666_G0_0n I1666_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I70_XG_MN2 (XI1666_I70_XG_n1 I1666_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I70_XG_MN0 (I1666_G4_3 I1666_pn4 XI1666_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I70_XG_MN1 (XI1666_I70_XG_n1 I1666_gn3 I1666_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I71_XG_MN2 (XI1666_I71_XG_n1 I1666_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I71_XG_MN0 (I1666_G5_4 I1666_pn5 XI1666_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I71_XG_MN1 (XI1666_I71_XG_n1 I1666_gn4 I1666_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I67_XG_MN2 (XI1620_I67_XG_n1 I1620_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I67_XG_MN0 (I1620_G1_0 I1620_pn1 XI1620_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I67_XG_MN1 (XI1620_I67_XG_n1 I1620_G0_0n I1620_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I68_XG_MN2 (XI1620_I68_XG_n1 I1620_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I68_XG_MN0 (I1620_G2_1 I1620_pn2 XI1620_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I68_XG_MN1 (XI1620_I68_XG_n1 I1620_gn1 I1620_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I69_XG_MN2 (XI1620_I69_XG_n1 I1620_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I69_XG_MN0 (I1620_G3_2 I1620_pn3 XI1620_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I69_XG_MN1 (XI1620_I69_XG_n1 I1620_gn2 I1620_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I70_XG_MN2 (XI1620_I70_XG_n1 I1620_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I70_XG_MN0 (I1620_G4_3 I1620_pn4 XI1620_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I70_XG_MN1 (XI1620_I70_XG_n1 I1620_gn3 I1620_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I71_XG_MN2 (XI1620_I71_XG_n1 I1620_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I71_XG_MN0 (I1620_G5_4 I1620_pn5 XI1620_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I71_XG_MN1 (XI1620_I71_XG_n1 I1620_gn4 I1620_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I71_XG_MN2 (XI1574_I71_XG_n1 I1574_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I71_XG_MN0 (I1574_G5_4 I1574_pn5 XI1574_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I71_XG_MN1 (XI1574_I71_XG_n1 I1574_gn4 I1574_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I72_XG_MN2 (XI1574_I72_XG_n1 I1574_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I72_XG_MN0 (I1574_G6_5 I1574_pn6 XI1574_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I72_XG_MN1 (XI1574_I72_XG_n1 I1574_gn5 I1574_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I133_XG_MN2 (XI1574_I133_XG_n1 I1574_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I133_XG_MN0 (I1574_G8_1 I1574_P8_5n XI1574_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I133_XG_MN1 (XI1574_I133_XG_n1 I1574_G4_1n I1574_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I183_XG_MN2 (XI1574_I183_XG_n1 I1574_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I183_XG_MN0 (I1574_G16_0 I1574_P16_1n XI1574_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I183_XG_MN1 (XI1574_I183_XG_n1 I1574_G0_0n I1574_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I94_XG_MN2 (XI1068_I94_XG_n1 I1068_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I94_XG_MN0 (I1068_G28_27 I1068_pn28 XI1068_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I94_XG_MN1 (XI1068_I94_XG_n1 I1068_gn27 I1068_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I92_XG_MN2 (XI1068_I92_XG_n1 I1068_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I92_XG_MN0 (I1068_G26_25 I1068_pn26 XI1068_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I92_XG_MN1 (XI1068_I92_XG_n1 I1068_gn25 I1068_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I155_XG_MN2 (XI1068_I155_XG_n1 I1068_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I155_XG_MN0 (I1068_G30_23 I1068_P30_27n XI1068_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I155_XG_MN1 (XI1068_I155_XG_n1 I1068_G26_23n I1068_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I201_XG_MN2 (XI1068_I201_XG_n1 I1068_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I201_XG_MN0 (c11_m I1068_P30_15n XI1068_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I201_XG_MN1 (XI1068_I201_XG_n1 I1068_G14_0n c11_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I151_XG_MN2 (XI1068_I151_XG_n1 I1068_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I151_XG_MN0 (I1068_G26_19 I1068_P26_23n XI1068_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I151_XG_MN1 (XI1068_I151_XG_n1 I1068_G22_19n I1068_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I147_XG_MN2 (XI1068_I147_XG_n1 I1068_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I147_XG_MN0 (I1068_G22_15 I1068_P22_19n XI1068_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I147_XG_MN1 (XI1068_I147_XG_n1 I1068_G18_15n I1068_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I192_XG_MN2 (XI1068_I192_XG_n1 I1068_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I192_XG_MN0 (I1068_G22_0 I1068_P22_7n XI1068_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I192_XG_MN1 (XI1068_I192_XG_n1 I1068_G6_0n I1068_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I143_XG_MN2 (XI1068_I143_XG_n1 I1068_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I143_XG_MN0 (I1068_G18_11 I1068_P18_15n XI1068_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I143_XG_MN1 (XI1068_I143_XG_n1 I1068_G14_11n I1068_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I139_XG_MN2 (XI1068_I139_XG_n1 I1068_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I139_XG_MN0 (I1068_G14_7 I1068_P14_11n XI1068_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I139_XG_MN1 (XI1068_I139_XG_n1 I1068_G10_7n I1068_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I137_XG_MN2 (XI1068_I137_XG_n1 I1068_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I137_XG_MN0 (I1068_G12_5 I1068_P12_9n XI1068_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I137_XG_MN1 (XI1068_I137_XG_n1 I1068_G8_5n I1068_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I133_XG_MN2 (XI1068_I133_XG_n1 I1068_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I133_XG_MN0 (I1068_G8_1 I1068_P8_5n XI1068_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I133_XG_MN1 (XI1068_I133_XG_n1 I1068_G4_1n I1068_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I76_XG_MN2 (XI1068_I76_XG_n1 I1068_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I76_XG_MN0 (I1068_G10_9 I1068_pn10 XI1068_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I76_XG_MN1 (XI1068_I76_XG_n1 I1068_gn9 I1068_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I128_XG_MN2 (XI1068_I128_XG_n1 I1068_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I128_XG_MN0 (I1068_G4_0 I1068_P4_1n XI1068_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I128_XG_MN1 (XI1068_I128_XG_n1 I1068_G0_0n I1068_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I130_XG_MN2 (XI1022_I130_XG_n1 I1022_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I130_XG_MN0 (I1022_G5_0 I1022_P5_2n XI1022_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I130_XG_MN1 (XI1022_I130_XG_n1 I1022_G1_0n I1022_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I128_XG_MN2 (XI1022_I128_XG_n1 I1022_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I128_XG_MN0 (I1022_G4_0 I1022_P4_1n XI1022_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I128_XG_MN1 (XI1022_I128_XG_n1 I1022_G0_0n I1022_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I131_XG_MN2 (XI1022_I131_XG_n1 I1022_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I131_XG_MN0 (I1022_G6_0 I1022_P6_3n XI1022_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I131_XG_MN1 (XI1022_I131_XG_n1 I1022_G2_0n I1022_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I72_XG_MN2 (XI1022_I72_XG_n1 I1022_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I72_XG_MN0 (I1022_G6_5 I1022_pn6 XI1022_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I72_XG_MN1 (XI1022_I72_XG_n1 I1022_gn5 I1022_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I71_XG_MN2 (XI1022_I71_XG_n1 I1022_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I71_XG_MN0 (I1022_G5_4 I1022_pn5 XI1022_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I71_XG_MN1 (XI1022_I71_XG_n1 I1022_gn4 I1022_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I71_XG_MN2 (XI976_I71_XG_n1 I976_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I71_XG_MN0 (I976_G5_4 I976_pn5 XI976_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I71_XG_MN1 (XI976_I71_XG_n1 I976_gn4 I976_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I72_XG_MN2 (XI976_I72_XG_n1 I976_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I72_XG_MN0 (I976_G6_5 I976_pn6 XI976_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I72_XG_MN1 (XI976_I72_XG_n1 I976_gn5 I976_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I128_XG_MN2 (XI930_I128_XG_n1 I930_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I128_XG_MN0 (I930_G4_0 I930_P4_1n XI930_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I128_XG_MN1 (XI930_I128_XG_n1 I930_G0_0n I930_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I133_XG_MN2 (XI930_I133_XG_n1 I930_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I133_XG_MN0 (I930_G8_1 I930_P8_5n XI930_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I133_XG_MN1 (XI930_I133_XG_n1 I930_G4_1n I930_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I75_XG_MN2 (XI930_I75_XG_n1 I930_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I75_XG_MN0 (I930_G9_8 I930_pn9 XI930_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I75_XG_MN1 (XI930_I75_XG_n1 I930_gn8 I930_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I195_XG_MN2 (XI1666_I195_XG_n1 I1666_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I195_XG_MN0 (I1666_G24_0 I1666_P24_9n XI1666_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I195_XG_MN1 (XI1666_I195_XG_n1 I1666_G8_0n I1666_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I133_XG_MN2 (XI1666_I133_XG_n1 I1666_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I133_XG_MN0 (I1666_G8_1 I1666_P8_5n XI1666_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I133_XG_MN1 (XI1666_I133_XG_n1 I1666_G4_1n I1666_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I185_XG_MN2 (XI1666_I185_XG_n1 I1666_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I185_XG_MN0 (I1666_G18_0 I1666_P18_3n XI1666_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I185_XG_MN1 (XI1666_I185_XG_n1 I1666_G2_0n I1666_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I131_XG_MN2 (XI1666_I131_XG_n1 I1666_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I131_XG_MN0 (I1666_G6_0 I1666_P6_3n XI1666_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I131_XG_MN1 (XI1666_I131_XG_n1 I1666_G2_0n I1666_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I130_XG_MN2 (XI1666_I130_XG_n1 I1666_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I130_XG_MN0 (I1666_G5_0 I1666_P5_2n XI1666_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I130_XG_MN1 (XI1666_I130_XG_n1 I1666_G1_0n I1666_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I72_XG_MN2 (XI1666_I72_XG_n1 I1666_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I72_XG_MN0 (I1666_G6_5 I1666_pn6 XI1666_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I72_XG_MN1 (XI1666_I72_XG_n1 I1666_gn5 I1666_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I73_XG_MN2 (XI1666_I73_XG_n1 I1666_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I73_XG_MN0 (I1666_G7_6 I1666_pn7 XI1666_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I73_XG_MN1 (XI1666_I73_XG_n1 I1666_gn6 I1666_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I128_XG_MN2 (XI1620_I128_XG_n1 I1620_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I128_XG_MN0 (I1620_G4_0 I1620_P4_1n XI1620_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I128_XG_MN1 (XI1620_I128_XG_n1 I1620_G0_0n I1620_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I131_XG_MN2 (XI1620_I131_XG_n1 I1620_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I131_XG_MN0 (I1620_G6_0 I1620_P6_3n XI1620_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I131_XG_MN1 (XI1620_I131_XG_n1 I1620_G2_0n I1620_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I72_XG_MN2 (XI1620_I72_XG_n1 I1620_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I72_XG_MN0 (I1620_G6_5 I1620_pn6 XI1620_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I72_XG_MN1 (XI1620_I72_XG_n1 I1620_gn5 I1620_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I73_XG_MN2 (XI1620_I73_XG_n1 I1620_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I73_XG_MN0 (I1620_G7_6 I1620_pn7 XI1620_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I73_XG_MN1 (XI1620_I73_XG_n1 I1620_gn6 I1620_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I74_XG_MN2 (XI1574_I74_XG_n1 I1574_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I74_XG_MN0 (I1574_G8_7 I1574_pn8 XI1574_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I74_XG_MN1 (XI1574_I74_XG_n1 I1574_gn7 I1574_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I73_XG_MN2 (XI1574_I73_XG_n1 I1574_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I73_XG_MN0 (I1574_G7_6 I1574_pn7 XI1574_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I73_XG_MN1 (XI1574_I73_XG_n1 I1574_gn6 I1574_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I131_XG_MN2 (XI1574_I131_XG_n1 I1574_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I131_XG_MN0 (I1574_G6_0 I1574_P6_3n XI1574_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I131_XG_MN1 (XI1574_I131_XG_n1 I1574_G2_0n I1574_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I137_XG_MN2 (XI1574_I137_XG_n1 I1574_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I137_XG_MN0 (I1574_G12_5 I1574_P12_9n XI1574_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I137_XG_MN1 (XI1574_I137_XG_n1 I1574_G8_5n I1574_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I188_XG_MN2 (XI1574_I188_XG_n1 I1574_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I188_XG_MN0 (I1574_G20_0 I1574_P20_5n XI1574_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I188_XG_MN1 (XI1574_I188_XG_n1 I1574_G4_0n I1574_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I95_XG_MN2 (XI1068_I95_XG_n1 I1068_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I95_XG_MN0 (I1068_G29_28 I1068_pn29 XI1068_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I95_XG_MN1 (XI1068_I95_XG_n1 I1068_gn28 I1068_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I91_XG_MN2 (XI1068_I91_XG_n1 I1068_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I91_XG_MN0 (I1068_G25_24 I1068_pn25 XI1068_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I91_XG_MN1 (XI1068_I91_XG_n1 I1068_gn24 I1068_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I153_XG_MN2 (XI1068_I153_XG_n1 I1068_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I153_XG_MN0 (I1068_G28_21 I1068_P28_25n XI1068_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I153_XG_MN1 (XI1068_I153_XG_n1 I1068_G24_21n I1068_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I199_XG_MN2 (XI1068_I199_XG_n1 I1068_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I199_XG_MN0 (I1068_G28_0 I1068_P28_13n XI1068_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I199_XG_MN1 (XI1068_I199_XG_n1 I1068_G12_0n I1068_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I149_XG_MN2 (XI1068_I149_XG_n1 I1068_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I149_XG_MN0 (I1068_G24_17 I1068_P24_21n XI1068_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I149_XG_MN1 (XI1068_I149_XG_n1 I1068_G20_17n I1068_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I188_XG_MN2 (XI1068_I188_XG_n1 I1068_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I188_XG_MN0 (I1068_G20_0 I1068_P20_5n XI1068_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I188_XG_MN1 (XI1068_I188_XG_n1 I1068_G4_0n I1068_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I145_XG_MN2 (XI1068_I145_XG_n1 I1068_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I145_XG_MN0 (I1068_G20_13 I1068_P20_17n XI1068_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I145_XG_MN1 (XI1068_I145_XG_n1 I1068_G16_13n I1068_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I141_XG_MN2 (XI1068_I141_XG_n1 I1068_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I141_XG_MN0 (I1068_G16_9 I1068_P16_13n XI1068_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I141_XG_MN1 (XI1068_I141_XG_n1 I1068_G12_9n I1068_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I183_XG_MN2 (XI1068_I183_XG_n1 I1068_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I183_XG_MN0 (I1068_G16_0 I1068_P16_1n XI1068_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I183_XG_MN1 (XI1068_I183_XG_n1 I1068_G0_0n I1068_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I77_XG_MN2 (XI1068_I77_XG_n1 I1068_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I77_XG_MN0 (I1068_G11_10 I1068_pn11 XI1068_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I77_XG_MN1 (XI1068_I77_XG_n1 I1068_gn10 I1068_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I134_XG_MN2 (XI1022_I134_XG_n1 I1022_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I134_XG_MN0 (I1022_G9_2 I1022_P9_6n XI1022_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I134_XG_MN1 (XI1022_I134_XG_n1 I1022_G5_2n I1022_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I183_XG_MN2 (XI1022_I183_XG_n1 I1022_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I183_XG_MN0 (I1022_G16_0 I1022_P16_1n XI1022_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I183_XG_MN1 (XI1022_I183_XG_n1 I1022_G0_0n I1022_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I133_XG_MN2 (XI1022_I133_XG_n1 I1022_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I133_XG_MN0 (I1022_G8_1 I1022_P8_5n XI1022_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I133_XG_MN1 (XI1022_I133_XG_n1 I1022_G4_1n I1022_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I73_XG_MN2 (XI1022_I73_XG_n1 I1022_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I73_XG_MN0 (I1022_G7_6 I1022_pn7 XI1022_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I73_XG_MN1 (XI1022_I73_XG_n1 I1022_gn6 I1022_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I74_XG_MN2 (XI1022_I74_XG_n1 I1022_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I74_XG_MN0 (I1022_G8_7 I1022_pn8 XI1022_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I74_XG_MN1 (XI1022_I74_XG_n1 I1022_gn7 I1022_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I75_XG_MN2 (XI1022_I75_XG_n1 I1022_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I75_XG_MN0 (I1022_G9_8 I1022_pn9 XI1022_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I75_XG_MN1 (XI1022_I75_XG_n1 I1022_gn8 I1022_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I128_XG_MN2 (XI976_I128_XG_n1 I976_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I128_XG_MN0 (I976_G4_0 I976_P4_1n XI976_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I128_XG_MN1 (XI976_I128_XG_n1 I976_G0_0n I976_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I74_XG_MN2 (XI976_I74_XG_n1 I976_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I74_XG_MN0 (I976_G8_7 I976_pn8 XI976_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I74_XG_MN1 (XI976_I74_XG_n1 I976_gn7 I976_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I73_XG_MN2 (XI976_I73_XG_n1 I976_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I73_XG_MN0 (I976_G7_6 I976_pn7 XI976_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I73_XG_MN1 (XI976_I73_XG_n1 I976_gn6 I976_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I183_XG_MN2 (XI930_I183_XG_n1 I930_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I183_XG_MN0 (I930_G16_0 I930_P16_1n XI930_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I183_XG_MN1 (XI930_I183_XG_n1 I930_G0_0n I930_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I131_XG_MN2 (XI930_I131_XG_n1 I930_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I131_XG_MN0 (I930_G6_0 I930_P6_3n XI930_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I131_XG_MN1 (XI930_I131_XG_n1 I930_G2_0n I930_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I76_XG_MN2 (XI930_I76_XG_n1 I930_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I76_XG_MN0 (I930_G10_9 I930_pn10 XI930_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I76_XG_MN1 (XI930_I76_XG_n1 I930_gn9 I930_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I77_XG_MN2 (XI930_I77_XG_n1 I930_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I77_XG_MN0 (I930_G11_10 I930_pn11 XI930_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I77_XG_MN1 (XI930_I77_XG_n1 I930_gn10 I930_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I134_XG_MN2 (XI930_I134_XG_n1 I930_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I134_XG_MN0 (I930_G9_2 I930_P9_6n XI930_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I134_XG_MN1 (XI930_I134_XG_n1 I930_G5_2n I930_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I130_XG_MN2 (XI930_I130_XG_n1 I930_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I130_XG_MN0 (I930_G5_0 I930_P5_2n XI930_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I130_XG_MN1 (XI930_I130_XG_n1 I930_G1_0n I930_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I137_XG_MN2 (XI1666_I137_XG_n1 I1666_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I137_XG_MN0 (I1666_G12_5 I1666_P12_9n XI1666_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I137_XG_MN1 (XI1666_I137_XG_n1 I1666_G8_5n I1666_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I135_XG_MN2 (XI1666_I135_XG_n1 I1666_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I135_XG_MN0 (I1666_G10_3 I1666_P10_7n XI1666_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I135_XG_MN1 (XI1666_I135_XG_n1 I1666_G6_3n I1666_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I134_XG_MN2 (XI1666_I134_XG_n1 I1666_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I134_XG_MN0 (I1666_G9_2 I1666_P9_6n XI1666_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I134_XG_MN1 (XI1666_I134_XG_n1 I1666_G5_2n I1666_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I132_XG_MN2 (XI1666_I132_XG_n1 I1666_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I132_XG_MN0 (I1666_G7_0 I1666_P7_4n XI1666_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I132_XG_MN1 (XI1666_I132_XG_n1 I1666_G3_0n I1666_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I75_XG_MN2 (XI1666_I75_XG_n1 I1666_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I75_XG_MN0 (I1666_G9_8 I1666_pn9 XI1666_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I75_XG_MN1 (XI1666_I75_XG_n1 I1666_gn8 I1666_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I76_XG_MN2 (XI1666_I76_XG_n1 I1666_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I76_XG_MN0 (I1666_G10_9 I1666_pn10 XI1666_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I76_XG_MN1 (XI1666_I76_XG_n1 I1666_gn9 I1666_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I74_XG_MN2 (XI1666_I74_XG_n1 I1666_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I74_XG_MN0 (I1666_G8_7 I1666_pn8 XI1666_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I74_XG_MN1 (XI1666_I74_XG_n1 I1666_gn7 I1666_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I130_XG_MN2 (XI1620_I130_XG_n1 I1620_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I130_XG_MN0 (I1620_G5_0 I1620_P5_2n XI1620_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I130_XG_MN1 (XI1620_I130_XG_n1 I1620_G1_0n I1620_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I133_XG_MN2 (XI1620_I133_XG_n1 I1620_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I133_XG_MN0 (I1620_G8_1 I1620_P8_5n XI1620_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I133_XG_MN1 (XI1620_I133_XG_n1 I1620_G4_1n I1620_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I135_XG_MN2 (XI1620_I135_XG_n1 I1620_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I135_XG_MN0 (I1620_G10_3 I1620_P10_7n XI1620_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I135_XG_MN1 (XI1620_I135_XG_n1 I1620_G6_3n I1620_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I74_XG_MN2 (XI1620_I74_XG_n1 I1620_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I74_XG_MN0 (I1620_G8_7 I1620_pn8 XI1620_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I74_XG_MN1 (XI1620_I74_XG_n1 I1620_gn7 I1620_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I75_XG_MN2 (XI1620_I75_XG_n1 I1620_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I75_XG_MN0 (I1620_G9_8 I1620_pn9 XI1620_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I75_XG_MN1 (XI1620_I75_XG_n1 I1620_gn8 I1620_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I132_XG_MN2 (XI1574_I132_XG_n1 I1574_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I132_XG_MN0 (I1574_G7_0 I1574_P7_4n XI1574_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I132_XG_MN1 (XI1574_I132_XG_n1 I1574_G3_0n I1574_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I130_XG_MN2 (XI1574_I130_XG_n1 I1574_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I130_XG_MN0 (I1574_G5_0 I1574_P5_2n XI1574_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I130_XG_MN1 (XI1574_I130_XG_n1 I1574_G1_0n I1574_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I134_XG_MN2 (XI1574_I134_XG_n1 I1574_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I134_XG_MN0 (I1574_G9_2 I1574_P9_6n XI1574_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I134_XG_MN1 (XI1574_I134_XG_n1 I1574_G5_2n I1574_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I75_XG_MN2 (XI1574_I75_XG_n1 I1574_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I75_XG_MN0 (I1574_G9_8 I1574_pn9 XI1574_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I75_XG_MN1 (XI1574_I75_XG_n1 I1574_gn8 I1574_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I76_XG_MN2 (XI1574_I76_XG_n1 I1574_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I76_XG_MN0 (I1574_G10_9 I1574_pn10 XI1574_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I76_XG_MN1 (XI1574_I76_XG_n1 I1574_gn9 I1574_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I135_XG_MN2 (XI1574_I135_XG_n1 I1574_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I135_XG_MN0 (I1574_G10_3 I1574_P10_7n XI1574_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I135_XG_MN1 (XI1574_I135_XG_n1 I1574_G6_3n I1574_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I141_XG_MN2 (XI1574_I141_XG_n1 I1574_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I141_XG_MN0 (I1574_G16_9 I1574_P16_13n XI1574_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I141_XG_MN1 (XI1574_I141_XG_n1 I1574_G12_9n I1574_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I96_XG_MN2 (XI1068_I96_XG_n1 I1068_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I96_XG_MN0 (I1068_G30_29 I1068_pn30 XI1068_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I96_XG_MN1 (XI1068_I96_XG_n1 I1068_gn29 I1068_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I90_XG_MN2 (XI1068_I90_XG_n1 I1068_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I90_XG_MN0 (I1068_G24_23 I1068_pn24 XI1068_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I90_XG_MN1 (XI1068_I90_XG_n1 I1068_gn23 I1068_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I89_XG_MN2 (XI1068_I89_XG_n1 I1068_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I89_XG_MN0 (I1068_G23_22 I1068_pn23 XI1068_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I89_XG_MN1 (XI1068_I89_XG_n1 I1068_gn22 I1068_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I88_XG_MN2 (XI1068_I88_XG_n1 I1068_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I88_XG_MN0 (I1068_G22_21 I1068_pn22 XI1068_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I88_XG_MN1 (XI1068_I88_XG_n1 I1068_gn21 I1068_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I87_XG_MN2 (XI1068_I87_XG_n1 I1068_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I87_XG_MN0 (I1068_G21_20 I1068_pn21 XI1068_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I87_XG_MN1 (XI1068_I87_XG_n1 I1068_gn20 I1068_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I86_XG_MN2 (XI1068_I86_XG_n1 I1068_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I86_XG_MN0 (I1068_G20_19 I1068_pn20 XI1068_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I86_XG_MN1 (XI1068_I86_XG_n1 I1068_gn19 I1068_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I85_XG_MN2 (XI1068_I85_XG_n1 I1068_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I85_XG_MN0 (I1068_G19_18 I1068_pn19 XI1068_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I85_XG_MN1 (XI1068_I85_XG_n1 I1068_gn18 I1068_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I195_XG_MN2 (XI1068_I195_XG_n1 I1068_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I195_XG_MN0 (I1068_G24_0 I1068_P24_9n XI1068_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I195_XG_MN1 (XI1068_I195_XG_n1 I1068_G8_0n I1068_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I79_XG_MN2 (XI1068_I79_XG_n1 I1068_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I79_XG_MN0 (I1068_G13_12 I1068_pn13 XI1068_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I79_XG_MN1 (XI1068_I79_XG_n1 I1068_gn12 I1068_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I78_XG_MN2 (XI1068_I78_XG_n1 I1068_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I78_XG_MN0 (I1068_G12_11 I1068_pn12 XI1068_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I78_XG_MN1 (XI1068_I78_XG_n1 I1068_gn11 I1068_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I184_XG_MN2 (XI1022_I184_XG_n1 I1022_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I184_XG_MN0 (I1022_G17_0 I1022_P17_2n XI1022_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I184_XG_MN1 (XI1022_I184_XG_n1 I1022_G1_0n I1022_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I132_XG_MN2 (XI1022_I132_XG_n1 I1022_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I132_XG_MN0 (I1022_G7_0 I1022_P7_4n XI1022_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I132_XG_MN1 (XI1022_I132_XG_n1 I1022_G3_0n I1022_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I136_XG_MN2 (XI1022_I136_XG_n1 I1022_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I136_XG_MN0 (I1022_G11_4 I1022_P11_8n XI1022_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I136_XG_MN1 (XI1022_I136_XG_n1 I1022_G7_4n I1022_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I195_XG_MN2 (XI1022_I195_XG_n1 I1022_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I195_XG_MN0 (I1022_G24_0 I1022_P24_9n XI1022_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I195_XG_MN1 (XI1022_I195_XG_n1 I1022_G8_0n I1022_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I135_XG_MN2 (XI1022_I135_XG_n1 I1022_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I135_XG_MN0 (I1022_G10_3 I1022_P10_7n XI1022_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I135_XG_MN1 (XI1022_I135_XG_n1 I1022_G6_3n I1022_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I76_XG_MN2 (XI1022_I76_XG_n1 I1022_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I76_XG_MN0 (I1022_G10_9 I1022_pn10 XI1022_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I76_XG_MN1 (XI1022_I76_XG_n1 I1022_gn9 I1022_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I77_XG_MN2 (XI1022_I77_XG_n1 I1022_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I77_XG_MN0 (I1022_G11_10 I1022_pn11 XI1022_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I77_XG_MN1 (XI1022_I77_XG_n1 I1022_gn10 I1022_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I133_XG_MN2 (XI976_I133_XG_n1 I976_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I133_XG_MN0 (I976_G8_1 I976_P8_5n XI976_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I133_XG_MN1 (XI976_I133_XG_n1 I976_G4_1n I976_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I131_XG_MN2 (XI976_I131_XG_n1 I976_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I131_XG_MN0 (I976_G6_0 I976_P6_3n XI976_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I131_XG_MN1 (XI976_I131_XG_n1 I976_G2_0n I976_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I130_XG_MN2 (XI976_I130_XG_n1 I976_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I130_XG_MN0 (I976_G5_0 I976_P5_2n XI976_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I130_XG_MN1 (XI976_I130_XG_n1 I976_G1_0n I976_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I132_XG_MN2 (XI976_I132_XG_n1 I976_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I132_XG_MN0 (I976_G7_0 I976_P7_4n XI976_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I132_XG_MN1 (XI976_I132_XG_n1 I976_G3_0n I976_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I75_XG_MN2 (XI976_I75_XG_n1 I976_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I75_XG_MN0 (I976_G9_8 I976_pn9 XI976_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I75_XG_MN1 (XI976_I75_XG_n1 I976_gn8 I976_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I76_XG_MN2 (XI976_I76_XG_n1 I976_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I76_XG_MN0 (I976_G10_9 I976_pn10 XI976_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I76_XG_MN1 (XI976_I76_XG_n1 I976_gn9 I976_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I195_XG_MN2 (XI930_I195_XG_n1 I930_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I195_XG_MN0 (I930_G24_0 I930_P24_9n XI930_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I195_XG_MN1 (XI930_I195_XG_n1 I930_G8_0n I930_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I141_XG_MN2 (XI930_I141_XG_n1 I930_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I141_XG_MN0 (I930_G16_9 I930_P16_13n XI930_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I141_XG_MN1 (XI930_I141_XG_n1 I930_G12_9n I930_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I137_XG_MN2 (XI930_I137_XG_n1 I930_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I137_XG_MN0 (I930_G12_5 I930_P12_9n XI930_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I137_XG_MN1 (XI930_I137_XG_n1 I930_G8_5n I930_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I135_XG_MN2 (XI930_I135_XG_n1 I930_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I135_XG_MN0 (I930_G10_3 I930_P10_7n XI930_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I135_XG_MN1 (XI930_I135_XG_n1 I930_G6_3n I930_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I78_XG_MN2 (XI930_I78_XG_n1 I930_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I78_XG_MN0 (I930_G12_11 I930_pn12 XI930_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I78_XG_MN1 (XI930_I78_XG_n1 I930_gn11 I930_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I132_XG_MN2 (XI930_I132_XG_n1 I930_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I132_XG_MN0 (I930_G7_0 I930_P7_4n XI930_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I132_XG_MN1 (XI930_I132_XG_n1 I930_G3_0n I930_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I184_XG_MN2 (XI930_I184_XG_n1 I930_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I184_XG_MN0 (I930_G17_0 I930_P17_2n XI930_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I184_XG_MN1 (XI930_I184_XG_n1 I930_G1_0n I930_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I188_XG_MN2 (XI1666_I188_XG_n1 I1666_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I188_XG_MN0 (I1666_G20_0 I1666_P20_5n XI1666_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I188_XG_MN1 (XI1666_I188_XG_n1 I1666_G4_0n I1666_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I141_XG_MN2 (XI1666_I141_XG_n1 I1666_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I141_XG_MN0 (I1666_G16_9 I1666_P16_13n XI1666_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I141_XG_MN1 (XI1666_I141_XG_n1 I1666_G12_9n I1666_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I184_XG_MN2 (XI1666_I184_XG_n1 I1666_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I184_XG_MN0 (I1666_G17_0 I1666_P17_2n XI1666_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I184_XG_MN1 (XI1666_I184_XG_n1 I1666_G1_0n I1666_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I136_XG_MN2 (XI1666_I136_XG_n1 I1666_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I136_XG_MN0 (I1666_G11_4 I1666_P11_8n XI1666_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I136_XG_MN1 (XI1666_I136_XG_n1 I1666_G7_4n I1666_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I77_XG_MN2 (XI1666_I77_XG_n1 I1666_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I77_XG_MN0 (I1666_G11_10 I1666_pn11 XI1666_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I77_XG_MN1 (XI1666_I77_XG_n1 I1666_gn10 I1666_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I78_XG_MN2 (XI1666_I78_XG_n1 I1666_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I78_XG_MN0 (I1666_G12_11 I1666_pn12 XI1666_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I78_XG_MN1 (XI1666_I78_XG_n1 I1666_gn11 I1666_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I132_XG_MN2 (XI1620_I132_XG_n1 I1620_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I132_XG_MN0 (I1620_G7_0 I1620_P7_4n XI1620_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I132_XG_MN1 (XI1620_I132_XG_n1 I1620_G3_0n I1620_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I134_XG_MN2 (XI1620_I134_XG_n1 I1620_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I134_XG_MN0 (I1620_G9_2 I1620_P9_6n XI1620_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I134_XG_MN1 (XI1620_I134_XG_n1 I1620_G5_2n I1620_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I183_XG_MN2 (XI1620_I183_XG_n1 I1620_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I183_XG_MN0 (I1620_G16_0 I1620_P16_1n XI1620_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I183_XG_MN1 (XI1620_I183_XG_n1 I1620_G0_0n I1620_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I76_XG_MN2 (XI1620_I76_XG_n1 I1620_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I76_XG_MN0 (I1620_G10_9 I1620_pn10 XI1620_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I76_XG_MN1 (XI1620_I76_XG_n1 I1620_gn9 I1620_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I77_XG_MN2 (XI1620_I77_XG_n1 I1620_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I77_XG_MN0 (I1620_G11_10 I1620_pn11 XI1620_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I77_XG_MN1 (XI1620_I77_XG_n1 I1620_gn10 I1620_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I136_XG_MN2 (XI1574_I136_XG_n1 I1574_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I136_XG_MN0 (I1574_G11_4 I1574_P11_8n XI1574_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I136_XG_MN1 (XI1574_I136_XG_n1 I1574_G7_4n I1574_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I184_XG_MN2 (XI1574_I184_XG_n1 I1574_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I184_XG_MN0 (I1574_G17_0 I1574_P17_2n XI1574_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I184_XG_MN1 (XI1574_I184_XG_n1 I1574_G1_0n I1574_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I77_XG_MN2 (XI1574_I77_XG_n1 I1574_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I77_XG_MN0 (I1574_G11_10 I1574_pn11 XI1574_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I77_XG_MN1 (XI1574_I77_XG_n1 I1574_gn10 I1574_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I78_XG_MN2 (XI1574_I78_XG_n1 I1574_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I78_XG_MN0 (I1574_G12_11 I1574_pn12 XI1574_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I78_XG_MN1 (XI1574_I78_XG_n1 I1574_gn11 I1574_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I185_XG_MN2 (XI1574_I185_XG_n1 I1574_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I185_XG_MN0 (I1574_G18_0 I1574_P18_3n XI1574_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I185_XG_MN1 (XI1574_I185_XG_n1 I1574_G2_0n I1574_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I195_XG_MN2 (XI1574_I195_XG_n1 I1574_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I195_XG_MN0 (I1574_G24_0 I1574_P24_9n XI1574_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I195_XG_MN1 (XI1574_I195_XG_n1 I1574_G8_0n I1574_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I84_XG_MN2 (XI1068_I84_XG_n1 I1068_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I84_XG_MN0 (I1068_G18_17 I1068_pn18 XI1068_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I84_XG_MN1 (XI1068_I84_XG_n1 I1068_gn17 I1068_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I83_XG_MN2 (XI1068_I83_XG_n1 I1068_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I83_XG_MN0 (I1068_G17_16 I1068_pn17 XI1068_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I83_XG_MN1 (XI1068_I83_XG_n1 I1068_gn16 I1068_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I81_XG_MN2 (XI1068_I81_XG_n1 I1068_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I81_XG_MN0 (I1068_G15_14 I1068_pn15 XI1068_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I81_XG_MN1 (XI1068_I81_XG_n1 I1068_gn14 I1068_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I80_XG_MN2 (XI1068_I80_XG_n1 I1068_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I80_XG_MN0 (I1068_G14_13 I1068_pn14 XI1068_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I80_XG_MN1 (XI1068_I80_XG_n1 I1068_gn13 I1068_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I196_XG_MN2 (XI1022_I196_XG_n1 I1022_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I196_XG_MN0 (I1022_G25_0 I1022_P25_10n XI1022_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I196_XG_MN1 (XI1022_I196_XG_n1 I1022_G9_0n I1022_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I138_XG_MN2 (XI1022_I138_XG_n1 I1022_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I138_XG_MN0 (I1022_G13_6 I1022_P13_10n XI1022_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I138_XG_MN1 (XI1022_I138_XG_n1 I1022_G9_6n I1022_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I185_XG_MN2 (XI1022_I185_XG_n1 I1022_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I185_XG_MN0 (I1022_G18_0 I1022_P18_3n XI1022_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I185_XG_MN1 (XI1022_I185_XG_n1 I1022_G2_0n I1022_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I141_XG_MN2 (XI1022_I141_XG_n1 I1022_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I141_XG_MN0 (I1022_G16_9 I1022_P16_13n XI1022_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I141_XG_MN1 (XI1022_I141_XG_n1 I1022_G12_9n I1022_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I137_XG_MN2 (XI1022_I137_XG_n1 I1022_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I137_XG_MN0 (I1022_G12_5 I1022_P12_9n XI1022_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I137_XG_MN1 (XI1022_I137_XG_n1 I1022_G8_5n I1022_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I79_XG_MN2 (XI1022_I79_XG_n1 I1022_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I79_XG_MN0 (I1022_G13_12 I1022_pn13 XI1022_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I79_XG_MN1 (XI1022_I79_XG_n1 I1022_gn12 I1022_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I78_XG_MN2 (XI1022_I78_XG_n1 I1022_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I78_XG_MN0 (I1022_G12_11 I1022_pn12 XI1022_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I78_XG_MN1 (XI1022_I78_XG_n1 I1022_gn11 I1022_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I183_XG_MN2 (XI976_I183_XG_n1 I976_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I183_XG_MN0 (I976_G16_0 I976_P16_1n XI976_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I183_XG_MN1 (XI976_I183_XG_n1 I976_G0_0n I976_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I134_XG_MN2 (XI976_I134_XG_n1 I976_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I134_XG_MN0 (I976_G9_2 I976_P9_6n XI976_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I134_XG_MN1 (XI976_I134_XG_n1 I976_G5_2n I976_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I77_XG_MN2 (XI976_I77_XG_n1 I976_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I77_XG_MN0 (I976_G11_10 I976_pn11 XI976_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I77_XG_MN1 (XI976_I77_XG_n1 I976_gn10 I976_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I188_XG_MN2 (XI930_I188_XG_n1 I930_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I188_XG_MN0 (I930_G20_0 I930_P20_5n XI930_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I188_XG_MN1 (XI930_I188_XG_n1 I930_G4_0n I930_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I79_XG_MN2 (XI930_I79_XG_n1 I930_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I79_XG_MN0 (I930_G13_12 I930_pn13 XI930_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I79_XG_MN1 (XI930_I79_XG_n1 I930_gn12 I930_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I136_XG_MN2 (XI930_I136_XG_n1 I930_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I136_XG_MN0 (I930_G11_4 I930_P11_8n XI930_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I136_XG_MN1 (XI930_I136_XG_n1 I930_G7_4n I930_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I138_XG_MN2 (XI930_I138_XG_n1 I930_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I138_XG_MN0 (I930_G13_6 I930_P13_10n XI930_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I138_XG_MN1 (XI930_I138_XG_n1 I930_G9_6n I930_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I197_XG_MN2 (XI1666_I197_XG_n1 I1666_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I197_XG_MN0 (I1666_G26_0 I1666_P26_11n XI1666_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I197_XG_MN1 (XI1666_I197_XG_n1 I1666_G10_0n I1666_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I139_XG_MN2 (XI1666_I139_XG_n1 I1666_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I139_XG_MN0 (I1666_G14_7 I1666_P14_11n XI1666_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I139_XG_MN1 (XI1666_I139_XG_n1 I1666_G10_7n I1666_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I196_XG_MN2 (XI1666_I196_XG_n1 I1666_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I196_XG_MN0 (I1666_G25_0 I1666_P25_10n XI1666_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I196_XG_MN1 (XI1666_I196_XG_n1 I1666_G9_0n I1666_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I186_XG_MN2 (XI1666_I186_XG_n1 I1666_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I186_XG_MN0 (I1666_G19_0 I1666_P19_4n XI1666_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I186_XG_MN1 (XI1666_I186_XG_n1 I1666_G3_0n I1666_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I138_XG_MN2 (XI1666_I138_XG_n1 I1666_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I138_XG_MN0 (I1666_G13_6 I1666_P13_10n XI1666_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I138_XG_MN1 (XI1666_I138_XG_n1 I1666_G9_6n I1666_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I79_XG_MN2 (XI1666_I79_XG_n1 I1666_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I79_XG_MN0 (I1666_G13_12 I1666_pn13 XI1666_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I79_XG_MN1 (XI1666_I79_XG_n1 I1666_gn12 I1666_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I136_XG_MN2 (XI1620_I136_XG_n1 I1620_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I136_XG_MN0 (I1620_G11_4 I1620_P11_8n XI1620_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I136_XG_MN1 (XI1620_I136_XG_n1 I1620_G7_4n I1620_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I184_XG_MN2 (XI1620_I184_XG_n1 I1620_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I184_XG_MN0 (I1620_G17_0 I1620_P17_2n XI1620_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I184_XG_MN1 (XI1620_I184_XG_n1 I1620_G1_0n I1620_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I185_XG_MN2 (XI1620_I185_XG_n1 I1620_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I185_XG_MN0 (I1620_G18_0 I1620_P18_3n XI1620_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I185_XG_MN1 (XI1620_I185_XG_n1 I1620_G2_0n I1620_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I195_XG_MN2 (XI1620_I195_XG_n1 I1620_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I195_XG_MN0 (I1620_G24_0 I1620_P24_9n XI1620_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I195_XG_MN1 (XI1620_I195_XG_n1 I1620_G8_0n I1620_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I137_XG_MN2 (XI1620_I137_XG_n1 I1620_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I137_XG_MN0 (I1620_G12_5 I1620_P12_9n XI1620_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I137_XG_MN1 (XI1620_I137_XG_n1 I1620_G8_5n I1620_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I141_XG_MN2 (XI1620_I141_XG_n1 I1620_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I141_XG_MN0 (I1620_G16_9 I1620_P16_13n XI1620_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I141_XG_MN1 (XI1620_I141_XG_n1 I1620_G12_9n I1620_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I78_XG_MN2 (XI1620_I78_XG_n1 I1620_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I78_XG_MN0 (I1620_G12_11 I1620_pn12 XI1620_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I78_XG_MN1 (XI1620_I78_XG_n1 I1620_gn11 I1620_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I79_XG_MN2 (XI1620_I79_XG_n1 I1620_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I79_XG_MN0 (I1620_G13_12 I1620_pn13 XI1620_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I79_XG_MN1 (XI1620_I79_XG_n1 I1620_gn12 I1620_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I186_XG_MN2 (XI1574_I186_XG_n1 I1574_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I186_XG_MN0 (I1574_G19_0 I1574_P19_4n XI1574_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I186_XG_MN1 (XI1574_I186_XG_n1 I1574_G3_0n I1574_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I138_XG_MN2 (XI1574_I138_XG_n1 I1574_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I138_XG_MN0 (I1574_G13_6 I1574_P13_10n XI1574_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I138_XG_MN1 (XI1574_I138_XG_n1 I1574_G9_6n I1574_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I79_XG_MN2 (XI1574_I79_XG_n1 I1574_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I79_XG_MN0 (I1574_G13_12 I1574_pn13 XI1574_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I79_XG_MN1 (XI1574_I79_XG_n1 I1574_gn12 I1574_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I80_XG_MN2 (XI1574_I80_XG_n1 I1574_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I80_XG_MN0 (I1574_G14_13 I1574_pn14 XI1574_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I80_XG_MN1 (XI1574_I80_XG_n1 I1574_gn13 I1574_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I139_XG_MN2 (XI1574_I139_XG_n1 I1574_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I139_XG_MN0 (I1574_G14_7 I1574_P14_11n XI1574_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I139_XG_MN1 (XI1574_I139_XG_n1 I1574_G10_7n I1574_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I143_XG_MN2 (XI1574_I143_XG_n1 I1574_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I143_XG_MN0 (I1574_G18_11 I1574_P18_15n XI1574_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I143_XG_MN1 (XI1574_I143_XG_n1 I1574_G14_11n I1574_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I197_XG_MN2 (XI1574_I197_XG_n1 I1574_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I197_XG_MN0 (I1574_G26_0 I1574_P26_11n XI1574_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I197_XG_MN1 (XI1574_I197_XG_n1 I1574_G10_0n I1574_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I97_XG_MN2 (XI1068_I97_XG_n1 I1068_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I97_XG_MN0 (I1068_G31_30 I1068_pn31 XI1068_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I97_XG_MN1 (XI1068_I97_XG_n1 I1068_gn30 I1068_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I82_XG_MN2 (XI1068_I82_XG_n1 I1068_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I82_XG_MN0 (I1068_G16_15 I1068_pn16 XI1068_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I82_XG_MN1 (XI1068_I82_XG_n1 I1068_gn15 I1068_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I142_XG_MN2 (XI1022_I142_XG_n1 I1022_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I142_XG_MN0 (I1022_G17_10 I1022_P17_14n XI1022_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I142_XG_MN1 (XI1022_I142_XG_n1 I1022_G13_10n I1022_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I186_XG_MN2 (XI1022_I186_XG_n1 I1022_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I186_XG_MN0 (I1022_G19_0 I1022_P19_4n XI1022_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I186_XG_MN1 (XI1022_I186_XG_n1 I1022_G3_0n I1022_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I188_XG_MN2 (XI1022_I188_XG_n1 I1022_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I188_XG_MN0 (I1022_G20_0 I1022_P20_5n XI1022_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I188_XG_MN1 (XI1022_I188_XG_n1 I1022_G4_0n I1022_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I139_XG_MN2 (XI1022_I139_XG_n1 I1022_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I139_XG_MN0 (I1022_G14_7 I1022_P14_11n XI1022_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I139_XG_MN1 (XI1022_I139_XG_n1 I1022_G10_7n I1022_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I80_XG_MN2 (XI1022_I80_XG_n1 I1022_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I80_XG_MN0 (I1022_G14_13 I1022_pn14 XI1022_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I80_XG_MN1 (XI1022_I80_XG_n1 I1022_gn13 I1022_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I137_XG_MN2 (XI976_I137_XG_n1 I976_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I137_XG_MN0 (I976_G12_5 I976_P12_9n XI976_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I137_XG_MN1 (XI976_I137_XG_n1 I976_G8_5n I976_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I135_XG_MN2 (XI976_I135_XG_n1 I976_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I135_XG_MN0 (I976_G10_3 I976_P10_7n XI976_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I135_XG_MN1 (XI976_I135_XG_n1 I976_G6_3n I976_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I184_XG_MN2 (XI976_I184_XG_n1 I976_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I184_XG_MN0 (I976_G17_0 I976_P17_2n XI976_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I184_XG_MN1 (XI976_I184_XG_n1 I976_G1_0n I976_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I136_XG_MN2 (XI976_I136_XG_n1 I976_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I136_XG_MN0 (I976_G11_4 I976_P11_8n XI976_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I136_XG_MN1 (XI976_I136_XG_n1 I976_G7_4n I976_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I78_XG_MN2 (XI976_I78_XG_n1 I976_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I78_XG_MN0 (I976_G12_11 I976_pn12 XI976_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I78_XG_MN1 (XI976_I78_XG_n1 I976_gn11 I976_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I79_XG_MN2 (XI976_I79_XG_n1 I976_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I79_XG_MN0 (I976_G13_12 I976_pn13 XI976_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I79_XG_MN1 (XI976_I79_XG_n1 I976_gn12 I976_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I82_XG_MN2 (XI930_I82_XG_n1 I930_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I82_XG_MN0 (I930_G16_15 I930_pn16 XI930_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I82_XG_MN1 (XI930_I82_XG_n1 I930_gn15 I930_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I145_XG_MN2 (XI930_I145_XG_n1 I930_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I145_XG_MN0 (I930_G20_13 I930_P20_17n XI930_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I145_XG_MN1 (XI930_I145_XG_n1 I930_G16_13n I930_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I139_XG_MN2 (XI930_I139_XG_n1 I930_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I139_XG_MN0 (I930_G14_7 I930_P14_11n XI930_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I139_XG_MN1 (XI930_I139_XG_n1 I930_G10_7n I930_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I81_XG_MN2 (XI930_I81_XG_n1 I930_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I81_XG_MN0 (I930_G15_14 I930_pn15 XI930_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I81_XG_MN1 (XI930_I81_XG_n1 I930_gn14 I930_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I80_XG_MN2 (XI930_I80_XG_n1 I930_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I80_XG_MN0 (I930_G14_13 I930_pn14 XI930_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I80_XG_MN1 (XI930_I80_XG_n1 I930_gn13 I930_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I186_XG_MN2 (XI930_I186_XG_n1 I930_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I186_XG_MN0 (I930_G19_0 I930_P19_4n XI930_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I186_XG_MN1 (XI930_I186_XG_n1 I930_G3_0n I930_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I142_XG_MN2 (XI930_I142_XG_n1 I930_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I142_XG_MN0 (I930_G17_10 I930_P17_14n XI930_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I142_XG_MN1 (XI930_I142_XG_n1 I930_G13_10n I930_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I199_XG_MN2 (XI1666_I199_XG_n1 I1666_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I199_XG_MN0 (I1666_G28_0 I1666_P28_13n XI1666_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I199_XG_MN1 (XI1666_I199_XG_n1 I1666_G12_0n I1666_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I145_XG_MN2 (XI1666_I145_XG_n1 I1666_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I145_XG_MN0 (I1666_G20_13 I1666_P20_17n XI1666_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I145_XG_MN1 (XI1666_I145_XG_n1 I1666_G16_13n I1666_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I143_XG_MN2 (XI1666_I143_XG_n1 I1666_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I143_XG_MN0 (I1666_G18_11 I1666_P18_15n XI1666_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I143_XG_MN1 (XI1666_I143_XG_n1 I1666_G14_11n I1666_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I142_XG_MN2 (XI1666_I142_XG_n1 I1666_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I142_XG_MN0 (I1666_G17_10 I1666_P17_14n XI1666_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I142_XG_MN1 (XI1666_I142_XG_n1 I1666_G13_10n I1666_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I82_XG_MN2 (XI1666_I82_XG_n1 I1666_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I82_XG_MN0 (I1666_G16_15 I1666_pn16 XI1666_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I82_XG_MN1 (XI1666_I82_XG_n1 I1666_gn15 I1666_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I80_XG_MN2 (XI1666_I80_XG_n1 I1666_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I80_XG_MN0 (I1666_G14_13 I1666_pn14 XI1666_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I80_XG_MN1 (XI1666_I80_XG_n1 I1666_gn13 I1666_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I81_XG_MN2 (XI1666_I81_XG_n1 I1666_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I81_XG_MN0 (I1666_G15_14 I1666_pn15 XI1666_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I81_XG_MN1 (XI1666_I81_XG_n1 I1666_gn14 I1666_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I140_XG_MN2 (XI1620_I140_XG_n1 I1620_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I140_XG_MN0 (I1620_G15_8 I1620_P15_12n XI1620_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I140_XG_MN1 (XI1620_I140_XG_n1 I1620_G11_8n I1620_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I138_XG_MN2 (XI1620_I138_XG_n1 I1620_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I138_XG_MN0 (I1620_G13_6 I1620_P13_10n XI1620_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I138_XG_MN1 (XI1620_I138_XG_n1 I1620_G9_6n I1620_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I139_XG_MN2 (XI1620_I139_XG_n1 I1620_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I139_XG_MN0 (I1620_G14_7 I1620_P14_11n XI1620_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I139_XG_MN1 (XI1620_I139_XG_n1 I1620_G10_7n I1620_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I143_XG_MN2 (XI1620_I143_XG_n1 I1620_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I143_XG_MN0 (I1620_G18_11 I1620_P18_15n XI1620_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I143_XG_MN1 (XI1620_I143_XG_n1 I1620_G14_11n I1620_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I80_XG_MN2 (XI1620_I80_XG_n1 I1620_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I80_XG_MN0 (I1620_G14_13 I1620_pn14 XI1620_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I80_XG_MN1 (XI1620_I80_XG_n1 I1620_gn13 I1620_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I81_XG_MN2 (XI1620_I81_XG_n1 I1620_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I81_XG_MN0 (I1620_G15_14 I1620_pn15 XI1620_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I81_XG_MN1 (XI1620_I81_XG_n1 I1620_gn14 I1620_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I196_XG_MN2 (XI1574_I196_XG_n1 I1574_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I196_XG_MN0 (I1574_G25_0 I1574_P25_10n XI1574_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I196_XG_MN1 (XI1574_I196_XG_n1 I1574_G9_0n I1574_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I142_XG_MN2 (XI1574_I142_XG_n1 I1574_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I142_XG_MN0 (I1574_G17_10 I1574_P17_14n XI1574_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I142_XG_MN1 (XI1574_I142_XG_n1 I1574_G13_10n I1574_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I81_XG_MN2 (XI1574_I81_XG_n1 I1574_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I81_XG_MN0 (I1574_G15_14 I1574_pn15 XI1574_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I81_XG_MN1 (XI1574_I81_XG_n1 I1574_gn14 I1574_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I145_XG_MN2 (XI1574_I145_XG_n1 I1574_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I145_XG_MN0 (I1574_G20_13 I1574_P20_17n XI1574_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I145_XG_MN1 (XI1574_I145_XG_n1 I1574_G16_13n I1574_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I190_XG_MN2 (XI1022_I190_XG_n1 I1022_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I190_XG_MN0 (I1022_G21_0 I1022_P21_6n XI1022_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I190_XG_MN1 (XI1022_I190_XG_n1 I1022_G5_0n I1022_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I140_XG_MN2 (XI1022_I140_XG_n1 I1022_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I140_XG_MN0 (I1022_G15_8 I1022_P15_12n XI1022_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I140_XG_MN1 (XI1022_I140_XG_n1 I1022_G11_8n I1022_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I197_XG_MN2 (XI1022_I197_XG_n1 I1022_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I197_XG_MN0 (I1022_G26_0 I1022_P26_11n XI1022_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I197_XG_MN1 (XI1022_I197_XG_n1 I1022_G10_0n I1022_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I143_XG_MN2 (XI1022_I143_XG_n1 I1022_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I143_XG_MN0 (I1022_G18_11 I1022_P18_15n XI1022_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I143_XG_MN1 (XI1022_I143_XG_n1 I1022_G14_11n I1022_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I145_XG_MN2 (XI1022_I145_XG_n1 I1022_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I145_XG_MN0 (I1022_G20_13 I1022_P20_17n XI1022_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I145_XG_MN1 (XI1022_I145_XG_n1 I1022_G16_13n I1022_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I81_XG_MN2 (XI1022_I81_XG_n1 I1022_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I81_XG_MN0 (I1022_G15_14 I1022_pn15 XI1022_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I81_XG_MN1 (XI1022_I81_XG_n1 I1022_gn14 I1022_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I82_XG_MN2 (XI1022_I82_XG_n1 I1022_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I82_XG_MN0 (I1022_G16_15 I1022_pn16 XI1022_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I82_XG_MN1 (XI1022_I82_XG_n1 I1022_gn15 I1022_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I138_XG_MN2 (XI976_I138_XG_n1 I976_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I138_XG_MN0 (I976_G13_6 I976_P13_10n XI976_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I138_XG_MN1 (XI976_I138_XG_n1 I976_G9_6n I976_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I140_XG_MN2 (XI976_I140_XG_n1 I976_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I140_XG_MN0 (I976_G15_8 I976_P15_12n XI976_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I140_XG_MN1 (XI976_I140_XG_n1 I976_G11_8n I976_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I81_XG_MN2 (XI976_I81_XG_n1 I976_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I81_XG_MN0 (I976_G15_14 I976_pn15 XI976_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I81_XG_MN1 (XI976_I81_XG_n1 I976_gn14 I976_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I80_XG_MN2 (XI976_I80_XG_n1 I976_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I80_XG_MN0 (I976_G14_13 I976_pn14 XI976_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I80_XG_MN1 (XI976_I80_XG_n1 I976_gn13 I976_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I83_XG_MN2 (XI930_I83_XG_n1 I930_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I83_XG_MN0 (I930_G17_16 I930_pn17 XI930_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I83_XG_MN1 (XI930_I83_XG_n1 I930_gn16 I930_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I84_XG_MN2 (XI930_I84_XG_n1 I930_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I84_XG_MN0 (I930_G18_17 I930_pn18 XI930_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I84_XG_MN1 (XI930_I84_XG_n1 I930_gn17 I930_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I149_XG_MN2 (XI930_I149_XG_n1 I930_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I149_XG_MN0 (I930_G24_17 I930_P24_21n XI930_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I149_XG_MN1 (XI930_I149_XG_n1 I930_G20_17n I930_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I143_XG_MN2 (XI930_I143_XG_n1 I930_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I143_XG_MN0 (I930_G18_11 I930_P18_15n XI930_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I143_XG_MN1 (XI930_I143_XG_n1 I930_G14_11n I930_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I185_XG_MN2 (XI930_I185_XG_n1 I930_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I185_XG_MN0 (I930_G18_0 I930_P18_3n XI930_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I185_XG_MN1 (XI930_I185_XG_n1 I930_G2_0n I930_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I144_XG_MN2 (XI930_I144_XG_n1 I930_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I144_XG_MN0 (I930_G19_12 I930_P19_16n XI930_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I144_XG_MN1 (XI930_I144_XG_n1 I930_G15_12n I930_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I140_XG_MN2 (XI930_I140_XG_n1 I930_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I140_XG_MN0 (I930_G15_8 I930_P15_12n XI930_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I140_XG_MN1 (XI930_I140_XG_n1 I930_G11_8n I930_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I196_XG_MN2 (XI930_I196_XG_n1 I930_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I196_XG_MN0 (I930_G25_0 I930_P25_10n XI930_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I196_XG_MN1 (XI930_I196_XG_n1 I930_G9_0n I930_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I149_XG_MN2 (XI1666_I149_XG_n1 I1666_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I149_XG_MN0 (I1666_G24_17 I1666_P24_21n XI1666_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I149_XG_MN1 (XI1666_I149_XG_n1 I1666_G20_17n I1666_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I192_XG_MN2 (XI1666_I192_XG_n1 I1666_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I192_XG_MN0 (I1666_G22_0 I1666_P22_7n XI1666_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I192_XG_MN1 (XI1666_I192_XG_n1 I1666_G6_0n I1666_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I190_XG_MN2 (XI1666_I190_XG_n1 I1666_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I190_XG_MN0 (I1666_G21_0 I1666_P21_6n XI1666_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I190_XG_MN1 (XI1666_I190_XG_n1 I1666_G5_0n I1666_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I146_XG_MN2 (XI1666_I146_XG_n1 I1666_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I146_XG_MN0 (I1666_G21_14 I1666_P21_18n XI1666_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I146_XG_MN1 (XI1666_I146_XG_n1 I1666_G17_14n I1666_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I144_XG_MN2 (XI1666_I144_XG_n1 I1666_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I144_XG_MN0 (I1666_G19_12 I1666_P19_16n XI1666_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I144_XG_MN1 (XI1666_I144_XG_n1 I1666_G15_12n I1666_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I140_XG_MN2 (XI1666_I140_XG_n1 I1666_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I140_XG_MN0 (I1666_G15_8 I1666_P15_12n XI1666_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I140_XG_MN1 (XI1666_I140_XG_n1 I1666_G11_8n I1666_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I84_XG_MN2 (XI1666_I84_XG_n1 I1666_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I84_XG_MN0 (I1666_G18_17 I1666_pn18 XI1666_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I84_XG_MN1 (XI1666_I84_XG_n1 I1666_gn17 I1666_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I83_XG_MN2 (XI1666_I83_XG_n1 I1666_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I83_XG_MN0 (I1666_G17_16 I1666_pn17 XI1666_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I83_XG_MN1 (XI1666_I83_XG_n1 I1666_gn16 I1666_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I186_XG_MN2 (XI1620_I186_XG_n1 I1620_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I186_XG_MN0 (I1620_G19_0 I1620_P19_4n XI1620_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I186_XG_MN1 (XI1620_I186_XG_n1 I1620_G3_0n I1620_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I142_XG_MN2 (XI1620_I142_XG_n1 I1620_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I142_XG_MN0 (I1620_G17_10 I1620_P17_14n XI1620_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I142_XG_MN1 (XI1620_I142_XG_n1 I1620_G13_10n I1620_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I188_XG_MN2 (XI1620_I188_XG_n1 I1620_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I188_XG_MN0 (I1620_G20_0 I1620_P20_5n XI1620_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I188_XG_MN1 (XI1620_I188_XG_n1 I1620_G4_0n I1620_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I145_XG_MN2 (XI1620_I145_XG_n1 I1620_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I145_XG_MN0 (I1620_G20_13 I1620_P20_17n XI1620_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I145_XG_MN1 (XI1620_I145_XG_n1 I1620_G16_13n I1620_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I82_XG_MN2 (XI1620_I82_XG_n1 I1620_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I82_XG_MN0 (I1620_G16_15 I1620_pn16 XI1620_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I82_XG_MN1 (XI1620_I82_XG_n1 I1620_gn15 I1620_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I83_XG_MN2 (XI1620_I83_XG_n1 I1620_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I83_XG_MN0 (I1620_G17_16 I1620_pn17 XI1620_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I83_XG_MN1 (XI1620_I83_XG_n1 I1620_gn16 I1620_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I190_XG_MN2 (XI1574_I190_XG_n1 I1574_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I190_XG_MN0 (I1574_G21_0 I1574_P21_6n XI1574_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I190_XG_MN1 (XI1574_I190_XG_n1 I1574_G5_0n I1574_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I140_XG_MN2 (XI1574_I140_XG_n1 I1574_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I140_XG_MN0 (I1574_G15_8 I1574_P15_12n XI1574_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I140_XG_MN1 (XI1574_I140_XG_n1 I1574_G11_8n I1574_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I146_XG_MN2 (XI1574_I146_XG_n1 I1574_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I146_XG_MN0 (I1574_G21_14 I1574_P21_18n XI1574_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I146_XG_MN1 (XI1574_I146_XG_n1 I1574_G17_14n I1574_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I82_XG_MN2 (XI1574_I82_XG_n1 I1574_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I82_XG_MN0 (I1574_G16_15 I1574_pn16 XI1574_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I82_XG_MN1 (XI1574_I82_XG_n1 I1574_gn15 I1574_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I83_XG_MN2 (XI1574_I83_XG_n1 I1574_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I83_XG_MN0 (I1574_G17_16 I1574_pn17 XI1574_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I83_XG_MN1 (XI1574_I83_XG_n1 I1574_gn16 I1574_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I192_XG_MN2 (XI1574_I192_XG_n1 I1574_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I192_XG_MN0 (I1574_G22_0 I1574_P22_7n XI1574_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I192_XG_MN1 (XI1574_I192_XG_n1 I1574_G6_0n I1574_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I199_XG_MN2 (XI1574_I199_XG_n1 I1574_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I199_XG_MN0 (I1574_G28_0 I1574_P28_13n XI1574_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I199_XG_MN1 (XI1574_I199_XG_n1 I1574_G12_0n I1574_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I149_XG_MN2 (XI1574_I149_XG_n1 I1574_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I149_XG_MN0 (I1574_G24_17 I1574_P24_21n XI1574_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I149_XG_MN1 (XI1574_I149_XG_n1 I1574_G20_17n I1574_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I200_XG_MN2 (XI1022_I200_XG_n1 I1022_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I200_XG_MN0 (I1022_G29_0 I1022_P29_14n XI1022_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I200_XG_MN1 (XI1022_I200_XG_n1 I1022_G13_0n I1022_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I146_XG_MN2 (XI1022_I146_XG_n1 I1022_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I146_XG_MN0 (I1022_G21_14 I1022_P21_18n XI1022_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I146_XG_MN1 (XI1022_I146_XG_n1 I1022_G17_14n I1022_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I198_XG_MN2 (XI1022_I198_XG_n1 I1022_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I198_XG_MN0 (I1022_G27_0 I1022_P27_12n XI1022_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I198_XG_MN1 (XI1022_I198_XG_n1 I1022_G11_0n I1022_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I144_XG_MN2 (XI1022_I144_XG_n1 I1022_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I144_XG_MN0 (I1022_G19_12 I1022_P19_16n XI1022_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I144_XG_MN1 (XI1022_I144_XG_n1 I1022_G15_12n I1022_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I149_XG_MN2 (XI1022_I149_XG_n1 I1022_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I149_XG_MN0 (I1022_G24_17 I1022_P24_21n XI1022_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I149_XG_MN1 (XI1022_I149_XG_n1 I1022_G20_17n I1022_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I84_XG_MN2 (XI1022_I84_XG_n1 I1022_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I84_XG_MN0 (I1022_G18_17 I1022_pn18 XI1022_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I84_XG_MN1 (XI1022_I84_XG_n1 I1022_gn17 I1022_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I85_XG_MN2 (XI1022_I85_XG_n1 I1022_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I85_XG_MN0 (I1022_G19_18 I1022_pn19 XI1022_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I85_XG_MN1 (XI1022_I85_XG_n1 I1022_gn18 I1022_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I83_XG_MN2 (XI1022_I83_XG_n1 I1022_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I83_XG_MN0 (I1022_G17_16 I1022_pn17 XI1022_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I83_XG_MN1 (XI1022_I83_XG_n1 I1022_gn16 I1022_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I185_XG_MN2 (XI976_I185_XG_n1 I976_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I185_XG_MN0 (I976_G18_0 I976_P18_3n XI976_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I185_XG_MN1 (XI976_I185_XG_n1 I976_G2_0n I976_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I141_XG_MN2 (XI976_I141_XG_n1 I976_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I141_XG_MN0 (I976_G16_9 I976_P16_13n XI976_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I141_XG_MN1 (XI976_I141_XG_n1 I976_G12_9n I976_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I139_XG_MN2 (XI976_I139_XG_n1 I976_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I139_XG_MN0 (I976_G14_7 I976_P14_11n XI976_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I139_XG_MN1 (XI976_I139_XG_n1 I976_G10_7n I976_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I142_XG_MN2 (XI976_I142_XG_n1 I976_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I142_XG_MN0 (I976_G17_10 I976_P17_14n XI976_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I142_XG_MN1 (XI976_I142_XG_n1 I976_G13_10n I976_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I82_XG_MN2 (XI976_I82_XG_n1 I976_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I82_XG_MN0 (I976_G16_15 I976_pn16 XI976_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I82_XG_MN1 (XI976_I82_XG_n1 I976_gn15 I976_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I83_XG_MN2 (XI976_I83_XG_n1 I976_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I83_XG_MN0 (I976_G17_16 I976_pn17 XI976_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I83_XG_MN1 (XI976_I83_XG_n1 I976_gn16 I976_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I85_XG_MN2 (XI930_I85_XG_n1 I930_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I85_XG_MN0 (I930_G19_18 I930_pn19 XI930_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I85_XG_MN1 (XI930_I85_XG_n1 I930_gn18 I930_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I192_XG_MN2 (XI930_I192_XG_n1 I930_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I192_XG_MN0 (I930_G22_0 I930_P22_7n XI930_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I192_XG_MN1 (XI930_I192_XG_n1 I930_G6_0n I930_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I197_XG_MN2 (XI930_I197_XG_n1 I930_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I197_XG_MN0 (I930_G26_0 I930_P26_11n XI930_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I197_XG_MN1 (XI930_I197_XG_n1 I930_G10_0n I930_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I194_XG_MN2 (XI930_I194_XG_n1 I930_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I194_XG_MN0 (I930_G23_0 I930_P23_8n XI930_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I194_XG_MN1 (XI930_I194_XG_n1 I930_G7_0n I930_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I202_XG_MN2 (XI930_I202_XG_n1 I930_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I202_XG_MN0 (c8_o I930_P31_16n XI930_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I202_XG_MN1 (XI930_I202_XG_n1 I930_G15_0n c8_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I146_XG_MN2 (XI930_I146_XG_n1 I930_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I146_XG_MN0 (I930_G21_14 I930_P21_18n XI930_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I146_XG_MN1 (XI930_I146_XG_n1 I930_G17_14n I930_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I190_XG_MN2 (XI930_I190_XG_n1 I930_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I190_XG_MN0 (I930_G21_0 I930_P21_6n XI930_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I190_XG_MN1 (XI930_I190_XG_n1 I930_G5_0n I930_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I153_XG_MN2 (XI1666_I153_XG_n1 I1666_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I153_XG_MN0 (I1666_G28_21 I1666_P28_25n XI1666_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I153_XG_MN1 (XI1666_I153_XG_n1 I1666_G24_21n I1666_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I151_XG_MN2 (XI1666_I151_XG_n1 I1666_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I151_XG_MN0 (I1666_G26_19 I1666_P26_23n XI1666_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I151_XG_MN1 (XI1666_I151_XG_n1 I1666_G22_19n I1666_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I147_XG_MN2 (XI1666_I147_XG_n1 I1666_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I147_XG_MN0 (I1666_G22_15 I1666_P22_19n XI1666_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I147_XG_MN1 (XI1666_I147_XG_n1 I1666_G18_15n I1666_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I200_XG_MN2 (XI1666_I200_XG_n1 I1666_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I200_XG_MN0 (I1666_G29_0 I1666_P29_14n XI1666_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I200_XG_MN1 (XI1666_I200_XG_n1 I1666_G13_0n I1666_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I150_XG_MN2 (XI1666_I150_XG_n1 I1666_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I150_XG_MN0 (I1666_G25_18 I1666_P25_22n XI1666_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I150_XG_MN1 (XI1666_I150_XG_n1 I1666_G21_18n I1666_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I87_XG_MN2 (XI1666_I87_XG_n1 I1666_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I87_XG_MN0 (I1666_G21_20 I1666_pn21 XI1666_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I87_XG_MN1 (XI1666_I87_XG_n1 I1666_gn20 I1666_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I85_XG_MN2 (XI1666_I85_XG_n1 I1666_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I85_XG_MN0 (I1666_G19_18 I1666_pn19 XI1666_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I85_XG_MN1 (XI1666_I85_XG_n1 I1666_gn18 I1666_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I86_XG_MN2 (XI1666_I86_XG_n1 I1666_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I86_XG_MN0 (I1666_G20_19 I1666_pn20 XI1666_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I86_XG_MN1 (XI1666_I86_XG_n1 I1666_gn19 I1666_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I144_XG_MN2 (XI1620_I144_XG_n1 I1620_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I144_XG_MN0 (I1620_G19_12 I1620_P19_16n XI1620_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I144_XG_MN1 (XI1620_I144_XG_n1 I1620_G15_12n I1620_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I190_XG_MN2 (XI1620_I190_XG_n1 I1620_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I190_XG_MN0 (I1620_G21_0 I1620_P21_6n XI1620_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I190_XG_MN1 (XI1620_I190_XG_n1 I1620_G5_0n I1620_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I146_XG_MN2 (XI1620_I146_XG_n1 I1620_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I146_XG_MN0 (I1620_G21_14 I1620_P21_18n XI1620_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I146_XG_MN1 (XI1620_I146_XG_n1 I1620_G17_14n I1620_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I197_XG_MN2 (XI1620_I197_XG_n1 I1620_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I197_XG_MN0 (I1620_G26_0 I1620_P26_11n XI1620_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I197_XG_MN1 (XI1620_I197_XG_n1 I1620_G10_0n I1620_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I149_XG_MN2 (XI1620_I149_XG_n1 I1620_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I149_XG_MN0 (I1620_G24_17 I1620_P24_21n XI1620_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I149_XG_MN1 (XI1620_I149_XG_n1 I1620_G20_17n I1620_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I84_XG_MN2 (XI1620_I84_XG_n1 I1620_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I84_XG_MN0 (I1620_G18_17 I1620_pn18 XI1620_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I84_XG_MN1 (XI1620_I84_XG_n1 I1620_gn17 I1620_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I85_XG_MN2 (XI1620_I85_XG_n1 I1620_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I85_XG_MN0 (I1620_G19_18 I1620_pn19 XI1620_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I85_XG_MN1 (XI1620_I85_XG_n1 I1620_gn18 I1620_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I144_XG_MN2 (XI1574_I144_XG_n1 I1574_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I144_XG_MN0 (I1574_G19_12 I1574_P19_16n XI1574_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I144_XG_MN1 (XI1574_I144_XG_n1 I1574_G15_12n I1574_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I150_XG_MN2 (XI1574_I150_XG_n1 I1574_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I150_XG_MN0 (I1574_G25_18 I1574_P25_22n XI1574_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I150_XG_MN1 (XI1574_I150_XG_n1 I1574_G21_18n I1574_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I85_XG_MN2 (XI1574_I85_XG_n1 I1574_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I85_XG_MN0 (I1574_G19_18 I1574_pn19 XI1574_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I85_XG_MN1 (XI1574_I85_XG_n1 I1574_gn18 I1574_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I84_XG_MN2 (XI1574_I84_XG_n1 I1574_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I84_XG_MN0 (I1574_G18_17 I1574_pn18 XI1574_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I84_XG_MN1 (XI1574_I84_XG_n1 I1574_gn17 I1574_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I147_XG_MN2 (XI1574_I147_XG_n1 I1574_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I147_XG_MN0 (I1574_G22_15 I1574_P22_19n XI1574_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I147_XG_MN1 (XI1574_I147_XG_n1 I1574_G18_15n I1574_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I81_XG_MN2 (XI1114_I81_XG_n1 I1114_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I81_XG_MN0 (I1114_G15_14 I1114_pn15 XI1114_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I81_XG_MN1 (XI1114_I81_XG_n1 I1114_gn14 I1114_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I80_XG_MN2 (XI1114_I80_XG_n1 I1114_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I80_XG_MN0 (I1114_G14_13 I1114_pn14 XI1114_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I80_XG_MN1 (XI1114_I80_XG_n1 I1114_gn13 I1114_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I150_XG_MN2 (XI1022_I150_XG_n1 I1022_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I150_XG_MN0 (I1022_G25_18 I1022_P25_22n XI1022_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I150_XG_MN1 (XI1022_I150_XG_n1 I1022_G21_18n I1022_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I192_XG_MN2 (XI1022_I192_XG_n1 I1022_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I192_XG_MN0 (I1022_G22_0 I1022_P22_7n XI1022_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I192_XG_MN1 (XI1022_I192_XG_n1 I1022_G6_0n I1022_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I151_XG_MN2 (XI1022_I151_XG_n1 I1022_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I151_XG_MN0 (I1022_G26_19 I1022_P26_23n XI1022_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I151_XG_MN1 (XI1022_I151_XG_n1 I1022_G22_19n I1022_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I147_XG_MN2 (XI1022_I147_XG_n1 I1022_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I147_XG_MN0 (I1022_G22_15 I1022_P22_19n XI1022_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I147_XG_MN1 (XI1022_I147_XG_n1 I1022_G18_15n I1022_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I87_XG_MN2 (XI1022_I87_XG_n1 I1022_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I87_XG_MN0 (I1022_G21_20 I1022_pn21 XI1022_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I87_XG_MN1 (XI1022_I87_XG_n1 I1022_gn20 I1022_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I86_XG_MN2 (XI1022_I86_XG_n1 I1022_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I86_XG_MN0 (I1022_G20_19 I1022_pn20 XI1022_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I86_XG_MN1 (XI1022_I86_XG_n1 I1022_gn19 I1022_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I188_XG_MN2 (XI976_I188_XG_n1 I976_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I188_XG_MN0 (I976_G20_0 I976_P20_5n XI976_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I188_XG_MN1 (XI976_I188_XG_n1 I976_G4_0n I976_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I143_XG_MN2 (XI976_I143_XG_n1 I976_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I143_XG_MN0 (I976_G18_11 I976_P18_15n XI976_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I143_XG_MN1 (XI976_I143_XG_n1 I976_G14_11n I976_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I186_XG_MN2 (XI976_I186_XG_n1 I976_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I186_XG_MN0 (I976_G19_0 I976_P19_4n XI976_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I186_XG_MN1 (XI976_I186_XG_n1 I976_G3_0n I976_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I196_XG_MN2 (XI976_I196_XG_n1 I976_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I196_XG_MN0 (I976_G25_0 I976_P25_10n XI976_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I196_XG_MN1 (XI976_I196_XG_n1 I976_G9_0n I976_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I144_XG_MN2 (XI976_I144_XG_n1 I976_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I144_XG_MN0 (I976_G19_12 I976_P19_16n XI976_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I144_XG_MN1 (XI976_I144_XG_n1 I976_G15_12n I976_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I84_XG_MN2 (XI976_I84_XG_n1 I976_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I84_XG_MN0 (I976_G18_17 I976_pn18 XI976_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I84_XG_MN1 (XI976_I84_XG_n1 I976_gn17 I976_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I85_XG_MN2 (XI976_I85_XG_n1 I976_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I85_XG_MN0 (I976_G19_18 I976_pn19 XI976_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I85_XG_MN1 (XI976_I85_XG_n1 I976_gn18 I976_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I86_XG_MN2 (XI930_I86_XG_n1 I930_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I86_XG_MN0 (I930_G20_19 I930_pn20 XI930_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I86_XG_MN1 (XI930_I86_XG_n1 I930_gn19 I930_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I147_XG_MN2 (XI930_I147_XG_n1 I930_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I147_XG_MN0 (I930_G22_15 I930_P22_19n XI930_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I147_XG_MN1 (XI930_I147_XG_n1 I930_G18_15n I930_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I151_XG_MN2 (XI930_I151_XG_n1 I930_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I151_XG_MN0 (I930_G26_19 I930_P26_23n XI930_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I151_XG_MN1 (XI930_I151_XG_n1 I930_G22_19n I930_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I87_XG_MN2 (XI930_I87_XG_n1 I930_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I87_XG_MN0 (I930_G21_20 I930_pn21 XI930_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I87_XG_MN1 (XI930_I87_XG_n1 I930_gn20 I930_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I148_XG_MN2 (XI930_I148_XG_n1 I930_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I148_XG_MN0 (I930_G23_16 I930_P23_20n XI930_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I148_XG_MN1 (XI930_I148_XG_n1 I930_G19_16n I930_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I198_XG_MN2 (XI930_I198_XG_n1 I930_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I198_XG_MN0 (I930_G27_0 I930_P27_12n XI930_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I198_XG_MN1 (XI930_I198_XG_n1 I930_G11_0n I930_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I150_XG_MN2 (XI930_I150_XG_n1 I930_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I150_XG_MN0 (I930_G25_18 I930_P25_22n XI930_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I150_XG_MN1 (XI930_I150_XG_n1 I930_G21_18n I930_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I201_XG_MN2 (XI1666_I201_XG_n1 I1666_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I201_XG_MN0 (c24_m I1666_P30_15n XI1666_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I201_XG_MN1 (XI1666_I201_XG_n1 I1666_G14_0n c24_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I198_XG_MN2 (XI1666_I198_XG_n1 I1666_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I198_XG_MN0 (I1666_G27_0 I1666_P27_12n XI1666_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I198_XG_MN1 (XI1666_I198_XG_n1 I1666_G11_0n I1666_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I194_XG_MN2 (XI1666_I194_XG_n1 I1666_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I194_XG_MN0 (I1666_G23_0 I1666_P23_8n XI1666_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I194_XG_MN1 (XI1666_I194_XG_n1 I1666_G7_0n I1666_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I88_XG_MN2 (XI1666_I88_XG_n1 I1666_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I88_XG_MN0 (I1666_G22_21 I1666_pn22 XI1666_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I88_XG_MN1 (XI1666_I88_XG_n1 I1666_gn21 I1666_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I196_XG_MN2 (XI1620_I196_XG_n1 I1620_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I196_XG_MN0 (I1620_G25_0 I1620_P25_10n XI1620_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I196_XG_MN1 (XI1620_I196_XG_n1 I1620_G9_0n I1620_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I150_XG_MN2 (XI1620_I150_XG_n1 I1620_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I150_XG_MN0 (I1620_G25_18 I1620_P25_22n XI1620_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I150_XG_MN1 (XI1620_I150_XG_n1 I1620_G21_18n I1620_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I192_XG_MN2 (XI1620_I192_XG_n1 I1620_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I192_XG_MN0 (I1620_G22_0 I1620_P22_7n XI1620_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I192_XG_MN1 (XI1620_I192_XG_n1 I1620_G6_0n I1620_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I151_XG_MN2 (XI1620_I151_XG_n1 I1620_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I151_XG_MN0 (I1620_G26_19 I1620_P26_23n XI1620_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I151_XG_MN1 (XI1620_I151_XG_n1 I1620_G22_19n I1620_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I147_XG_MN2 (XI1620_I147_XG_n1 I1620_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I147_XG_MN0 (I1620_G22_15 I1620_P22_19n XI1620_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I147_XG_MN1 (XI1620_I147_XG_n1 I1620_G18_15n I1620_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I87_XG_MN2 (XI1620_I87_XG_n1 I1620_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I87_XG_MN0 (I1620_G21_20 I1620_pn21 XI1620_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I87_XG_MN1 (XI1620_I87_XG_n1 I1620_gn20 I1620_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I86_XG_MN2 (XI1620_I86_XG_n1 I1620_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I86_XG_MN0 (I1620_G20_19 I1620_pn20 XI1620_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I86_XG_MN1 (XI1620_I86_XG_n1 I1620_gn19 I1620_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I194_XG_MN2 (XI1574_I194_XG_n1 I1574_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I194_XG_MN0 (I1574_G23_0 I1574_P23_8n XI1574_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I194_XG_MN1 (XI1574_I194_XG_n1 I1574_G7_0n I1574_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I200_XG_MN2 (XI1574_I200_XG_n1 I1574_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I200_XG_MN0 (I1574_G29_0 I1574_P29_14n XI1574_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I200_XG_MN1 (XI1574_I200_XG_n1 I1574_G13_0n I1574_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I86_XG_MN2 (XI1574_I86_XG_n1 I1574_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I86_XG_MN0 (I1574_G20_19 I1574_pn20 XI1574_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I86_XG_MN1 (XI1574_I86_XG_n1 I1574_gn19 I1574_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I87_XG_MN2 (XI1574_I87_XG_n1 I1574_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I87_XG_MN0 (I1574_G21_20 I1574_pn21 XI1574_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I87_XG_MN1 (XI1574_I87_XG_n1 I1574_gn20 I1574_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I201_XG_MN2 (XI1574_I201_XG_n1 I1574_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I201_XG_MN0 (c22_m I1574_P30_15n XI1574_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I201_XG_MN1 (XI1574_I201_XG_n1 I1574_G14_0n c22_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I153_XG_MN2 (XI1574_I153_XG_n1 I1574_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I153_XG_MN0 (I1574_G28_21 I1574_P28_25n XI1574_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I153_XG_MN1 (XI1574_I153_XG_n1 I1574_G24_21n I1574_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I151_XG_MN2 (XI1574_I151_XG_n1 I1574_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I151_XG_MN0 (I1574_G26_19 I1574_P26_23n XI1574_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I151_XG_MN1 (XI1574_I151_XG_n1 I1574_G22_19n I1574_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I95_XG_MN2 (XI1114_I95_XG_n1 I1114_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I95_XG_MN0 (I1114_G29_28 I1114_pn29 XI1114_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I95_XG_MN1 (XI1114_I95_XG_n1 I1114_gn28 I1114_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I93_XG_MN2 (XI1114_I93_XG_n1 I1114_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I93_XG_MN0 (I1114_G27_26 I1114_pn27 XI1114_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I93_XG_MN1 (XI1114_I93_XG_n1 I1114_gn26 I1114_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I94_XG_MN2 (XI1114_I94_XG_n1 I1114_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I94_XG_MN0 (I1114_G28_27 I1114_pn28 XI1114_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I94_XG_MN1 (XI1114_I94_XG_n1 I1114_gn27 I1114_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I92_XG_MN2 (XI1114_I92_XG_n1 I1114_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I92_XG_MN0 (I1114_G26_25 I1114_pn26 XI1114_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I92_XG_MN1 (XI1114_I92_XG_n1 I1114_gn25 I1114_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I91_XG_MN2 (XI1114_I91_XG_n1 I1114_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I91_XG_MN0 (I1114_G25_24 I1114_pn25 XI1114_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I91_XG_MN1 (XI1114_I91_XG_n1 I1114_gn24 I1114_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I90_XG_MN2 (XI1114_I90_XG_n1 I1114_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I90_XG_MN0 (I1114_G24_23 I1114_pn24 XI1114_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I90_XG_MN1 (XI1114_I90_XG_n1 I1114_gn23 I1114_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I89_XG_MN2 (XI1114_I89_XG_n1 I1114_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I89_XG_MN0 (I1114_G23_22 I1114_pn23 XI1114_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I89_XG_MN1 (XI1114_I89_XG_n1 I1114_gn22 I1114_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I88_XG_MN2 (XI1114_I88_XG_n1 I1114_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I88_XG_MN0 (I1114_G22_21 I1114_pn22 XI1114_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I88_XG_MN1 (XI1114_I88_XG_n1 I1114_gn21 I1114_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I87_XG_MN2 (XI1114_I87_XG_n1 I1114_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I87_XG_MN0 (I1114_G21_20 I1114_pn21 XI1114_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I87_XG_MN1 (XI1114_I87_XG_n1 I1114_gn20 I1114_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I86_XG_MN2 (XI1114_I86_XG_n1 I1114_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I86_XG_MN0 (I1114_G20_19 I1114_pn20 XI1114_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I86_XG_MN1 (XI1114_I86_XG_n1 I1114_gn19 I1114_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I85_XG_MN2 (XI1114_I85_XG_n1 I1114_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I85_XG_MN0 (I1114_G19_18 I1114_pn19 XI1114_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I85_XG_MN1 (XI1114_I85_XG_n1 I1114_gn18 I1114_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I84_XG_MN2 (XI1114_I84_XG_n1 I1114_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I84_XG_MN0 (I1114_G18_17 I1114_pn18 XI1114_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I84_XG_MN1 (XI1114_I84_XG_n1 I1114_gn17 I1114_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I83_XG_MN2 (XI1114_I83_XG_n1 I1114_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I83_XG_MN0 (I1114_G17_16 I1114_pn17 XI1114_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I83_XG_MN1 (XI1114_I83_XG_n1 I1114_gn16 I1114_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I82_XG_MN2 (XI1114_I82_XG_n1 I1114_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I82_XG_MN0 (I1114_G16_15 I1114_pn16 XI1114_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I82_XG_MN1 (XI1114_I82_XG_n1 I1114_gn15 I1114_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I79_XG_MN2 (XI1114_I79_XG_n1 I1114_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I79_XG_MN0 (I1114_G13_12 I1114_pn13 XI1114_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I79_XG_MN1 (XI1114_I79_XG_n1 I1114_gn12 I1114_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I78_XG_MN2 (XI1114_I78_XG_n1 I1114_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I78_XG_MN0 (I1114_G12_11 I1114_pn12 XI1114_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I78_XG_MN1 (XI1114_I78_XG_n1 I1114_gn11 I1114_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I77_XG_MN2 (XI1114_I77_XG_n1 I1114_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I77_XG_MN0 (I1114_G11_10 I1114_pn11 XI1114_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I77_XG_MN1 (XI1114_I77_XG_n1 I1114_gn10 I1114_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I154_XG_MN2 (XI1022_I154_XG_n1 I1022_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I154_XG_MN0 (I1022_G29_22 I1022_P29_26n XI1022_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I154_XG_MN1 (XI1022_I154_XG_n1 I1022_G25_22n I1022_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I194_XG_MN2 (XI1022_I194_XG_n1 I1022_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I194_XG_MN0 (I1022_G23_0 I1022_P23_8n XI1022_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I194_XG_MN1 (XI1022_I194_XG_n1 I1022_G7_0n I1022_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I148_XG_MN2 (XI1022_I148_XG_n1 I1022_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I148_XG_MN0 (I1022_G23_16 I1022_P23_20n XI1022_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I148_XG_MN1 (XI1022_I148_XG_n1 I1022_G19_16n I1022_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I152_XG_MN2 (XI1022_I152_XG_n1 I1022_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I152_XG_MN0 (I1022_G27_20 I1022_P27_24n XI1022_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I152_XG_MN1 (XI1022_I152_XG_n1 I1022_G23_20n I1022_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I199_XG_MN2 (XI1022_I199_XG_n1 I1022_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I199_XG_MN0 (I1022_G28_0 I1022_P28_13n XI1022_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I199_XG_MN1 (XI1022_I199_XG_n1 I1022_G12_0n I1022_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I153_XG_MN2 (XI1022_I153_XG_n1 I1022_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I153_XG_MN0 (I1022_G28_21 I1022_P28_25n XI1022_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I153_XG_MN1 (XI1022_I153_XG_n1 I1022_G24_21n I1022_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I88_XG_MN2 (XI1022_I88_XG_n1 I1022_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I88_XG_MN0 (I1022_G22_21 I1022_pn22 XI1022_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I88_XG_MN1 (XI1022_I88_XG_n1 I1022_gn21 I1022_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I89_XG_MN2 (XI1022_I89_XG_n1 I1022_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I89_XG_MN0 (I1022_G23_22 I1022_pn23 XI1022_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I89_XG_MN1 (XI1022_I89_XG_n1 I1022_gn22 I1022_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I195_XG_MN2 (XI976_I195_XG_n1 I976_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I195_XG_MN0 (I976_G24_0 I976_P24_9n XI976_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I195_XG_MN1 (XI976_I195_XG_n1 I976_G8_0n I976_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I145_XG_MN2 (XI976_I145_XG_n1 I976_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I145_XG_MN0 (I976_G20_13 I976_P20_17n XI976_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I145_XG_MN1 (XI976_I145_XG_n1 I976_G16_13n I976_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I149_XG_MN2 (XI976_I149_XG_n1 I976_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I149_XG_MN0 (I976_G24_17 I976_P24_21n XI976_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I149_XG_MN1 (XI976_I149_XG_n1 I976_G20_17n I976_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I190_XG_MN2 (XI976_I190_XG_n1 I976_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I190_XG_MN0 (I976_G21_0 I976_P21_6n XI976_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I190_XG_MN1 (XI976_I190_XG_n1 I976_G5_0n I976_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I150_XG_MN2 (XI976_I150_XG_n1 I976_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I150_XG_MN0 (I976_G25_18 I976_P25_22n XI976_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I150_XG_MN1 (XI976_I150_XG_n1 I976_G21_18n I976_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I146_XG_MN2 (XI976_I146_XG_n1 I976_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I146_XG_MN0 (I976_G21_14 I976_P21_18n XI976_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I146_XG_MN1 (XI976_I146_XG_n1 I976_G17_14n I976_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I87_XG_MN2 (XI976_I87_XG_n1 I976_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I87_XG_MN0 (I976_G21_20 I976_pn21 XI976_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I87_XG_MN1 (XI976_I87_XG_n1 I976_gn20 I976_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I86_XG_MN2 (XI976_I86_XG_n1 I976_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I86_XG_MN0 (I976_G20_19 I976_pn20 XI976_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I86_XG_MN1 (XI976_I86_XG_n1 I976_gn19 I976_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I199_XG_MN2 (XI930_I199_XG_n1 I930_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I199_XG_MN0 (I930_G28_0 I930_P28_13n XI930_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I199_XG_MN1 (XI930_I199_XG_n1 I930_G12_0n I930_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I88_XG_MN2 (XI930_I88_XG_n1 I930_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I88_XG_MN0 (I930_G22_21 I930_pn22 XI930_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I88_XG_MN1 (XI930_I88_XG_n1 I930_gn21 I930_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I152_XG_MN2 (XI930_I152_XG_n1 I930_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I152_XG_MN0 (I930_G27_20 I930_P27_24n XI930_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I152_XG_MN1 (XI930_I152_XG_n1 I930_G23_20n I930_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I200_XG_MN2 (XI930_I200_XG_n1 I930_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I200_XG_MN0 (I930_G29_0 I930_P29_14n XI930_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I200_XG_MN1 (XI930_I200_XG_n1 I930_G13_0n I930_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I90_XG_MN2 (XI1666_I90_XG_n1 I1666_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I90_XG_MN0 (I1666_G24_23 I1666_pn24 XI1666_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I90_XG_MN1 (XI1666_I90_XG_n1 I1666_gn23 I1666_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I91_XG_MN2 (XI1666_I91_XG_n1 I1666_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I91_XG_MN0 (I1666_G25_24 I1666_pn25 XI1666_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I91_XG_MN1 (XI1666_I91_XG_n1 I1666_gn24 I1666_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I155_XG_MN2 (XI1666_I155_XG_n1 I1666_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I155_XG_MN0 (I1666_G30_23 I1666_P30_27n XI1666_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I155_XG_MN1 (XI1666_I155_XG_n1 I1666_G26_23n I1666_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I154_XG_MN2 (XI1666_I154_XG_n1 I1666_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I154_XG_MN0 (I1666_G29_22 I1666_P29_26n XI1666_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I154_XG_MN1 (XI1666_I154_XG_n1 I1666_G25_22n I1666_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I152_XG_MN2 (XI1666_I152_XG_n1 I1666_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I152_XG_MN0 (I1666_G27_20 I1666_P27_24n XI1666_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I152_XG_MN1 (XI1666_I152_XG_n1 I1666_G23_20n I1666_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I148_XG_MN2 (XI1666_I148_XG_n1 I1666_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I148_XG_MN0 (I1666_G23_16 I1666_P23_20n XI1666_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I148_XG_MN1 (XI1666_I148_XG_n1 I1666_G19_16n I1666_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I89_XG_MN2 (XI1666_I89_XG_n1 I1666_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I89_XG_MN0 (I1666_G23_22 I1666_pn23 XI1666_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I89_XG_MN1 (XI1666_I89_XG_n1 I1666_gn22 I1666_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I194_XG_MN2 (XI1620_I194_XG_n1 I1620_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I194_XG_MN0 (I1620_G23_0 I1620_P23_8n XI1620_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I194_XG_MN1 (XI1620_I194_XG_n1 I1620_G7_0n I1620_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I148_XG_MN2 (XI1620_I148_XG_n1 I1620_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I148_XG_MN0 (I1620_G23_16 I1620_P23_20n XI1620_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I148_XG_MN1 (XI1620_I148_XG_n1 I1620_G19_16n I1620_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I200_XG_MN2 (XI1620_I200_XG_n1 I1620_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I200_XG_MN0 (I1620_G29_0 I1620_P29_14n XI1620_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I200_XG_MN1 (XI1620_I200_XG_n1 I1620_G13_0n I1620_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I199_XG_MN2 (XI1620_I199_XG_n1 I1620_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I199_XG_MN0 (I1620_G28_0 I1620_P28_13n XI1620_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I199_XG_MN1 (XI1620_I199_XG_n1 I1620_G12_0n I1620_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I153_XG_MN2 (XI1620_I153_XG_n1 I1620_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I153_XG_MN0 (I1620_G28_21 I1620_P28_25n XI1620_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I153_XG_MN1 (XI1620_I153_XG_n1 I1620_G24_21n I1620_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I88_XG_MN2 (XI1620_I88_XG_n1 I1620_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I88_XG_MN0 (I1620_G22_21 I1620_pn22 XI1620_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I88_XG_MN1 (XI1620_I88_XG_n1 I1620_gn21 I1620_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I89_XG_MN2 (XI1620_I89_XG_n1 I1620_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I89_XG_MN0 (I1620_G23_22 I1620_pn23 XI1620_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I89_XG_MN1 (XI1620_I89_XG_n1 I1620_gn22 I1620_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I90_XG_MN2 (XI1620_I90_XG_n1 I1620_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I90_XG_MN0 (I1620_G24_23 I1620_pn24 XI1620_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I90_XG_MN1 (XI1620_I90_XG_n1 I1620_gn23 I1620_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I198_XG_MN2 (XI1574_I198_XG_n1 I1574_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I198_XG_MN0 (I1574_G27_0 I1574_P27_12n XI1574_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I198_XG_MN1 (XI1574_I198_XG_n1 I1574_G11_0n I1574_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I152_XG_MN2 (XI1574_I152_XG_n1 I1574_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I152_XG_MN0 (I1574_G27_20 I1574_P27_24n XI1574_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I152_XG_MN1 (XI1574_I152_XG_n1 I1574_G23_20n I1574_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I148_XG_MN2 (XI1574_I148_XG_n1 I1574_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I148_XG_MN0 (I1574_G23_16 I1574_P23_20n XI1574_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I148_XG_MN1 (XI1574_I148_XG_n1 I1574_G19_16n I1574_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I88_XG_MN2 (XI1574_I88_XG_n1 I1574_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I88_XG_MN0 (I1574_G22_21 I1574_pn22 XI1574_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I88_XG_MN1 (XI1574_I88_XG_n1 I1574_gn21 I1574_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I89_XG_MN2 (XI1574_I89_XG_n1 I1574_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I89_XG_MN0 (I1574_G23_22 I1574_pn23 XI1574_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I89_XG_MN1 (XI1574_I89_XG_n1 I1574_gn22 I1574_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I155_XG_MN2 (XI1574_I155_XG_n1 I1574_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I155_XG_MN0 (I1574_G30_23 I1574_P30_27n XI1574_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I155_XG_MN1 (XI1574_I155_XG_n1 I1574_G26_23n I1574_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I96_XG_MN2 (XI1114_I96_XG_n1 I1114_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I96_XG_MN0 (I1114_G30_29 I1114_pn30 XI1114_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I96_XG_MN1 (XI1114_I96_XG_n1 I1114_gn29 I1114_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I155_XG_MN2 (XI1114_I155_XG_n1 I1114_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I155_XG_MN0 (I1114_G30_23 I1114_P30_27n XI1114_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I155_XG_MN1 (XI1114_I155_XG_n1 I1114_G26_23n I1114_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I153_XG_MN2 (XI1114_I153_XG_n1 I1114_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I153_XG_MN0 (I1114_G28_21 I1114_P28_25n XI1114_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I153_XG_MN1 (XI1114_I153_XG_n1 I1114_G24_21n I1114_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I151_XG_MN2 (XI1114_I151_XG_n1 I1114_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I151_XG_MN0 (I1114_G26_19 I1114_P26_23n XI1114_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I151_XG_MN1 (XI1114_I151_XG_n1 I1114_G22_19n I1114_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I149_XG_MN2 (XI1114_I149_XG_n1 I1114_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I149_XG_MN0 (I1114_G24_17 I1114_P24_21n XI1114_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I149_XG_MN1 (XI1114_I149_XG_n1 I1114_G20_17n I1114_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I145_XG_MN2 (XI1114_I145_XG_n1 I1114_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I145_XG_MN0 (I1114_G20_13 I1114_P20_17n XI1114_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I145_XG_MN1 (XI1114_I145_XG_n1 I1114_G16_13n I1114_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I143_XG_MN2 (XI1114_I143_XG_n1 I1114_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I143_XG_MN0 (I1114_G18_11 I1114_P18_15n XI1114_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I143_XG_MN1 (XI1114_I143_XG_n1 I1114_G14_11n I1114_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I141_XG_MN2 (XI1114_I141_XG_n1 I1114_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I141_XG_MN0 (I1114_G16_9 I1114_P16_13n XI1114_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I141_XG_MN1 (XI1114_I141_XG_n1 I1114_G12_9n I1114_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I76_XG_MN2 (XI1114_I76_XG_n1 I1114_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I76_XG_MN0 (I1114_G10_9 I1114_pn10 XI1114_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I76_XG_MN1 (XI1114_I76_XG_n1 I1114_gn9 I1114_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I75_XG_MN2 (XI1114_I75_XG_n1 I1114_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I75_XG_MN0 (I1114_G9_8 I1114_pn9 XI1114_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I75_XG_MN1 (XI1114_I75_XG_n1 I1114_gn8 I1114_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I74_XG_MN2 (XI1114_I74_XG_n1 I1114_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I74_XG_MN0 (I1114_G8_7 I1114_pn8 XI1114_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I74_XG_MN1 (XI1114_I74_XG_n1 I1114_gn7 I1114_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I73_XG_MN2 (XI1114_I73_XG_n1 I1114_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I73_XG_MN0 (I1114_G7_6 I1114_pn7 XI1114_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I73_XG_MN1 (XI1114_I73_XG_n1 I1114_gn6 I1114_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I202_XG_MN2 (XI1022_I202_XG_n1 I1022_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I202_XG_MN0 (c10_o I1022_P31_16n XI1022_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I202_XG_MN1 (XI1022_I202_XG_n1 I1022_G15_0n c10_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I201_XG_MN2 (XI1022_I201_XG_n1 I1022_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I201_XG_MN0 (c10_m I1022_P30_15n XI1022_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I201_XG_MN1 (XI1022_I201_XG_n1 I1022_G14_0n c10_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I155_XG_MN2 (XI1022_I155_XG_n1 I1022_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I155_XG_MN0 (I1022_G30_23 I1022_P30_27n XI1022_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I155_XG_MN1 (XI1022_I155_XG_n1 I1022_G26_23n I1022_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I90_XG_MN2 (XI1022_I90_XG_n1 I1022_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I90_XG_MN0 (I1022_G24_23 I1022_pn24 XI1022_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I90_XG_MN1 (XI1022_I90_XG_n1 I1022_gn23 I1022_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I91_XG_MN2 (XI1022_I91_XG_n1 I1022_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I91_XG_MN0 (I1022_G25_24 I1022_pn25 XI1022_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I91_XG_MN1 (XI1022_I91_XG_n1 I1022_gn24 I1022_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I192_XG_MN2 (XI976_I192_XG_n1 I976_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I192_XG_MN0 (I976_G22_0 I976_P22_7n XI976_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I192_XG_MN1 (XI976_I192_XG_n1 I976_G6_0n I976_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I147_XG_MN2 (XI976_I147_XG_n1 I976_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I147_XG_MN0 (I976_G22_15 I976_P22_19n XI976_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I147_XG_MN1 (XI976_I147_XG_n1 I976_G18_15n I976_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I194_XG_MN2 (XI976_I194_XG_n1 I976_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I194_XG_MN0 (I976_G23_0 I976_P23_8n XI976_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I194_XG_MN1 (XI976_I194_XG_n1 I976_G7_0n I976_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I88_XG_MN2 (XI976_I88_XG_n1 I976_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I88_XG_MN0 (I976_G22_21 I976_pn22 XI976_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I88_XG_MN1 (XI976_I88_XG_n1 I976_gn21 I976_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I153_XG_MN2 (XI930_I153_XG_n1 I930_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I153_XG_MN0 (I930_G28_21 I930_P28_25n XI930_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I153_XG_MN1 (XI930_I153_XG_n1 I930_G24_21n I930_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I89_XG_MN2 (XI930_I89_XG_n1 I930_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I89_XG_MN0 (I930_G23_22 I930_pn23 XI930_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I89_XG_MN1 (XI930_I89_XG_n1 I930_gn22 I930_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I90_XG_MN2 (XI930_I90_XG_n1 I930_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I90_XG_MN0 (I930_G24_23 I930_pn24 XI930_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I90_XG_MN1 (XI930_I90_XG_n1 I930_gn23 I930_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I91_XG_MN2 (XI930_I91_XG_n1 I930_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I91_XG_MN0 (I930_G25_24 I930_pn25 XI930_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I91_XG_MN1 (XI930_I91_XG_n1 I930_gn24 I930_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I156_XG_MN2 (XI930_I156_XG_n1 I930_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I156_XG_MN0 (I930_G31_24 I930_P31_28n XI930_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I156_XG_MN1 (XI930_I156_XG_n1 I930_G27_24n I930_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I154_XG_MN2 (XI930_I154_XG_n1 I930_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I154_XG_MN0 (I930_G29_22 I930_P29_26n XI930_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I154_XG_MN1 (XI930_I154_XG_n1 I930_G25_22n I930_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I92_XG_MN2 (XI1666_I92_XG_n1 I1666_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I92_XG_MN0 (I1666_G26_25 I1666_pn26 XI1666_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I92_XG_MN1 (XI1666_I92_XG_n1 I1666_gn25 I1666_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I93_XG_MN2 (XI1666_I93_XG_n1 I1666_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I93_XG_MN0 (I1666_G27_26 I1666_pn27 XI1666_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I93_XG_MN1 (XI1666_I93_XG_n1 I1666_gn26 I1666_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I94_XG_MN2 (XI1666_I94_XG_n1 I1666_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I94_XG_MN0 (I1666_G28_27 I1666_pn28 XI1666_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I94_XG_MN1 (XI1666_I94_XG_n1 I1666_gn27 I1666_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I156_XG_MN2 (XI1666_I156_XG_n1 I1666_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I156_XG_MN0 (I1666_G31_24 I1666_P31_28n XI1666_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I156_XG_MN1 (XI1666_I156_XG_n1 I1666_G27_24n I1666_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I202_XG_MN2 (XI1666_I202_XG_n1 I1666_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I202_XG_MN0 (c24_o I1666_P31_16n XI1666_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I202_XG_MN1 (XI1666_I202_XG_n1 I1666_G15_0n c24_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I202_XG_MN2 (XI1620_I202_XG_n1 I1620_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I202_XG_MN0 (c23_o I1620_P31_16n XI1620_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I202_XG_MN1 (XI1620_I202_XG_n1 I1620_G15_0n c23_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I198_XG_MN2 (XI1620_I198_XG_n1 I1620_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I198_XG_MN0 (I1620_G27_0 I1620_P27_12n XI1620_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I198_XG_MN1 (XI1620_I198_XG_n1 I1620_G11_0n I1620_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I152_XG_MN2 (XI1620_I152_XG_n1 I1620_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I152_XG_MN0 (I1620_G27_20 I1620_P27_24n XI1620_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I152_XG_MN1 (XI1620_I152_XG_n1 I1620_G23_20n I1620_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I154_XG_MN2 (XI1620_I154_XG_n1 I1620_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I154_XG_MN0 (I1620_G29_22 I1620_P29_26n XI1620_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I154_XG_MN1 (XI1620_I154_XG_n1 I1620_G25_22n I1620_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I201_XG_MN2 (XI1620_I201_XG_n1 I1620_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I201_XG_MN0 (c23_m I1620_P30_15n XI1620_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I201_XG_MN1 (XI1620_I201_XG_n1 I1620_G14_0n c23_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I155_XG_MN2 (XI1620_I155_XG_n1 I1620_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I155_XG_MN0 (I1620_G30_23 I1620_P30_27n XI1620_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I155_XG_MN1 (XI1620_I155_XG_n1 I1620_G26_23n I1620_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I92_XG_MN2 (XI1620_I92_XG_n1 I1620_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I92_XG_MN0 (I1620_G26_25 I1620_pn26 XI1620_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I92_XG_MN1 (XI1620_I92_XG_n1 I1620_gn25 I1620_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I91_XG_MN2 (XI1620_I91_XG_n1 I1620_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I91_XG_MN0 (I1620_G25_24 I1620_pn25 XI1620_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I91_XG_MN1 (XI1620_I91_XG_n1 I1620_gn24 I1620_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I202_XG_MN2 (XI1574_I202_XG_n1 I1574_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I202_XG_MN0 (c22_o I1574_P31_16n XI1574_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I202_XG_MN1 (XI1574_I202_XG_n1 I1574_G15_0n c22_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I156_XG_MN2 (XI1574_I156_XG_n1 I1574_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I156_XG_MN0 (I1574_G31_24 I1574_P31_28n XI1574_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I156_XG_MN1 (XI1574_I156_XG_n1 I1574_G27_24n I1574_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I154_XG_MN2 (XI1574_I154_XG_n1 I1574_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I154_XG_MN0 (I1574_G29_22 I1574_P29_26n XI1574_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I154_XG_MN1 (XI1574_I154_XG_n1 I1574_G25_22n I1574_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I90_XG_MN2 (XI1574_I90_XG_n1 I1574_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I90_XG_MN0 (I1574_G24_23 I1574_pn24 XI1574_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I90_XG_MN1 (XI1574_I90_XG_n1 I1574_gn23 I1574_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I91_XG_MN2 (XI1574_I91_XG_n1 I1574_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I91_XG_MN0 (I1574_G25_24 I1574_pn25 XI1574_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I91_XG_MN1 (XI1574_I91_XG_n1 I1574_gn24 I1574_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I97_XG_MN2 (XI1114_I97_XG_n1 I1114_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I97_XG_MN0 (I1114_G31_30 I1114_pn31 XI1114_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I97_XG_MN1 (XI1114_I97_XG_n1 I1114_gn30 I1114_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I201_XG_MN2 (XI1114_I201_XG_n1 I1114_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I201_XG_MN0 (c12_m I1114_P30_15n XI1114_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I201_XG_MN1 (XI1114_I201_XG_n1 I1114_G14_0n c12_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I199_XG_MN2 (XI1114_I199_XG_n1 I1114_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I199_XG_MN0 (I1114_G28_0 I1114_P28_13n XI1114_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I199_XG_MN1 (XI1114_I199_XG_n1 I1114_G12_0n I1114_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I147_XG_MN2 (XI1114_I147_XG_n1 I1114_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I147_XG_MN0 (I1114_G22_15 I1114_P22_19n XI1114_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I147_XG_MN1 (XI1114_I147_XG_n1 I1114_G18_15n I1114_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I139_XG_MN2 (XI1114_I139_XG_n1 I1114_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I139_XG_MN0 (I1114_G14_7 I1114_P14_11n XI1114_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I139_XG_MN1 (XI1114_I139_XG_n1 I1114_G10_7n I1114_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I137_XG_MN2 (XI1114_I137_XG_n1 I1114_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I137_XG_MN0 (I1114_G12_5 I1114_P12_9n XI1114_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I137_XG_MN1 (XI1114_I137_XG_n1 I1114_G8_5n I1114_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I135_XG_MN2 (XI1114_I135_XG_n1 I1114_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I135_XG_MN0 (I1114_G10_3 I1114_P10_7n XI1114_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I135_XG_MN1 (XI1114_I135_XG_n1 I1114_G6_3n I1114_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I72_XG_MN2 (XI1114_I72_XG_n1 I1114_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I72_XG_MN0 (I1114_G6_5 I1114_pn6 XI1114_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I72_XG_MN1 (XI1114_I72_XG_n1 I1114_gn5 I1114_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I71_XG_MN2 (XI1114_I71_XG_n1 I1114_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I71_XG_MN0 (I1114_G5_4 I1114_pn5 XI1114_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I71_XG_MN1 (XI1114_I71_XG_n1 I1114_gn4 I1114_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I70_XG_MN2 (XI1114_I70_XG_n1 I1114_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I70_XG_MN0 (I1114_G4_3 I1114_pn4 XI1114_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I70_XG_MN1 (XI1114_I70_XG_n1 I1114_gn3 I1114_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I65_XG_MN2 (XI1068_I65_XG_n1 I1068_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I65_XG_MN0 (I1068_G0_0 I1068_pn0 XI1068_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I65_XG_MN1 (XI1068_I65_XG_n1 I1068_cinn I1068_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I156_XG_MN2 (XI1022_I156_XG_n1 I1022_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I156_XG_MN0 (I1022_G31_24 I1022_P31_28n XI1022_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I156_XG_MN1 (XI1022_I156_XG_n1 I1022_G27_24n I1022_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I94_XG_MN2 (XI1022_I94_XG_n1 I1022_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I94_XG_MN0 (I1022_G28_27 I1022_pn28 XI1022_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I94_XG_MN1 (XI1022_I94_XG_n1 I1022_gn27 I1022_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I93_XG_MN2 (XI1022_I93_XG_n1 I1022_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I93_XG_MN0 (I1022_G27_26 I1022_pn27 XI1022_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I93_XG_MN1 (XI1022_I93_XG_n1 I1022_gn26 I1022_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I92_XG_MN2 (XI1022_I92_XG_n1 I1022_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I92_XG_MN0 (I1022_G26_25 I1022_pn26 XI1022_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I92_XG_MN1 (XI1022_I92_XG_n1 I1022_gn25 I1022_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I197_XG_MN2 (XI976_I197_XG_n1 I976_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I197_XG_MN0 (I976_G26_0 I976_P26_11n XI976_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I197_XG_MN1 (XI976_I197_XG_n1 I976_G10_0n I976_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I151_XG_MN2 (XI976_I151_XG_n1 I976_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I151_XG_MN0 (I976_G26_19 I976_P26_23n XI976_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I151_XG_MN1 (XI976_I151_XG_n1 I976_G22_19n I976_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I198_XG_MN2 (XI976_I198_XG_n1 I976_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I198_XG_MN0 (I976_G27_0 I976_P27_12n XI976_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I198_XG_MN1 (XI976_I198_XG_n1 I976_G11_0n I976_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I148_XG_MN2 (XI976_I148_XG_n1 I976_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I148_XG_MN0 (I976_G23_16 I976_P23_20n XI976_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I148_XG_MN1 (XI976_I148_XG_n1 I976_G19_16n I976_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I152_XG_MN2 (XI976_I152_XG_n1 I976_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I152_XG_MN0 (I976_G27_20 I976_P27_24n XI976_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I152_XG_MN1 (XI976_I152_XG_n1 I976_G23_20n I976_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I90_XG_MN2 (XI976_I90_XG_n1 I976_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I90_XG_MN0 (I976_G24_23 I976_pn24 XI976_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I90_XG_MN1 (XI976_I90_XG_n1 I976_gn23 I976_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I89_XG_MN2 (XI976_I89_XG_n1 I976_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I89_XG_MN0 (I976_G23_22 I976_pn23 XI976_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I89_XG_MN1 (XI976_I89_XG_n1 I976_gn22 I976_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I91_XG_MN2 (XI976_I91_XG_n1 I976_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I91_XG_MN0 (I976_G25_24 I976_pn25 XI976_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I91_XG_MN1 (XI976_I91_XG_n1 I976_gn24 I976_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I155_XG_MN2 (XI930_I155_XG_n1 I930_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I155_XG_MN0 (I930_G30_23 I930_P30_27n XI930_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I155_XG_MN1 (XI930_I155_XG_n1 I930_G26_23n I930_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I92_XG_MN2 (XI930_I92_XG_n1 I930_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I92_XG_MN0 (I930_G26_25 I930_pn26 XI930_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I92_XG_MN1 (XI930_I92_XG_n1 I930_gn25 I930_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I93_XG_MN2 (XI930_I93_XG_n1 I930_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I93_XG_MN0 (I930_G27_26 I930_pn27 XI930_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I93_XG_MN1 (XI930_I93_XG_n1 I930_gn26 I930_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I95_XG_MN2 (XI1666_I95_XG_n1 I1666_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I95_XG_MN0 (I1666_G29_28 I1666_pn29 XI1666_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I95_XG_MN1 (XI1666_I95_XG_n1 I1666_gn28 I1666_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I96_XG_MN2 (XI1666_I96_XG_n1 I1666_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I96_XG_MN0 (I1666_G30_29 I1666_pn30 XI1666_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I96_XG_MN1 (XI1666_I96_XG_n1 I1666_gn29 I1666_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I97_XG_MN2 (XI1666_I97_XG_n1 I1666_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I97_XG_MN0 (I1666_G31_30 I1666_pn31 XI1666_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I97_XG_MN1 (XI1666_I97_XG_n1 I1666_gn30 I1666_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I156_XG_MN2 (XI1620_I156_XG_n1 I1620_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I156_XG_MN0 (I1620_G31_24 I1620_P31_28n XI1620_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I156_XG_MN1 (XI1620_I156_XG_n1 I1620_G27_24n I1620_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I94_XG_MN2 (XI1620_I94_XG_n1 I1620_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I94_XG_MN0 (I1620_G28_27 I1620_pn28 XI1620_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I94_XG_MN1 (XI1620_I94_XG_n1 I1620_gn27 I1620_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I93_XG_MN2 (XI1620_I93_XG_n1 I1620_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I93_XG_MN0 (I1620_G27_26 I1620_pn27 XI1620_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I93_XG_MN1 (XI1620_I93_XG_n1 I1620_gn26 I1620_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I92_XG_MN2 (XI1574_I92_XG_n1 I1574_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I92_XG_MN0 (I1574_G26_25 I1574_pn26 XI1574_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I92_XG_MN1 (XI1574_I92_XG_n1 I1574_gn25 I1574_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I192_XG_MN2 (XI1114_I192_XG_n1 I1114_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I192_XG_MN0 (I1114_G22_0 I1114_P22_7n XI1114_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I192_XG_MN1 (XI1114_I192_XG_n1 I1114_G6_0n I1114_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I197_XG_MN2 (XI1114_I197_XG_n1 I1114_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I197_XG_MN0 (I1114_G26_0 I1114_P26_11n XI1114_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I197_XG_MN1 (XI1114_I197_XG_n1 I1114_G10_0n I1114_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I188_XG_MN2 (XI1114_I188_XG_n1 I1114_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I188_XG_MN0 (I1114_G20_0 I1114_P20_5n XI1114_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I188_XG_MN1 (XI1114_I188_XG_n1 I1114_G4_0n I1114_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I195_XG_MN2 (XI1114_I195_XG_n1 I1114_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I195_XG_MN0 (I1114_G24_0 I1114_P24_9n XI1114_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I195_XG_MN1 (XI1114_I195_XG_n1 I1114_G8_0n I1114_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I185_XG_MN2 (XI1114_I185_XG_n1 I1114_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I185_XG_MN0 (I1114_G18_0 I1114_P18_3n XI1114_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I185_XG_MN1 (XI1114_I185_XG_n1 I1114_G2_0n I1114_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I183_XG_MN2 (XI1114_I183_XG_n1 I1114_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I183_XG_MN0 (I1114_G16_0 I1114_P16_1n XI1114_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I183_XG_MN1 (XI1114_I183_XG_n1 I1114_G0_0n I1114_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I133_XG_MN2 (XI1114_I133_XG_n1 I1114_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I133_XG_MN0 (I1114_G8_1 I1114_P8_5n XI1114_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I133_XG_MN1 (XI1114_I133_XG_n1 I1114_G4_1n I1114_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I131_XG_MN2 (XI1114_I131_XG_n1 I1114_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I131_XG_MN0 (I1114_G6_0 I1114_P6_3n XI1114_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I131_XG_MN1 (XI1114_I131_XG_n1 I1114_G2_0n I1114_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I128_XG_MN2 (XI1114_I128_XG_n1 I1114_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I128_XG_MN0 (I1114_G4_0 I1114_P4_1n XI1114_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I128_XG_MN1 (XI1114_I128_XG_n1 I1114_G0_0n I1114_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I69_XG_MN2 (XI1114_I69_XG_n1 I1114_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I69_XG_MN0 (I1114_G3_2 I1114_pn3 XI1114_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I69_XG_MN1 (XI1114_I69_XG_n1 I1114_gn2 I1114_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I97_XG_MN2 (XI1022_I97_XG_n1 I1022_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I97_XG_MN0 (I1022_G31_30 I1022_pn31 XI1022_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I97_XG_MN1 (XI1022_I97_XG_n1 I1022_gn30 I1022_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I96_XG_MN2 (XI1022_I96_XG_n1 I1022_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I96_XG_MN0 (I1022_G30_29 I1022_pn30 XI1022_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I96_XG_MN1 (XI1022_I96_XG_n1 I1022_gn29 I1022_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I95_XG_MN2 (XI1022_I95_XG_n1 I1022_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I95_XG_MN0 (I1022_G29_28 I1022_pn29 XI1022_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I95_XG_MN1 (XI1022_I95_XG_n1 I1022_gn28 I1022_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I199_XG_MN2 (XI976_I199_XG_n1 I976_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I199_XG_MN0 (I976_G28_0 I976_P28_13n XI976_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I199_XG_MN1 (XI976_I199_XG_n1 I976_G12_0n I976_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I153_XG_MN2 (XI976_I153_XG_n1 I976_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I153_XG_MN0 (I976_G28_21 I976_P28_25n XI976_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I153_XG_MN1 (XI976_I153_XG_n1 I976_G24_21n I976_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I200_XG_MN2 (XI976_I200_XG_n1 I976_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I200_XG_MN0 (I976_G29_0 I976_P29_14n XI976_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I200_XG_MN1 (XI976_I200_XG_n1 I976_G13_0n I976_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I154_XG_MN2 (XI976_I154_XG_n1 I976_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I154_XG_MN0 (I976_G29_22 I976_P29_26n XI976_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I154_XG_MN1 (XI976_I154_XG_n1 I976_G25_22n I976_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I92_XG_MN2 (XI976_I92_XG_n1 I976_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I92_XG_MN0 (I976_G26_25 I976_pn26 XI976_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I92_XG_MN1 (XI976_I92_XG_n1 I976_gn25 I976_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I93_XG_MN2 (XI976_I93_XG_n1 I976_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I93_XG_MN0 (I976_G27_26 I976_pn27 XI976_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I93_XG_MN1 (XI976_I93_XG_n1 I976_gn26 I976_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I201_XG_MN2 (XI930_I201_XG_n1 I930_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I201_XG_MN0 (c8_m I930_P30_15n XI930_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I201_XG_MN1 (XI930_I201_XG_n1 I930_G14_0n c8_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I94_XG_MN2 (XI930_I94_XG_n1 I930_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I94_XG_MN0 (I930_G28_27 I930_pn28 XI930_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I94_XG_MN1 (XI930_I94_XG_n1 I930_gn27 I930_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I97_XG_MN2 (XI1620_I97_XG_n1 I1620_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I97_XG_MN0 (I1620_G31_30 I1620_pn31 XI1620_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I97_XG_MN1 (XI1620_I97_XG_n1 I1620_gn30 I1620_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I96_XG_MN2 (XI1620_I96_XG_n1 I1620_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I96_XG_MN0 (I1620_G30_29 I1620_pn30 XI1620_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I96_XG_MN1 (XI1620_I96_XG_n1 I1620_gn29 I1620_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I95_XG_MN2 (XI1620_I95_XG_n1 I1620_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I95_XG_MN0 (I1620_G29_28 I1620_pn29 XI1620_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I95_XG_MN1 (XI1620_I95_XG_n1 I1620_gn28 I1620_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I65_XG_MN2 (XI1528_I65_XG_n1 I1528_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I65_XG_MN0 (I1528_G0_0 I1528_pn0 XI1528_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I65_XG_MN1 (XI1528_I65_XG_n1 I1528_cinn I1528_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I97_XG_MN2 (XI1574_I97_XG_n1 I1574_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I97_XG_MN0 (I1574_G31_30 I1574_pn31 XI1574_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I97_XG_MN1 (XI1574_I97_XG_n1 I1574_gn30 I1574_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I96_XG_MN2 (XI1574_I96_XG_n1 I1574_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I96_XG_MN0 (I1574_G30_29 I1574_pn30 XI1574_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I96_XG_MN1 (XI1574_I96_XG_n1 I1574_gn29 I1574_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I95_XG_MN2 (XI1574_I95_XG_n1 I1574_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I95_XG_MN0 (I1574_G29_28 I1574_pn29 XI1574_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I95_XG_MN1 (XI1574_I95_XG_n1 I1574_gn28 I1574_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I93_XG_MN2 (XI1574_I93_XG_n1 I1574_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I93_XG_MN0 (I1574_G27_26 I1574_pn27 XI1574_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I93_XG_MN1 (XI1574_I93_XG_n1 I1574_gn26 I1574_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I94_XG_MN2 (XI1574_I94_XG_n1 I1574_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I94_XG_MN0 (I1574_G28_27 I1574_pn28 XI1574_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I94_XG_MN1 (XI1574_I94_XG_n1 I1574_gn27 I1574_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I154_XG_MN2 (XI1114_I154_XG_n1 I1114_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I154_XG_MN0 (I1114_G29_22 I1114_P29_26n XI1114_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I154_XG_MN1 (XI1114_I154_XG_n1 I1114_G25_22n I1114_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I150_XG_MN2 (XI1114_I150_XG_n1 I1114_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I150_XG_MN0 (I1114_G25_18 I1114_P25_22n XI1114_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I150_XG_MN1 (XI1114_I150_XG_n1 I1114_G21_18n I1114_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I146_XG_MN2 (XI1114_I146_XG_n1 I1114_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I146_XG_MN0 (I1114_G21_14 I1114_P21_18n XI1114_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I146_XG_MN1 (XI1114_I146_XG_n1 I1114_G17_14n I1114_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I67_XG_MN2 (XI1114_I67_XG_n1 I1114_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I67_XG_MN0 (I1114_G1_0 I1114_pn1 XI1114_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I67_XG_MN1 (XI1114_I67_XG_n1 I1114_G0_0n I1114_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I68_XG_MN2 (XI1114_I68_XG_n1 I1114_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I68_XG_MN0 (I1114_G2_1 I1114_pn2 XI1114_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I68_XG_MN1 (XI1114_I68_XG_n1 I1114_gn1 I1114_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I201_XG_MN2 (XI976_I201_XG_n1 I976_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I201_XG_MN0 (c9_m I976_P30_15n XI976_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I201_XG_MN1 (XI976_I201_XG_n1 I976_G14_0n c9_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I155_XG_MN2 (XI976_I155_XG_n1 I976_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I155_XG_MN0 (I976_G30_23 I976_P30_27n XI976_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I155_XG_MN1 (XI976_I155_XG_n1 I976_G26_23n I976_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I202_XG_MN2 (XI976_I202_XG_n1 I976_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I202_XG_MN0 (c9_o I976_P31_16n XI976_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I202_XG_MN1 (XI976_I202_XG_n1 I976_G15_0n c9_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I156_XG_MN2 (XI976_I156_XG_n1 I976_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I156_XG_MN0 (I976_G31_24 I976_P31_28n XI976_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I156_XG_MN1 (XI976_I156_XG_n1 I976_G27_24n I976_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I95_XG_MN2 (XI976_I95_XG_n1 I976_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I95_XG_MN0 (I976_G29_28 I976_pn29 XI976_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I95_XG_MN1 (XI976_I95_XG_n1 I976_gn28 I976_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I94_XG_MN2 (XI976_I94_XG_n1 I976_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I94_XG_MN0 (I976_G28_27 I976_pn28 XI976_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I94_XG_MN1 (XI976_I94_XG_n1 I976_gn27 I976_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I97_XG_MN2 (XI930_I97_XG_n1 I930_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I97_XG_MN0 (I930_G31_30 I930_pn31 XI930_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I97_XG_MN1 (XI930_I97_XG_n1 I930_gn30 I930_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I96_XG_MN2 (XI930_I96_XG_n1 I930_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I96_XG_MN0 (I930_G30_29 I930_pn30 XI930_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I96_XG_MN1 (XI930_I96_XG_n1 I930_gn29 I930_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I95_XG_MN2 (XI930_I95_XG_n1 I930_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I95_XG_MN0 (I930_G29_28 I930_pn29 XI930_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I95_XG_MN1 (XI930_I95_XG_n1 I930_gn28 I930_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I65_XG_MN2 (XI1344_I65_XG_n1 I1344_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I65_XG_MN0 (I1344_G0_0 I1344_pn0 XI1344_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I65_XG_MN1 (XI1344_I65_XG_n1 I1344_cinn I1344_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I65_XG_MN2 (XI1390_I65_XG_n1 I1390_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I65_XG_MN0 (I1390_G0_0 I1390_pn0 XI1390_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I65_XG_MN1 (XI1390_I65_XG_n1 I1390_cinn I1390_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I65_XG_MN2 (XI1436_I65_XG_n1 I1436_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I65_XG_MN0 (I1436_G0_0 I1436_pn0 XI1436_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I65_XG_MN1 (XI1436_I65_XG_n1 I1436_cinn I1436_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I65_XG_MN2 (XI1482_I65_XG_n1 I1482_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I65_XG_MN0 (I1482_G0_0 I1482_pn0 XI1482_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I65_XG_MN1 (XI1482_I65_XG_n1 I1482_cinn I1482_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I69_XG_MN2 (XI1528_I69_XG_n1 I1528_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I69_XG_MN0 (I1528_G3_2 I1528_pn3 XI1528_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I69_XG_MN1 (XI1528_I69_XG_n1 I1528_gn2 I1528_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I68_XG_MN2 (XI1528_I68_XG_n1 I1528_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I68_XG_MN0 (I1528_G2_1 I1528_pn2 XI1528_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I68_XG_MN1 (XI1528_I68_XG_n1 I1528_gn1 I1528_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I67_XG_MN2 (XI1528_I67_XG_n1 I1528_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I67_XG_MN0 (I1528_G1_0 I1528_pn1 XI1528_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I67_XG_MN1 (XI1528_I67_XG_n1 I1528_G0_0n I1528_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I183_XG_MN2 (XI1528_I183_XG_n1 I1528_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I183_XG_MN0 (I1528_G16_0 I1528_P16_1n XI1528_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I183_XG_MN1 (XI1528_I183_XG_n1 I1528_G0_0n I1528_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I156_XG_MN2 (XI1114_I156_XG_n1 I1114_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I156_XG_MN0 (I1114_G31_24 I1114_P31_28n XI1114_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I156_XG_MN1 (XI1114_I156_XG_n1 I1114_G27_24n I1114_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I152_XG_MN2 (XI1114_I152_XG_n1 I1114_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I152_XG_MN0 (I1114_G27_20 I1114_P27_24n XI1114_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I152_XG_MN1 (XI1114_I152_XG_n1 I1114_G23_20n I1114_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I148_XG_MN2 (XI1114_I148_XG_n1 I1114_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I148_XG_MN0 (I1114_G23_16 I1114_P23_20n XI1114_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I148_XG_MN1 (XI1114_I148_XG_n1 I1114_G19_16n I1114_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I200_XG_MN2 (XI1114_I200_XG_n1 I1114_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I200_XG_MN0 (I1114_G29_0 I1114_P29_14n XI1114_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I200_XG_MN1 (XI1114_I200_XG_n1 I1114_G13_0n I1114_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I196_XG_MN2 (XI1114_I196_XG_n1 I1114_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I196_XG_MN0 (I1114_G25_0 I1114_P25_10n XI1114_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I196_XG_MN1 (XI1114_I196_XG_n1 I1114_G9_0n I1114_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I142_XG_MN2 (XI1114_I142_XG_n1 I1114_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I142_XG_MN0 (I1114_G17_10 I1114_P17_14n XI1114_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I142_XG_MN1 (XI1114_I142_XG_n1 I1114_G13_10n I1114_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I138_XG_MN2 (XI1114_I138_XG_n1 I1114_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I138_XG_MN0 (I1114_G13_6 I1114_P13_10n XI1114_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I138_XG_MN1 (XI1114_I138_XG_n1 I1114_G9_6n I1114_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I184_XG_MN2 (XI1114_I184_XG_n1 I1114_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I184_XG_MN0 (I1114_G17_0 I1114_P17_2n XI1114_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I184_XG_MN1 (XI1114_I184_XG_n1 I1114_G1_0n I1114_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I134_XG_MN2 (XI1114_I134_XG_n1 I1114_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I134_XG_MN0 (I1114_G9_2 I1114_P9_6n XI1114_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I134_XG_MN1 (XI1114_I134_XG_n1 I1114_G5_2n I1114_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I130_XG_MN2 (XI1114_I130_XG_n1 I1114_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I130_XG_MN0 (I1114_G5_0 I1114_P5_2n XI1114_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I130_XG_MN1 (XI1114_I130_XG_n1 I1114_G1_0n I1114_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I65_XG_MN2 (XI1114_I65_XG_n1 I1114_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I65_XG_MN0 (I1114_G0_0 I1114_pn0 XI1114_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I65_XG_MN1 (XI1114_I65_XG_n1 I1114_cinn I1114_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I97_XG_MN2 (XI976_I97_XG_n1 I976_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I97_XG_MN0 (I976_G31_30 I976_pn31 XI976_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I97_XG_MN1 (XI976_I97_XG_n1 I976_gn30 I976_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I96_XG_MN2 (XI976_I96_XG_n1 I976_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I96_XG_MN0 (I976_G30_29 I976_pn30 XI976_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I96_XG_MN1 (XI976_I96_XG_n1 I976_gn29 I976_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I68_XG_MN2 (XI1482_I68_XG_n1 I1482_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I68_XG_MN0 (I1482_G2_1 I1482_pn2 XI1482_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I68_XG_MN1 (XI1482_I68_XG_n1 I1482_gn1 I1482_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I67_XG_MN2 (XI1482_I67_XG_n1 I1482_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I67_XG_MN0 (I1482_G1_0 I1482_pn1 XI1482_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I67_XG_MN1 (XI1482_I67_XG_n1 I1482_G0_0n I1482_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I71_XG_MN2 (XI1528_I71_XG_n1 I1528_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I71_XG_MN0 (I1528_G5_4 I1528_pn5 XI1528_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I71_XG_MN1 (XI1528_I71_XG_n1 I1528_gn4 I1528_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I70_XG_MN2 (XI1528_I70_XG_n1 I1528_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I70_XG_MN0 (I1528_G4_3 I1528_pn4 XI1528_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I70_XG_MN1 (XI1528_I70_XG_n1 I1528_gn3 I1528_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I128_XG_MN2 (XI1528_I128_XG_n1 I1528_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I128_XG_MN0 (I1528_G4_0 I1528_P4_1n XI1528_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I128_XG_MN1 (XI1528_I128_XG_n1 I1528_G0_0n I1528_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I184_XG_MN2 (XI1528_I184_XG_n1 I1528_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I184_XG_MN0 (I1528_G17_0 I1528_P17_2n XI1528_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I184_XG_MN1 (XI1528_I184_XG_n1 I1528_G1_0n I1528_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I202_XG_MN2 (XI1114_I202_XG_n1 I1114_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I202_XG_MN0 (c12_o I1114_P31_16n XI1114_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I202_XG_MN1 (XI1114_I202_XG_n1 I1114_G15_0n c12_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I198_XG_MN2 (XI1114_I198_XG_n1 I1114_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I198_XG_MN0 (I1114_G27_0 I1114_P27_12n XI1114_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I198_XG_MN1 (XI1114_I198_XG_n1 I1114_G11_0n I1114_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I190_XG_MN2 (XI1114_I190_XG_n1 I1114_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I190_XG_MN0 (I1114_G21_0 I1114_P21_6n XI1114_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I190_XG_MN1 (XI1114_I190_XG_n1 I1114_G5_0n I1114_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I144_XG_MN2 (XI1114_I144_XG_n1 I1114_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I144_XG_MN0 (I1114_G19_12 I1114_P19_16n XI1114_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I144_XG_MN1 (XI1114_I144_XG_n1 I1114_G15_12n I1114_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I140_XG_MN2 (XI1114_I140_XG_n1 I1114_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I140_XG_MN0 (I1114_G15_8 I1114_P15_12n XI1114_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I140_XG_MN1 (XI1114_I140_XG_n1 I1114_G11_8n I1114_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I136_XG_MN2 (XI1114_I136_XG_n1 I1114_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I136_XG_MN0 (I1114_G11_4 I1114_P11_8n XI1114_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I136_XG_MN1 (XI1114_I136_XG_n1 I1114_G7_4n I1114_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I132_XG_MN2 (XI1114_I132_XG_n1 I1114_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I132_XG_MN0 (I1114_G7_0 I1114_P7_4n XI1114_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I132_XG_MN1 (XI1114_I132_XG_n1 I1114_G3_0n I1114_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I65_XG_MN2 (XI1160_I65_XG_n1 I1160_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I65_XG_MN0 (I1160_G0_0 I1160_pn0 XI1160_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I65_XG_MN1 (XI1160_I65_XG_n1 I1160_cinn I1160_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I65_XG_MN2 (XI1206_I65_XG_n1 I1206_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I65_XG_MN0 (I1206_G0_0 I1206_pn0 XI1206_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I65_XG_MN1 (XI1206_I65_XG_n1 I1206_cinn I1206_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I65_XG_MN2 (XI1252_I65_XG_n1 I1252_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I65_XG_MN0 (I1252_G0_0 I1252_pn0 XI1252_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I65_XG_MN1 (XI1252_I65_XG_n1 I1252_cinn I1252_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I68_XG_MN2 (XI1298_I68_XG_n1 I1298_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I68_XG_MN0 (I1298_G2_1 I1298_pn2 XI1298_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I68_XG_MN1 (XI1298_I68_XG_n1 I1298_gn1 I1298_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I67_XG_MN2 (XI1298_I67_XG_n1 I1298_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I67_XG_MN0 (I1298_G1_0 I1298_pn1 XI1298_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I67_XG_MN1 (XI1298_I67_XG_n1 I1298_G0_0n I1298_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I65_XG_MN2 (XI1298_I65_XG_n1 I1298_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I65_XG_MN0 (I1298_G0_0 I1298_pn0 XI1298_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I65_XG_MN1 (XI1298_I65_XG_n1 I1298_cinn I1298_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I71_XG_MN2 (XI1344_I71_XG_n1 I1344_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I71_XG_MN0 (I1344_G5_4 I1344_pn5 XI1344_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I71_XG_MN1 (XI1344_I71_XG_n1 I1344_gn4 I1344_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I70_XG_MN2 (XI1344_I70_XG_n1 I1344_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I70_XG_MN0 (I1344_G4_3 I1344_pn4 XI1344_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I70_XG_MN1 (XI1344_I70_XG_n1 I1344_gn3 I1344_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I69_XG_MN2 (XI1344_I69_XG_n1 I1344_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I69_XG_MN0 (I1344_G3_2 I1344_pn3 XI1344_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I69_XG_MN1 (XI1344_I69_XG_n1 I1344_gn2 I1344_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I68_XG_MN2 (XI1344_I68_XG_n1 I1344_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I68_XG_MN0 (I1344_G2_1 I1344_pn2 XI1344_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I68_XG_MN1 (XI1344_I68_XG_n1 I1344_gn1 I1344_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I67_XG_MN2 (XI1344_I67_XG_n1 I1344_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I67_XG_MN0 (I1344_G1_0 I1344_pn1 XI1344_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I67_XG_MN1 (XI1344_I67_XG_n1 I1344_G0_0n I1344_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I70_XG_MN2 (XI1390_I70_XG_n1 I1390_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I70_XG_MN0 (I1390_G4_3 I1390_pn4 XI1390_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I70_XG_MN1 (XI1390_I70_XG_n1 I1390_gn3 I1390_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I69_XG_MN2 (XI1390_I69_XG_n1 I1390_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I69_XG_MN0 (I1390_G3_2 I1390_pn3 XI1390_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I69_XG_MN1 (XI1390_I69_XG_n1 I1390_gn2 I1390_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I68_XG_MN2 (XI1390_I68_XG_n1 I1390_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I68_XG_MN0 (I1390_G2_1 I1390_pn2 XI1390_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I68_XG_MN1 (XI1390_I68_XG_n1 I1390_gn1 I1390_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I67_XG_MN2 (XI1390_I67_XG_n1 I1390_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I67_XG_MN0 (I1390_G1_0 I1390_pn1 XI1390_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I67_XG_MN1 (XI1390_I67_XG_n1 I1390_G0_0n I1390_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I70_XG_MN2 (XI1436_I70_XG_n1 I1436_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I70_XG_MN0 (I1436_G4_3 I1436_pn4 XI1436_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I70_XG_MN1 (XI1436_I70_XG_n1 I1436_gn3 I1436_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I69_XG_MN2 (XI1436_I69_XG_n1 I1436_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I69_XG_MN0 (I1436_G3_2 I1436_pn3 XI1436_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I69_XG_MN1 (XI1436_I69_XG_n1 I1436_gn2 I1436_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I68_XG_MN2 (XI1436_I68_XG_n1 I1436_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I68_XG_MN0 (I1436_G2_1 I1436_pn2 XI1436_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I68_XG_MN1 (XI1436_I68_XG_n1 I1436_gn1 I1436_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I67_XG_MN2 (XI1436_I67_XG_n1 I1436_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I67_XG_MN0 (I1436_G1_0 I1436_pn1 XI1436_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I67_XG_MN1 (XI1436_I67_XG_n1 I1436_G0_0n I1436_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I70_XG_MN2 (XI1482_I70_XG_n1 I1482_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I70_XG_MN0 (I1482_G4_3 I1482_pn4 XI1482_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I70_XG_MN1 (XI1482_I70_XG_n1 I1482_gn3 I1482_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I69_XG_MN2 (XI1482_I69_XG_n1 I1482_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I69_XG_MN0 (I1482_G3_2 I1482_pn3 XI1482_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I69_XG_MN1 (XI1482_I69_XG_n1 I1482_gn2 I1482_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I72_XG_MN2 (XI1528_I72_XG_n1 I1528_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I72_XG_MN0 (I1528_G6_5 I1528_pn6 XI1528_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I72_XG_MN1 (XI1528_I72_XG_n1 I1528_gn5 I1528_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I73_XG_MN2 (XI1528_I73_XG_n1 I1528_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I73_XG_MN0 (I1528_G7_6 I1528_pn7 XI1528_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I73_XG_MN1 (XI1528_I73_XG_n1 I1528_gn6 I1528_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I131_XG_MN2 (XI1528_I131_XG_n1 I1528_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I131_XG_MN0 (I1528_G6_0 I1528_P6_3n XI1528_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I131_XG_MN1 (XI1528_I131_XG_n1 I1528_G2_0n I1528_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I133_XG_MN2 (XI1528_I133_XG_n1 I1528_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I133_XG_MN0 (I1528_G8_1 I1528_P8_5n XI1528_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I133_XG_MN1 (XI1528_I133_XG_n1 I1528_G4_1n I1528_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I195_XG_MN2 (XI1528_I195_XG_n1 I1528_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I195_XG_MN0 (I1528_G24_0 I1528_P24_9n XI1528_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I195_XG_MN1 (XI1528_I195_XG_n1 I1528_G8_0n I1528_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I130_XG_MN2 (XI1528_I130_XG_n1 I1528_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I130_XG_MN0 (I1528_G5_0 I1528_P5_2n XI1528_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I130_XG_MN1 (XI1528_I130_XG_n1 I1528_G1_0n I1528_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I134_XG_MN2 (XI1528_I134_XG_n1 I1528_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I134_XG_MN0 (I1528_G9_2 I1528_P9_6n XI1528_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I134_XG_MN1 (XI1528_I134_XG_n1 I1528_G5_2n I1528_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I194_XG_MN2 (XI1114_I194_XG_n1 I1114_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I194_XG_MN0 (I1114_G23_0 I1114_P23_8n XI1114_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I194_XG_MN1 (XI1114_I194_XG_n1 I1114_G7_0n I1114_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I186_XG_MN2 (XI1114_I186_XG_n1 I1114_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I186_XG_MN0 (I1114_G19_0 I1114_P19_4n XI1114_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I186_XG_MN1 (XI1114_I186_XG_n1 I1114_G3_0n I1114_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I68_XG_MN2 (XI1252_I68_XG_n1 I1252_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I68_XG_MN0 (I1252_G2_1 I1252_pn2 XI1252_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I68_XG_MN1 (XI1252_I68_XG_n1 I1252_gn1 I1252_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I67_XG_MN2 (XI1252_I67_XG_n1 I1252_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I67_XG_MN0 (I1252_G1_0 I1252_pn1 XI1252_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I67_XG_MN1 (XI1252_I67_XG_n1 I1252_G0_0n I1252_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I69_XG_MN2 (XI1298_I69_XG_n1 I1298_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I69_XG_MN0 (I1298_G3_2 I1298_pn3 XI1298_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I69_XG_MN1 (XI1298_I69_XG_n1 I1298_gn2 I1298_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I70_XG_MN2 (XI1298_I70_XG_n1 I1298_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I70_XG_MN0 (I1298_G4_3 I1298_pn4 XI1298_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I70_XG_MN1 (XI1298_I70_XG_n1 I1298_gn3 I1298_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I72_XG_MN2 (XI1344_I72_XG_n1 I1344_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I72_XG_MN0 (I1344_G6_5 I1344_pn6 XI1344_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I72_XG_MN1 (XI1344_I72_XG_n1 I1344_gn5 I1344_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I128_XG_MN2 (XI1344_I128_XG_n1 I1344_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I128_XG_MN0 (I1344_G4_0 I1344_P4_1n XI1344_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I128_XG_MN1 (XI1344_I128_XG_n1 I1344_G0_0n I1344_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I72_XG_MN2 (XI1390_I72_XG_n1 I1390_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I72_XG_MN0 (I1390_G6_5 I1390_pn6 XI1390_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I72_XG_MN1 (XI1390_I72_XG_n1 I1390_gn5 I1390_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I71_XG_MN2 (XI1390_I71_XG_n1 I1390_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I71_XG_MN0 (I1390_G5_4 I1390_pn5 XI1390_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I71_XG_MN1 (XI1390_I71_XG_n1 I1390_gn4 I1390_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I128_XG_MN2 (XI1390_I128_XG_n1 I1390_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I128_XG_MN0 (I1390_G4_0 I1390_P4_1n XI1390_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I128_XG_MN1 (XI1390_I128_XG_n1 I1390_G0_0n I1390_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I72_XG_MN2 (XI1436_I72_XG_n1 I1436_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I72_XG_MN0 (I1436_G6_5 I1436_pn6 XI1436_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I72_XG_MN1 (XI1436_I72_XG_n1 I1436_gn5 I1436_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I71_XG_MN2 (XI1436_I71_XG_n1 I1436_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I71_XG_MN0 (I1436_G5_4 I1436_pn5 XI1436_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I71_XG_MN1 (XI1436_I71_XG_n1 I1436_gn4 I1436_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I128_XG_MN2 (XI1436_I128_XG_n1 I1436_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I128_XG_MN0 (I1436_G4_0 I1436_P4_1n XI1436_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I128_XG_MN1 (XI1436_I128_XG_n1 I1436_G0_0n I1436_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I71_XG_MN2 (XI1482_I71_XG_n1 I1482_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I71_XG_MN0 (I1482_G5_4 I1482_pn5 XI1482_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I71_XG_MN1 (XI1482_I71_XG_n1 I1482_gn4 I1482_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I72_XG_MN2 (XI1482_I72_XG_n1 I1482_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I72_XG_MN0 (I1482_G6_5 I1482_pn6 XI1482_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I72_XG_MN1 (XI1482_I72_XG_n1 I1482_gn5 I1482_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I74_XG_MN2 (XI1528_I74_XG_n1 I1528_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I74_XG_MN0 (I1528_G8_7 I1528_pn8 XI1528_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I74_XG_MN1 (XI1528_I74_XG_n1 I1528_gn7 I1528_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I75_XG_MN2 (XI1528_I75_XG_n1 I1528_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I75_XG_MN0 (I1528_G9_8 I1528_pn9 XI1528_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I75_XG_MN1 (XI1528_I75_XG_n1 I1528_gn8 I1528_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I137_XG_MN2 (XI1528_I137_XG_n1 I1528_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I137_XG_MN0 (I1528_G12_5 I1528_P12_9n XI1528_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I137_XG_MN1 (XI1528_I137_XG_n1 I1528_G8_5n I1528_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I188_XG_MN2 (XI1528_I188_XG_n1 I1528_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I188_XG_MN0 (I1528_G20_0 I1528_P20_5n XI1528_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I188_XG_MN1 (XI1528_I188_XG_n1 I1528_G4_0n I1528_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I132_XG_MN2 (XI1528_I132_XG_n1 I1528_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I132_XG_MN0 (I1528_G7_0 I1528_P7_4n XI1528_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I132_XG_MN1 (XI1528_I132_XG_n1 I1528_G3_0n I1528_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I196_XG_MN2 (XI1528_I196_XG_n1 I1528_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I196_XG_MN0 (I1528_G25_0 I1528_P25_10n XI1528_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I196_XG_MN1 (XI1528_I196_XG_n1 I1528_G9_0n I1528_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I87_XG_MN2 (XI1160_I87_XG_n1 I1160_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I87_XG_MN0 (I1160_G21_20 I1160_pn21 XI1160_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I87_XG_MN1 (XI1160_I87_XG_n1 I1160_gn20 I1160_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I73_XG_MN2 (XI1160_I73_XG_n1 I1160_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I73_XG_MN0 (I1160_G7_6 I1160_pn7 XI1160_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I73_XG_MN1 (XI1160_I73_XG_n1 I1160_gn6 I1160_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I72_XG_MN2 (XI1160_I72_XG_n1 I1160_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I72_XG_MN0 (I1160_G6_5 I1160_pn6 XI1160_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I72_XG_MN1 (XI1160_I72_XG_n1 I1160_gn5 I1160_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I71_XG_MN2 (XI1160_I71_XG_n1 I1160_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I71_XG_MN0 (I1160_G5_4 I1160_pn5 XI1160_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I71_XG_MN1 (XI1160_I71_XG_n1 I1160_gn4 I1160_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I70_XG_MN2 (XI1160_I70_XG_n1 I1160_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I70_XG_MN0 (I1160_G4_3 I1160_pn4 XI1160_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I70_XG_MN1 (XI1160_I70_XG_n1 I1160_gn3 I1160_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I69_XG_MN2 (XI1160_I69_XG_n1 I1160_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I69_XG_MN0 (I1160_G3_2 I1160_pn3 XI1160_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I69_XG_MN1 (XI1160_I69_XG_n1 I1160_gn2 I1160_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I67_XG_MN2 (XI1160_I67_XG_n1 I1160_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I67_XG_MN0 (I1160_G1_0 I1160_pn1 XI1160_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I67_XG_MN1 (XI1160_I67_XG_n1 I1160_G0_0n I1160_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I68_XG_MN2 (XI1160_I68_XG_n1 I1160_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I68_XG_MN0 (I1160_G2_1 I1160_pn2 XI1160_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I68_XG_MN1 (XI1160_I68_XG_n1 I1160_gn1 I1160_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I68_XG_MN2 (XI1206_I68_XG_n1 I1206_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I68_XG_MN0 (I1206_G2_1 I1206_pn2 XI1206_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I68_XG_MN1 (XI1206_I68_XG_n1 I1206_gn1 I1206_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I67_XG_MN2 (XI1206_I67_XG_n1 I1206_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I67_XG_MN0 (I1206_G1_0 I1206_pn1 XI1206_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I67_XG_MN1 (XI1206_I67_XG_n1 I1206_G0_0n I1206_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I70_XG_MN2 (XI1252_I70_XG_n1 I1252_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I70_XG_MN0 (I1252_G4_3 I1252_pn4 XI1252_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I70_XG_MN1 (XI1252_I70_XG_n1 I1252_gn3 I1252_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I69_XG_MN2 (XI1252_I69_XG_n1 I1252_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I69_XG_MN0 (I1252_G3_2 I1252_pn3 XI1252_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I69_XG_MN1 (XI1252_I69_XG_n1 I1252_gn2 I1252_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I72_XG_MN2 (XI1298_I72_XG_n1 I1298_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I72_XG_MN0 (I1298_G6_5 I1298_pn6 XI1298_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I72_XG_MN1 (XI1298_I72_XG_n1 I1298_gn5 I1298_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I71_XG_MN2 (XI1298_I71_XG_n1 I1298_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I71_XG_MN0 (I1298_G5_4 I1298_pn5 XI1298_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I71_XG_MN1 (XI1298_I71_XG_n1 I1298_gn4 I1298_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I128_XG_MN2 (XI1298_I128_XG_n1 I1298_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I128_XG_MN0 (I1298_G4_0 I1298_P4_1n XI1298_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I128_XG_MN1 (XI1298_I128_XG_n1 I1298_G0_0n I1298_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I73_XG_MN2 (XI1344_I73_XG_n1 I1344_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I73_XG_MN0 (I1344_G7_6 I1344_pn7 XI1344_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I73_XG_MN1 (XI1344_I73_XG_n1 I1344_gn6 I1344_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I74_XG_MN2 (XI1344_I74_XG_n1 I1344_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I74_XG_MN0 (I1344_G8_7 I1344_pn8 XI1344_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I74_XG_MN1 (XI1344_I74_XG_n1 I1344_gn7 I1344_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I133_XG_MN2 (XI1344_I133_XG_n1 I1344_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I133_XG_MN0 (I1344_G8_1 I1344_P8_5n XI1344_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I133_XG_MN1 (XI1344_I133_XG_n1 I1344_G4_1n I1344_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I130_XG_MN2 (XI1344_I130_XG_n1 I1344_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I130_XG_MN0 (I1344_G5_0 I1344_P5_2n XI1344_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I130_XG_MN1 (XI1344_I130_XG_n1 I1344_G1_0n I1344_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I74_XG_MN2 (XI1390_I74_XG_n1 I1390_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I74_XG_MN0 (I1390_G8_7 I1390_pn8 XI1390_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I74_XG_MN1 (XI1390_I74_XG_n1 I1390_gn7 I1390_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I73_XG_MN2 (XI1390_I73_XG_n1 I1390_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I73_XG_MN0 (I1390_G7_6 I1390_pn7 XI1390_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I73_XG_MN1 (XI1390_I73_XG_n1 I1390_gn6 I1390_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I133_XG_MN2 (XI1390_I133_XG_n1 I1390_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I133_XG_MN0 (I1390_G8_1 I1390_P8_5n XI1390_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I133_XG_MN1 (XI1390_I133_XG_n1 I1390_G4_1n I1390_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I130_XG_MN2 (XI1390_I130_XG_n1 I1390_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I130_XG_MN0 (I1390_G5_0 I1390_P5_2n XI1390_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I130_XG_MN1 (XI1390_I130_XG_n1 I1390_G1_0n I1390_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I74_XG_MN2 (XI1436_I74_XG_n1 I1436_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I74_XG_MN0 (I1436_G8_7 I1436_pn8 XI1436_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I74_XG_MN1 (XI1436_I74_XG_n1 I1436_gn7 I1436_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I73_XG_MN2 (XI1436_I73_XG_n1 I1436_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I73_XG_MN0 (I1436_G7_6 I1436_pn7 XI1436_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I73_XG_MN1 (XI1436_I73_XG_n1 I1436_gn6 I1436_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I133_XG_MN2 (XI1436_I133_XG_n1 I1436_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I133_XG_MN0 (I1436_G8_1 I1436_P8_5n XI1436_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I133_XG_MN1 (XI1436_I133_XG_n1 I1436_G4_1n I1436_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I131_XG_MN2 (XI1436_I131_XG_n1 I1436_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I131_XG_MN0 (I1436_G6_0 I1436_P6_3n XI1436_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I131_XG_MN1 (XI1436_I131_XG_n1 I1436_G2_0n I1436_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I74_XG_MN2 (XI1482_I74_XG_n1 I1482_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I74_XG_MN0 (I1482_G8_7 I1482_pn8 XI1482_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I74_XG_MN1 (XI1482_I74_XG_n1 I1482_gn7 I1482_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I73_XG_MN2 (XI1482_I73_XG_n1 I1482_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I73_XG_MN0 (I1482_G7_6 I1482_pn7 XI1482_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I73_XG_MN1 (XI1482_I73_XG_n1 I1482_gn6 I1482_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I128_XG_MN2 (XI1482_I128_XG_n1 I1482_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I128_XG_MN0 (I1482_G4_0 I1482_P4_1n XI1482_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I128_XG_MN1 (XI1482_I128_XG_n1 I1482_G0_0n I1482_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I76_XG_MN2 (XI1528_I76_XG_n1 I1528_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I76_XG_MN0 (I1528_G10_9 I1528_pn10 XI1528_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I76_XG_MN1 (XI1528_I76_XG_n1 I1528_gn9 I1528_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I77_XG_MN2 (XI1528_I77_XG_n1 I1528_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I77_XG_MN0 (I1528_G11_10 I1528_pn11 XI1528_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I77_XG_MN1 (XI1528_I77_XG_n1 I1528_gn10 I1528_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I135_XG_MN2 (XI1528_I135_XG_n1 I1528_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I135_XG_MN0 (I1528_G10_3 I1528_P10_7n XI1528_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I135_XG_MN1 (XI1528_I135_XG_n1 I1528_G6_3n I1528_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I141_XG_MN2 (XI1528_I141_XG_n1 I1528_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I141_XG_MN0 (I1528_G16_9 I1528_P16_13n XI1528_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I141_XG_MN1 (XI1528_I141_XG_n1 I1528_G12_9n I1528_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I136_XG_MN2 (XI1528_I136_XG_n1 I1528_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I136_XG_MN0 (I1528_G11_4 I1528_P11_8n XI1528_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I136_XG_MN1 (XI1528_I136_XG_n1 I1528_G7_4n I1528_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I186_XG_MN2 (XI1528_I186_XG_n1 I1528_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I186_XG_MN0 (I1528_G19_0 I1528_P19_4n XI1528_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I186_XG_MN1 (XI1528_I186_XG_n1 I1528_G3_0n I1528_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I89_XG_MN2 (XI1160_I89_XG_n1 I1160_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I89_XG_MN0 (I1160_G23_22 I1160_pn23 XI1160_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I89_XG_MN1 (XI1160_I89_XG_n1 I1160_gn22 I1160_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I88_XG_MN2 (XI1160_I88_XG_n1 I1160_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I88_XG_MN0 (I1160_G22_21 I1160_pn22 XI1160_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I88_XG_MN1 (XI1160_I88_XG_n1 I1160_gn21 I1160_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I86_XG_MN2 (XI1160_I86_XG_n1 I1160_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I86_XG_MN0 (I1160_G20_19 I1160_pn20 XI1160_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I86_XG_MN1 (XI1160_I86_XG_n1 I1160_gn19 I1160_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I85_XG_MN2 (XI1160_I85_XG_n1 I1160_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I85_XG_MN0 (I1160_G19_18 I1160_pn19 XI1160_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I85_XG_MN1 (XI1160_I85_XG_n1 I1160_gn18 I1160_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I84_XG_MN2 (XI1160_I84_XG_n1 I1160_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I84_XG_MN0 (I1160_G18_17 I1160_pn18 XI1160_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I84_XG_MN1 (XI1160_I84_XG_n1 I1160_gn17 I1160_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
