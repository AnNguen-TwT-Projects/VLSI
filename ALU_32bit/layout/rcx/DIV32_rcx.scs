    I_MXI702_MP3 (XI702_p1 c3_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI702_MP0 (VDD h3 XI702_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI644_MP1 (VDD qu30_b3_3 XI644_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI644_MP5 (b2_22 XI644_Bn XI644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI644_MP4 (XI644_p1 XI644_An b2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI644_MP2 (VDD dd22_b3_0 XI644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI644_MP3 (XI644_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI644_MP0 (VDD dd22_b3_0 XI644_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI598_MP1 (VDD qu31_b3_3 XI598_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI598_MP5 (b1_22 XI598_Bn XI598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI598_MP4 (XI598_p1 XI598_An b1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI598_MP2 (VDD dd22_b3_0 XI598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI598_MP3 (XI598_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI598_MP0 (VDD dd22_b3_0 XI598_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI552_MP1 (VDD VDD XI552_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI552_MP5 (b0_22 XI552_Bn XI552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI552_MP4 (XI552_p1 XI552_An b0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI552_MP2 (VDD dd22_b3_0 XI552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI552_MP3 (XI552_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI552_MP0 (VDD dd22_b3_0 XI552_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI563_MP1 (VDD VDD XI563_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI563_MP5 (h0 XI563_Bn XI563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI563_MP4 (XI563_p1 XI563_An h0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI563_MP2 (VDD VSS XI563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI563_MP3 (XI563_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI563_MP0 (VDD VSS XI563_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I218_MP1 (VDD I2066_G14_0n XI2066_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I218_MP5 (ru15 XI2066_I218_Bn XI2066_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I218_MP4 (XI2066_I218_p1 XI2066_I218_An ru15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I218_MP2 (VDD I2066_pn15 XI2066_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I218_MP3 (XI2066_I218_p1 I2066_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I218_MP0 (VDD I2066_pn15 XI2066_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1978_MP1 (VDD qu1_b3_3 XI1978_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1978_MP5 (b31_22 XI1978_Bn XI1978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1978_MP4 (XI1978_p1 XI1978_An b31_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1978_MP2 (VDD dd22_b3_5 XI1978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1978_MP3 (XI1978_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1978_MP0 (VDD dd22_b3_5 XI1978_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1979_MP1 (VDD qu1_b3_3 XI1979_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1979_MP5 (b31_23 XI1979_Bn XI1979_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1979_MP4 (XI1979_p1 XI1979_An b31_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1979_MP2 (VDD dd23_b3_5 XI1979_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1979_MP3 (XI1979_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1979_MP0 (VDD dd23_b3_5 XI1979_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1933_MP1 (VDD qu2_b3_3 XI1933_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1933_MP5 (b30_23 XI1933_Bn XI1933_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1933_MP4 (XI1933_p1 XI1933_An b30_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1933_MP2 (VDD dd23_b3_5 XI1933_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1933_MP3 (XI1933_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1933_MP0 (VDD dd23_b3_5 XI1933_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1932_MP1 (VDD qu2_b3_3 XI1932_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1932_MP5 (b30_22 XI1932_Bn XI1932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1932_MP4 (XI1932_p1 XI1932_An b30_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1932_MP2 (VDD dd22_b3_5 XI1932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1932_MP3 (XI1932_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1932_MP0 (VDD dd22_b3_5 XI1932_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI689_MP1 (VDD qu29_b3_3 XI689_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI689_MP5 (b3_21 XI689_Bn XI689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI689_MP4 (XI689_p1 XI689_An b3_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI689_MP2 (VDD dd21_b3_0 XI689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI689_MP3 (XI689_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI689_MP0 (VDD dd21_b3_0 XI689_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI691_MP1 (VDD qu29_b3_3 XI691_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI691_MP5 (b3_23 XI691_Bn XI691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI691_MP4 (XI691_p1 XI691_An b3_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI691_MP2 (VDD dd23_b3_0 XI691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI691_MP3 (XI691_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI691_MP0 (VDD dd23_b3_0 XI691_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI642_MP1 (VDD qu30_b3_3 XI642_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI642_MP5 (b2_20 XI642_Bn XI642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI642_MP4 (XI642_p1 XI642_An b2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI642_MP2 (VDD dd20_b3_0 XI642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI642_MP3 (XI642_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI642_MP0 (VDD dd20_b3_0 XI642_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI643_MP1 (VDD qu30_b3_3 XI643_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI643_MP5 (b2_21 XI643_Bn XI643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI643_MP4 (XI643_p1 XI643_An b2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI643_MP2 (VDD dd21_b3_0 XI643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI643_MP3 (XI643_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI643_MP0 (VDD dd21_b3_0 XI643_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI596_MP1 (VDD qu31_b3_3 XI596_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI596_MP5 (b1_20 XI596_Bn XI596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI596_MP4 (XI596_p1 XI596_An b1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI596_MP2 (VDD dd20_b3_0 XI596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI596_MP3 (XI596_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI596_MP0 (VDD dd20_b3_0 XI596_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI597_MP1 (VDD qu31_b3_3 XI597_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI597_MP5 (b1_21 XI597_Bn XI597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI597_MP4 (XI597_p1 XI597_An b1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI597_MP2 (VDD dd21_b3_0 XI597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI597_MP3 (XI597_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI597_MP0 (VDD dd21_b3_0 XI597_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI551_MP1 (VDD VDD XI551_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI551_MP5 (b0_21 XI551_Bn XI551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI551_MP4 (XI551_p1 XI551_An b0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI551_MP2 (VDD dd21_b3_0 XI551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI551_MP3 (XI551_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI551_MP0 (VDD dd21_b3_0 XI551_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI550_MP1 (VDD VDD XI550_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI550_MP5 (b0_20 XI550_Bn XI550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI550_MP4 (XI550_p1 XI550_An b0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI550_MP2 (VDD dd20_b3_0 XI550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI550_MP3 (XI550_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI550_MP0 (VDD dd20_b3_0 XI550_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1977_MP1 (VDD qu1_b3_3 XI1977_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1977_MP5 (b31_21 XI1977_Bn XI1977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1977_MP4 (XI1977_p1 XI1977_An b31_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1977_MP2 (VDD dd21_b3_5 XI1977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1977_MP3 (XI1977_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1977_MP0 (VDD dd21_b3_5 XI1977_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1931_MP1 (VDD qu2_b3_3 XI1931_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1931_MP5 (b30_21 XI1931_Bn XI1931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1931_MP4 (XI1931_p1 XI1931_An b30_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1931_MP2 (VDD dd21_b3_5 XI1931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1931_MP3 (XI1931_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1931_MP0 (VDD dd21_b3_5 XI1931_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1885_MP1 (VDD qu3_b3_3 XI1885_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1885_MP5 (b29_21 XI1885_Bn XI1885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1885_MP4 (XI1885_p1 XI1885_An b29_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1885_MP2 (VDD dd21_b3_5 XI1885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1885_MP3 (XI1885_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1885_MP0 (VDD dd21_b3_5 XI1885_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1887_MP1 (VDD qu3_b3_3 XI1887_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1887_MP5 (b29_23 XI1887_Bn XI1887_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1887_MP4 (XI1887_p1 XI1887_An b29_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1887_MP2 (VDD dd23_b3_5 XI1887_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1887_MP3 (XI1887_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1887_MP0 (VDD dd23_b3_5 XI1887_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1894_MP1 (VDD qu3_b3_5 XI1894_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1894_MP5 (b29_30 XI1894_Bn XI1894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1894_MP4 (XI1894_p1 XI1894_An b29_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1894_MP2 (VDD dd30_b3_5 XI1894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1894_MP3 (XI1894_p1 qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1894_MP0 (VDD dd30_b3_5 XI1894_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1895_MP1 (VDD qu3_b3_5 XI1895_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1895_MP5 (b29_31 XI1895_Bn XI1895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1895_MP4 (XI1895_p1 XI1895_An b29_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1895_MP2 (VDD dd31_b3_5 XI1895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1895_MP3 (XI1895_p1 qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1895_MP0 (VDD dd31_b3_5 XI1895_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI688_MP1 (VDD qu29_b3_3 XI688_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI688_MP5 (b3_20 XI688_Bn XI688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI688_MP4 (XI688_p1 XI688_An b3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI688_MP2 (VDD dd20_b3_0 XI688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI688_MP3 (XI688_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI688_MP0 (VDD dd20_b3_0 XI688_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI686_MP1 (VDD qu29_b3_3 XI686_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI686_MP5 (b3_18 XI686_Bn XI686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI686_MP4 (XI686_p1 XI686_An b3_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI686_MP2 (VDD dd18_b3_0 XI686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI686_MP3 (XI686_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI686_MP0 (VDD dd18_b3_0 XI686_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI687_MP1 (VDD qu29_b3_3 XI687_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI687_MP5 (b3_19 XI687_Bn XI687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI687_MP4 (XI687_p1 XI687_An b3_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI687_MP2 (VDD dd19_b3_0 XI687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI687_MP3 (XI687_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI687_MP0 (VDD dd19_b3_0 XI687_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI640_MP1 (VDD qu30_b3_3 XI640_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI640_MP5 (b2_18 XI640_Bn XI640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI640_MP4 (XI640_p1 XI640_An b2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI640_MP2 (VDD dd18_b3_0 XI640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI640_MP3 (XI640_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI640_MP0 (VDD dd18_b3_0 XI640_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI641_MP1 (VDD qu30_b3_3 XI641_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI641_MP5 (b2_19 XI641_Bn XI641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI641_MP4 (XI641_p1 XI641_An b2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI641_MP2 (VDD dd19_b3_0 XI641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI641_MP3 (XI641_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI641_MP0 (VDD dd19_b3_0 XI641_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I219_MP1 (VDD I608_G15_0n XI608_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I219_MP5 (p1_16 XI608_I219_Bn XI608_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I219_MP4 (XI608_I219_p1 XI608_I219_An p1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I219_MP2 (VDD I608_pn16 XI608_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I219_MP3 (XI608_I219_p1 I608_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I219_MP0 (VDD I608_pn16 XI608_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI594_MP1 (VDD qu31_b3_3 XI594_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI594_MP5 (b1_18 XI594_Bn XI594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI594_MP4 (XI594_p1 XI594_An b1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI594_MP2 (VDD dd18_b3_0 XI594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI594_MP3 (XI594_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI594_MP0 (VDD dd18_b3_0 XI594_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI595_MP1 (VDD qu31_b3_3 XI595_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI595_MP5 (b1_19 XI595_Bn XI595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI595_MP4 (XI595_p1 XI595_An b1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI595_MP2 (VDD dd19_b3_0 XI595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI595_MP3 (XI595_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI595_MP0 (VDD dd19_b3_0 XI595_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI549_MP1 (VDD VDD XI549_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI549_MP5 (b0_19 XI549_Bn XI549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI549_MP4 (XI549_p1 XI549_An b0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI549_MP2 (VDD dd19_b3_0 XI549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI549_MP3 (XI549_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI549_MP0 (VDD dd19_b3_0 XI549_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I217_MP1 (VDD I2066_G13_0n XI2066_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I217_MP5 (ru14 XI2066_I217_Bn XI2066_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I217_MP4 (XI2066_I217_p1 XI2066_I217_An ru14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I217_MP2 (VDD I2066_pn14 XI2066_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I217_MP3 (XI2066_I217_p1 I2066_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I217_MP0 (VDD I2066_pn14 XI2066_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1976_MP1 (VDD qu1_b3_3 XI1976_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1976_MP5 (b31_20 XI1976_Bn XI1976_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1976_MP4 (XI1976_p1 XI1976_An b31_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1976_MP2 (VDD dd20_b3_5 XI1976_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1976_MP3 (XI1976_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1976_MP0 (VDD dd20_b3_5 XI1976_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1975_MP1 (VDD qu1_b3_3 XI1975_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1975_MP5 (b31_19 XI1975_Bn XI1975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1975_MP4 (XI1975_p1 XI1975_An b31_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1975_MP2 (VDD dd19_b3_5 XI1975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1975_MP3 (XI1975_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1975_MP0 (VDD dd19_b3_5 XI1975_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1928_MP1 (VDD qu2_b3_3 XI1928_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1928_MP5 (b30_18 XI1928_Bn XI1928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1928_MP4 (XI1928_p1 XI1928_An b30_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1928_MP2 (VDD dd18_b3_5 XI1928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1928_MP3 (XI1928_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1928_MP0 (VDD dd18_b3_5 XI1928_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1930_MP1 (VDD qu2_b3_3 XI1930_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1930_MP5 (b30_20 XI1930_Bn XI1930_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1930_MP4 (XI1930_p1 XI1930_An b30_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1930_MP2 (VDD dd20_b3_5 XI1930_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1930_MP3 (XI1930_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1930_MP0 (VDD dd20_b3_5 XI1930_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1929_MP1 (VDD qu2_b3_3 XI1929_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1929_MP5 (b30_19 XI1929_Bn XI1929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1929_MP4 (XI1929_p1 XI1929_An b30_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1929_MP2 (VDD dd19_b3_5 XI1929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1929_MP3 (XI1929_p1 qu2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1929_MP0 (VDD dd19_b3_5 XI1929_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1882_MP1 (VDD qu3_b3_3 XI1882_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1882_MP5 (b29_18 XI1882_Bn XI1882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1882_MP4 (XI1882_p1 XI1882_An b29_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1882_MP2 (VDD dd18_b3_5 XI1882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1882_MP3 (XI1882_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1882_MP0 (VDD dd18_b3_5 XI1882_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1883_MP1 (VDD qu3_b3_3 XI1883_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1883_MP5 (b29_19 XI1883_Bn XI1883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1883_MP4 (XI1883_p1 XI1883_An b29_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1883_MP2 (VDD dd19_b3_5 XI1883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1883_MP3 (XI1883_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1883_MP0 (VDD dd19_b3_5 XI1883_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1884_MP1 (VDD qu3_b3_3 XI1884_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1884_MP5 (b29_20 XI1884_Bn XI1884_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1884_MP4 (XI1884_p1 XI1884_An b29_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1884_MP2 (VDD dd20_b3_5 XI1884_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1884_MP3 (XI1884_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1884_MP0 (VDD dd20_b3_5 XI1884_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1886_MP1 (VDD qu3_b3_3 XI1886_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1886_MP5 (b29_22 XI1886_Bn XI1886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1886_MP4 (XI1886_p1 XI1886_An b29_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1886_MP2 (VDD dd22_b3_5 XI1886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1886_MP3 (XI1886_p1 qu3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1886_MP0 (VDD dd22_b3_5 XI1886_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I219_MP1 (VDD I654_G15_0n XI654_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I219_MP5 (p2_16 XI654_I219_Bn XI654_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I219_MP4 (XI654_I219_p1 XI654_I219_An p2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I219_MP2 (VDD I654_pn16 XI654_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I219_MP3 (XI654_I219_p1 I654_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I219_MP0 (VDD I654_pn16 XI654_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I218_MP1 (VDD I608_G14_0n XI608_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I218_MP5 (p1_15 XI608_I218_Bn XI608_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I218_MP4 (XI608_I218_p1 XI608_I218_An p1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I218_MP2 (VDD I608_pn15 XI608_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I218_MP3 (XI608_I218_p1 I608_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I218_MP0 (VDD I608_pn15 XI608_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI548_MP1 (VDD VDD XI548_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI548_MP5 (b0_18 XI548_Bn XI548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI548_MP4 (XI548_p1 XI548_An b0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI548_MP2 (VDD dd18_b3_0 XI548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI548_MP3 (XI548_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI548_MP0 (VDD dd18_b3_0 XI548_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I219_MP1 (VDD I562_G15_0n XI562_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I219_MP5 (p0_16 XI562_I219_Bn XI562_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I219_MP4 (XI562_I219_p1 XI562_I219_An p0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I219_MP2 (VDD I562_pn16 XI562_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I219_MP3 (XI562_I219_p1 I562_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I219_MP0 (VDD I562_pn16 XI562_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1974_MP1 (VDD qu1_b3_3 XI1974_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1974_MP5 (b31_18 XI1974_Bn XI1974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1974_MP4 (XI1974_p1 XI1974_An b31_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1974_MP2 (VDD dd18_b3_5 XI1974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1974_MP3 (XI1974_p1 qu1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1974_MP0 (VDD dd18_b3_5 XI1974_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I219_MP1 (VDD I1942_G15_0n XI1942_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I219_MP5 (p30_16 XI1942_I219_Bn XI1942_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I219_MP4 (XI1942_I219_p1 XI1942_I219_An p30_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I219_MP2 (VDD I1942_pn16 XI1942_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I219_MP3 (XI1942_I219_p1 I1942_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I219_MP0 (VDD I1942_pn16 XI1942_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I216_MP1 (VDD I1896_G12_0n XI1896_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I216_MP5 (p29_13 XI1896_I216_Bn XI1896_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I216_MP4 (XI1896_I216_p1 XI1896_I216_An p29_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I216_MP2 (VDD I1896_pn13 XI1896_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I216_MP3 (XI1896_I216_p1 I1896_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I216_MP0 (VDD I1896_pn13 XI1896_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I218_MP1 (VDD I1896_G14_0n XI1896_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I218_MP5 (p29_15 XI1896_I218_Bn XI1896_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I218_MP4 (XI1896_I218_p1 XI1896_I218_An p29_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I218_MP2 (VDD I1896_pn15 XI1896_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I218_MP3 (XI1896_I218_p1 I1896_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I218_MP0 (VDD I1896_pn15 XI1896_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I217_MP1 (VDD I1896_G13_0n XI1896_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I217_MP5 (p29_14 XI1896_I217_Bn XI1896_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I217_MP4 (XI1896_I217_p1 XI1896_I217_An p29_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I217_MP2 (VDD I1896_pn14 XI1896_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I217_MP3 (XI1896_I217_p1 I1896_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I217_MP0 (VDD I1896_pn14 XI1896_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I219_MP1 (VDD I1896_G15_0n XI1896_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I219_MP5 (p29_16 XI1896_I219_Bn XI1896_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I219_MP4 (XI1896_I219_p1 XI1896_I219_An p29_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I219_MP2 (VDD I1896_pn16 XI1896_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I219_MP3 (XI1896_I219_p1 I1896_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I219_MP0 (VDD I1896_pn16 XI1896_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1898_MP1 (VDD c29_o XI1898_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1898_MP5 (p29_32 XI1898_Bn XI1898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1898_MP4 (XI1898_p1 XI1898_An p29_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1898_MP2 (VDD h29 XI1898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1898_MP3 (XI1898_p1 c29_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1898_MP0 (VDD h29 XI1898_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI685_MP1 (VDD qu29_b3_2 XI685_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI685_MP5 (b3_17 XI685_Bn XI685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI685_MP4 (XI685_p1 XI685_An b3_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI685_MP2 (VDD dd17_b3_0 XI685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI685_MP3 (XI685_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI685_MP0 (VDD dd17_b3_0 XI685_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI684_MP1 (VDD qu29_b3_2 XI684_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI684_MP5 (b3_16 XI684_Bn XI684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI684_MP4 (XI684_p1 XI684_An b3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI684_MP2 (VDD dd16_b3_0 XI684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI684_MP3 (XI684_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI684_MP0 (VDD dd16_b3_0 XI684_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I217_MP1 (VDD I654_G13_0n XI654_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I217_MP5 (p2_14 XI654_I217_Bn XI654_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I217_MP4 (XI654_I217_p1 XI654_I217_An p2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I217_MP2 (VDD I654_pn14 XI654_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I217_MP3 (XI654_I217_p1 I654_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I217_MP0 (VDD I654_pn14 XI654_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I218_MP1 (VDD I654_G14_0n XI654_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I218_MP5 (p2_15 XI654_I218_Bn XI654_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I218_MP4 (XI654_I218_p1 XI654_I218_An p2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I218_MP2 (VDD I654_pn15 XI654_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I218_MP3 (XI654_I218_p1 I654_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I218_MP0 (VDD I654_pn15 XI654_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI638_MP1 (VDD qu30_b3_2 XI638_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI638_MP5 (b2_16 XI638_Bn XI638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI638_MP4 (XI638_p1 XI638_An b2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI638_MP2 (VDD dd16_b3_0 XI638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI638_MP3 (XI638_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI638_MP0 (VDD dd16_b3_0 XI638_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI639_MP1 (VDD qu30_b3_2 XI639_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI639_MP5 (b2_17 XI639_Bn XI639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI639_MP4 (XI639_p1 XI639_An b2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI639_MP2 (VDD dd17_b3_0 XI639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI639_MP3 (XI639_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI639_MP0 (VDD dd17_b3_0 XI639_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I217_MP1 (VDD I608_G13_0n XI608_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I217_MP5 (p1_14 XI608_I217_Bn XI608_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I217_MP4 (XI608_I217_p1 XI608_I217_An p1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I217_MP2 (VDD I608_pn14 XI608_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I217_MP3 (XI608_I217_p1 I608_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I217_MP0 (VDD I608_pn14 XI608_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI593_MP1 (VDD qu31_b3_2 XI593_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI593_MP5 (b1_17 XI593_Bn XI593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI593_MP4 (XI593_p1 XI593_An b1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI593_MP2 (VDD dd17_b3_0 XI593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI593_MP3 (XI593_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI593_MP0 (VDD dd17_b3_0 XI593_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI592_MP1 (VDD qu31_b3_2 XI592_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI592_MP5 (b1_16 XI592_Bn XI592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI592_MP4 (XI592_p1 XI592_An b1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI592_MP2 (VDD dd16_b3_0 XI592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI592_MP3 (XI592_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI592_MP0 (VDD dd16_b3_0 XI592_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI547_MP1 (VDD VDD XI547_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI547_MP5 (b0_17 XI547_Bn XI547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI547_MP4 (XI547_p1 XI547_An b0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI547_MP2 (VDD dd17_b3_0 XI547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI547_MP3 (XI547_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI547_MP0 (VDD dd17_b3_0 XI547_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I218_MP1 (VDD I562_G14_0n XI562_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I218_MP5 (p0_15 XI562_I218_Bn XI562_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I218_MP4 (XI562_I218_p1 XI562_I218_An p0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I218_MP2 (VDD I562_pn15 XI562_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I218_MP3 (XI562_I218_p1 I562_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I218_MP0 (VDD I562_pn15 XI562_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I217_MP1 (VDD I562_G13_0n XI562_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I217_MP5 (p0_14 XI562_I217_Bn XI562_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I217_MP4 (XI562_I217_p1 XI562_I217_An p0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I217_MP2 (VDD I562_pn14 XI562_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I217_MP3 (XI562_I217_p1 I562_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I217_MP0 (VDD I562_pn14 XI562_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I215_MP1 (VDD I2066_G11_0n XI2066_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I215_MP5 (ru12 XI2066_I215_Bn XI2066_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I215_MP4 (XI2066_I215_p1 XI2066_I215_An ru12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I215_MP2 (VDD I2066_pn12 XI2066_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I215_MP3 (XI2066_I215_p1 I2066_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I215_MP0 (VDD I2066_pn12 XI2066_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I216_MP1 (VDD I2066_G12_0n XI2066_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I216_MP5 (ru13 XI2066_I216_Bn XI2066_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I216_MP4 (XI2066_I216_p1 XI2066_I216_An ru13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I216_MP2 (VDD I2066_pn13 XI2066_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I216_MP3 (XI2066_I216_p1 I2066_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I216_MP0 (VDD I2066_pn13 XI2066_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I218_MP1 (VDD I1988_G14_0n XI1988_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I218_MP5 (p31_15 XI1988_I218_Bn XI1988_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I218_MP4 (XI1988_I218_p1 XI1988_I218_An p31_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I218_MP2 (VDD I1988_pn15 XI1988_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I218_MP3 (XI1988_I218_p1 I1988_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I218_MP0 (VDD I1988_pn15 XI1988_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I219_MP1 (VDD I1988_G15_0n XI1988_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I219_MP5 (p31_16 XI1988_I219_Bn XI1988_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I219_MP4 (XI1988_I219_p1 XI1988_I219_An p31_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I219_MP2 (VDD I1988_pn16 XI1988_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I219_MP3 (XI1988_I219_p1 I1988_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I219_MP0 (VDD I1988_pn16 XI1988_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1972_MP1 (VDD qu1_b3_2 XI1972_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1972_MP5 (b31_16 XI1972_Bn XI1972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1972_MP4 (XI1972_p1 XI1972_An b31_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1972_MP2 (VDD dd16_b3_5 XI1972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1972_MP3 (XI1972_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1972_MP0 (VDD dd16_b3_5 XI1972_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1973_MP1 (VDD qu1_b3_2 XI1973_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1973_MP5 (b31_17 XI1973_Bn XI1973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1973_MP4 (XI1973_p1 XI1973_An b31_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1973_MP2 (VDD dd17_b3_5 XI1973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1973_MP3 (XI1973_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1973_MP0 (VDD dd17_b3_5 XI1973_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I218_MP1 (VDD I1942_G14_0n XI1942_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I218_MP5 (p30_15 XI1942_I218_Bn XI1942_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I218_MP4 (XI1942_I218_p1 XI1942_I218_An p30_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I218_MP2 (VDD I1942_pn15 XI1942_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I218_MP3 (XI1942_I218_p1 I1942_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I218_MP0 (VDD I1942_pn15 XI1942_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I217_MP1 (VDD I1942_G13_0n XI1942_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I217_MP5 (p30_14 XI1942_I217_Bn XI1942_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I217_MP4 (XI1942_I217_p1 XI1942_I217_An p30_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I217_MP2 (VDD I1942_pn14 XI1942_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I217_MP3 (XI1942_I217_p1 I1942_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I217_MP0 (VDD I1942_pn14 XI1942_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1926_MP1 (VDD qu2_b3_2 XI1926_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1926_MP5 (b30_16 XI1926_Bn XI1926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1926_MP4 (XI1926_p1 XI1926_An b30_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1926_MP2 (VDD dd16_b3_5 XI1926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1926_MP3 (XI1926_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1926_MP0 (VDD dd16_b3_5 XI1926_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1927_MP1 (VDD qu2_b3_2 XI1927_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1927_MP5 (b30_17 XI1927_Bn XI1927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1927_MP4 (XI1927_p1 XI1927_An b30_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1927_MP2 (VDD dd17_b3_5 XI1927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1927_MP3 (XI1927_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1927_MP0 (VDD dd17_b3_5 XI1927_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I214_MP1 (VDD I1896_G10_0n XI1896_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I214_MP5 (p29_11 XI1896_I214_Bn XI1896_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I214_MP4 (XI1896_I214_p1 XI1896_I214_An p29_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I214_MP2 (VDD I1896_pn11 XI1896_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I214_MP3 (XI1896_I214_p1 I1896_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I214_MP0 (VDD I1896_pn11 XI1896_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I215_MP1 (VDD I1896_G11_0n XI1896_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I215_MP5 (p29_12 XI1896_I215_Bn XI1896_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I215_MP4 (XI1896_I215_p1 XI1896_I215_An p29_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I215_MP2 (VDD I1896_pn12 XI1896_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I215_MP3 (XI1896_I215_p1 I1896_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I215_MP0 (VDD I1896_pn12 XI1896_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1881_MP1 (VDD qu3_b3_2 XI1881_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1881_MP5 (b29_17 XI1881_Bn XI1881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1881_MP4 (XI1881_p1 XI1881_An b29_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1881_MP2 (VDD dd17_b3_5 XI1881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1881_MP3 (XI1881_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1881_MP0 (VDD dd17_b3_5 XI1881_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1897_MP1 (VDD qu3_b3_5 XI1897_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1897_MP5 (h29 XI1897_Bn XI1897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1897_MP4 (XI1897_p1 XI1897_An h29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1897_MP2 (VDD p28_31 XI1897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1897_MP3 (XI1897_p1 qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1897_MP0 (VDD p28_31 XI1897_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I215_MP1 (VDD I654_G11_0n XI654_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I215_MP5 (p2_12 XI654_I215_Bn XI654_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I215_MP4 (XI654_I215_p1 XI654_I215_An p2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I215_MP2 (VDD I654_pn12 XI654_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I215_MP3 (XI654_I215_p1 I654_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I215_MP0 (VDD I654_pn12 XI654_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI682_MP1 (VDD qu29_b3_2 XI682_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI682_MP5 (b3_14 XI682_Bn XI682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI682_MP4 (XI682_p1 XI682_An b3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI682_MP2 (VDD dd14_b3_0 XI682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI682_MP3 (XI682_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI682_MP0 (VDD dd14_b3_0 XI682_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI683_MP1 (VDD qu29_b3_2 XI683_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI683_MP5 (b3_15 XI683_Bn XI683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI683_MP4 (XI683_p1 XI683_An b3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI683_MP2 (VDD dd15_b3_0 XI683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI683_MP3 (XI683_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI683_MP0 (VDD dd15_b3_0 XI683_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I216_MP1 (VDD I654_G12_0n XI654_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I216_MP5 (p2_13 XI654_I216_Bn XI654_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I216_MP4 (XI654_I216_p1 XI654_I216_An p2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I216_MP2 (VDD I654_pn13 XI654_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I216_MP3 (XI654_I216_p1 I654_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I216_MP0 (VDD I654_pn13 XI654_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI637_MP1 (VDD qu30_b3_2 XI637_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI637_MP5 (b2_15 XI637_Bn XI637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI637_MP4 (XI637_p1 XI637_An b2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI637_MP2 (VDD dd15_b3_0 XI637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI637_MP3 (XI637_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI637_MP0 (VDD dd15_b3_0 XI637_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI636_MP1 (VDD qu30_b3_2 XI636_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI636_MP5 (b2_14 XI636_Bn XI636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI636_MP4 (XI636_p1 XI636_An b2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI636_MP2 (VDD dd14_b3_0 XI636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI636_MP3 (XI636_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI636_MP0 (VDD dd14_b3_0 XI636_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I215_MP1 (VDD I608_G11_0n XI608_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I215_MP5 (p1_12 XI608_I215_Bn XI608_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I215_MP4 (XI608_I215_p1 XI608_I215_An p1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I215_MP2 (VDD I608_pn12 XI608_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I215_MP3 (XI608_I215_p1 I608_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I215_MP0 (VDD I608_pn12 XI608_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I216_MP1 (VDD I608_G12_0n XI608_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I216_MP5 (p1_13 XI608_I216_Bn XI608_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I216_MP4 (XI608_I216_p1 XI608_I216_An p1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I216_MP2 (VDD I608_pn13 XI608_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I216_MP3 (XI608_I216_p1 I608_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I216_MP0 (VDD I608_pn13 XI608_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI591_MP1 (VDD qu31_b3_2 XI591_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI591_MP5 (b1_15 XI591_Bn XI591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI591_MP4 (XI591_p1 XI591_An b1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI591_MP2 (VDD dd15_b3_0 XI591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI591_MP3 (XI591_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI591_MP0 (VDD dd15_b3_0 XI591_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI545_MP1 (VDD VDD XI545_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI545_MP5 (b0_15 XI545_Bn XI545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI545_MP4 (XI545_p1 XI545_An b0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI545_MP2 (VDD dd15_b3_0 XI545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI545_MP3 (XI545_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI545_MP0 (VDD dd15_b3_0 XI545_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI546_MP1 (VDD VDD XI546_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI546_MP5 (b0_16 XI546_Bn XI546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI546_MP4 (XI546_p1 XI546_An b0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI546_MP2 (VDD dd16_b3_0 XI546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI546_MP3 (XI546_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI546_MP0 (VDD dd16_b3_0 XI546_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I216_MP1 (VDD I562_G12_0n XI562_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I216_MP5 (p0_13 XI562_I216_Bn XI562_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I216_MP4 (XI562_I216_p1 XI562_I216_An p0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I216_MP2 (VDD I562_pn13 XI562_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I216_MP3 (XI562_I216_p1 I562_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I216_MP0 (VDD I562_pn13 XI562_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I215_MP1 (VDD I562_G11_0n XI562_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I215_MP5 (p0_12 XI562_I215_Bn XI562_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I215_MP4 (XI562_I215_p1 XI562_I215_An p0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I215_MP2 (VDD I562_pn12 XI562_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I215_MP3 (XI562_I215_p1 I562_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I215_MP0 (VDD I562_pn12 XI562_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I217_MP1 (VDD I1988_G13_0n XI1988_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I217_MP5 (p31_14 XI1988_I217_Bn XI1988_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I217_MP4 (XI1988_I217_p1 XI1988_I217_An p31_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I217_MP2 (VDD I1988_pn14 XI1988_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I217_MP3 (XI1988_I217_p1 I1988_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I217_MP0 (VDD I1988_pn14 XI1988_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1970_MP1 (VDD qu1_b3_2 XI1970_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1970_MP5 (b31_14 XI1970_Bn XI1970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1970_MP4 (XI1970_p1 XI1970_An b31_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1970_MP2 (VDD dd14_b3_5 XI1970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1970_MP3 (XI1970_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1970_MP0 (VDD dd14_b3_5 XI1970_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1971_MP1 (VDD qu1_b3_2 XI1971_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1971_MP5 (b31_15 XI1971_Bn XI1971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1971_MP4 (XI1971_p1 XI1971_An b31_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1971_MP2 (VDD dd15_b3_5 XI1971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1971_MP3 (XI1971_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1971_MP0 (VDD dd15_b3_5 XI1971_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I216_MP1 (VDD I1942_G12_0n XI1942_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I216_MP5 (p30_13 XI1942_I216_Bn XI1942_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I216_MP4 (XI1942_I216_p1 XI1942_I216_An p30_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I216_MP2 (VDD I1942_pn13 XI1942_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I216_MP3 (XI1942_I216_p1 I1942_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I216_MP0 (VDD I1942_pn13 XI1942_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I215_MP1 (VDD I1942_G11_0n XI1942_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I215_MP5 (p30_12 XI1942_I215_Bn XI1942_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I215_MP4 (XI1942_I215_p1 XI1942_I215_An p30_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I215_MP2 (VDD I1942_pn12 XI1942_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I215_MP3 (XI1942_I215_p1 I1942_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I215_MP0 (VDD I1942_pn12 XI1942_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1925_MP1 (VDD qu2_b3_2 XI1925_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1925_MP5 (b30_15 XI1925_Bn XI1925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1925_MP4 (XI1925_p1 XI1925_An b30_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1925_MP2 (VDD dd15_b3_5 XI1925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1925_MP3 (XI1925_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1925_MP0 (VDD dd15_b3_5 XI1925_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1924_MP1 (VDD qu2_b3_2 XI1924_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1924_MP5 (b30_14 XI1924_Bn XI1924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1924_MP4 (XI1924_p1 XI1924_An b30_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1924_MP2 (VDD dd14_b3_5 XI1924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1924_MP3 (XI1924_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1924_MP0 (VDD dd14_b3_5 XI1924_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I212_MP1 (VDD I1896_G8_0n XI1896_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I212_MP5 (p29_9 XI1896_I212_Bn XI1896_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I212_MP4 (XI1896_I212_p1 XI1896_I212_An p29_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I212_MP2 (VDD I1896_pn9 XI1896_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I212_MP3 (XI1896_I212_p1 I1896_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I212_MP0 (VDD I1896_pn9 XI1896_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I213_MP1 (VDD I1896_G9_0n XI1896_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I213_MP5 (p29_10 XI1896_I213_Bn XI1896_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I213_MP4 (XI1896_I213_p1 XI1896_I213_An p29_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I213_MP2 (VDD I1896_pn10 XI1896_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I213_MP3 (XI1896_I213_p1 I1896_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I213_MP0 (VDD I1896_pn10 XI1896_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1878_MP1 (VDD qu3_b3_2 XI1878_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1878_MP5 (b29_14 XI1878_Bn XI1878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1878_MP4 (XI1878_p1 XI1878_An b29_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1878_MP2 (VDD dd14_b3_5 XI1878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1878_MP3 (XI1878_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1878_MP0 (VDD dd14_b3_5 XI1878_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1880_MP1 (VDD qu3_b3_2 XI1880_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1880_MP5 (b29_16 XI1880_Bn XI1880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1880_MP4 (XI1880_p1 XI1880_An b29_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1880_MP2 (VDD dd16_b3_5 XI1880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1880_MP3 (XI1880_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1880_MP0 (VDD dd16_b3_5 XI1880_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI681_MP1 (VDD qu29_b3_2 XI681_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI681_MP5 (b3_13 XI681_Bn XI681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI681_MP4 (XI681_p1 XI681_An b3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI681_MP2 (VDD dd13_b3_0 XI681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI681_MP3 (XI681_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI681_MP0 (VDD dd13_b3_0 XI681_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI680_MP1 (VDD qu29_b3_2 XI680_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI680_MP5 (b3_12 XI680_Bn XI680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI680_MP4 (XI680_p1 XI680_An b3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI680_MP2 (VDD dd12_b3_0 XI680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI680_MP3 (XI680_p1 qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI680_MP0 (VDD dd12_b3_0 XI680_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I214_MP1 (VDD I654_G10_0n XI654_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I214_MP5 (p2_11 XI654_I214_Bn XI654_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I214_MP4 (XI654_I214_p1 XI654_I214_An p2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I214_MP2 (VDD I654_pn11 XI654_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I214_MP3 (XI654_I214_p1 I654_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I214_MP0 (VDD I654_pn11 XI654_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI635_MP1 (VDD qu30_b3_2 XI635_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI635_MP5 (b2_13 XI635_Bn XI635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI635_MP4 (XI635_p1 XI635_An b2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI635_MP2 (VDD dd13_b3_0 XI635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI635_MP3 (XI635_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI635_MP0 (VDD dd13_b3_0 XI635_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI634_MP1 (VDD qu30_b3_2 XI634_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI634_MP5 (b2_12 XI634_Bn XI634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI634_MP4 (XI634_p1 XI634_An b2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI634_MP2 (VDD dd12_b3_0 XI634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI634_MP3 (XI634_p1 qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI634_MP0 (VDD dd12_b3_0 XI634_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I213_MP1 (VDD I608_G9_0n XI608_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I213_MP5 (p1_10 XI608_I213_Bn XI608_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I213_MP4 (XI608_I213_p1 XI608_I213_An p1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I213_MP2 (VDD I608_pn10 XI608_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I213_MP3 (XI608_I213_p1 I608_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I213_MP0 (VDD I608_pn10 XI608_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I214_MP1 (VDD I608_G10_0n XI608_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I214_MP5 (p1_11 XI608_I214_Bn XI608_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I214_MP4 (XI608_I214_p1 XI608_I214_An p1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I214_MP2 (VDD I608_pn11 XI608_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I214_MP3 (XI608_I214_p1 I608_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I214_MP0 (VDD I608_pn11 XI608_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI589_MP1 (VDD qu31_b3_2 XI589_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI589_MP5 (b1_13 XI589_Bn XI589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI589_MP4 (XI589_p1 XI589_An b1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI589_MP2 (VDD dd13_b3_0 XI589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI589_MP3 (XI589_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI589_MP0 (VDD dd13_b3_0 XI589_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI590_MP1 (VDD qu31_b3_2 XI590_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI590_MP5 (b1_14 XI590_Bn XI590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI590_MP4 (XI590_p1 XI590_An b1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI590_MP2 (VDD dd14_b3_0 XI590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI590_MP3 (XI590_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI590_MP0 (VDD dd14_b3_0 XI590_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI544_MP1 (VDD VDD XI544_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI544_MP5 (b0_14 XI544_Bn XI544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI544_MP4 (XI544_p1 XI544_An b0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI544_MP2 (VDD dd14_b3_0 XI544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI544_MP3 (XI544_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI544_MP0 (VDD dd14_b3_0 XI544_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI543_MP1 (VDD VDD XI543_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI543_MP5 (b0_13 XI543_Bn XI543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI543_MP4 (XI543_p1 XI543_An b0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI543_MP2 (VDD dd13_b3_0 XI543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI543_MP3 (XI543_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI543_MP0 (VDD dd13_b3_0 XI543_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I213_MP1 (VDD I2066_G9_0n XI2066_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I213_MP5 (ru10 XI2066_I213_Bn XI2066_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I213_MP4 (XI2066_I213_p1 XI2066_I213_An ru10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I213_MP2 (VDD I2066_pn10 XI2066_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I213_MP3 (XI2066_I213_p1 I2066_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I213_MP0 (VDD I2066_pn10 XI2066_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I214_MP1 (VDD I2066_G10_0n XI2066_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I214_MP5 (ru11 XI2066_I214_Bn XI2066_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I214_MP4 (XI2066_I214_p1 XI2066_I214_An ru11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I214_MP2 (VDD I2066_pn11 XI2066_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I214_MP3 (XI2066_I214_p1 I2066_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I214_MP0 (VDD I2066_pn11 XI2066_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I212_MP1 (VDD I2066_G8_0n XI2066_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I212_MP5 (ru9 XI2066_I212_Bn XI2066_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I212_MP4 (XI2066_I212_p1 XI2066_I212_An ru9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I212_MP2 (VDD I2066_pn9 XI2066_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I212_MP3 (XI2066_I212_p1 I2066_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I212_MP0 (VDD I2066_pn9 XI2066_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I216_MP1 (VDD I1988_G12_0n XI1988_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I216_MP5 (p31_13 XI1988_I216_Bn XI1988_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I216_MP4 (XI1988_I216_p1 XI1988_I216_An p31_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I216_MP2 (VDD I1988_pn13 XI1988_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I216_MP3 (XI1988_I216_p1 I1988_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I216_MP0 (VDD I1988_pn13 XI1988_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I215_MP1 (VDD I1988_G11_0n XI1988_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I215_MP5 (p31_12 XI1988_I215_Bn XI1988_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I215_MP4 (XI1988_I215_p1 XI1988_I215_An p31_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I215_MP2 (VDD I1988_pn12 XI1988_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I215_MP3 (XI1988_I215_p1 I1988_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I215_MP0 (VDD I1988_pn12 XI1988_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1969_MP1 (VDD qu1_b3_2 XI1969_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1969_MP5 (b31_13 XI1969_Bn XI1969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1969_MP4 (XI1969_p1 XI1969_An b31_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1969_MP2 (VDD dd13_b3_5 XI1969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1969_MP3 (XI1969_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1969_MP0 (VDD dd13_b3_5 XI1969_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1968_MP1 (VDD qu1_b3_2 XI1968_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1968_MP5 (b31_12 XI1968_Bn XI1968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1968_MP4 (XI1968_p1 XI1968_An b31_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1968_MP2 (VDD dd12_b3_5 XI1968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1968_MP3 (XI1968_p1 qu1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1968_MP0 (VDD dd12_b3_5 XI1968_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I214_MP1 (VDD I1942_G10_0n XI1942_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I214_MP5 (p30_11 XI1942_I214_Bn XI1942_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I214_MP4 (XI1942_I214_p1 XI1942_I214_An p30_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I214_MP2 (VDD I1942_pn11 XI1942_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I214_MP3 (XI1942_I214_p1 I1942_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I214_MP0 (VDD I1942_pn11 XI1942_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1922_MP1 (VDD qu2_b3_2 XI1922_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1922_MP5 (b30_12 XI1922_Bn XI1922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1922_MP4 (XI1922_p1 XI1922_An b30_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1922_MP2 (VDD dd12_b3_5 XI1922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1922_MP3 (XI1922_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1922_MP0 (VDD dd12_b3_5 XI1922_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1923_MP1 (VDD qu2_b3_2 XI1923_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1923_MP5 (b30_13 XI1923_Bn XI1923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1923_MP4 (XI1923_p1 XI1923_An b30_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1923_MP2 (VDD dd13_b3_5 XI1923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1923_MP3 (XI1923_p1 qu2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1923_MP0 (VDD dd13_b3_5 XI1923_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1876_MP1 (VDD qu3_b3_2 XI1876_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1876_MP5 (b29_12 XI1876_Bn XI1876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1876_MP4 (XI1876_p1 XI1876_An b29_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1876_MP2 (VDD dd12_b3_5 XI1876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1876_MP3 (XI1876_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1876_MP0 (VDD dd12_b3_5 XI1876_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1877_MP1 (VDD qu3_b3_2 XI1877_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1877_MP5 (b29_13 XI1877_Bn XI1877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1877_MP4 (XI1877_p1 XI1877_An b29_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1877_MP2 (VDD dd13_b3_5 XI1877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1877_MP3 (XI1877_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1877_MP0 (VDD dd13_b3_5 XI1877_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I215_MP1 (VDD I1850_G11_0n XI1850_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I215_MP5 (p28_12 XI1850_I215_Bn XI1850_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I215_MP4 (XI1850_I215_p1 XI1850_I215_An p28_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I215_MP2 (VDD I1850_pn12 XI1850_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I215_MP3 (XI1850_I215_p1 I1850_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I215_MP0 (VDD I1850_pn12 XI1850_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1879_MP1 (VDD qu3_b3_2 XI1879_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1879_MP5 (b29_15 XI1879_Bn XI1879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1879_MP4 (XI1879_p1 XI1879_An b29_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1879_MP2 (VDD dd15_b3_5 XI1879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1879_MP3 (XI1879_p1 qu3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1879_MP0 (VDD dd15_b3_5 XI1879_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I219_MP1 (VDD I1850_G15_0n XI1850_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I219_MP5 (p28_16 XI1850_I219_Bn XI1850_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I219_MP4 (XI1850_I219_p1 XI1850_I219_An p28_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I219_MP2 (VDD I1850_pn16 XI1850_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I219_MP3 (XI1850_I219_p1 I1850_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I219_MP0 (VDD I1850_pn16 XI1850_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1852_MP1 (VDD c28_o XI1852_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1852_MP5 (p28_32 XI1852_Bn XI1852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1852_MP4 (XI1852_p1 XI1852_An p28_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1852_MP2 (VDD h28 XI1852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1852_MP3 (XI1852_p1 c28_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1852_MP0 (VDD h28 XI1852_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I219_MP1 (VDD I700_G15_0n XI700_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I219_MP5 (p3_16 XI700_I219_Bn XI700_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I219_MP4 (XI700_I219_p1 XI700_I219_An p3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I219_MP2 (VDD I700_pn16 XI700_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I219_MP3 (XI700_I219_p1 I700_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I219_MP0 (VDD I700_pn16 XI700_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I213_MP1 (VDD I654_G9_0n XI654_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I213_MP5 (p2_10 XI654_I213_Bn XI654_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I213_MP4 (XI654_I213_p1 XI654_I213_An p2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I213_MP2 (VDD I654_pn10 XI654_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I213_MP3 (XI654_I213_p1 I654_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I213_MP0 (VDD I654_pn10 XI654_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I212_MP1 (VDD I654_G8_0n XI654_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I212_MP5 (p2_9 XI654_I212_Bn XI654_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I212_MP4 (XI654_I212_p1 XI654_I212_An p2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I212_MP2 (VDD I654_pn9 XI654_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I212_MP3 (XI654_I212_p1 I654_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I212_MP0 (VDD I654_pn9 XI654_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I212_MP1 (VDD I608_G8_0n XI608_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I212_MP5 (p1_9 XI608_I212_Bn XI608_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I212_MP4 (XI608_I212_p1 XI608_I212_An p1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I212_MP2 (VDD I608_pn9 XI608_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I212_MP3 (XI608_I212_p1 I608_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I212_MP0 (VDD I608_pn9 XI608_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI588_MP1 (VDD qu31_b3_2 XI588_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI588_MP5 (b1_12 XI588_Bn XI588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI588_MP4 (XI588_p1 XI588_An b1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI588_MP2 (VDD dd12_b3_0 XI588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI588_MP3 (XI588_p1 qu31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI588_MP0 (VDD dd12_b3_0 XI588_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI542_MP1 (VDD VDD XI542_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI542_MP5 (b0_12 XI542_Bn XI542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI542_MP4 (XI542_p1 XI542_An b0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI542_MP2 (VDD dd12_b3_0 XI542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI542_MP3 (XI542_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI542_MP0 (VDD dd12_b3_0 XI542_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I214_MP1 (VDD I562_G10_0n XI562_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I214_MP5 (p0_11 XI562_I214_Bn XI562_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I214_MP4 (XI562_I214_p1 XI562_I214_An p0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I214_MP2 (VDD I562_pn11 XI562_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I214_MP3 (XI562_I214_p1 I562_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I214_MP0 (VDD I562_pn11 XI562_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I213_MP1 (VDD I562_G9_0n XI562_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I213_MP5 (p0_10 XI562_I213_Bn XI562_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I213_MP4 (XI562_I213_p1 XI562_I213_An p0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I213_MP2 (VDD I562_pn10 XI562_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I213_MP3 (XI562_I213_p1 I562_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I213_MP0 (VDD I562_pn10 XI562_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I214_MP1 (VDD I1988_G10_0n XI1988_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I214_MP5 (p31_11 XI1988_I214_Bn XI1988_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I214_MP4 (XI1988_I214_p1 XI1988_I214_An p31_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I214_MP2 (VDD I1988_pn11 XI1988_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I214_MP3 (XI1988_I214_p1 I1988_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I214_MP0 (VDD I1988_pn11 XI1988_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I213_MP1 (VDD I1988_G9_0n XI1988_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I213_MP5 (p31_10 XI1988_I213_Bn XI1988_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I213_MP4 (XI1988_I213_p1 XI1988_I213_An p31_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I213_MP2 (VDD I1988_pn10 XI1988_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I213_MP3 (XI1988_I213_p1 I1988_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I213_MP0 (VDD I1988_pn10 XI1988_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I212_MP1 (VDD I1942_G8_0n XI1942_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I212_MP5 (p30_9 XI1942_I212_Bn XI1942_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I212_MP4 (XI1942_I212_p1 XI1942_I212_An p30_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I212_MP2 (VDD I1942_pn9 XI1942_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I212_MP3 (XI1942_I212_p1 I1942_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I212_MP0 (VDD I1942_pn9 XI1942_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I213_MP1 (VDD I1942_G9_0n XI1942_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I213_MP5 (p30_10 XI1942_I213_Bn XI1942_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I213_MP4 (XI1942_I213_p1 XI1942_I213_An p30_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I213_MP2 (VDD I1942_pn10 XI1942_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I213_MP3 (XI1942_I213_p1 I1942_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I213_MP0 (VDD I1942_pn10 XI1942_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1875_MP1 (VDD qu3_b3_1 XI1875_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1875_MP5 (b29_11 XI1875_Bn XI1875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1875_MP4 (XI1875_p1 XI1875_An b29_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1875_MP2 (VDD dd11_b3_5 XI1875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1875_MP3 (XI1875_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1875_MP0 (VDD dd11_b3_5 XI1875_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1874_MP1 (VDD qu3_b3_1 XI1874_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1874_MP5 (b29_10 XI1874_Bn XI1874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1874_MP4 (XI1874_p1 XI1874_An b29_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1874_MP2 (VDD dd10_b3_5 XI1874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1874_MP3 (XI1874_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1874_MP0 (VDD dd10_b3_5 XI1874_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I213_MP1 (VDD I1850_G9_0n XI1850_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I213_MP5 (p28_10 XI1850_I213_Bn XI1850_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I213_MP4 (XI1850_I213_p1 XI1850_I213_An p28_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I213_MP2 (VDD I1850_pn10 XI1850_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I213_MP3 (XI1850_I213_p1 I1850_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I213_MP0 (VDD I1850_pn10 XI1850_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I217_MP1 (VDD I1850_G13_0n XI1850_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I217_MP5 (p28_14 XI1850_I217_Bn XI1850_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I217_MP4 (XI1850_I217_p1 XI1850_I217_An p28_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I217_MP2 (VDD I1850_pn14 XI1850_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I217_MP3 (XI1850_I217_p1 I1850_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I217_MP0 (VDD I1850_pn14 XI1850_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I217_MP1 (VDD I700_G13_0n XI700_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I217_MP5 (p3_14 XI700_I217_Bn XI700_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I217_MP4 (XI700_I217_p1 XI700_I217_An p3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I217_MP2 (VDD I700_pn14 XI700_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I217_MP3 (XI700_I217_p1 I700_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I217_MP0 (VDD I700_pn14 XI700_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI679_MP1 (VDD qu29_b3_1 XI679_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI679_MP5 (b3_11 XI679_Bn XI679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI679_MP4 (XI679_p1 XI679_An b3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI679_MP2 (VDD dd11_b3_0 XI679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI679_MP3 (XI679_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI679_MP0 (VDD dd11_b3_0 XI679_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI678_MP1 (VDD qu29_b3_1 XI678_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI678_MP5 (b3_10 XI678_Bn XI678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI678_MP4 (XI678_p1 XI678_An b3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI678_MP2 (VDD dd10_b3_0 XI678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI678_MP3 (XI678_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI678_MP0 (VDD dd10_b3_0 XI678_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI632_MP1 (VDD qu30_b3_1 XI632_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI632_MP5 (b2_10 XI632_Bn XI632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI632_MP4 (XI632_p1 XI632_An b2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI632_MP2 (VDD dd10_b3_0 XI632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI632_MP3 (XI632_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI632_MP0 (VDD dd10_b3_0 XI632_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI587_MP1 (VDD qu31_b3_1 XI587_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI587_MP5 (b1_11 XI587_Bn XI587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI587_MP4 (XI587_p1 XI587_An b1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI587_MP2 (VDD dd11_b3_0 XI587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI587_MP3 (XI587_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI587_MP0 (VDD dd11_b3_0 XI587_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I212_MP1 (VDD I562_G8_0n XI562_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I212_MP5 (p0_9 XI562_I212_Bn XI562_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I212_MP4 (XI562_I212_p1 XI562_I212_An p0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I212_MP2 (VDD I562_pn9 XI562_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I212_MP3 (XI562_I212_p1 I562_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I212_MP0 (VDD I562_pn9 XI562_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI541_MP1 (VDD VDD XI541_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI541_MP5 (b0_11 XI541_Bn XI541_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI541_MP4 (XI541_p1 XI541_An b0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI541_MP2 (VDD dd11_b3_0 XI541_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI541_MP3 (XI541_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI541_MP0 (VDD dd11_b3_0 XI541_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I207_MP1 (VDD I2066_G3_0n XI2066_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I207_MP5 (ru4 XI2066_I207_Bn XI2066_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I207_MP4 (XI2066_I207_p1 XI2066_I207_An ru4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I207_MP2 (VDD I2066_pn4 XI2066_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I207_MP3 (XI2066_I207_p1 I2066_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I207_MP0 (VDD I2066_pn4 XI2066_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I212_MP1 (VDD I1988_G8_0n XI1988_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I212_MP5 (p31_9 XI1988_I212_Bn XI1988_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I212_MP4 (XI1988_I212_p1 XI1988_I212_An p31_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I212_MP2 (VDD I1988_pn9 XI1988_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I212_MP3 (XI1988_I212_p1 I1988_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I212_MP0 (VDD I1988_pn9 XI1988_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1966_MP1 (VDD qu1_b3_1 XI1966_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1966_MP5 (b31_10 XI1966_Bn XI1966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1966_MP4 (XI1966_p1 XI1966_An b31_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1966_MP2 (VDD dd10_b3_5 XI1966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1966_MP3 (XI1966_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1966_MP0 (VDD dd10_b3_5 XI1966_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1965_MP1 (VDD qu1_b3_1 XI1965_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1965_MP5 (b31_9 XI1965_Bn XI1965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1965_MP4 (XI1965_p1 XI1965_An b31_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1965_MP2 (VDD dd9_b3_5 XI1965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1965_MP3 (XI1965_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1965_MP0 (VDD dd9_b3_5 XI1965_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1967_MP1 (VDD qu1_b3_1 XI1967_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1967_MP5 (b31_11 XI1967_Bn XI1967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1967_MP4 (XI1967_p1 XI1967_An b31_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1967_MP2 (VDD dd11_b3_5 XI1967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1967_MP3 (XI1967_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1967_MP0 (VDD dd11_b3_5 XI1967_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1920_MP1 (VDD qu2_b3_1 XI1920_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1920_MP5 (b30_10 XI1920_Bn XI1920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1920_MP4 (XI1920_p1 XI1920_An b30_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1920_MP2 (VDD dd10_b3_5 XI1920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1920_MP3 (XI1920_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1920_MP0 (VDD dd10_b3_5 XI1920_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1919_MP1 (VDD qu2_b3_1 XI1919_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1919_MP5 (b30_9 XI1919_Bn XI1919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1919_MP4 (XI1919_p1 XI1919_An b30_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1919_MP2 (VDD dd9_b3_5 XI1919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1919_MP3 (XI1919_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1919_MP0 (VDD dd9_b3_5 XI1919_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1921_MP1 (VDD qu2_b3_1 XI1921_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1921_MP5 (b30_11 XI1921_Bn XI1921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1921_MP4 (XI1921_p1 XI1921_An b30_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1921_MP2 (VDD dd11_b3_5 XI1921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1921_MP3 (XI1921_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1921_MP0 (VDD dd11_b3_5 XI1921_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1873_MP1 (VDD qu3_b3_1 XI1873_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1873_MP5 (b29_9 XI1873_Bn XI1873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1873_MP4 (XI1873_p1 XI1873_An b29_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1873_MP2 (VDD dd9_b3_5 XI1873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1873_MP3 (XI1873_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1873_MP0 (VDD dd9_b3_5 XI1873_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I215_MP1 (VDD I700_G11_0n XI700_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I215_MP5 (p3_12 XI700_I215_Bn XI700_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I215_MP4 (XI700_I215_p1 XI700_I215_An p3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I215_MP2 (VDD I700_pn12 XI700_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I215_MP3 (XI700_I215_p1 I700_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I215_MP0 (VDD I700_pn12 XI700_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI677_MP1 (VDD qu29_b3_1 XI677_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI677_MP5 (b3_9 XI677_Bn XI677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI677_MP4 (XI677_p1 XI677_An b3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI677_MP2 (VDD dd9_b3_0 XI677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI677_MP3 (XI677_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI677_MP0 (VDD dd9_b3_0 XI677_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI676_MP1 (VDD qu29_b3_1 XI676_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI676_MP5 (b3_8 XI676_Bn XI676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI676_MP4 (XI676_p1 XI676_An b3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI676_MP2 (VDD dd8_b3_0 XI676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI676_MP3 (XI676_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI676_MP0 (VDD dd8_b3_0 XI676_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI630_MP1 (VDD qu30_b3_1 XI630_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI630_MP5 (b2_8 XI630_Bn XI630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI630_MP4 (XI630_p1 XI630_An b2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI630_MP2 (VDD dd8_b3_0 XI630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI630_MP3 (XI630_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI630_MP0 (VDD dd8_b3_0 XI630_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI633_MP1 (VDD qu30_b3_1 XI633_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI633_MP5 (b2_11 XI633_Bn XI633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI633_MP4 (XI633_p1 XI633_An b2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI633_MP2 (VDD dd11_b3_0 XI633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI633_MP3 (XI633_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI633_MP0 (VDD dd11_b3_0 XI633_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI631_MP1 (VDD qu30_b3_1 XI631_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI631_MP5 (b2_9 XI631_Bn XI631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI631_MP4 (XI631_p1 XI631_An b2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI631_MP2 (VDD dd9_b3_0 XI631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI631_MP3 (XI631_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI631_MP0 (VDD dd9_b3_0 XI631_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I207_MP1 (VDD I608_G3_0n XI608_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I207_MP5 (p1_4 XI608_I207_Bn XI608_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I207_MP4 (XI608_I207_p1 XI608_I207_An p1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I207_MP2 (VDD I608_pn4 XI608_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I207_MP3 (XI608_I207_p1 I608_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I207_MP0 (VDD I608_pn4 XI608_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI584_MP1 (VDD qu31_b3_1 XI584_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI584_MP5 (b1_8 XI584_Bn XI584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI584_MP4 (XI584_p1 XI584_An b1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI584_MP2 (VDD dd8_b3_0 XI584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI584_MP3 (XI584_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI584_MP0 (VDD dd8_b3_0 XI584_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI585_MP1 (VDD qu31_b3_1 XI585_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI585_MP5 (b1_9 XI585_Bn XI585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI585_MP4 (XI585_p1 XI585_An b1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI585_MP2 (VDD dd9_b3_0 XI585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI585_MP3 (XI585_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI585_MP0 (VDD dd9_b3_0 XI585_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI586_MP1 (VDD qu31_b3_1 XI586_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI586_MP5 (b1_10 XI586_Bn XI586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI586_MP4 (XI586_p1 XI586_An b1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI586_MP2 (VDD dd10_b3_0 XI586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI586_MP3 (XI586_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI586_MP0 (VDD dd10_b3_0 XI586_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I207_MP1 (VDD I562_G3_0n XI562_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I207_MP5 (p0_4 XI562_I207_Bn XI562_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I207_MP4 (XI562_I207_p1 XI562_I207_An p0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I207_MP2 (VDD I562_pn4 XI562_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I207_MP3 (XI562_I207_p1 I562_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I207_MP0 (VDD I562_pn4 XI562_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI540_MP1 (VDD VDD XI540_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI540_MP5 (b0_10 XI540_Bn XI540_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI540_MP4 (XI540_p1 XI540_An b0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI540_MP2 (VDD dd10_b3_0 XI540_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI540_MP3 (XI540_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI540_MP0 (VDD dd10_b3_0 XI540_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I206_MP1 (VDD I2066_G2_0n XI2066_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I206_MP5 (ru3 XI2066_I206_Bn XI2066_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I206_MP4 (XI2066_I206_p1 XI2066_I206_An ru3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I206_MP2 (VDD I2066_pn3 XI2066_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I206_MP3 (XI2066_I206_p1 I2066_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I206_MP0 (VDD I2066_pn3 XI2066_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1963_MP1 (VDD qu1_b3_1 XI1963_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1963_MP5 (b31_7 XI1963_Bn XI1963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1963_MP4 (XI1963_p1 XI1963_An b31_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1963_MP2 (VDD dd7_b3_5 XI1963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1963_MP3 (XI1963_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1963_MP0 (VDD dd7_b3_5 XI1963_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1964_MP1 (VDD qu1_b3_1 XI1964_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1964_MP5 (b31_8 XI1964_Bn XI1964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1964_MP4 (XI1964_p1 XI1964_An b31_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1964_MP2 (VDD dd8_b3_5 XI1964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1964_MP3 (XI1964_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1964_MP0 (VDD dd8_b3_5 XI1964_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1917_MP1 (VDD qu2_b3_1 XI1917_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1917_MP5 (b30_7 XI1917_Bn XI1917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1917_MP4 (XI1917_p1 XI1917_An b30_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1917_MP2 (VDD dd7_b3_5 XI1917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1917_MP3 (XI1917_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1917_MP0 (VDD dd7_b3_5 XI1917_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1918_MP1 (VDD qu2_b3_1 XI1918_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1918_MP5 (b30_8 XI1918_Bn XI1918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1918_MP4 (XI1918_p1 XI1918_An b30_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1918_MP2 (VDD dd8_b3_5 XI1918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1918_MP3 (XI1918_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1918_MP0 (VDD dd8_b3_5 XI1918_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I207_MP1 (VDD I1896_G3_0n XI1896_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I207_MP5 (p29_4 XI1896_I207_Bn XI1896_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I207_MP4 (XI1896_I207_p1 XI1896_I207_An p29_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I207_MP2 (VDD I1896_pn4 XI1896_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I207_MP3 (XI1896_I207_p1 I1896_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I207_MP0 (VDD I1896_pn4 XI1896_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1870_MP1 (VDD qu3_b3_1 XI1870_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1870_MP5 (b29_6 XI1870_Bn XI1870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1870_MP4 (XI1870_p1 XI1870_An b29_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1870_MP2 (VDD dd6_b3_5 XI1870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1870_MP3 (XI1870_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1870_MP0 (VDD dd6_b3_5 XI1870_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1871_MP1 (VDD qu3_b3_1 XI1871_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1871_MP5 (b29_7 XI1871_Bn XI1871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1871_MP4 (XI1871_p1 XI1871_An b29_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1871_MP2 (VDD dd7_b3_5 XI1871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1871_MP3 (XI1871_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1871_MP0 (VDD dd7_b3_5 XI1871_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1872_MP1 (VDD qu3_b3_1 XI1872_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1872_MP5 (b29_8 XI1872_Bn XI1872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1872_MP4 (XI1872_p1 XI1872_An b29_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1872_MP2 (VDD dd8_b3_5 XI1872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1872_MP3 (XI1872_p1 qu3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1872_MP0 (VDD dd8_b3_5 XI1872_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I212_MP1 (VDD I1850_G8_0n XI1850_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I212_MP5 (p28_9 XI1850_I212_Bn XI1850_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I212_MP4 (XI1850_I212_p1 XI1850_I212_An p28_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I212_MP2 (VDD I1850_pn9 XI1850_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I212_MP3 (XI1850_I212_p1 I1850_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I212_MP0 (VDD I1850_pn9 XI1850_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I216_MP1 (VDD I1850_G12_0n XI1850_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I216_MP5 (p28_13 XI1850_I216_Bn XI1850_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I216_MP4 (XI1850_I216_p1 XI1850_I216_An p28_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I216_MP2 (VDD I1850_pn13 XI1850_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I216_MP3 (XI1850_I216_p1 I1850_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I216_MP0 (VDD I1850_pn13 XI1850_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI675_MP1 (VDD qu29_b3_1 XI675_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI675_MP5 (b3_7 XI675_Bn XI675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI675_MP4 (XI675_p1 XI675_An b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI675_MP2 (VDD dd7_b3_0 XI675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI675_MP3 (XI675_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI675_MP0 (VDD dd7_b3_0 XI675_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I207_MP1 (VDD I654_G3_0n XI654_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I207_MP5 (p2_4 XI654_I207_Bn XI654_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I207_MP4 (XI654_I207_p1 XI654_I207_An p2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I207_MP2 (VDD I654_pn4 XI654_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I207_MP3 (XI654_I207_p1 I654_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I207_MP0 (VDD I654_pn4 XI654_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI674_MP1 (VDD qu29_b3_1 XI674_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI674_MP5 (b3_6 XI674_Bn XI674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI674_MP4 (XI674_p1 XI674_An b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI674_MP2 (VDD dd6_b3_0 XI674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI674_MP3 (XI674_p1 qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI674_MP0 (VDD dd6_b3_0 XI674_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I206_MP1 (VDD I654_G2_0n XI654_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I206_MP5 (p2_3 XI654_I206_Bn XI654_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI654_I206_MP4 (XI654_I206_p1 XI654_I206_An p2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I206_MP2 (VDD I654_pn3 XI654_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI654_I206_MP3 (XI654_I206_p1 I654_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I206_MP0 (VDD I654_pn3 XI654_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI627_MP1 (VDD qu30_b3_0 XI627_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI627_MP5 (b2_5 XI627_Bn XI627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI627_MP4 (XI627_p1 XI627_An b2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI627_MP2 (VDD dd5_b3_0 XI627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI627_MP3 (XI627_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI627_MP0 (VDD dd5_b3_0 XI627_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI629_MP1 (VDD qu30_b3_1 XI629_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI629_MP5 (b2_7 XI629_Bn XI629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI629_MP4 (XI629_p1 XI629_An b2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI629_MP2 (VDD dd7_b3_0 XI629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI629_MP3 (XI629_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI629_MP0 (VDD dd7_b3_0 XI629_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI628_MP1 (VDD qu30_b3_1 XI628_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI628_MP5 (b2_6 XI628_Bn XI628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI628_MP4 (XI628_p1 XI628_An b2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI628_MP2 (VDD dd6_b3_0 XI628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI628_MP3 (XI628_p1 qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI628_MP0 (VDD dd6_b3_0 XI628_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I206_MP1 (VDD I608_G2_0n XI608_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I206_MP5 (p1_3 XI608_I206_Bn XI608_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI608_I206_MP4 (XI608_I206_p1 XI608_I206_An p1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I206_MP2 (VDD I608_pn3 XI608_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI608_I206_MP3 (XI608_I206_p1 I608_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI608_I206_MP0 (VDD I608_pn3 XI608_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI581_MP1 (VDD qu31_b3_0 XI581_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI581_MP5 (b1_5 XI581_Bn XI581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI581_MP4 (XI581_p1 XI581_An b1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI581_MP2 (VDD dd5_b3_0 XI581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI581_MP3 (XI581_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI581_MP0 (VDD dd5_b3_0 XI581_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI583_MP1 (VDD qu31_b3_1 XI583_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI583_MP5 (b1_7 XI583_Bn XI583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI583_MP4 (XI583_p1 XI583_An b1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI583_MP2 (VDD dd7_b3_0 XI583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI583_MP3 (XI583_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI583_MP0 (VDD dd7_b3_0 XI583_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI582_MP1 (VDD qu31_b3_1 XI582_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI582_MP5 (b1_6 XI582_Bn XI582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI582_MP4 (XI582_p1 XI582_An b1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI582_MP2 (VDD dd6_b3_0 XI582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI582_MP3 (XI582_p1 qu31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI582_MP0 (VDD dd6_b3_0 XI582_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I206_MP1 (VDD I562_G2_0n XI562_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I206_MP5 (p0_3 XI562_I206_Bn XI562_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI562_I206_MP4 (XI562_I206_p1 XI562_I206_An p0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I206_MP2 (VDD I562_pn3 XI562_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI562_I206_MP3 (XI562_I206_p1 I562_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI562_I206_MP0 (VDD I562_pn3 XI562_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI539_MP1 (VDD VDD XI539_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI539_MP5 (b0_9 XI539_Bn XI539_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI539_MP4 (XI539_p1 XI539_An b0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI539_MP2 (VDD dd9_b3_0 XI539_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI539_MP3 (XI539_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI539_MP0 (VDD dd9_b3_0 XI539_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I206_MP1 (VDD I1988_G2_0n XI1988_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I206_MP5 (p31_3 XI1988_I206_Bn XI1988_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I206_MP4 (XI1988_I206_p1 XI1988_I206_An p31_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I206_MP2 (VDD I1988_pn3 XI1988_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I206_MP3 (XI1988_I206_p1 I1988_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I206_MP0 (VDD I1988_pn3 XI1988_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I207_MP1 (VDD I1988_G3_0n XI1988_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I207_MP5 (p31_4 XI1988_I207_Bn XI1988_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1988_I207_MP4 (XI1988_I207_p1 XI1988_I207_An p31_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I207_MP2 (VDD I1988_pn4 XI1988_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1988_I207_MP3 (XI1988_I207_p1 I1988_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1988_I207_MP0 (VDD I1988_pn4 XI1988_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1962_MP1 (VDD qu1_b3_1 XI1962_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1962_MP5 (b31_6 XI1962_Bn XI1962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1962_MP4 (XI1962_p1 XI1962_An b31_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1962_MP2 (VDD dd6_b3_5 XI1962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1962_MP3 (XI1962_p1 qu1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1962_MP0 (VDD dd6_b3_5 XI1962_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I206_MP1 (VDD I1942_G2_0n XI1942_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I206_MP5 (p30_3 XI1942_I206_Bn XI1942_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I206_MP4 (XI1942_I206_p1 XI1942_I206_An p30_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I206_MP2 (VDD I1942_pn3 XI1942_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I206_MP3 (XI1942_I206_p1 I1942_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I206_MP0 (VDD I1942_pn3 XI1942_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I207_MP1 (VDD I1942_G3_0n XI1942_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I207_MP5 (p30_4 XI1942_I207_Bn XI1942_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1942_I207_MP4 (XI1942_I207_p1 XI1942_I207_An p30_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I207_MP2 (VDD I1942_pn4 XI1942_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1942_I207_MP3 (XI1942_I207_p1 I1942_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1942_I207_MP0 (VDD I1942_pn4 XI1942_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1916_MP1 (VDD qu2_b3_1 XI1916_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1916_MP5 (b30_6 XI1916_Bn XI1916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1916_MP4 (XI1916_p1 XI1916_An b30_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1916_MP2 (VDD dd6_b3_5 XI1916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1916_MP3 (XI1916_p1 qu2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1916_MP0 (VDD dd6_b3_5 XI1916_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I206_MP1 (VDD I1896_G2_0n XI1896_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I206_MP5 (p29_3 XI1896_I206_Bn XI1896_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1896_I206_MP4 (XI1896_I206_p1 XI1896_I206_An p29_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I206_MP2 (VDD I1896_pn3 XI1896_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1896_I206_MP3 (XI1896_I206_p1 I1896_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1896_I206_MP0 (VDD I1896_pn3 XI1896_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I206_MP1 (VDD I1850_G2_0n XI1850_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I206_MP5 (p28_3 XI1850_I206_Bn XI1850_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I206_MP4 (XI1850_I206_p1 XI1850_I206_An p28_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I206_MP2 (VDD I1850_pn3 XI1850_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I206_MP3 (XI1850_I206_p1 I1850_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I206_MP0 (VDD I1850_pn3 XI1850_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I207_MP1 (VDD I1850_G3_0n XI1850_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I207_MP5 (p28_4 XI1850_I207_Bn XI1850_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I207_MP4 (XI1850_I207_p1 XI1850_I207_An p28_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I207_MP2 (VDD I1850_pn4 XI1850_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I207_MP3 (XI1850_I207_p1 I1850_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I207_MP0 (VDD I1850_pn4 XI1850_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I214_MP1 (VDD I1850_G10_0n XI1850_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I214_MP5 (p28_11 XI1850_I214_Bn XI1850_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I214_MP4 (XI1850_I214_p1 XI1850_I214_An p28_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I214_MP2 (VDD I1850_pn11 XI1850_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I214_MP3 (XI1850_I214_p1 I1850_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I214_MP0 (VDD I1850_pn11 XI1850_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I218_MP1 (VDD I1850_G14_0n XI1850_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I218_MP5 (p28_15 XI1850_I218_Bn XI1850_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1850_I218_MP4 (XI1850_I218_p1 XI1850_I218_An p28_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I218_MP2 (VDD I1850_pn15 XI1850_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1850_I218_MP3 (XI1850_I218_p1 I1850_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1850_I218_MP0 (VDD I1850_pn15 XI1850_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I218_MP1 (VDD I700_G14_0n XI700_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I218_MP5 (p3_15 XI700_I218_Bn XI700_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I218_MP4 (XI700_I218_p1 XI700_I218_An p3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I218_MP2 (VDD I700_pn15 XI700_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I218_MP3 (XI700_I218_p1 I700_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I218_MP0 (VDD I700_pn15 XI700_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I213_MP1 (VDD I700_G9_0n XI700_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I213_MP5 (p3_10 XI700_I213_Bn XI700_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I213_MP4 (XI700_I213_p1 XI700_I213_An p3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I213_MP2 (VDD I700_pn10 XI700_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I213_MP3 (XI700_I213_p1 I700_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I213_MP0 (VDD I700_pn10 XI700_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI673_MP1 (VDD qu29_b3_0 XI673_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI673_MP5 (b3_5 XI673_Bn XI673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI673_MP4 (XI673_p1 XI673_An b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI673_MP2 (VDD dd5_b3_0 XI673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI673_MP3 (XI673_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI673_MP0 (VDD dd5_b3_0 XI673_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI672_MP1 (VDD qu29_b3_0 XI672_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI672_MP5 (b3_4 XI672_Bn XI672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI672_MP4 (XI672_p1 XI672_An b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI672_MP2 (VDD dd4_b3_0 XI672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI672_MP3 (XI672_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI672_MP0 (VDD dd4_b3_0 XI672_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI624_MP1 (VDD qu30_b3_0 XI624_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI624_MP5 (b2_2 XI624_Bn XI624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI624_MP4 (XI624_p1 XI624_An b2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI624_MP2 (VDD dd2_b3_0 XI624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI624_MP3 (XI624_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI624_MP0 (VDD dd2_b3_0 XI624_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI626_MP1 (VDD qu30_b3_0 XI626_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI626_MP5 (b2_4 XI626_Bn XI626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI626_MP4 (XI626_p1 XI626_An b2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI626_MP2 (VDD dd4_b3_0 XI626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI626_MP3 (XI626_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI626_MP0 (VDD dd4_b3_0 XI626_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI578_MP1 (VDD qu31_b3_0 XI578_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI578_MP5 (b1_2 XI578_Bn XI578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI578_MP4 (XI578_p1 XI578_An b1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI578_MP2 (VDD dd2_b3_0 XI578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI578_MP3 (XI578_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI578_MP0 (VDD dd2_b3_0 XI578_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI580_MP1 (VDD qu31_b3_0 XI580_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI580_MP5 (b1_4 XI580_Bn XI580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI580_MP4 (XI580_p1 XI580_An b1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI580_MP2 (VDD dd4_b3_0 XI580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI580_MP3 (XI580_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI580_MP0 (VDD dd4_b3_0 XI580_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI536_MP1 (VDD VDD XI536_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI536_MP5 (b0_6 XI536_Bn XI536_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI536_MP4 (XI536_p1 XI536_An b0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI536_MP2 (VDD dd6_b3_0 XI536_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI536_MP3 (XI536_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI536_MP0 (VDD dd6_b3_0 XI536_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI538_MP1 (VDD VDD XI538_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI538_MP5 (b0_8 XI538_Bn XI538_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI538_MP4 (XI538_p1 XI538_An b0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI538_MP2 (VDD dd8_b3_0 XI538_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI538_MP3 (XI538_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI538_MP0 (VDD dd8_b3_0 XI538_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1961_MP1 (VDD qu1_b3_0 XI1961_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1961_MP5 (b31_5 XI1961_Bn XI1961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1961_MP4 (XI1961_p1 XI1961_An b31_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1961_MP2 (VDD dd5_b3_5 XI1961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1961_MP3 (XI1961_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1961_MP0 (VDD dd5_b3_5 XI1961_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1915_MP1 (VDD qu2_b3_0 XI1915_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1915_MP5 (b30_5 XI1915_Bn XI1915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1915_MP4 (XI1915_p1 XI1915_An b30_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1915_MP2 (VDD dd5_b3_5 XI1915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1915_MP3 (XI1915_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1915_MP0 (VDD dd5_b3_5 XI1915_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1867_MP1 (VDD qu3_b3_0 XI1867_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1867_MP5 (b29_3 XI1867_Bn XI1867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1867_MP4 (XI1867_p1 XI1867_An b29_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1867_MP2 (VDD dd3_b3_5 XI1867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1867_MP3 (XI1867_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1867_MP0 (VDD dd3_b3_5 XI1867_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1868_MP1 (VDD qu3_b3_0 XI1868_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1868_MP5 (b29_4 XI1868_Bn XI1868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1868_MP4 (XI1868_p1 XI1868_An b29_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1868_MP2 (VDD dd4_b3_5 XI1868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1868_MP3 (XI1868_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1868_MP0 (VDD dd4_b3_5 XI1868_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1869_MP1 (VDD qu3_b3_0 XI1869_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1869_MP5 (b29_5 XI1869_Bn XI1869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1869_MP4 (XI1869_p1 XI1869_An b29_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1869_MP2 (VDD dd5_b3_5 XI1869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1869_MP3 (XI1869_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1869_MP0 (VDD dd5_b3_5 XI1869_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I207_MP1 (VDD I700_G3_0n XI700_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I207_MP5 (p3_4 XI700_I207_Bn XI700_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I207_MP4 (XI700_I207_p1 XI700_I207_An p3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I207_MP2 (VDD I700_pn4 XI700_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I207_MP3 (XI700_I207_p1 I700_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I207_MP0 (VDD I700_pn4 XI700_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI671_MP1 (VDD qu29_b3_0 XI671_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI671_MP5 (b3_3 XI671_Bn XI671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI671_MP4 (XI671_p1 XI671_An b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI671_MP2 (VDD dd3_b3_0 XI671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI671_MP3 (XI671_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI671_MP0 (VDD dd3_b3_0 XI671_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI670_MP1 (VDD qu29_b3_0 XI670_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI670_MP5 (b3_2 XI670_Bn XI670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI670_MP4 (XI670_p1 XI670_An b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI670_MP2 (VDD dd2_b3_0 XI670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI670_MP3 (XI670_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI670_MP0 (VDD dd2_b3_0 XI670_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI625_MP1 (VDD qu30_b3_0 XI625_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI625_MP5 (b2_3 XI625_Bn XI625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI625_MP4 (XI625_p1 XI625_An b2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI625_MP2 (VDD dd3_b3_0 XI625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI625_MP3 (XI625_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI625_MP0 (VDD dd3_b3_0 XI625_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI623_MP1 (VDD qu30_b3_0 XI623_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI623_MP5 (b2_1 XI623_Bn XI623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI623_MP4 (XI623_p1 XI623_An b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI623_MP2 (VDD dd1_b3_0 XI623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI623_MP3 (XI623_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI623_MP0 (VDD dd1_b3_0 XI623_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI669_MP1 (VDD qu29_b3_0 XI669_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI669_MP5 (b3_1 XI669_Bn XI669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI669_MP4 (XI669_p1 XI669_An b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI669_MP2 (VDD dd1_b3_0 XI669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI669_MP3 (XI669_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI669_MP0 (VDD dd1_b3_0 XI669_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI622_MP1 (VDD qu30_b3_0 XI622_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI622_MP5 (b2_0 XI622_Bn XI622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI622_MP4 (XI622_p1 XI622_An b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI622_MP2 (VDD B_0_b3_0 XI622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI622_MP3 (XI622_p1 qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI622_MP0 (VDD B_0_b3_0 XI622_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI668_MP1 (VDD qu29_b3_0 XI668_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI668_MP5 (b3_0 XI668_Bn XI668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI668_MP4 (XI668_p1 XI668_An b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI668_MP2 (VDD B_0_b3_0 XI668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI668_MP3 (XI668_p1 qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI668_MP0 (VDD B_0_b3_0 XI668_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI577_MP1 (VDD qu31_b3_0 XI577_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI577_MP5 (b1_1 XI577_Bn XI577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI577_MP4 (XI577_p1 XI577_An b1_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI577_MP2 (VDD dd1_b3_0 XI577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI577_MP3 (XI577_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI577_MP0 (VDD dd1_b3_0 XI577_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI576_MP1 (VDD qu31_b3_0 XI576_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI576_MP5 (b1_0 XI576_Bn XI576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI576_MP4 (XI576_p1 XI576_An b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI576_MP2 (VDD B_0_b3_0 XI576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI576_MP3 (XI576_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI576_MP0 (VDD B_0_b3_0 XI576_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI579_MP1 (VDD qu31_b3_0 XI579_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI579_MP5 (b1_3 XI579_Bn XI579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI579_MP4 (XI579_p1 XI579_An b1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI579_MP2 (VDD dd3_b3_0 XI579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI579_MP3 (XI579_p1 qu31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI579_MP0 (VDD dd3_b3_0 XI579_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI532_MP1 (VDD VDD XI532_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI532_MP5 (b0_2 XI532_Bn XI532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI532_MP4 (XI532_p1 XI532_An b0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI532_MP2 (VDD dd2_b3_0 XI532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI532_MP3 (XI532_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI532_MP0 (VDD dd2_b3_0 XI532_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI534_MP1 (VDD VDD XI534_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI534_MP5 (b0_4 XI534_Bn XI534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI534_MP4 (XI534_p1 XI534_An b0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI534_MP2 (VDD dd4_b3_0 XI534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI534_MP3 (XI534_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI534_MP0 (VDD dd4_b3_0 XI534_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI533_MP1 (VDD VDD XI533_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI533_MP5 (b0_3 XI533_Bn XI533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI533_MP4 (XI533_p1 XI533_An b0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI533_MP2 (VDD dd3_b3_0 XI533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI533_MP3 (XI533_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI533_MP0 (VDD dd3_b3_0 XI533_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI537_MP1 (VDD VDD XI537_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI537_MP5 (b0_7 XI537_Bn XI537_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI537_MP4 (XI537_p1 XI537_An b0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI537_MP2 (VDD dd7_b3_0 XI537_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI537_MP3 (XI537_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI537_MP0 (VDD dd7_b3_0 XI537_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1957_MP1 (VDD qu1_b3_0 XI1957_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1957_MP5 (b31_1 XI1957_Bn XI1957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1957_MP4 (XI1957_p1 XI1957_An b31_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1957_MP2 (VDD dd1_b3_5 XI1957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1957_MP3 (XI1957_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1957_MP0 (VDD dd1_b3_5 XI1957_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1958_MP1 (VDD qu1_b3_0 XI1958_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1958_MP5 (b31_2 XI1958_Bn XI1958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1958_MP4 (XI1958_p1 XI1958_An b31_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1958_MP2 (VDD dd2_b3_5 XI1958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1958_MP3 (XI1958_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1958_MP0 (VDD dd2_b3_5 XI1958_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1959_MP1 (VDD qu1_b3_0 XI1959_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1959_MP5 (b31_3 XI1959_Bn XI1959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1959_MP4 (XI1959_p1 XI1959_An b31_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1959_MP2 (VDD dd3_b3_5 XI1959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1959_MP3 (XI1959_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1959_MP0 (VDD dd3_b3_5 XI1959_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1960_MP1 (VDD qu1_b3_0 XI1960_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1960_MP5 (b31_4 XI1960_Bn XI1960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1960_MP4 (XI1960_p1 XI1960_An b31_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1960_MP2 (VDD dd4_b3_5 XI1960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1960_MP3 (XI1960_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1960_MP0 (VDD dd4_b3_5 XI1960_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1910_MP1 (VDD qu2_b3_0 XI1910_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1910_MP5 (b30_0 XI1910_Bn XI1910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1910_MP4 (XI1910_p1 XI1910_An b30_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1910_MP2 (VDD B_0_b3_5 XI1910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1910_MP3 (XI1910_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1910_MP0 (VDD B_0_b3_5 XI1910_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1911_MP1 (VDD qu2_b3_0 XI1911_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1911_MP5 (b30_1 XI1911_Bn XI1911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1911_MP4 (XI1911_p1 XI1911_An b30_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1911_MP2 (VDD dd1_b3_5 XI1911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1911_MP3 (XI1911_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1911_MP0 (VDD dd1_b3_5 XI1911_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1912_MP1 (VDD qu2_b3_0 XI1912_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1912_MP5 (b30_2 XI1912_Bn XI1912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1912_MP4 (XI1912_p1 XI1912_An b30_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1912_MP2 (VDD dd2_b3_5 XI1912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1912_MP3 (XI1912_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1912_MP0 (VDD dd2_b3_5 XI1912_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1914_MP1 (VDD qu2_b3_0 XI1914_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1914_MP5 (b30_4 XI1914_Bn XI1914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1914_MP4 (XI1914_p1 XI1914_An b30_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1914_MP2 (VDD dd4_b3_5 XI1914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1914_MP3 (XI1914_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1914_MP0 (VDD dd4_b3_5 XI1914_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1913_MP1 (VDD qu2_b3_0 XI1913_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1913_MP5 (b30_3 XI1913_Bn XI1913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1913_MP4 (XI1913_p1 XI1913_An b30_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1913_MP2 (VDD dd3_b3_5 XI1913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1913_MP3 (XI1913_p1 qu2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1913_MP0 (VDD dd3_b3_5 XI1913_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1819_MP1 (VDD qu4_b3_0 XI1819_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1819_MP5 (b28_1 XI1819_Bn XI1819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1819_MP4 (XI1819_p1 XI1819_An b28_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1819_MP2 (VDD dd1_b3_5 XI1819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1819_MP3 (XI1819_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1819_MP0 (VDD dd1_b3_5 XI1819_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1865_MP1 (VDD qu3_b3_0 XI1865_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1865_MP5 (b29_1 XI1865_Bn XI1865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1865_MP4 (XI1865_p1 XI1865_An b29_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1865_MP2 (VDD dd1_b3_5 XI1865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1865_MP3 (XI1865_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1865_MP0 (VDD dd1_b3_5 XI1865_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1820_MP1 (VDD qu4_b3_0 XI1820_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1820_MP5 (b28_2 XI1820_Bn XI1820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1820_MP4 (XI1820_p1 XI1820_An b28_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1820_MP2 (VDD dd2_b3_5 XI1820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1820_MP3 (XI1820_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1820_MP0 (VDD dd2_b3_5 XI1820_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1866_MP1 (VDD qu3_b3_0 XI1866_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1866_MP5 (b29_2 XI1866_Bn XI1866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1866_MP4 (XI1866_p1 XI1866_An b29_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1866_MP2 (VDD dd2_b3_5 XI1866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1866_MP3 (XI1866_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1866_MP0 (VDD dd2_b3_5 XI1866_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1821_MP1 (VDD qu4_b3_0 XI1821_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1821_MP5 (b28_3 XI1821_Bn XI1821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1821_MP4 (XI1821_p1 XI1821_An b28_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1821_MP2 (VDD dd3_b3_5 XI1821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1821_MP3 (XI1821_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1821_MP0 (VDD dd3_b3_5 XI1821_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1822_MP1 (VDD qu4_b3_0 XI1822_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1822_MP5 (b28_4 XI1822_Bn XI1822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1822_MP4 (XI1822_p1 XI1822_An b28_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1822_MP2 (VDD dd4_b3_5 XI1822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1822_MP3 (XI1822_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1822_MP0 (VDD dd4_b3_5 XI1822_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I214_MP1 (VDD I700_G10_0n XI700_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I214_MP5 (p3_11 XI700_I214_Bn XI700_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I214_MP4 (XI700_I214_p1 XI700_I214_An p3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I214_MP2 (VDD I700_pn11 XI700_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I214_MP3 (XI700_I214_p1 I700_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I214_MP0 (VDD I700_pn11 XI700_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I212_MP1 (VDD I700_G8_0n XI700_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I212_MP5 (p3_9 XI700_I212_Bn XI700_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I212_MP4 (XI700_I212_p1 XI700_I212_An p3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I212_MP2 (VDD I700_pn9 XI700_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I212_MP3 (XI700_I212_p1 I700_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I212_MP0 (VDD I700_pn9 XI700_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I206_MP1 (VDD I700_G2_0n XI700_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I206_MP5 (p3_3 XI700_I206_Bn XI700_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I206_MP4 (XI700_I206_p1 XI700_I206_An p3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I206_MP2 (VDD I700_pn3 XI700_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I206_MP3 (XI700_I206_p1 I700_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I206_MP0 (VDD I700_pn3 XI700_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI717_MP1 (VDD qu28_b3_0 XI717_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI717_MP5 (b4_3 XI717_Bn XI717_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI717_MP4 (XI717_p1 XI717_An b4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI717_MP2 (VDD dd3_b3_0 XI717_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI717_MP3 (XI717_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI717_MP0 (VDD dd3_b3_0 XI717_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI718_MP1 (VDD qu28_b3_0 XI718_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI718_MP5 (b4_4 XI718_Bn XI718_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI718_MP4 (XI718_p1 XI718_An b4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI718_MP2 (VDD dd4_b3_0 XI718_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI718_MP3 (XI718_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI718_MP0 (VDD dd4_b3_0 XI718_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI716_MP1 (VDD qu28_b3_0 XI716_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI716_MP5 (b4_2 XI716_Bn XI716_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI716_MP4 (XI716_p1 XI716_An b4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI716_MP2 (VDD dd2_b3_0 XI716_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI716_MP3 (XI716_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI716_MP0 (VDD dd2_b3_0 XI716_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI715_MP1 (VDD qu28_b3_0 XI715_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI715_MP5 (b4_1 XI715_Bn XI715_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI715_MP4 (XI715_p1 XI715_An b4_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI715_MP2 (VDD dd1_b3_0 XI715_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI715_MP3 (XI715_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI715_MP0 (VDD dd1_b3_0 XI715_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI714_MP1 (VDD qu28_b3_0 XI714_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI714_MP5 (b4_0 XI714_Bn XI714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI714_MP4 (XI714_p1 XI714_An b4_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI714_MP2 (VDD B_0_b3_0 XI714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI714_MP3 (XI714_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI714_MP0 (VDD B_0_b3_0 XI714_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI763_MP1 (VDD qu27_b3_0 XI763_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI763_MP5 (b5_3 XI763_Bn XI763_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI763_MP4 (XI763_p1 XI763_An b5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI763_MP2 (VDD dd3_b3_0 XI763_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI763_MP3 (XI763_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI763_MP0 (VDD dd3_b3_0 XI763_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI530_MP1 (VDD VDD XI530_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI530_MP5 (b0_0 XI530_Bn XI530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI530_MP4 (XI530_p1 XI530_An b0_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI530_MP2 (VDD B_0_b3_0 XI530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI530_MP3 (XI530_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI530_MP0 (VDD B_0_b3_0 XI530_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI531_MP1 (VDD VDD XI531_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI531_MP5 (b0_1 XI531_Bn XI531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI531_MP4 (XI531_p1 XI531_An b0_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI531_MP2 (VDD dd1_b3_0 XI531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI531_MP3 (XI531_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI531_MP0 (VDD dd1_b3_0 XI531_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI535_MP1 (VDD VDD XI535_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI535_MP5 (b0_5 XI535_Bn XI535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI535_MP4 (XI535_p1 XI535_An b0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI535_MP2 (VDD dd5_b3_0 XI535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI535_MP3 (XI535_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI535_MP0 (VDD dd5_b3_0 XI535_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2067_MP1 (VDD B_31_b3_5 XI2067_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2067_MP5 (sq XI2067_Bn XI2067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2067_MP4 (XI2067_p1 XI2067_An sq VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2067_MP2 (VDD A_31_b3_5 XI2067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2067_MP3 (XI2067_p1 B_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2067_MP0 (VDD A_31_b3_5 XI2067_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1956_MP1 (VDD qu1_b3_0 XI1956_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1956_MP5 (b31_0 XI1956_Bn XI1956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1956_MP4 (XI1956_p1 XI1956_An b31_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1956_MP2 (VDD B_0_b3_5 XI1956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1956_MP3 (XI1956_p1 qu1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1956_MP0 (VDD B_0_b3_5 XI1956_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1864_MP1 (VDD qu3_b3_0 XI1864_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1864_MP5 (b29_0 XI1864_Bn XI1864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1864_MP4 (XI1864_p1 XI1864_An b29_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1864_MP2 (VDD B_0_b3_5 XI1864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1864_MP3 (XI1864_p1 qu3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1864_MP0 (VDD B_0_b3_5 XI1864_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1823_MP1 (VDD qu4_b3_0 XI1823_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1823_MP5 (b28_5 XI1823_Bn XI1823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1823_MP4 (XI1823_p1 XI1823_An b28_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1823_MP2 (VDD dd5_b3_5 XI1823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1823_MP3 (XI1823_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1823_MP0 (VDD dd5_b3_5 XI1823_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1829_MP1 (VDD qu4_b3_1 XI1829_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1829_MP5 (b28_11 XI1829_Bn XI1829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1829_MP4 (XI1829_p1 XI1829_An b28_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1829_MP2 (VDD dd11_b3_5 XI1829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1829_MP3 (XI1829_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1829_MP0 (VDD dd11_b3_5 XI1829_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1828_MP1 (VDD qu4_b3_1 XI1828_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1828_MP5 (b28_10 XI1828_Bn XI1828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1828_MP4 (XI1828_p1 XI1828_An b28_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1828_MP2 (VDD dd10_b3_5 XI1828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1828_MP3 (XI1828_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1828_MP0 (VDD dd10_b3_5 XI1828_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I216_MP1 (VDD I700_G12_0n XI700_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I216_MP5 (p3_13 XI700_I216_Bn XI700_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI700_I216_MP4 (XI700_I216_p1 XI700_I216_An p3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I216_MP2 (VDD I700_pn13 XI700_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI700_I216_MP3 (XI700_I216_p1 I700_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI700_I216_MP0 (VDD I700_pn13 XI700_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI730_MP1 (VDD qu28_b3_2 XI730_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI730_MP5 (b4_16 XI730_Bn XI730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI730_MP4 (XI730_p1 XI730_An b4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI730_MP2 (VDD dd16_b3_0 XI730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI730_MP3 (XI730_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI730_MP0 (VDD dd16_b3_0 XI730_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI731_MP1 (VDD qu28_b3_2 XI731_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI731_MP5 (b4_17 XI731_Bn XI731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI731_MP4 (XI731_p1 XI731_An b4_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI731_MP2 (VDD dd17_b3_0 XI731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI731_MP3 (XI731_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI731_MP0 (VDD dd17_b3_0 XI731_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI729_MP1 (VDD qu28_b3_2 XI729_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI729_MP5 (b4_15 XI729_Bn XI729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI729_MP4 (XI729_p1 XI729_An b4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI729_MP2 (VDD dd15_b3_0 XI729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI729_MP3 (XI729_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI729_MP0 (VDD dd15_b3_0 XI729_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI725_MP1 (VDD qu28_b3_1 XI725_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI725_MP5 (b4_11 XI725_Bn XI725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI725_MP4 (XI725_p1 XI725_An b4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI725_MP2 (VDD dd11_b3_0 XI725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI725_MP3 (XI725_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI725_MP0 (VDD dd11_b3_0 XI725_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI721_MP1 (VDD qu28_b3_1 XI721_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI721_MP5 (b4_7 XI721_Bn XI721_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI721_MP4 (XI721_p1 XI721_An b4_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI721_MP2 (VDD dd7_b3_0 XI721_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI721_MP3 (XI721_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI721_MP0 (VDD dd7_b3_0 XI721_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI724_MP1 (VDD qu28_b3_1 XI724_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI724_MP5 (b4_10 XI724_Bn XI724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI724_MP4 (XI724_p1 XI724_An b4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI724_MP2 (VDD dd10_b3_0 XI724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI724_MP3 (XI724_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI724_MP0 (VDD dd10_b3_0 XI724_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI720_MP1 (VDD qu28_b3_1 XI720_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI720_MP5 (b4_6 XI720_Bn XI720_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI720_MP4 (XI720_p1 XI720_An b4_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI720_MP2 (VDD dd6_b3_0 XI720_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI720_MP3 (XI720_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI720_MP0 (VDD dd6_b3_0 XI720_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI719_MP1 (VDD qu28_b3_0 XI719_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI719_MP5 (b4_5 XI719_Bn XI719_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI719_MP4 (XI719_p1 XI719_An b4_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI719_MP2 (VDD dd5_b3_0 XI719_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI719_MP3 (XI719_p1 qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI719_MP0 (VDD dd5_b3_0 XI719_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI775_MP1 (VDD qu27_b3_2 XI775_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI775_MP5 (b5_15 XI775_Bn XI775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI775_MP4 (XI775_p1 XI775_An b5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI775_MP2 (VDD dd15_b3_0 XI775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI775_MP3 (XI775_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI775_MP0 (VDD dd15_b3_0 XI775_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI777_MP1 (VDD qu27_b3_2 XI777_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI777_MP5 (b5_17 XI777_Bn XI777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI777_MP4 (XI777_p1 XI777_An b5_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI777_MP2 (VDD dd17_b3_0 XI777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI777_MP3 (XI777_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI777_MP0 (VDD dd17_b3_0 XI777_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI770_MP1 (VDD qu27_b3_1 XI770_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI770_MP5 (b5_10 XI770_Bn XI770_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI770_MP4 (XI770_p1 XI770_An b5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI770_MP2 (VDD dd10_b3_0 XI770_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI770_MP3 (XI770_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI770_MP0 (VDD dd10_b3_0 XI770_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI767_MP1 (VDD qu27_b3_1 XI767_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI767_MP5 (b5_7 XI767_Bn XI767_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI767_MP4 (XI767_p1 XI767_An b5_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI767_MP2 (VDD dd7_b3_0 XI767_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI767_MP3 (XI767_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI767_MP0 (VDD dd7_b3_0 XI767_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI765_MP1 (VDD qu27_b3_0 XI765_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI765_MP5 (b5_5 XI765_Bn XI765_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI765_MP4 (XI765_p1 XI765_An b5_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI765_MP2 (VDD dd5_b3_0 XI765_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI765_MP3 (XI765_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI765_MP0 (VDD dd5_b3_0 XI765_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI764_MP1 (VDD qu27_b3_0 XI764_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI764_MP5 (b5_4 XI764_Bn XI764_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI764_MP4 (XI764_p1 XI764_An b5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI764_MP2 (VDD dd4_b3_0 XI764_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI764_MP3 (XI764_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI764_MP0 (VDD dd4_b3_0 XI764_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI762_MP1 (VDD qu27_b3_0 XI762_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI762_MP5 (b5_2 XI762_Bn XI762_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI762_MP4 (XI762_p1 XI762_An b5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI762_MP2 (VDD dd2_b3_0 XI762_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI762_MP3 (XI762_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI762_MP0 (VDD dd2_b3_0 XI762_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI761_MP1 (VDD qu27_b3_0 XI761_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI761_MP5 (b5_1 XI761_Bn XI761_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI761_MP4 (XI761_p1 XI761_An b5_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI761_MP2 (VDD dd1_b3_0 XI761_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI761_MP3 (XI761_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI761_MP0 (VDD dd1_b3_0 XI761_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI760_MP1 (VDD qu27_b3_0 XI760_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI760_MP5 (b5_0 XI760_Bn XI760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI760_MP4 (XI760_p1 XI760_An b5_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI760_MP2 (VDD B_0_b3_1 XI760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI760_MP3 (XI760_p1 qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI760_MP0 (VDD B_0_b3_1 XI760_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI809_MP1 (VDD qu26_b3_0 XI809_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI809_MP5 (b6_3 XI809_Bn XI809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI809_MP4 (XI809_p1 XI809_An b6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI809_MP2 (VDD dd3_b3_1 XI809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI809_MP3 (XI809_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI809_MP0 (VDD dd3_b3_1 XI809_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI807_MP1 (VDD qu26_b3_0 XI807_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI807_MP5 (b6_1 XI807_Bn XI807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI807_MP4 (XI807_p1 XI807_An b6_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI807_MP2 (VDD dd1_b3_1 XI807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI807_MP3 (XI807_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI807_MP0 (VDD dd1_b3_1 XI807_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI806_MP1 (VDD qu26_b3_0 XI806_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI806_MP5 (b6_0 XI806_Bn XI806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI806_MP4 (XI806_p1 XI806_An b6_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI806_MP2 (VDD B_0_b3_1 XI806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI806_MP3 (XI806_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI806_MP0 (VDD B_0_b3_1 XI806_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1818_MP1 (VDD qu4_b3_0 XI1818_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1818_MP5 (b28_0 XI1818_Bn XI1818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1818_MP4 (XI1818_p1 XI1818_An b28_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1818_MP2 (VDD B_0_b3_4 XI1818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1818_MP3 (XI1818_p1 qu4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1818_MP0 (VDD B_0_b3_4 XI1818_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1824_MP1 (VDD qu4_b3_1 XI1824_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1824_MP5 (b28_6 XI1824_Bn XI1824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1824_MP4 (XI1824_p1 XI1824_An b28_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1824_MP2 (VDD dd6_b3_5 XI1824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1824_MP3 (XI1824_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1824_MP0 (VDD dd6_b3_5 XI1824_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1827_MP1 (VDD qu4_b3_1 XI1827_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1827_MP5 (b28_9 XI1827_Bn XI1827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1827_MP4 (XI1827_p1 XI1827_An b28_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1827_MP2 (VDD dd9_b3_5 XI1827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1827_MP3 (XI1827_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1827_MP0 (VDD dd9_b3_5 XI1827_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1825_MP1 (VDD qu4_b3_1 XI1825_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1825_MP5 (b28_7 XI1825_Bn XI1825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1825_MP4 (XI1825_p1 XI1825_An b28_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1825_MP2 (VDD dd7_b3_5 XI1825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1825_MP3 (XI1825_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1825_MP0 (VDD dd7_b3_5 XI1825_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1830_MP1 (VDD qu4_b3_2 XI1830_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1830_MP5 (b28_12 XI1830_Bn XI1830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1830_MP4 (XI1830_p1 XI1830_An b28_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1830_MP2 (VDD dd12_b3_5 XI1830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1830_MP3 (XI1830_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1830_MP0 (VDD dd12_b3_5 XI1830_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1832_MP1 (VDD qu4_b3_2 XI1832_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1832_MP5 (b28_14 XI1832_Bn XI1832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1832_MP4 (XI1832_p1 XI1832_An b28_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1832_MP2 (VDD dd14_b3_5 XI1832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1832_MP3 (XI1832_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1832_MP0 (VDD dd14_b3_5 XI1832_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1833_MP1 (VDD qu4_b3_2 XI1833_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1833_MP5 (b28_15 XI1833_Bn XI1833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1833_MP4 (XI1833_p1 XI1833_An b28_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1833_MP2 (VDD dd15_b3_5 XI1833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1833_MP3 (XI1833_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1833_MP0 (VDD dd15_b3_5 XI1833_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1834_MP1 (VDD qu4_b3_2 XI1834_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1834_MP5 (b28_16 XI1834_Bn XI1834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1834_MP4 (XI1834_p1 XI1834_An b28_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1834_MP2 (VDD dd16_b3_5 XI1834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1834_MP3 (XI1834_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1834_MP0 (VDD dd16_b3_5 XI1834_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1839_MP1 (VDD qu4_b3_3 XI1839_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1839_MP5 (b28_21 XI1839_Bn XI1839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1839_MP4 (XI1839_p1 XI1839_An b28_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1839_MP2 (VDD dd21_b3_5 XI1839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1839_MP3 (XI1839_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1839_MP0 (VDD dd21_b3_5 XI1839_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI747_MP1 (VDD qu28_b3_5 XI747_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI747_MP5 (h4 XI747_Bn XI747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI747_MP4 (XI747_p1 XI747_An h4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI747_MP2 (VDD p3_31 XI747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI747_MP3 (XI747_p1 qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI747_MP0 (VDD p3_31 XI747_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI735_MP1 (VDD qu28_b3_3 XI735_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI735_MP5 (b4_21 XI735_Bn XI735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI735_MP4 (XI735_p1 XI735_An b4_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI735_MP2 (VDD dd21_b3_0 XI735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI735_MP3 (XI735_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI735_MP0 (VDD dd21_b3_0 XI735_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI734_MP1 (VDD qu28_b3_3 XI734_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI734_MP5 (b4_20 XI734_Bn XI734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI734_MP4 (XI734_p1 XI734_An b4_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI734_MP2 (VDD dd20_b3_0 XI734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI734_MP3 (XI734_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI734_MP0 (VDD dd20_b3_0 XI734_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI728_MP1 (VDD qu28_b3_2 XI728_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI728_MP5 (b4_14 XI728_Bn XI728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI728_MP4 (XI728_p1 XI728_An b4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI728_MP2 (VDD dd14_b3_0 XI728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI728_MP3 (XI728_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI728_MP0 (VDD dd14_b3_0 XI728_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI727_MP1 (VDD qu28_b3_2 XI727_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI727_MP5 (b4_13 XI727_Bn XI727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI727_MP4 (XI727_p1 XI727_An b4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI727_MP2 (VDD dd13_b3_0 XI727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI727_MP3 (XI727_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI727_MP0 (VDD dd13_b3_0 XI727_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI723_MP1 (VDD qu28_b3_1 XI723_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI723_MP5 (b4_9 XI723_Bn XI723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI723_MP4 (XI723_p1 XI723_An b4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI723_MP2 (VDD dd9_b3_0 XI723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI723_MP3 (XI723_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI723_MP0 (VDD dd9_b3_0 XI723_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI722_MP1 (VDD qu28_b3_1 XI722_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI722_MP5 (b4_8 XI722_Bn XI722_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI722_MP4 (XI722_p1 XI722_An b4_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI722_MP2 (VDD dd8_b3_0 XI722_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI722_MP3 (XI722_p1 qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI722_MP0 (VDD dd8_b3_0 XI722_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI774_MP1 (VDD qu27_b3_2 XI774_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI774_MP5 (b5_14 XI774_Bn XI774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI774_MP4 (XI774_p1 XI774_An b5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI774_MP2 (VDD dd14_b3_0 XI774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI774_MP3 (XI774_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI774_MP0 (VDD dd14_b3_0 XI774_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI776_MP1 (VDD qu27_b3_2 XI776_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI776_MP5 (b5_16 XI776_Bn XI776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI776_MP4 (XI776_p1 XI776_An b5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI776_MP2 (VDD dd16_b3_0 XI776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI776_MP3 (XI776_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI776_MP0 (VDD dd16_b3_0 XI776_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI773_MP1 (VDD qu27_b3_2 XI773_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI773_MP5 (b5_13 XI773_Bn XI773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI773_MP4 (XI773_p1 XI773_An b5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI773_MP2 (VDD dd13_b3_0 XI773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI773_MP3 (XI773_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI773_MP0 (VDD dd13_b3_0 XI773_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI771_MP1 (VDD qu27_b3_1 XI771_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI771_MP5 (b5_11 XI771_Bn XI771_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI771_MP4 (XI771_p1 XI771_An b5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI771_MP2 (VDD dd11_b3_0 XI771_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI771_MP3 (XI771_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI771_MP0 (VDD dd11_b3_0 XI771_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI768_MP1 (VDD qu27_b3_1 XI768_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI768_MP5 (b5_8 XI768_Bn XI768_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI768_MP4 (XI768_p1 XI768_An b5_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI768_MP2 (VDD dd8_b3_0 XI768_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI768_MP3 (XI768_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI768_MP0 (VDD dd8_b3_0 XI768_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI766_MP1 (VDD qu27_b3_1 XI766_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI766_MP5 (b5_6 XI766_Bn XI766_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI766_MP4 (XI766_p1 XI766_An b5_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI766_MP2 (VDD dd6_b3_0 XI766_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI766_MP3 (XI766_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI766_MP0 (VDD dd6_b3_0 XI766_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI769_MP1 (VDD qu27_b3_1 XI769_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI769_MP5 (b5_9 XI769_Bn XI769_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI769_MP4 (XI769_p1 XI769_An b5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI769_MP2 (VDD dd9_b3_0 XI769_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI769_MP3 (XI769_p1 qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI769_MP0 (VDD dd9_b3_0 XI769_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI811_MP1 (VDD qu26_b3_0 XI811_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI811_MP5 (b6_5 XI811_Bn XI811_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI811_MP4 (XI811_p1 XI811_An b6_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI811_MP2 (VDD dd5_b3_1 XI811_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI811_MP3 (XI811_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI811_MP0 (VDD dd5_b3_1 XI811_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI810_MP1 (VDD qu26_b3_0 XI810_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI810_MP5 (b6_4 XI810_Bn XI810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI810_MP4 (XI810_p1 XI810_An b6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI810_MP2 (VDD dd4_b3_1 XI810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI810_MP3 (XI810_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI810_MP0 (VDD dd4_b3_1 XI810_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI808_MP1 (VDD qu26_b3_0 XI808_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI808_MP5 (b6_2 XI808_Bn XI808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI808_MP4 (XI808_p1 XI808_An b6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI808_MP2 (VDD dd2_b3_1 XI808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI808_MP3 (XI808_p1 qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI808_MP0 (VDD dd2_b3_1 XI808_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI852_MP1 (VDD qu25_b3_0 XI852_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI852_MP5 (b7_0 XI852_Bn XI852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI852_MP4 (XI852_p1 XI852_An b7_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI852_MP2 (VDD B_0_b3_1 XI852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI852_MP3 (XI852_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI852_MP0 (VDD B_0_b3_1 XI852_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI853_MP1 (VDD qu25_b3_0 XI853_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI853_MP5 (b7_1 XI853_Bn XI853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI853_MP4 (XI853_p1 XI853_An b7_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI853_MP2 (VDD dd1_b3_1 XI853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI853_MP3 (XI853_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI853_MP0 (VDD dd1_b3_1 XI853_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI854_MP1 (VDD qu25_b3_0 XI854_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI854_MP5 (b7_2 XI854_Bn XI854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI854_MP4 (XI854_p1 XI854_An b7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI854_MP2 (VDD dd2_b3_1 XI854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI854_MP3 (XI854_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI854_MP0 (VDD dd2_b3_1 XI854_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI855_MP1 (VDD qu25_b3_0 XI855_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI855_MP5 (b7_3 XI855_Bn XI855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI855_MP4 (XI855_p1 XI855_An b7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI855_MP2 (VDD dd3_b3_1 XI855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI855_MP3 (XI855_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI855_MP0 (VDD dd3_b3_1 XI855_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1682_MP1 (VDD qu7_b3_0 XI1682_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1682_MP5 (b25_2 XI1682_Bn XI1682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1682_MP4 (XI1682_p1 XI1682_An b25_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1682_MP2 (VDD dd2_b3_4 XI1682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1682_MP3 (XI1682_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1682_MP0 (VDD dd2_b3_4 XI1682_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1683_MP1 (VDD qu7_b3_0 XI1683_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1683_MP5 (b25_3 XI1683_Bn XI1683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1683_MP4 (XI1683_p1 XI1683_An b25_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1683_MP2 (VDD dd3_b3_4 XI1683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1683_MP3 (XI1683_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1683_MP0 (VDD dd3_b3_4 XI1683_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1680_MP1 (VDD qu7_b3_0 XI1680_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1680_MP5 (b25_0 XI1680_Bn XI1680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1680_MP4 (XI1680_p1 XI1680_An b25_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1680_MP2 (VDD B_0_b3_4 XI1680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1680_MP3 (XI1680_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1680_MP0 (VDD B_0_b3_4 XI1680_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1728_MP1 (VDD qu6_b3_0 XI1728_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1728_MP5 (b26_2 XI1728_Bn XI1728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1728_MP4 (XI1728_p1 XI1728_An b26_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1728_MP2 (VDD dd2_b3_4 XI1728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1728_MP3 (XI1728_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1728_MP0 (VDD dd2_b3_4 XI1728_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1727_MP1 (VDD qu6_b3_0 XI1727_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1727_MP5 (b26_1 XI1727_Bn XI1727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1727_MP4 (XI1727_p1 XI1727_An b26_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1727_MP2 (VDD dd1_b3_4 XI1727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1727_MP3 (XI1727_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1727_MP0 (VDD dd1_b3_4 XI1727_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1726_MP1 (VDD qu6_b3_0 XI1726_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1726_MP5 (b26_0 XI1726_Bn XI1726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1726_MP4 (XI1726_p1 XI1726_An b26_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1726_MP2 (VDD B_0_b3_4 XI1726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1726_MP3 (XI1726_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1726_MP0 (VDD B_0_b3_4 XI1726_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1772_MP1 (VDD qu5_b3_0 XI1772_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1772_MP5 (b27_0 XI1772_Bn XI1772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1772_MP4 (XI1772_p1 XI1772_An b27_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1772_MP2 (VDD B_0_b3_4 XI1772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1772_MP3 (XI1772_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1772_MP0 (VDD B_0_b3_4 XI1772_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1774_MP1 (VDD qu5_b3_0 XI1774_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1774_MP5 (b27_2 XI1774_Bn XI1774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1774_MP4 (XI1774_p1 XI1774_An b27_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1774_MP2 (VDD dd2_b3_4 XI1774_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1774_MP3 (XI1774_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1774_MP0 (VDD dd2_b3_4 XI1774_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1826_MP1 (VDD qu4_b3_1 XI1826_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1826_MP5 (b28_8 XI1826_Bn XI1826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1826_MP4 (XI1826_p1 XI1826_An b28_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1826_MP2 (VDD dd8_b3_5 XI1826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1826_MP3 (XI1826_p1 qu4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1826_MP0 (VDD dd8_b3_5 XI1826_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I206_MP1 (VDD I1804_G2_0n XI1804_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I206_MP5 (p27_3 XI1804_I206_Bn XI1804_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I206_MP4 (XI1804_I206_p1 XI1804_I206_An p27_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I206_MP2 (VDD I1804_pn3 XI1804_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I206_MP3 (XI1804_I206_p1 I1804_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I206_MP0 (VDD I1804_pn3 XI1804_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I207_MP1 (VDD I1804_G3_0n XI1804_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I207_MP5 (p27_4 XI1804_I207_Bn XI1804_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I207_MP4 (XI1804_I207_p1 XI1804_I207_An p27_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I207_MP2 (VDD I1804_pn4 XI1804_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I207_MP3 (XI1804_I207_p1 I1804_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I207_MP0 (VDD I1804_pn4 XI1804_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1831_MP1 (VDD qu4_b3_2 XI1831_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1831_MP5 (b28_13 XI1831_Bn XI1831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1831_MP4 (XI1831_p1 XI1831_An b28_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1831_MP2 (VDD dd13_b3_5 XI1831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1831_MP3 (XI1831_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1831_MP0 (VDD dd13_b3_5 XI1831_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1835_MP1 (VDD qu4_b3_2 XI1835_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1835_MP5 (b28_17 XI1835_Bn XI1835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1835_MP4 (XI1835_p1 XI1835_An b28_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1835_MP2 (VDD dd17_b3_5 XI1835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1835_MP3 (XI1835_p1 qu4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1835_MP0 (VDD dd17_b3_5 XI1835_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1836_MP1 (VDD qu4_b3_3 XI1836_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1836_MP5 (b28_18 XI1836_Bn XI1836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1836_MP4 (XI1836_p1 XI1836_An b28_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1836_MP2 (VDD dd18_b3_5 XI1836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1836_MP3 (XI1836_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1836_MP0 (VDD dd18_b3_5 XI1836_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1837_MP1 (VDD qu4_b3_3 XI1837_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1837_MP5 (b28_19 XI1837_Bn XI1837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1837_MP4 (XI1837_p1 XI1837_An b28_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1837_MP2 (VDD dd19_b3_5 XI1837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1837_MP3 (XI1837_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1837_MP0 (VDD dd19_b3_5 XI1837_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1840_MP1 (VDD qu4_b3_3 XI1840_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1840_MP5 (b28_22 XI1840_Bn XI1840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1840_MP4 (XI1840_p1 XI1840_An b28_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1840_MP2 (VDD dd22_b3_5 XI1840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1840_MP3 (XI1840_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1840_MP0 (VDD dd22_b3_5 XI1840_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1841_MP1 (VDD qu4_b3_3 XI1841_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1841_MP5 (b28_23 XI1841_Bn XI1841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1841_MP4 (XI1841_p1 XI1841_An b28_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1841_MP2 (VDD dd23_b3_5 XI1841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1841_MP3 (XI1841_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1841_MP0 (VDD dd23_b3_5 XI1841_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1847_MP1 (VDD qu4_b3_4 XI1847_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1847_MP5 (b28_29 XI1847_Bn XI1847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1847_MP4 (XI1847_p1 XI1847_An b28_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1847_MP2 (VDD dd29_b3_5 XI1847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1847_MP3 (XI1847_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1847_MP0 (VDD dd29_b3_5 XI1847_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1846_MP1 (VDD qu4_b3_4 XI1846_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1846_MP5 (b28_28 XI1846_Bn XI1846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1846_MP4 (XI1846_p1 XI1846_An b28_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1846_MP2 (VDD dd28_b3_5 XI1846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1846_MP3 (XI1846_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1846_MP0 (VDD dd28_b3_5 XI1846_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI748_MP1 (VDD c4_o XI748_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI748_MP5 (p4_32 XI748_Bn XI748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI748_MP4 (XI748_p1 XI748_An p4_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI748_MP2 (VDD h4 XI748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI748_MP3 (XI748_p1 c4_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI748_MP0 (VDD h4 XI748_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI736_MP1 (VDD qu28_b3_3 XI736_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI736_MP5 (b4_22 XI736_Bn XI736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI736_MP4 (XI736_p1 XI736_An b4_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI736_MP2 (VDD dd22_b3_0 XI736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI736_MP3 (XI736_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI736_MP0 (VDD dd22_b3_0 XI736_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI733_MP1 (VDD qu28_b3_3 XI733_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI733_MP5 (b4_19 XI733_Bn XI733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI733_MP4 (XI733_p1 XI733_An b4_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI733_MP2 (VDD dd19_b3_0 XI733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI733_MP3 (XI733_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI733_MP0 (VDD dd19_b3_0 XI733_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI732_MP1 (VDD qu28_b3_3 XI732_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI732_MP5 (b4_18 XI732_Bn XI732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI732_MP4 (XI732_p1 XI732_An b4_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI732_MP2 (VDD dd18_b3_0 XI732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI732_MP3 (XI732_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI732_MP0 (VDD dd18_b3_0 XI732_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI726_MP1 (VDD qu28_b3_2 XI726_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI726_MP5 (b4_12 XI726_Bn XI726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI726_MP4 (XI726_p1 XI726_An b4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI726_MP2 (VDD dd12_b3_0 XI726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI726_MP3 (XI726_p1 qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI726_MP0 (VDD dd12_b3_0 XI726_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI779_MP1 (VDD qu27_b3_3 XI779_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI779_MP5 (b5_19 XI779_Bn XI779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI779_MP4 (XI779_p1 XI779_An b5_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI779_MP2 (VDD dd19_b3_0 XI779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI779_MP3 (XI779_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI779_MP0 (VDD dd19_b3_0 XI779_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I207_MP1 (VDD I746_G3_0n XI746_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I207_MP5 (p4_4 XI746_I207_Bn XI746_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I207_MP4 (XI746_I207_p1 XI746_I207_An p4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I207_MP2 (VDD I746_pn4 XI746_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I207_MP3 (XI746_I207_p1 I746_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I207_MP0 (VDD I746_pn4 XI746_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI772_MP1 (VDD qu27_b3_2 XI772_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI772_MP5 (b5_12 XI772_Bn XI772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI772_MP4 (XI772_p1 XI772_An b5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI772_MP2 (VDD dd12_b3_0 XI772_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI772_MP3 (XI772_p1 qu27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI772_MP0 (VDD dd12_b3_0 XI772_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I206_MP1 (VDD I746_G2_0n XI746_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I206_MP5 (p4_3 XI746_I206_Bn XI746_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I206_MP4 (XI746_I206_p1 XI746_I206_An p4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I206_MP2 (VDD I746_pn3 XI746_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I206_MP3 (XI746_I206_p1 I746_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I206_MP0 (VDD I746_pn3 XI746_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I207_MP1 (VDD I792_G3_0n XI792_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I207_MP5 (p5_4 XI792_I207_Bn XI792_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I207_MP4 (XI792_I207_p1 XI792_I207_An p5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I207_MP2 (VDD I792_pn4 XI792_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I207_MP3 (XI792_I207_p1 I792_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I207_MP0 (VDD I792_pn4 XI792_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I206_MP1 (VDD I792_G2_0n XI792_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I206_MP5 (p5_3 XI792_I206_Bn XI792_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I206_MP4 (XI792_I206_p1 XI792_I206_An p5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I206_MP2 (VDD I792_pn3 XI792_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I206_MP3 (XI792_I206_p1 I792_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I206_MP0 (VDD I792_pn3 XI792_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I207_MP1 (VDD I838_G3_0n XI838_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I207_MP5 (p6_4 XI838_I207_Bn XI838_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I207_MP4 (XI838_I207_p1 XI838_I207_An p6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I207_MP2 (VDD I838_pn4 XI838_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I207_MP3 (XI838_I207_p1 I838_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I207_MP0 (VDD I838_pn4 XI838_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I206_MP1 (VDD I838_G2_0n XI838_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I206_MP5 (p6_3 XI838_I206_Bn XI838_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I206_MP4 (XI838_I206_p1 XI838_I206_An p6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I206_MP2 (VDD I838_pn3 XI838_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I206_MP3 (XI838_I206_p1 I838_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I206_MP0 (VDD I838_pn3 XI838_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI857_MP1 (VDD qu25_b3_0 XI857_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI857_MP5 (b7_5 XI857_Bn XI857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI857_MP4 (XI857_p1 XI857_An b7_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI857_MP2 (VDD dd5_b3_1 XI857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI857_MP3 (XI857_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI857_MP0 (VDD dd5_b3_1 XI857_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI856_MP1 (VDD qu25_b3_0 XI856_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI856_MP5 (b7_4 XI856_Bn XI856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI856_MP4 (XI856_p1 XI856_An b7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI856_MP2 (VDD dd4_b3_1 XI856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI856_MP3 (XI856_p1 qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI856_MP0 (VDD dd4_b3_1 XI856_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I206_MP1 (VDD I1712_G2_0n XI1712_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I206_MP5 (p25_3 XI1712_I206_Bn XI1712_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I206_MP4 (XI1712_I206_p1 XI1712_I206_An p25_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I206_MP2 (VDD I1712_pn3 XI1712_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I206_MP3 (XI1712_I206_p1 I1712_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I206_MP0 (VDD I1712_pn3 XI1712_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1684_MP1 (VDD qu7_b3_0 XI1684_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1684_MP5 (b25_4 XI1684_Bn XI1684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1684_MP4 (XI1684_p1 XI1684_An b25_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1684_MP2 (VDD dd4_b3_4 XI1684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1684_MP3 (XI1684_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1684_MP0 (VDD dd4_b3_4 XI1684_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1730_MP1 (VDD qu6_b3_0 XI1730_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1730_MP5 (b26_4 XI1730_Bn XI1730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1730_MP4 (XI1730_p1 XI1730_An b26_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1730_MP2 (VDD dd4_b3_4 XI1730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1730_MP3 (XI1730_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1730_MP0 (VDD dd4_b3_4 XI1730_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1729_MP1 (VDD qu6_b3_0 XI1729_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1729_MP5 (b26_3 XI1729_Bn XI1729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1729_MP4 (XI1729_p1 XI1729_An b26_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1729_MP2 (VDD dd3_b3_4 XI1729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1729_MP3 (XI1729_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1729_MP0 (VDD dd3_b3_4 XI1729_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1776_MP1 (VDD qu5_b3_0 XI1776_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1776_MP5 (b27_4 XI1776_Bn XI1776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1776_MP4 (XI1776_p1 XI1776_An b27_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1776_MP2 (VDD dd4_b3_4 XI1776_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1776_MP3 (XI1776_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1776_MP0 (VDD dd4_b3_4 XI1776_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1773_MP1 (VDD qu5_b3_0 XI1773_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1773_MP5 (b27_1 XI1773_Bn XI1773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1773_MP4 (XI1773_p1 XI1773_An b27_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1773_MP2 (VDD dd1_b3_4 XI1773_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1773_MP3 (XI1773_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1773_MP0 (VDD dd1_b3_4 XI1773_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1775_MP1 (VDD qu5_b3_0 XI1775_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1775_MP5 (b27_3 XI1775_Bn XI1775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1775_MP4 (XI1775_p1 XI1775_An b27_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1775_MP2 (VDD dd3_b3_4 XI1775_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1775_MP3 (XI1775_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1775_MP0 (VDD dd3_b3_4 XI1775_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1838_MP1 (VDD qu4_b3_3 XI1838_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1838_MP5 (b28_20 XI1838_Bn XI1838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1838_MP4 (XI1838_p1 XI1838_An b28_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1838_MP2 (VDD dd20_b3_5 XI1838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1838_MP3 (XI1838_p1 qu4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1838_MP0 (VDD dd20_b3_5 XI1838_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1843_MP1 (VDD qu4_b3_4 XI1843_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1843_MP5 (b28_25 XI1843_Bn XI1843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1843_MP4 (XI1843_p1 XI1843_An b28_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1843_MP2 (VDD dd25_b3_5 XI1843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1843_MP3 (XI1843_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1843_MP0 (VDD dd25_b3_5 XI1843_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1844_MP1 (VDD qu4_b3_4 XI1844_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1844_MP5 (b28_26 XI1844_Bn XI1844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1844_MP4 (XI1844_p1 XI1844_An b28_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1844_MP2 (VDD dd26_b3_5 XI1844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1844_MP3 (XI1844_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1844_MP0 (VDD dd26_b3_5 XI1844_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1845_MP1 (VDD qu4_b3_4 XI1845_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1845_MP5 (b28_27 XI1845_Bn XI1845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1845_MP4 (XI1845_p1 XI1845_An b28_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1845_MP2 (VDD dd27_b3_5 XI1845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1845_MP3 (XI1845_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1845_MP0 (VDD dd27_b3_5 XI1845_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1848_MP1 (VDD qu4_b3_5 XI1848_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1848_MP5 (b28_30 XI1848_Bn XI1848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1848_MP4 (XI1848_p1 XI1848_An b28_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1848_MP2 (VDD dd30_b3_5 XI1848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1848_MP3 (XI1848_p1 qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1848_MP0 (VDD dd30_b3_5 XI1848_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI737_MP1 (VDD qu28_b3_3 XI737_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI737_MP5 (b4_23 XI737_Bn XI737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI737_MP4 (XI737_p1 XI737_An b4_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI737_MP2 (VDD dd23_b3_0 XI737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI737_MP3 (XI737_p1 qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI737_MP0 (VDD dd23_b3_0 XI737_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI781_MP1 (VDD qu27_b3_3 XI781_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI781_MP5 (b5_21 XI781_Bn XI781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI781_MP4 (XI781_p1 XI781_An b5_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI781_MP2 (VDD dd21_b3_0 XI781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI781_MP3 (XI781_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI781_MP0 (VDD dd21_b3_0 XI781_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI783_MP1 (VDD qu27_b3_3 XI783_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI783_MP5 (b5_23 XI783_Bn XI783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI783_MP4 (XI783_p1 XI783_An b5_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI783_MP2 (VDD dd23_b3_0 XI783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI783_MP3 (XI783_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI783_MP0 (VDD dd23_b3_0 XI783_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI780_MP1 (VDD qu27_b3_3 XI780_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI780_MP5 (b5_20 XI780_Bn XI780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI780_MP4 (XI780_p1 XI780_An b5_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI780_MP2 (VDD dd20_b3_0 XI780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI780_MP3 (XI780_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI780_MP0 (VDD dd20_b3_0 XI780_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI778_MP1 (VDD qu27_b3_3 XI778_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI778_MP5 (b5_18 XI778_Bn XI778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI778_MP4 (XI778_p1 XI778_An b5_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI778_MP2 (VDD dd18_b3_0 XI778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI778_MP3 (XI778_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI778_MP0 (VDD dd18_b3_0 XI778_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI813_MP1 (VDD qu26_b3_1 XI813_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI813_MP5 (b6_7 XI813_Bn XI813_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI813_MP4 (XI813_p1 XI813_An b6_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI813_MP2 (VDD dd7_b3_1 XI813_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI813_MP3 (XI813_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI813_MP0 (VDD dd7_b3_1 XI813_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI812_MP1 (VDD qu26_b3_1 XI812_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI812_MP5 (b6_6 XI812_Bn XI812_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI812_MP4 (XI812_p1 XI812_An b6_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI812_MP2 (VDD dd6_b3_1 XI812_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI812_MP3 (XI812_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI812_MP0 (VDD dd6_b3_1 XI812_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI858_MP1 (VDD qu25_b3_1 XI858_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI858_MP5 (b7_6 XI858_Bn XI858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI858_MP4 (XI858_p1 XI858_An b7_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI858_MP2 (VDD dd6_b3_1 XI858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI858_MP3 (XI858_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI858_MP0 (VDD dd6_b3_1 XI858_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI859_MP1 (VDD qu25_b3_1 XI859_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI859_MP5 (b7_7 XI859_Bn XI859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI859_MP4 (XI859_p1 XI859_An b7_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI859_MP2 (VDD dd7_b3_1 XI859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI859_MP3 (XI859_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI859_MP0 (VDD dd7_b3_1 XI859_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I206_MP1 (VDD I884_G2_0n XI884_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I206_MP5 (p7_3 XI884_I206_Bn XI884_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I206_MP4 (XI884_I206_p1 XI884_I206_An p7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I206_MP2 (VDD I884_pn3 XI884_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I206_MP3 (XI884_I206_p1 I884_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I206_MP0 (VDD I884_pn3 XI884_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1681_MP1 (VDD qu7_b3_0 XI1681_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1681_MP5 (b25_1 XI1681_Bn XI1681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1681_MP4 (XI1681_p1 XI1681_An b25_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1681_MP2 (VDD dd1_b3_4 XI1681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1681_MP3 (XI1681_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1681_MP0 (VDD dd1_b3_4 XI1681_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I207_MP1 (VDD I1712_G3_0n XI1712_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I207_MP5 (p25_4 XI1712_I207_Bn XI1712_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I207_MP4 (XI1712_I207_p1 XI1712_I207_An p25_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I207_MP2 (VDD I1712_pn4 XI1712_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I207_MP3 (XI1712_I207_p1 I1712_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I207_MP0 (VDD I1712_pn4 XI1712_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1731_MP1 (VDD qu6_b3_0 XI1731_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1731_MP5 (b26_5 XI1731_Bn XI1731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1731_MP4 (XI1731_p1 XI1731_An b26_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1731_MP2 (VDD dd5_b3_4 XI1731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1731_MP3 (XI1731_p1 qu6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1731_MP0 (VDD dd5_b3_4 XI1731_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I206_MP1 (VDD I1758_G2_0n XI1758_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I206_MP5 (p26_3 XI1758_I206_Bn XI1758_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I206_MP4 (XI1758_I206_p1 XI1758_I206_An p26_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I206_MP2 (VDD I1758_pn3 XI1758_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I206_MP3 (XI1758_I206_p1 I1758_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I206_MP0 (VDD I1758_pn3 XI1758_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I207_MP1 (VDD I1758_G3_0n XI1758_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I207_MP5 (p26_4 XI1758_I207_Bn XI1758_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I207_MP4 (XI1758_I207_p1 XI1758_I207_An p26_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I207_MP2 (VDD I1758_pn4 XI1758_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I207_MP3 (XI1758_I207_p1 I1758_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I207_MP0 (VDD I1758_pn4 XI1758_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1777_MP1 (VDD qu5_b3_0 XI1777_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1777_MP5 (b27_5 XI1777_Bn XI1777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1777_MP4 (XI1777_p1 XI1777_An b27_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1777_MP2 (VDD dd5_b3_4 XI1777_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1777_MP3 (XI1777_p1 qu5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1777_MP0 (VDD dd5_b3_4 XI1777_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I212_MP1 (VDD I1804_G8_0n XI1804_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I212_MP5 (p27_9 XI1804_I212_Bn XI1804_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I212_MP4 (XI1804_I212_p1 XI1804_I212_An p27_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I212_MP2 (VDD I1804_pn9 XI1804_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I212_MP3 (XI1804_I212_p1 I1804_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I212_MP0 (VDD I1804_pn9 XI1804_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1842_MP1 (VDD qu4_b3_4 XI1842_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1842_MP5 (b28_24 XI1842_Bn XI1842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1842_MP4 (XI1842_p1 XI1842_An b28_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1842_MP2 (VDD dd24_b3_5 XI1842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1842_MP3 (XI1842_p1 qu4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1842_MP0 (VDD dd24_b3_5 XI1842_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I213_MP1 (VDD I746_G9_0n XI746_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I213_MP5 (p4_10 XI746_I213_Bn XI746_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I213_MP4 (XI746_I213_p1 XI746_I213_An p4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I213_MP2 (VDD I746_pn10 XI746_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I213_MP3 (XI746_I213_p1 I746_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I213_MP0 (VDD I746_pn10 XI746_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I212_MP1 (VDD I746_G8_0n XI746_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I212_MP5 (p4_9 XI746_I212_Bn XI746_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I212_MP4 (XI746_I212_p1 XI746_I212_An p4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I212_MP2 (VDD I746_pn9 XI746_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I212_MP3 (XI746_I212_p1 I746_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I212_MP0 (VDD I746_pn9 XI746_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI782_MP1 (VDD qu27_b3_3 XI782_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI782_MP5 (b5_22 XI782_Bn XI782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI782_MP4 (XI782_p1 XI782_An b5_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI782_MP2 (VDD dd22_b3_0 XI782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI782_MP3 (XI782_p1 qu27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI782_MP0 (VDD dd22_b3_0 XI782_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I212_MP1 (VDD I792_G8_0n XI792_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I212_MP5 (p5_9 XI792_I212_Bn XI792_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I212_MP4 (XI792_I212_p1 XI792_I212_An p5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I212_MP2 (VDD I792_pn9 XI792_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I212_MP3 (XI792_I212_p1 I792_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I212_MP0 (VDD I792_pn9 XI792_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI815_MP1 (VDD qu26_b3_1 XI815_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI815_MP5 (b6_9 XI815_Bn XI815_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI815_MP4 (XI815_p1 XI815_An b6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI815_MP2 (VDD dd9_b3_1 XI815_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI815_MP3 (XI815_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI815_MP0 (VDD dd9_b3_1 XI815_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI814_MP1 (VDD qu26_b3_1 XI814_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI814_MP5 (b6_8 XI814_Bn XI814_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI814_MP4 (XI814_p1 XI814_An b6_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI814_MP2 (VDD dd8_b3_1 XI814_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI814_MP3 (XI814_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI814_MP0 (VDD dd8_b3_1 XI814_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I212_MP1 (VDD I838_G8_0n XI838_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I212_MP5 (p6_9 XI838_I212_Bn XI838_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I212_MP4 (XI838_I212_p1 XI838_I212_An p6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I212_MP2 (VDD I838_pn9 XI838_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I212_MP3 (XI838_I212_p1 I838_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I212_MP0 (VDD I838_pn9 XI838_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI860_MP1 (VDD qu25_b3_1 XI860_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI860_MP5 (b7_8 XI860_Bn XI860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI860_MP4 (XI860_p1 XI860_An b7_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI860_MP2 (VDD dd8_b3_1 XI860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI860_MP3 (XI860_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI860_MP0 (VDD dd8_b3_1 XI860_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I207_MP1 (VDD I884_G3_0n XI884_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I207_MP5 (p7_4 XI884_I207_Bn XI884_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I207_MP4 (XI884_I207_p1 XI884_I207_An p7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I207_MP2 (VDD I884_pn4 XI884_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I207_MP3 (XI884_I207_p1 I884_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I207_MP0 (VDD I884_pn4 XI884_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1686_MP1 (VDD qu7_b3_1 XI1686_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1686_MP5 (b25_6 XI1686_Bn XI1686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1686_MP4 (XI1686_p1 XI1686_An b25_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1686_MP2 (VDD dd6_b3_4 XI1686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1686_MP3 (XI1686_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1686_MP0 (VDD dd6_b3_4 XI1686_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1685_MP1 (VDD qu7_b3_0 XI1685_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1685_MP5 (b25_5 XI1685_Bn XI1685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1685_MP4 (XI1685_p1 XI1685_An b25_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1685_MP2 (VDD dd5_b3_4 XI1685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1685_MP3 (XI1685_p1 qu7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1685_MP0 (VDD dd5_b3_4 XI1685_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1734_MP1 (VDD qu6_b3_1 XI1734_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1734_MP5 (b26_8 XI1734_Bn XI1734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1734_MP4 (XI1734_p1 XI1734_An b26_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1734_MP2 (VDD dd8_b3_4 XI1734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1734_MP3 (XI1734_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1734_MP0 (VDD dd8_b3_4 XI1734_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1732_MP1 (VDD qu6_b3_1 XI1732_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1732_MP5 (b26_6 XI1732_Bn XI1732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1732_MP4 (XI1732_p1 XI1732_An b26_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1732_MP2 (VDD dd6_b3_4 XI1732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1732_MP3 (XI1732_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1732_MP0 (VDD dd6_b3_4 XI1732_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1733_MP1 (VDD qu6_b3_1 XI1733_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1733_MP5 (b26_7 XI1733_Bn XI1733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1733_MP4 (XI1733_p1 XI1733_An b26_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1733_MP2 (VDD dd7_b3_4 XI1733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1733_MP3 (XI1733_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1733_MP0 (VDD dd7_b3_4 XI1733_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I213_MP1 (VDD I1804_G9_0n XI1804_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I213_MP5 (p27_10 XI1804_I213_Bn XI1804_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I213_MP4 (XI1804_I213_p1 XI1804_I213_An p27_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I213_MP2 (VDD I1804_pn10 XI1804_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I213_MP3 (XI1804_I213_p1 I1804_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I213_MP0 (VDD I1804_pn10 XI1804_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I214_MP1 (VDD I1804_G10_0n XI1804_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I214_MP5 (p27_11 XI1804_I214_Bn XI1804_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I214_MP4 (XI1804_I214_p1 XI1804_I214_An p27_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I214_MP2 (VDD I1804_pn11 XI1804_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I214_MP3 (XI1804_I214_p1 I1804_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I214_MP0 (VDD I1804_pn11 XI1804_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1851_MP1 (VDD qu4_b3_5 XI1851_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1851_MP5 (h28 XI1851_Bn XI1851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1851_MP4 (XI1851_p1 XI1851_An h28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1851_MP2 (VDD p27_31 XI1851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1851_MP3 (XI1851_p1 qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1851_MP0 (VDD p27_31 XI1851_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1849_MP1 (VDD qu4_b3_5 XI1849_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1849_MP5 (b28_31 XI1849_Bn XI1849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1849_MP4 (XI1849_p1 XI1849_An b28_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1849_MP2 (VDD dd31_b3_5 XI1849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1849_MP3 (XI1849_p1 qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1849_MP0 (VDD dd31_b3_5 XI1849_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I219_MP1 (VDD I746_G15_0n XI746_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I219_MP5 (p4_16 XI746_I219_Bn XI746_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I219_MP4 (XI746_I219_p1 XI746_I219_An p4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I219_MP2 (VDD I746_pn16 XI746_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I219_MP3 (XI746_I219_p1 I746_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I219_MP0 (VDD I746_pn16 XI746_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I215_MP1 (VDD I746_G11_0n XI746_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I215_MP5 (p4_12 XI746_I215_Bn XI746_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I215_MP4 (XI746_I215_p1 XI746_I215_An p4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I215_MP2 (VDD I746_pn12 XI746_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I215_MP3 (XI746_I215_p1 I746_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I215_MP0 (VDD I746_pn12 XI746_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I214_MP1 (VDD I746_G10_0n XI746_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I214_MP5 (p4_11 XI746_I214_Bn XI746_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I214_MP4 (XI746_I214_p1 XI746_I214_An p4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I214_MP2 (VDD I746_pn11 XI746_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I214_MP3 (XI746_I214_p1 I746_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I214_MP0 (VDD I746_pn11 XI746_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I213_MP1 (VDD I792_G9_0n XI792_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I213_MP5 (p5_10 XI792_I213_Bn XI792_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I213_MP4 (XI792_I213_p1 XI792_I213_An p5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I213_MP2 (VDD I792_pn10 XI792_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I213_MP3 (XI792_I213_p1 I792_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I213_MP0 (VDD I792_pn10 XI792_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI817_MP1 (VDD qu26_b3_1 XI817_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI817_MP5 (b6_11 XI817_Bn XI817_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI817_MP4 (XI817_p1 XI817_An b6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI817_MP2 (VDD dd11_b3_1 XI817_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI817_MP3 (XI817_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI817_MP0 (VDD dd11_b3_1 XI817_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI816_MP1 (VDD qu26_b3_1 XI816_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI816_MP5 (b6_10 XI816_Bn XI816_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI816_MP4 (XI816_p1 XI816_An b6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI816_MP2 (VDD dd10_b3_1 XI816_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI816_MP3 (XI816_p1 qu26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI816_MP0 (VDD dd10_b3_1 XI816_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I213_MP1 (VDD I838_G9_0n XI838_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I213_MP5 (p6_10 XI838_I213_Bn XI838_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I213_MP4 (XI838_I213_p1 XI838_I213_An p6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I213_MP2 (VDD I838_pn10 XI838_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I213_MP3 (XI838_I213_p1 I838_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I213_MP0 (VDD I838_pn10 XI838_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI863_MP1 (VDD qu25_b3_1 XI863_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI863_MP5 (b7_11 XI863_Bn XI863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI863_MP4 (XI863_p1 XI863_An b7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI863_MP2 (VDD dd11_b3_1 XI863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI863_MP3 (XI863_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI863_MP0 (VDD dd11_b3_1 XI863_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI862_MP1 (VDD qu25_b3_1 XI862_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI862_MP5 (b7_10 XI862_Bn XI862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI862_MP4 (XI862_p1 XI862_An b7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI862_MP2 (VDD dd10_b3_1 XI862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI862_MP3 (XI862_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI862_MP0 (VDD dd10_b3_1 XI862_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI861_MP1 (VDD qu25_b3_1 XI861_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI861_MP5 (b7_9 XI861_Bn XI861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI861_MP4 (XI861_p1 XI861_An b7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI861_MP2 (VDD dd9_b3_1 XI861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI861_MP3 (XI861_p1 qu25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI861_MP0 (VDD dd9_b3_1 XI861_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I212_MP1 (VDD I884_G8_0n XI884_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I212_MP5 (p7_9 XI884_I212_Bn XI884_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I212_MP4 (XI884_I212_p1 XI884_I212_An p7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I212_MP2 (VDD I884_pn9 XI884_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I212_MP3 (XI884_I212_p1 I884_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I212_MP0 (VDD I884_pn9 XI884_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I213_MP1 (VDD I884_G9_0n XI884_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I213_MP5 (p7_10 XI884_I213_Bn XI884_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I213_MP4 (XI884_I213_p1 XI884_I213_An p7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I213_MP2 (VDD I884_pn10 XI884_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I213_MP3 (XI884_I213_p1 I884_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I213_MP0 (VDD I884_pn10 XI884_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I212_MP1 (VDD I1712_G8_0n XI1712_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I212_MP5 (p25_9 XI1712_I212_Bn XI1712_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I212_MP4 (XI1712_I212_p1 XI1712_I212_An p25_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I212_MP2 (VDD I1712_pn9 XI1712_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I212_MP3 (XI1712_I212_p1 I1712_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I212_MP0 (VDD I1712_pn9 XI1712_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1688_MP1 (VDD qu7_b3_1 XI1688_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1688_MP5 (b25_8 XI1688_Bn XI1688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1688_MP4 (XI1688_p1 XI1688_An b25_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1688_MP2 (VDD dd8_b3_4 XI1688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1688_MP3 (XI1688_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1688_MP0 (VDD dd8_b3_4 XI1688_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1687_MP1 (VDD qu7_b3_1 XI1687_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1687_MP5 (b25_7 XI1687_Bn XI1687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1687_MP4 (XI1687_p1 XI1687_An b25_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1687_MP2 (VDD dd7_b3_4 XI1687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1687_MP3 (XI1687_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1687_MP0 (VDD dd7_b3_4 XI1687_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1735_MP1 (VDD qu6_b3_1 XI1735_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1735_MP5 (b26_9 XI1735_Bn XI1735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1735_MP4 (XI1735_p1 XI1735_An b26_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1735_MP2 (VDD dd9_b3_4 XI1735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1735_MP3 (XI1735_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1735_MP0 (VDD dd9_b3_4 XI1735_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I212_MP1 (VDD I1758_G8_0n XI1758_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I212_MP5 (p26_9 XI1758_I212_Bn XI1758_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I212_MP4 (XI1758_I212_p1 XI1758_I212_An p26_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I212_MP2 (VDD I1758_pn9 XI1758_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I212_MP3 (XI1758_I212_p1 I1758_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I212_MP0 (VDD I1758_pn9 XI1758_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1779_MP1 (VDD qu5_b3_1 XI1779_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1779_MP5 (b27_7 XI1779_Bn XI1779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1779_MP4 (XI1779_p1 XI1779_An b27_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1779_MP2 (VDD dd7_b3_4 XI1779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1779_MP3 (XI1779_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1779_MP0 (VDD dd7_b3_4 XI1779_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1778_MP1 (VDD qu5_b3_1 XI1778_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1778_MP5 (b27_6 XI1778_Bn XI1778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1778_MP4 (XI1778_p1 XI1778_An b27_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1778_MP2 (VDD dd6_b3_4 XI1778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1778_MP3 (XI1778_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1778_MP0 (VDD dd6_b3_4 XI1778_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1780_MP1 (VDD qu5_b3_1 XI1780_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1780_MP5 (b27_8 XI1780_Bn XI1780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1780_MP4 (XI1780_p1 XI1780_An b27_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1780_MP2 (VDD dd8_b3_4 XI1780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1780_MP3 (XI1780_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1780_MP0 (VDD dd8_b3_4 XI1780_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I216_MP1 (VDD I1804_G12_0n XI1804_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I216_MP5 (p27_13 XI1804_I216_Bn XI1804_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I216_MP4 (XI1804_I216_p1 XI1804_I216_An p27_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I216_MP2 (VDD I1804_pn13 XI1804_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I216_MP3 (XI1804_I216_p1 I1804_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I216_MP0 (VDD I1804_pn13 XI1804_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I217_MP1 (VDD I746_G13_0n XI746_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I217_MP5 (p4_14 XI746_I217_Bn XI746_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I217_MP4 (XI746_I217_p1 XI746_I217_An p4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I217_MP2 (VDD I746_pn14 XI746_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I217_MP3 (XI746_I217_p1 I746_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I217_MP0 (VDD I746_pn14 XI746_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I215_MP1 (VDD I792_G11_0n XI792_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I215_MP5 (p5_12 XI792_I215_Bn XI792_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I215_MP4 (XI792_I215_p1 XI792_I215_An p5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I215_MP2 (VDD I792_pn12 XI792_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I215_MP3 (XI792_I215_p1 I792_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I215_MP0 (VDD I792_pn12 XI792_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I214_MP1 (VDD I792_G10_0n XI792_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I214_MP5 (p5_11 XI792_I214_Bn XI792_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I214_MP4 (XI792_I214_p1 XI792_I214_An p5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I214_MP2 (VDD I792_pn11 XI792_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I214_MP3 (XI792_I214_p1 I792_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I214_MP0 (VDD I792_pn11 XI792_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I215_MP1 (VDD I838_G11_0n XI838_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I215_MP5 (p6_12 XI838_I215_Bn XI838_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I215_MP4 (XI838_I215_p1 XI838_I215_An p6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I215_MP2 (VDD I838_pn12 XI838_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I215_MP3 (XI838_I215_p1 I838_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I215_MP0 (VDD I838_pn12 XI838_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I214_MP1 (VDD I838_G10_0n XI838_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I214_MP5 (p6_11 XI838_I214_Bn XI838_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I214_MP4 (XI838_I214_p1 XI838_I214_An p6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I214_MP2 (VDD I838_pn11 XI838_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I214_MP3 (XI838_I214_p1 I838_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I214_MP0 (VDD I838_pn11 XI838_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I214_MP1 (VDD I884_G10_0n XI884_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I214_MP5 (p7_11 XI884_I214_Bn XI884_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I214_MP4 (XI884_I214_p1 XI884_I214_An p7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I214_MP2 (VDD I884_pn11 XI884_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I214_MP3 (XI884_I214_p1 I884_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I214_MP0 (VDD I884_pn11 XI884_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1690_MP1 (VDD qu7_b3_1 XI1690_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1690_MP5 (b25_10 XI1690_Bn XI1690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1690_MP4 (XI1690_p1 XI1690_An b25_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1690_MP2 (VDD dd10_b3_4 XI1690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1690_MP3 (XI1690_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1690_MP0 (VDD dd10_b3_4 XI1690_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1689_MP1 (VDD qu7_b3_1 XI1689_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1689_MP5 (b25_9 XI1689_Bn XI1689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1689_MP4 (XI1689_p1 XI1689_An b25_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1689_MP2 (VDD dd9_b3_4 XI1689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1689_MP3 (XI1689_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1689_MP0 (VDD dd9_b3_4 XI1689_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I213_MP1 (VDD I1712_G9_0n XI1712_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I213_MP5 (p25_10 XI1712_I213_Bn XI1712_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I213_MP4 (XI1712_I213_p1 XI1712_I213_An p25_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I213_MP2 (VDD I1712_pn10 XI1712_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I213_MP3 (XI1712_I213_p1 I1712_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I213_MP0 (VDD I1712_pn10 XI1712_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1736_MP1 (VDD qu6_b3_1 XI1736_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1736_MP5 (b26_10 XI1736_Bn XI1736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1736_MP4 (XI1736_p1 XI1736_An b26_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1736_MP2 (VDD dd10_b3_4 XI1736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1736_MP3 (XI1736_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1736_MP0 (VDD dd10_b3_4 XI1736_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1737_MP1 (VDD qu6_b3_1 XI1737_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1737_MP5 (b26_11 XI1737_Bn XI1737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1737_MP4 (XI1737_p1 XI1737_An b26_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1737_MP2 (VDD dd11_b3_4 XI1737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1737_MP3 (XI1737_p1 qu6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1737_MP0 (VDD dd11_b3_4 XI1737_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I214_MP1 (VDD I1758_G10_0n XI1758_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I214_MP5 (p26_11 XI1758_I214_Bn XI1758_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I214_MP4 (XI1758_I214_p1 XI1758_I214_An p26_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I214_MP2 (VDD I1758_pn11 XI1758_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I214_MP3 (XI1758_I214_p1 I1758_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I214_MP0 (VDD I1758_pn11 XI1758_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I213_MP1 (VDD I1758_G9_0n XI1758_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I213_MP5 (p26_10 XI1758_I213_Bn XI1758_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I213_MP4 (XI1758_I213_p1 XI1758_I213_An p26_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I213_MP2 (VDD I1758_pn10 XI1758_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I213_MP3 (XI1758_I213_p1 I1758_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I213_MP0 (VDD I1758_pn10 XI1758_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1781_MP1 (VDD qu5_b3_1 XI1781_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1781_MP5 (b27_9 XI1781_Bn XI1781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1781_MP4 (XI1781_p1 XI1781_An b27_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1781_MP2 (VDD dd9_b3_4 XI1781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1781_MP3 (XI1781_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1781_MP0 (VDD dd9_b3_4 XI1781_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1782_MP1 (VDD qu5_b3_1 XI1782_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1782_MP5 (b27_10 XI1782_Bn XI1782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1782_MP4 (XI1782_p1 XI1782_An b27_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1782_MP2 (VDD dd10_b3_4 XI1782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1782_MP3 (XI1782_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1782_MP0 (VDD dd10_b3_4 XI1782_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I215_MP1 (VDD I1804_G11_0n XI1804_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I215_MP5 (p27_12 XI1804_I215_Bn XI1804_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I215_MP4 (XI1804_I215_p1 XI1804_I215_An p27_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I215_MP2 (VDD I1804_pn12 XI1804_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I215_MP3 (XI1804_I215_p1 I1804_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I215_MP0 (VDD I1804_pn12 XI1804_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I218_MP1 (VDD I1804_G14_0n XI1804_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I218_MP5 (p27_15 XI1804_I218_Bn XI1804_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I218_MP4 (XI1804_I218_p1 XI1804_I218_An p27_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I218_MP2 (VDD I1804_pn15 XI1804_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I218_MP3 (XI1804_I218_p1 I1804_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I218_MP0 (VDD I1804_pn15 XI1804_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I218_MP1 (VDD I746_G14_0n XI746_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I218_MP5 (p4_15 XI746_I218_Bn XI746_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I218_MP4 (XI746_I218_p1 XI746_I218_An p4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I218_MP2 (VDD I746_pn15 XI746_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I218_MP3 (XI746_I218_p1 I746_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I218_MP0 (VDD I746_pn15 XI746_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I216_MP1 (VDD I746_G12_0n XI746_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I216_MP5 (p4_13 XI746_I216_Bn XI746_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I216_MP4 (XI746_I216_p1 XI746_I216_An p4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I216_MP2 (VDD I746_pn13 XI746_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI746_I216_MP3 (XI746_I216_p1 I746_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I216_MP0 (VDD I746_pn13 XI746_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI819_MP1 (VDD qu26_b3_2 XI819_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI819_MP5 (b6_13 XI819_Bn XI819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI819_MP4 (XI819_p1 XI819_An b6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI819_MP2 (VDD dd13_b3_1 XI819_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI819_MP3 (XI819_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI819_MP0 (VDD dd13_b3_1 XI819_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI818_MP1 (VDD qu26_b3_2 XI818_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI818_MP5 (b6_12 XI818_Bn XI818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI818_MP4 (XI818_p1 XI818_An b6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI818_MP2 (VDD dd12_b3_1 XI818_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI818_MP3 (XI818_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI818_MP0 (VDD dd12_b3_1 XI818_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I216_MP1 (VDD I838_G12_0n XI838_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I216_MP5 (p6_13 XI838_I216_Bn XI838_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I216_MP4 (XI838_I216_p1 XI838_I216_An p6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I216_MP2 (VDD I838_pn13 XI838_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I216_MP3 (XI838_I216_p1 I838_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I216_MP0 (VDD I838_pn13 XI838_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI864_MP1 (VDD qu25_b3_2 XI864_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI864_MP5 (b7_12 XI864_Bn XI864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI864_MP4 (XI864_p1 XI864_An b7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI864_MP2 (VDD dd12_b3_1 XI864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI864_MP3 (XI864_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI864_MP0 (VDD dd12_b3_1 XI864_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI865_MP1 (VDD qu25_b3_2 XI865_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI865_MP5 (b7_13 XI865_Bn XI865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI865_MP4 (XI865_p1 XI865_An b7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI865_MP2 (VDD dd13_b3_1 XI865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI865_MP3 (XI865_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI865_MP0 (VDD dd13_b3_1 XI865_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I214_MP1 (VDD I1712_G10_0n XI1712_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I214_MP5 (p25_11 XI1712_I214_Bn XI1712_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I214_MP4 (XI1712_I214_p1 XI1712_I214_An p25_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I214_MP2 (VDD I1712_pn11 XI1712_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I214_MP3 (XI1712_I214_p1 I1712_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I214_MP0 (VDD I1712_pn11 XI1712_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1691_MP1 (VDD qu7_b3_1 XI1691_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1691_MP5 (b25_11 XI1691_Bn XI1691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1691_MP4 (XI1691_p1 XI1691_An b25_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1691_MP2 (VDD dd11_b3_4 XI1691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1691_MP3 (XI1691_p1 qu7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1691_MP0 (VDD dd11_b3_4 XI1691_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1738_MP1 (VDD qu6_b3_2 XI1738_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1738_MP5 (b26_12 XI1738_Bn XI1738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1738_MP4 (XI1738_p1 XI1738_An b26_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1738_MP2 (VDD dd12_b3_4 XI1738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1738_MP3 (XI1738_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1738_MP0 (VDD dd12_b3_4 XI1738_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1783_MP1 (VDD qu5_b3_1 XI1783_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1783_MP5 (b27_11 XI1783_Bn XI1783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1783_MP4 (XI1783_p1 XI1783_An b27_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1783_MP2 (VDD dd11_b3_4 XI1783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1783_MP3 (XI1783_p1 qu5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1783_MP0 (VDD dd11_b3_4 XI1783_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I215_MP1 (VDD I1758_G11_0n XI1758_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I215_MP5 (p26_12 XI1758_I215_Bn XI1758_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I215_MP4 (XI1758_I215_p1 XI1758_I215_An p26_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I215_MP2 (VDD I1758_pn12 XI1758_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I215_MP3 (XI1758_I215_p1 I1758_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I215_MP0 (VDD I1758_pn12 XI1758_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1784_MP1 (VDD qu5_b3_2 XI1784_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1784_MP5 (b27_12 XI1784_Bn XI1784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1784_MP4 (XI1784_p1 XI1784_An b27_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1784_MP2 (VDD dd12_b3_4 XI1784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1784_MP3 (XI1784_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1784_MP0 (VDD dd12_b3_4 XI1784_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I217_MP1 (VDD I1804_G13_0n XI1804_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I217_MP5 (p27_14 XI1804_I217_Bn XI1804_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I217_MP4 (XI1804_I217_p1 XI1804_I217_An p27_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I217_MP2 (VDD I1804_pn14 XI1804_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I217_MP3 (XI1804_I217_p1 I1804_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I217_MP0 (VDD I1804_pn14 XI1804_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI738_MP1 (VDD qu28_b3_4 XI738_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI738_MP5 (b4_24 XI738_Bn XI738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI738_MP4 (XI738_p1 XI738_An b4_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI738_MP2 (VDD dd24_b3_0 XI738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI738_MP3 (XI738_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI738_MP0 (VDD dd24_b3_0 XI738_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI739_MP1 (VDD qu28_b3_4 XI739_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI739_MP5 (b4_25 XI739_Bn XI739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI739_MP4 (XI739_p1 XI739_An b4_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI739_MP2 (VDD dd25_b3_0 XI739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI739_MP3 (XI739_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI739_MP0 (VDD dd25_b3_0 XI739_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I217_MP1 (VDD I792_G13_0n XI792_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I217_MP5 (p5_14 XI792_I217_Bn XI792_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I217_MP4 (XI792_I217_p1 XI792_I217_An p5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I217_MP2 (VDD I792_pn14 XI792_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I217_MP3 (XI792_I217_p1 I792_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I217_MP0 (VDD I792_pn14 XI792_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I216_MP1 (VDD I792_G12_0n XI792_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I216_MP5 (p5_13 XI792_I216_Bn XI792_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I216_MP4 (XI792_I216_p1 XI792_I216_An p5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I216_MP2 (VDD I792_pn13 XI792_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I216_MP3 (XI792_I216_p1 I792_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I216_MP0 (VDD I792_pn13 XI792_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI820_MP1 (VDD qu26_b3_2 XI820_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI820_MP5 (b6_14 XI820_Bn XI820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI820_MP4 (XI820_p1 XI820_An b6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI820_MP2 (VDD dd14_b3_1 XI820_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI820_MP3 (XI820_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI820_MP0 (VDD dd14_b3_1 XI820_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI821_MP1 (VDD qu26_b3_2 XI821_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI821_MP5 (b6_15 XI821_Bn XI821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI821_MP4 (XI821_p1 XI821_An b6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI821_MP2 (VDD dd15_b3_1 XI821_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI821_MP3 (XI821_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI821_MP0 (VDD dd15_b3_1 XI821_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I217_MP1 (VDD I838_G13_0n XI838_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I217_MP5 (p6_14 XI838_I217_Bn XI838_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I217_MP4 (XI838_I217_p1 XI838_I217_An p6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I217_MP2 (VDD I838_pn14 XI838_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I217_MP3 (XI838_I217_p1 I838_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I217_MP0 (VDD I838_pn14 XI838_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I218_MP1 (VDD I838_G14_0n XI838_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I218_MP5 (p6_15 XI838_I218_Bn XI838_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I218_MP4 (XI838_I218_p1 XI838_I218_An p6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I218_MP2 (VDD I838_pn15 XI838_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I218_MP3 (XI838_I218_p1 I838_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I218_MP0 (VDD I838_pn15 XI838_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI867_MP1 (VDD qu25_b3_2 XI867_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI867_MP5 (b7_15 XI867_Bn XI867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI867_MP4 (XI867_p1 XI867_An b7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI867_MP2 (VDD dd15_b3_1 XI867_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI867_MP3 (XI867_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI867_MP0 (VDD dd15_b3_1 XI867_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI866_MP1 (VDD qu25_b3_2 XI866_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI866_MP5 (b7_14 XI866_Bn XI866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI866_MP4 (XI866_p1 XI866_An b7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI866_MP2 (VDD dd14_b3_1 XI866_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI866_MP3 (XI866_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI866_MP0 (VDD dd14_b3_1 XI866_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I216_MP1 (VDD I1712_G12_0n XI1712_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I216_MP5 (p25_13 XI1712_I216_Bn XI1712_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I216_MP4 (XI1712_I216_p1 XI1712_I216_An p25_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I216_MP2 (VDD I1712_pn13 XI1712_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I216_MP3 (XI1712_I216_p1 I1712_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I216_MP0 (VDD I1712_pn13 XI1712_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1692_MP1 (VDD qu7_b3_2 XI1692_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1692_MP5 (b25_12 XI1692_Bn XI1692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1692_MP4 (XI1692_p1 XI1692_An b25_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1692_MP2 (VDD dd12_b3_4 XI1692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1692_MP3 (XI1692_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1692_MP0 (VDD dd12_b3_4 XI1692_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1693_MP1 (VDD qu7_b3_2 XI1693_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1693_MP5 (b25_13 XI1693_Bn XI1693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1693_MP4 (XI1693_p1 XI1693_An b25_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1693_MP2 (VDD dd13_b3_4 XI1693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1693_MP3 (XI1693_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1693_MP0 (VDD dd13_b3_4 XI1693_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I215_MP1 (VDD I1712_G11_0n XI1712_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I215_MP5 (p25_12 XI1712_I215_Bn XI1712_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I215_MP4 (XI1712_I215_p1 XI1712_I215_An p25_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I215_MP2 (VDD I1712_pn12 XI1712_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I215_MP3 (XI1712_I215_p1 I1712_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I215_MP0 (VDD I1712_pn12 XI1712_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1739_MP1 (VDD qu6_b3_2 XI1739_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1739_MP5 (b26_13 XI1739_Bn XI1739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1739_MP4 (XI1739_p1 XI1739_An b26_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1739_MP2 (VDD dd13_b3_4 XI1739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1739_MP3 (XI1739_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1739_MP0 (VDD dd13_b3_4 XI1739_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I216_MP1 (VDD I1758_G12_0n XI1758_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I216_MP5 (p26_13 XI1758_I216_Bn XI1758_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I216_MP4 (XI1758_I216_p1 XI1758_I216_An p26_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I216_MP2 (VDD I1758_pn13 XI1758_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I216_MP3 (XI1758_I216_p1 I1758_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I216_MP0 (VDD I1758_pn13 XI1758_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I217_MP1 (VDD I1758_G13_0n XI1758_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I217_MP5 (p26_14 XI1758_I217_Bn XI1758_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I217_MP4 (XI1758_I217_p1 XI1758_I217_An p26_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I217_MP2 (VDD I1758_pn14 XI1758_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I217_MP3 (XI1758_I217_p1 I1758_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I217_MP0 (VDD I1758_pn14 XI1758_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1785_MP1 (VDD qu5_b3_2 XI1785_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1785_MP5 (b27_13 XI1785_Bn XI1785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1785_MP4 (XI1785_p1 XI1785_An b27_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1785_MP2 (VDD dd13_b3_4 XI1785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1785_MP3 (XI1785_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1785_MP0 (VDD dd13_b3_4 XI1785_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1786_MP1 (VDD qu5_b3_2 XI1786_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1786_MP5 (b27_14 XI1786_Bn XI1786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1786_MP4 (XI1786_p1 XI1786_An b27_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1786_MP2 (VDD dd14_b3_4 XI1786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1786_MP3 (XI1786_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1786_MP0 (VDD dd14_b3_4 XI1786_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I219_MP1 (VDD I1804_G15_0n XI1804_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I219_MP5 (p27_16 XI1804_I219_Bn XI1804_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I219_MP4 (XI1804_I219_p1 XI1804_I219_An p27_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I219_MP2 (VDD I1804_pn16 XI1804_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1804_I219_MP3 (XI1804_I219_p1 I1804_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I219_MP0 (VDD I1804_pn16 XI1804_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI740_MP1 (VDD qu28_b3_4 XI740_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI740_MP5 (b4_26 XI740_Bn XI740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI740_MP4 (XI740_p1 XI740_An b4_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI740_MP2 (VDD dd26_b3_0 XI740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI740_MP3 (XI740_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI740_MP0 (VDD dd26_b3_0 XI740_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI784_MP1 (VDD qu27_b3_4 XI784_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI784_MP5 (b5_24 XI784_Bn XI784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI784_MP4 (XI784_p1 XI784_An b5_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI784_MP2 (VDD dd24_b3_0 XI784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI784_MP3 (XI784_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI784_MP0 (VDD dd24_b3_0 XI784_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI785_MP1 (VDD qu27_b3_4 XI785_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI785_MP5 (b5_25 XI785_Bn XI785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI785_MP4 (XI785_p1 XI785_An b5_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI785_MP2 (VDD dd25_b3_0 XI785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI785_MP3 (XI785_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI785_MP0 (VDD dd25_b3_0 XI785_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I218_MP1 (VDD I792_G14_0n XI792_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I218_MP5 (p5_15 XI792_I218_Bn XI792_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I218_MP4 (XI792_I218_p1 XI792_I218_An p5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I218_MP2 (VDD I792_pn15 XI792_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I218_MP3 (XI792_I218_p1 I792_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I218_MP0 (VDD I792_pn15 XI792_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I219_MP1 (VDD I838_G15_0n XI838_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I219_MP5 (p6_16 XI838_I219_Bn XI838_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I219_MP4 (XI838_I219_p1 XI838_I219_An p6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I219_MP2 (VDD I838_pn16 XI838_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI838_I219_MP3 (XI838_I219_p1 I838_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I219_MP0 (VDD I838_pn16 XI838_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI868_MP1 (VDD qu25_b3_2 XI868_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI868_MP5 (b7_16 XI868_Bn XI868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI868_MP4 (XI868_p1 XI868_An b7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI868_MP2 (VDD dd16_b3_1 XI868_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI868_MP3 (XI868_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI868_MP0 (VDD dd16_b3_1 XI868_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I216_MP1 (VDD I884_G12_0n XI884_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I216_MP5 (p7_13 XI884_I216_Bn XI884_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I216_MP4 (XI884_I216_p1 XI884_I216_An p7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I216_MP2 (VDD I884_pn13 XI884_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I216_MP3 (XI884_I216_p1 I884_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I216_MP0 (VDD I884_pn13 XI884_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I218_MP1 (VDD I1712_G14_0n XI1712_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I218_MP5 (p25_15 XI1712_I218_Bn XI1712_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I218_MP4 (XI1712_I218_p1 XI1712_I218_An p25_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I218_MP2 (VDD I1712_pn15 XI1712_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I218_MP3 (XI1712_I218_p1 I1712_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I218_MP0 (VDD I1712_pn15 XI1712_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1695_MP1 (VDD qu7_b3_2 XI1695_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1695_MP5 (b25_15 XI1695_Bn XI1695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1695_MP4 (XI1695_p1 XI1695_An b25_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1695_MP2 (VDD dd15_b3_4 XI1695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1695_MP3 (XI1695_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1695_MP0 (VDD dd15_b3_4 XI1695_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1694_MP1 (VDD qu7_b3_2 XI1694_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1694_MP5 (b25_14 XI1694_Bn XI1694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1694_MP4 (XI1694_p1 XI1694_An b25_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1694_MP2 (VDD dd14_b3_4 XI1694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1694_MP3 (XI1694_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1694_MP0 (VDD dd14_b3_4 XI1694_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I217_MP1 (VDD I1712_G13_0n XI1712_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I217_MP5 (p25_14 XI1712_I217_Bn XI1712_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I217_MP4 (XI1712_I217_p1 XI1712_I217_An p25_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I217_MP2 (VDD I1712_pn14 XI1712_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I217_MP3 (XI1712_I217_p1 I1712_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I217_MP0 (VDD I1712_pn14 XI1712_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1740_MP1 (VDD qu6_b3_2 XI1740_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1740_MP5 (b26_14 XI1740_Bn XI1740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1740_MP4 (XI1740_p1 XI1740_An b26_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1740_MP2 (VDD dd14_b3_4 XI1740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1740_MP3 (XI1740_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1740_MP0 (VDD dd14_b3_4 XI1740_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1741_MP1 (VDD qu6_b3_2 XI1741_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1741_MP5 (b26_15 XI1741_Bn XI1741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1741_MP4 (XI1741_p1 XI1741_An b26_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1741_MP2 (VDD dd15_b3_4 XI1741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1741_MP3 (XI1741_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1741_MP0 (VDD dd15_b3_4 XI1741_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I218_MP1 (VDD I1758_G14_0n XI1758_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I218_MP5 (p26_15 XI1758_I218_Bn XI1758_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I218_MP4 (XI1758_I218_p1 XI1758_I218_An p26_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I218_MP2 (VDD I1758_pn15 XI1758_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I218_MP3 (XI1758_I218_p1 I1758_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I218_MP0 (VDD I1758_pn15 XI1758_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I219_MP1 (VDD I1758_G15_0n XI1758_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I219_MP5 (p26_16 XI1758_I219_Bn XI1758_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I219_MP4 (XI1758_I219_p1 XI1758_I219_An p26_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I219_MP2 (VDD I1758_pn16 XI1758_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1758_I219_MP3 (XI1758_I219_p1 I1758_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I219_MP0 (VDD I1758_pn16 XI1758_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1787_MP1 (VDD qu5_b3_2 XI1787_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1787_MP5 (b27_15 XI1787_Bn XI1787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1787_MP4 (XI1787_p1 XI1787_An b27_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1787_MP2 (VDD dd15_b3_4 XI1787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1787_MP3 (XI1787_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1787_MP0 (VDD dd15_b3_4 XI1787_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI745_MP1 (VDD qu28_b3_5 XI745_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI745_MP5 (b4_31 XI745_Bn XI745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI745_MP4 (XI745_p1 XI745_An b4_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI745_MP2 (VDD dd31_b3_0 XI745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI745_MP3 (XI745_p1 qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI745_MP0 (VDD dd31_b3_0 XI745_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI741_MP1 (VDD qu28_b3_4 XI741_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI741_MP5 (b4_27 XI741_Bn XI741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI741_MP4 (XI741_p1 XI741_An b4_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI741_MP2 (VDD dd27_b3_0 XI741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI741_MP3 (XI741_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI741_MP0 (VDD dd27_b3_0 XI741_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI787_MP1 (VDD qu27_b3_4 XI787_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI787_MP5 (b5_27 XI787_Bn XI787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI787_MP4 (XI787_p1 XI787_An b5_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI787_MP2 (VDD dd27_b3_0 XI787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI787_MP3 (XI787_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI787_MP0 (VDD dd27_b3_0 XI787_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI786_MP1 (VDD qu27_b3_4 XI786_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI786_MP5 (b5_26 XI786_Bn XI786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI786_MP4 (XI786_p1 XI786_An b5_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI786_MP2 (VDD dd26_b3_0 XI786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI786_MP3 (XI786_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI786_MP0 (VDD dd26_b3_0 XI786_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I219_MP1 (VDD I792_G15_0n XI792_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I219_MP5 (p5_16 XI792_I219_Bn XI792_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I219_MP4 (XI792_I219_p1 XI792_I219_An p5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I219_MP2 (VDD I792_pn16 XI792_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI792_I219_MP3 (XI792_I219_p1 I792_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I219_MP0 (VDD I792_pn16 XI792_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI823_MP1 (VDD qu26_b3_2 XI823_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI823_MP5 (b6_17 XI823_Bn XI823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI823_MP4 (XI823_p1 XI823_An b6_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI823_MP2 (VDD dd17_b3_1 XI823_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI823_MP3 (XI823_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI823_MP0 (VDD dd17_b3_1 XI823_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI822_MP1 (VDD qu26_b3_2 XI822_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI822_MP5 (b6_16 XI822_Bn XI822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI822_MP4 (XI822_p1 XI822_An b6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI822_MP2 (VDD dd16_b3_1 XI822_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI822_MP3 (XI822_p1 qu26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI822_MP0 (VDD dd16_b3_1 XI822_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI869_MP1 (VDD qu25_b3_2 XI869_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI869_MP5 (b7_17 XI869_Bn XI869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI869_MP4 (XI869_p1 XI869_An b7_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI869_MP2 (VDD dd17_b3_1 XI869_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI869_MP3 (XI869_p1 qu25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI869_MP0 (VDD dd17_b3_1 XI869_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I215_MP1 (VDD I884_G11_0n XI884_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I215_MP5 (p7_12 XI884_I215_Bn XI884_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I215_MP4 (XI884_I215_p1 XI884_I215_An p7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I215_MP2 (VDD I884_pn12 XI884_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I215_MP3 (XI884_I215_p1 I884_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I215_MP0 (VDD I884_pn12 XI884_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1696_MP1 (VDD qu7_b3_2 XI1696_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1696_MP5 (b25_16 XI1696_Bn XI1696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1696_MP4 (XI1696_p1 XI1696_An b25_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1696_MP2 (VDD dd16_b3_4 XI1696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1696_MP3 (XI1696_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1696_MP0 (VDD dd16_b3_4 XI1696_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1697_MP1 (VDD qu7_b3_2 XI1697_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1697_MP5 (b25_17 XI1697_Bn XI1697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1697_MP4 (XI1697_p1 XI1697_An b25_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1697_MP2 (VDD dd17_b3_4 XI1697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1697_MP3 (XI1697_p1 qu7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1697_MP0 (VDD dd17_b3_4 XI1697_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I219_MP1 (VDD I1712_G15_0n XI1712_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I219_MP5 (p25_16 XI1712_I219_Bn XI1712_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I219_MP4 (XI1712_I219_p1 XI1712_I219_An p25_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I219_MP2 (VDD I1712_pn16 XI1712_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1712_I219_MP3 (XI1712_I219_p1 I1712_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I219_MP0 (VDD I1712_pn16 XI1712_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1742_MP1 (VDD qu6_b3_2 XI1742_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1742_MP5 (b26_16 XI1742_Bn XI1742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1742_MP4 (XI1742_p1 XI1742_An b26_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1742_MP2 (VDD dd16_b3_4 XI1742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1742_MP3 (XI1742_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1742_MP0 (VDD dd16_b3_4 XI1742_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1743_MP1 (VDD qu6_b3_2 XI1743_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1743_MP5 (b26_17 XI1743_Bn XI1743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1743_MP4 (XI1743_p1 XI1743_An b26_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1743_MP2 (VDD dd17_b3_4 XI1743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1743_MP3 (XI1743_p1 qu6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1743_MP0 (VDD dd17_b3_4 XI1743_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1789_MP1 (VDD qu5_b3_2 XI1789_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1789_MP5 (b27_17 XI1789_Bn XI1789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1789_MP4 (XI1789_p1 XI1789_An b27_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1789_MP2 (VDD dd17_b3_4 XI1789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1789_MP3 (XI1789_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1789_MP0 (VDD dd17_b3_4 XI1789_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1788_MP1 (VDD qu5_b3_2 XI1788_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1788_MP5 (b27_16 XI1788_Bn XI1788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1788_MP4 (XI1788_p1 XI1788_An b27_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1788_MP2 (VDD dd16_b3_4 XI1788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1788_MP3 (XI1788_p1 qu5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1788_MP0 (VDD dd16_b3_4 XI1788_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI744_MP1 (VDD qu28_b3_5 XI744_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI744_MP5 (b4_30 XI744_Bn XI744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI744_MP4 (XI744_p1 XI744_An b4_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI744_MP2 (VDD dd30_b3_0 XI744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI744_MP3 (XI744_p1 qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI744_MP0 (VDD dd30_b3_0 XI744_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI791_MP1 (VDD qu27_b3_5 XI791_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI791_MP5 (b5_31 XI791_Bn XI791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI791_MP4 (XI791_p1 XI791_An b5_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI791_MP2 (VDD dd31_b3_0 XI791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI791_MP3 (XI791_p1 qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI791_MP0 (VDD dd31_b3_0 XI791_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI790_MP1 (VDD qu27_b3_5 XI790_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI790_MP5 (b5_30 XI790_Bn XI790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI790_MP4 (XI790_p1 XI790_An b5_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI790_MP2 (VDD dd30_b3_0 XI790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI790_MP3 (XI790_p1 qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI790_MP0 (VDD dd30_b3_0 XI790_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI840_MP1 (VDD c6_o XI840_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI840_MP5 (p6_32 XI840_Bn XI840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI840_MP4 (XI840_p1 XI840_An p6_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI840_MP2 (VDD h6 XI840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI840_MP3 (XI840_p1 c6_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI840_MP0 (VDD h6 XI840_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I218_MP1 (VDD I884_G14_0n XI884_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I218_MP5 (p7_15 XI884_I218_Bn XI884_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I218_MP4 (XI884_I218_p1 XI884_I218_An p7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I218_MP2 (VDD I884_pn15 XI884_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I218_MP3 (XI884_I218_p1 I884_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I218_MP0 (VDD I884_pn15 XI884_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I217_MP1 (VDD I884_G13_0n XI884_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I217_MP5 (p7_14 XI884_I217_Bn XI884_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I217_MP4 (XI884_I217_p1 XI884_I217_An p7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I217_MP2 (VDD I884_pn14 XI884_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I217_MP3 (XI884_I217_p1 I884_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I217_MP0 (VDD I884_pn14 XI884_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI743_MP1 (VDD qu28_b3_4 XI743_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI743_MP5 (b4_29 XI743_Bn XI743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI743_MP4 (XI743_p1 XI743_An b4_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI743_MP2 (VDD dd29_b3_0 XI743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI743_MP3 (XI743_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI743_MP0 (VDD dd29_b3_0 XI743_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI742_MP1 (VDD qu28_b3_4 XI742_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI742_MP5 (b4_28 XI742_Bn XI742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI742_MP4 (XI742_p1 XI742_An b4_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI742_MP2 (VDD dd28_b3_0 XI742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI742_MP3 (XI742_p1 qu28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI742_MP0 (VDD dd28_b3_0 XI742_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI793_MP1 (VDD qu27_b3_5 XI793_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI793_MP5 (h5 XI793_Bn XI793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI793_MP4 (XI793_p1 XI793_An h5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI793_MP2 (VDD p4_31 XI793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI793_MP3 (XI793_p1 qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI793_MP0 (VDD p4_31 XI793_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI789_MP1 (VDD qu27_b3_4 XI789_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI789_MP5 (b5_29 XI789_Bn XI789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI789_MP4 (XI789_p1 XI789_An b5_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI789_MP2 (VDD dd29_b3_0 XI789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI789_MP3 (XI789_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI789_MP0 (VDD dd29_b3_0 XI789_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI788_MP1 (VDD qu27_b3_4 XI788_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI788_MP5 (b5_28 XI788_Bn XI788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI788_MP4 (XI788_p1 XI788_An b5_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI788_MP2 (VDD dd28_b3_0 XI788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI788_MP3 (XI788_p1 qu27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI788_MP0 (VDD dd28_b3_0 XI788_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI839_MP1 (VDD qu26_b3_5 XI839_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI839_MP5 (h6 XI839_Bn XI839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI839_MP4 (XI839_p1 XI839_An h6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI839_MP2 (VDD p5_31 XI839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI839_MP3 (XI839_p1 qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI839_MP0 (VDD p5_31 XI839_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI826_MP1 (VDD qu26_b3_3 XI826_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI826_MP5 (b6_20 XI826_Bn XI826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI826_MP4 (XI826_p1 XI826_An b6_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI826_MP2 (VDD dd20_b3_1 XI826_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI826_MP3 (XI826_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI826_MP0 (VDD dd20_b3_1 XI826_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI872_MP1 (VDD qu25_b3_3 XI872_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI872_MP5 (b7_20 XI872_Bn XI872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI872_MP4 (XI872_p1 XI872_An b7_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI872_MP2 (VDD dd20_b3_1 XI872_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI872_MP3 (XI872_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI872_MP0 (VDD dd20_b3_1 XI872_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1746_MP1 (VDD qu6_b3_3 XI1746_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1746_MP5 (b26_20 XI1746_Bn XI1746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1746_MP4 (XI1746_p1 XI1746_An b26_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1746_MP2 (VDD dd20_b3_4 XI1746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1746_MP3 (XI1746_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1746_MP0 (VDD dd20_b3_4 XI1746_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1745_MP1 (VDD qu6_b3_3 XI1745_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1745_MP5 (b26_19 XI1745_Bn XI1745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1745_MP4 (XI1745_p1 XI1745_An b26_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1745_MP2 (VDD dd19_b3_4 XI1745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1745_MP3 (XI1745_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1745_MP0 (VDD dd19_b3_4 XI1745_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1805_MP1 (VDD qu5_b3_5 XI1805_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1805_MP5 (h27 XI1805_Bn XI1805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1805_MP4 (XI1805_p1 XI1805_An h27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1805_MP2 (VDD p26_31 XI1805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1805_MP3 (XI1805_p1 qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1805_MP0 (VDD p26_31 XI1805_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1791_MP1 (VDD qu5_b3_3 XI1791_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1791_MP5 (b27_19 XI1791_Bn XI1791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1791_MP4 (XI1791_p1 XI1791_An b27_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1791_MP2 (VDD dd19_b3_4 XI1791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1791_MP3 (XI1791_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1791_MP0 (VDD dd19_b3_4 XI1791_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1806_MP1 (VDD c27_o XI1806_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1806_MP5 (p27_32 XI1806_Bn XI1806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1806_MP4 (XI1806_p1 XI1806_An p27_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1806_MP2 (VDD h27 XI1806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1806_MP3 (XI1806_p1 c27_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1806_MP0 (VDD h27 XI1806_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1792_MP1 (VDD qu5_b3_3 XI1792_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1792_MP5 (b27_20 XI1792_Bn XI1792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1792_MP4 (XI1792_p1 XI1792_An b27_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1792_MP2 (VDD dd20_b3_4 XI1792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1792_MP3 (XI1792_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1792_MP0 (VDD dd20_b3_4 XI1792_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI794_MP1 (VDD c5_o XI794_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI794_MP5 (p5_32 XI794_Bn XI794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI794_MP4 (XI794_p1 XI794_An p5_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI794_MP2 (VDD h5 XI794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI794_MP3 (XI794_p1 c5_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI794_MP0 (VDD h5 XI794_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI825_MP1 (VDD qu26_b3_3 XI825_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI825_MP5 (b6_19 XI825_Bn XI825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI825_MP4 (XI825_p1 XI825_An b6_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI825_MP2 (VDD dd19_b3_1 XI825_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI825_MP3 (XI825_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI825_MP0 (VDD dd19_b3_1 XI825_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI824_MP1 (VDD qu26_b3_3 XI824_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI824_MP5 (b6_18 XI824_Bn XI824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI824_MP4 (XI824_p1 XI824_An b6_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI824_MP2 (VDD dd18_b3_1 XI824_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI824_MP3 (XI824_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI824_MP0 (VDD dd18_b3_1 XI824_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI885_MP1 (VDD qu25_b3_5 XI885_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI885_MP5 (h7 XI885_Bn XI885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI885_MP4 (XI885_p1 XI885_An h7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI885_MP2 (VDD p6_31 XI885_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI885_MP3 (XI885_p1 qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI885_MP0 (VDD p6_31 XI885_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI873_MP1 (VDD qu25_b3_3 XI873_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI873_MP5 (b7_21 XI873_Bn XI873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI873_MP4 (XI873_p1 XI873_An b7_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI873_MP2 (VDD dd21_b3_1 XI873_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI873_MP3 (XI873_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI873_MP0 (VDD dd21_b3_1 XI873_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI871_MP1 (VDD qu25_b3_3 XI871_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI871_MP5 (b7_19 XI871_Bn XI871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI871_MP4 (XI871_p1 XI871_An b7_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI871_MP2 (VDD dd19_b3_1 XI871_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI871_MP3 (XI871_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI871_MP0 (VDD dd19_b3_1 XI871_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI875_MP1 (VDD qu25_b3_3 XI875_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI875_MP5 (b7_23 XI875_Bn XI875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI875_MP4 (XI875_p1 XI875_An b7_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI875_MP2 (VDD dd23_b3_1 XI875_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI875_MP3 (XI875_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI875_MP0 (VDD dd23_b3_1 XI875_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI870_MP1 (VDD qu25_b3_3 XI870_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI870_MP5 (b7_18 XI870_Bn XI870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI870_MP4 (XI870_p1 XI870_An b7_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI870_MP2 (VDD dd18_b3_1 XI870_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI870_MP3 (XI870_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI870_MP0 (VDD dd18_b3_1 XI870_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I219_MP1 (VDD I884_G15_0n XI884_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I219_MP5 (p7_16 XI884_I219_Bn XI884_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I219_MP4 (XI884_I219_p1 XI884_I219_An p7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I219_MP2 (VDD I884_pn16 XI884_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI884_I219_MP3 (XI884_I219_p1 I884_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I219_MP0 (VDD I884_pn16 XI884_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1698_MP1 (VDD qu7_b3_3 XI1698_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1698_MP5 (b25_18 XI1698_Bn XI1698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1698_MP4 (XI1698_p1 XI1698_An b25_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1698_MP2 (VDD dd18_b3_4 XI1698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1698_MP3 (XI1698_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1698_MP0 (VDD dd18_b3_4 XI1698_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1699_MP1 (VDD qu7_b3_3 XI1699_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1699_MP5 (b25_19 XI1699_Bn XI1699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1699_MP4 (XI1699_p1 XI1699_An b25_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1699_MP2 (VDD dd19_b3_4 XI1699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1699_MP3 (XI1699_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1699_MP0 (VDD dd19_b3_4 XI1699_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1714_MP1 (VDD c25_o XI1714_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1714_MP5 (p25_32 XI1714_Bn XI1714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1714_MP4 (XI1714_p1 XI1714_An p25_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1714_MP2 (VDD h25 XI1714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1714_MP3 (XI1714_p1 c25_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1714_MP0 (VDD h25 XI1714_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1748_MP1 (VDD qu6_b3_3 XI1748_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1748_MP5 (b26_22 XI1748_Bn XI1748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1748_MP4 (XI1748_p1 XI1748_An b26_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1748_MP2 (VDD dd22_b3_4 XI1748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1748_MP3 (XI1748_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1748_MP0 (VDD dd22_b3_4 XI1748_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1747_MP1 (VDD qu6_b3_3 XI1747_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1747_MP5 (b26_21 XI1747_Bn XI1747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1747_MP4 (XI1747_p1 XI1747_An b26_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1747_MP2 (VDD dd21_b3_4 XI1747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1747_MP3 (XI1747_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
