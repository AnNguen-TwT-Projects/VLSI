    I_MXI838_I175_XG_MP0 (VDD I838_P24_17 XI838_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I175_XG_MP1 (XI838_I175_XG_p1 I838_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I163_XG_MP2 (XI838_I163_XG_p1 I838_G12_5 I838_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I163_XG_MP0 (VDD I838_P12_5 XI838_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I163_XG_MP1 (XI838_I163_XG_p1 I838_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I108_XG_MP2 (XI884_I108_XG_p1 I884_G12_11 I884_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I108_XG_MP0 (VDD I884_P12_11 XI884_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I108_XG_MP1 (XI884_I108_XG_p1 I884_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I160_XG_MP2 (XI884_I160_XG_p1 I884_G10_3 I884_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I160_XG_MP0 (VDD I884_P10_3 XI884_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I160_XG_MP1 (XI884_I160_XG_p1 I884_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I107_XG_MP2 (XI884_I107_XG_p1 I884_G11_10 I884_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I107_XG_MP0 (VDD I884_P11_10 XI884_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I107_XG_MP1 (XI884_I107_XG_p1 I884_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I168_XG_MP2 (XI884_I168_XG_p1 I884_G17_10 I884_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I168_XG_MP0 (VDD I884_P17_10 XI884_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I168_XG_MP1 (XI884_I168_XG_p1 I884_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I169_XG_MP2 (XI1712_I169_XG_p1 I1712_G18_11 I1712_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I169_XG_MP0 (VDD I1712_P18_11 XI1712_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I169_XG_MP1 (XI1712_I169_XG_p1 I1712_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I160_XG_MP2 (XI1712_I160_XG_p1 I1712_G10_3 I1712_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I160_XG_MP0 (VDD I1712_P10_3 XI1712_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I160_XG_MP1 (XI1712_I160_XG_p1 I1712_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I108_XG_MP2 (XI1712_I108_XG_p1 I1712_G12_11 I1712_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I108_XG_MP0 (VDD I1712_P12_11 XI1712_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I108_XG_MP1 (XI1712_I108_XG_p1 I1712_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I105_XG_MP2 (XI1712_I105_XG_p1 I1712_G9_8 I1712_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I105_XG_MP0 (VDD I1712_P9_8 XI1712_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I105_XG_MP1 (XI1712_I105_XG_p1 I1712_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I158_XG_MP2 (XI1712_I158_XG_p1 I1712_G9_2 I1712_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I158_XG_MP0 (VDD I1712_P9_2 XI1712_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I158_XG_MP1 (XI1712_I158_XG_p1 I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I108_XG_MP2 (XI1758_I108_XG_p1 I1758_G12_11 I1758_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I108_XG_MP0 (VDD I1758_P12_11 XI1758_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I108_XG_MP1 (XI1758_I108_XG_p1 I1758_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I169_XG_MP2 (XI1758_I169_XG_p1 I1758_G18_11 I1758_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I169_XG_MP0 (VDD I1758_P18_11 XI1758_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I169_XG_MP1 (XI1758_I169_XG_p1 I1758_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I160_XG_MP2 (XI1758_I160_XG_p1 I1758_G10_3 I1758_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I160_XG_MP0 (VDD I1758_P10_3 XI1758_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I160_XG_MP1 (XI1758_I160_XG_p1 I1758_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I168_XG_MP2 (XI1758_I168_XG_p1 I1758_G17_10 I1758_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I168_XG_MP0 (VDD I1758_P17_10 XI1758_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I168_XG_MP1 (XI1758_I168_XG_p1 I1758_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I158_XG_MP2 (XI1758_I158_XG_p1 I1758_G9_2 I1758_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I158_XG_MP0 (VDD I1758_P9_2 XI1758_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I158_XG_MP1 (XI1758_I158_XG_p1 I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I107_XG_MP2 (XI1804_I107_XG_p1 I1804_G11_10 I1804_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I107_XG_MP0 (VDD I1804_P11_10 XI1804_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I107_XG_MP1 (XI1804_I107_XG_p1 I1804_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I162_XG_MP2 (XI1804_I162_XG_p1 I1804_G11_4 I1804_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I162_XG_MP0 (VDD I1804_P11_4 XI1804_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I162_XG_MP1 (XI1804_I162_XG_p1 I1804_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I168_XG_MP2 (XI1804_I168_XG_p1 I1804_G17_10 I1804_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I168_XG_MP0 (VDD I1804_P17_10 XI1804_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I168_XG_MP1 (XI1804_I168_XG_p1 I1804_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I110_XG_MP2 (XI1804_I110_XG_p1 I1804_G14_13 I1804_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I110_XG_MP0 (VDD I1804_P14_13 XI1804_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I110_XG_MP1 (XI1804_I110_XG_p1 I1804_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I165_XG_MP2 (XI1804_I165_XG_p1 I1804_G14_7 I1804_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I165_XG_MP0 (VDD I1804_P14_7 XI1804_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I165_XG_MP1 (XI1804_I165_XG_p1 I1804_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I177_XG_MP2 (XI1804_I177_XG_p1 I1804_G26_19 I1804_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I177_XG_MP0 (VDD I1804_P26_19 XI1804_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I177_XG_MP1 (XI1804_I177_XG_p1 I1804_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I173_XG_MP2 (XI1804_I173_XG_p1 I1804_G22_15 I1804_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I173_XG_MP0 (VDD I1804_P22_15 XI1804_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I173_XG_MP1 (XI1804_I173_XG_p1 I1804_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I121_XG_MP2 (XI746_I121_XG_p1 I746_G25_24 I746_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I121_XG_MP0 (VDD I746_P25_24 XI746_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I121_XG_MP1 (XI746_I121_XG_p1 I746_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I180_XG_MP2 (XI746_I180_XG_p1 I746_G29_22 I746_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I180_XG_MP0 (VDD I746_P29_22 XI746_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I180_XG_MP1 (XI746_I180_XG_p1 I746_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I114_XG_MP2 (XI746_I114_XG_p1 I746_G18_17 I746_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I114_XG_MP0 (VDD I746_P18_17 XI746_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I114_XG_MP1 (XI746_I114_XG_p1 I746_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I112_XG_MP2 (XI746_I112_XG_p1 I746_G16_15 I746_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I112_XG_MP0 (VDD I746_P16_15 XI746_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I112_XG_MP1 (XI746_I112_XG_p1 I746_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I163_XG_MP2 (XI746_I163_XG_p1 I746_G12_5 I746_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I163_XG_MP0 (VDD I746_P12_5 XI746_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I163_XG_MP1 (XI746_I163_XG_p1 I746_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I160_XG_MP2 (XI746_I160_XG_p1 I746_G10_3 I746_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I160_XG_MP0 (VDD I746_P10_3 XI746_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I160_XG_MP1 (XI746_I160_XG_p1 I746_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I111_XG_MP2 (XI792_I111_XG_p1 I792_G15_14 I792_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I111_XG_MP0 (VDD I792_P15_14 XI792_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I111_XG_MP1 (XI792_I111_XG_p1 I792_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I162_XG_MP2 (XI792_I162_XG_p1 I792_G11_4 I792_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I162_XG_MP0 (VDD I792_P11_4 XI792_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I162_XG_MP1 (XI792_I162_XG_p1 I792_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I112_XG_MP2 (XI792_I112_XG_p1 I792_G16_15 I792_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I112_XG_MP0 (VDD I792_P16_15 XI792_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I112_XG_MP1 (XI792_I112_XG_p1 I792_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I163_XG_MP2 (XI792_I163_XG_p1 I792_G12_5 I792_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I163_XG_MP0 (VDD I792_P12_5 XI792_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I163_XG_MP1 (XI792_I163_XG_p1 I792_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I169_XG_MP2 (XI792_I169_XG_p1 I792_G18_11 I792_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I169_XG_MP0 (VDD I792_P18_11 XI792_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I169_XG_MP1 (XI792_I169_XG_p1 I792_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I111_XG_MP2 (XI838_I111_XG_p1 I838_G15_14 I838_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I111_XG_MP0 (VDD I838_P15_14 XI838_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I111_XG_MP1 (XI838_I111_XG_p1 I838_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I162_XG_MP2 (XI838_I162_XG_p1 I838_G11_4 I838_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I162_XG_MP0 (VDD I838_P11_4 XI838_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I162_XG_MP1 (XI838_I162_XG_p1 I838_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I172_XG_MP2 (XI838_I172_XG_p1 I838_G21_14 I838_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I172_XG_MP0 (VDD I838_P21_14 XI838_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I172_XG_MP1 (XI838_I172_XG_p1 I838_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I164_XG_MP2 (XI838_I164_XG_p1 I838_G13_6 I838_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I164_XG_MP0 (VDD I838_P13_6 XI838_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I164_XG_MP1 (XI838_I164_XG_p1 I838_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I110_XG_MP2 (XI838_I110_XG_p1 I838_G14_13 I838_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I110_XG_MP0 (VDD I838_P14_13 XI838_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I110_XG_MP1 (XI838_I110_XG_p1 I838_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I171_XG_MP2 (XI838_I171_XG_p1 I838_G20_13 I838_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I171_XG_MP0 (VDD I838_P20_13 XI838_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I171_XG_MP1 (XI838_I171_XG_p1 I838_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I110_XG_MP2 (XI884_I110_XG_p1 I884_G14_13 I884_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I110_XG_MP0 (VDD I884_P14_13 XI884_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I110_XG_MP1 (XI884_I110_XG_p1 I884_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I169_XG_MP2 (XI884_I169_XG_p1 I884_G18_11 I884_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I169_XG_MP0 (VDD I884_P18_11 XI884_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I169_XG_MP1 (XI884_I169_XG_p1 I884_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I175_XG_MP2 (XI884_I175_XG_p1 I884_G24_17 I884_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I175_XG_MP0 (VDD I884_P24_17 XI884_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I175_XG_MP1 (XI884_I175_XG_p1 I884_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I163_XG_MP2 (XI884_I163_XG_p1 I884_G12_5 I884_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I163_XG_MP0 (VDD I884_P12_5 XI884_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I163_XG_MP1 (XI884_I163_XG_p1 I884_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I109_XG_MP2 (XI884_I109_XG_p1 I884_G13_12 I884_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I109_XG_MP0 (VDD I884_P13_12 XI884_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I109_XG_MP1 (XI884_I109_XG_p1 I884_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I164_XG_MP2 (XI884_I164_XG_p1 I884_G13_6 I884_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I164_XG_MP0 (VDD I884_P13_6 XI884_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I164_XG_MP1 (XI884_I164_XG_p1 I884_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I176_XG_MP2 (XI884_I176_XG_p1 I884_G25_18 I884_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I176_XG_MP0 (VDD I884_P25_18 XI884_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I176_XG_MP1 (XI884_I176_XG_p1 I884_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I165_XG_MP2 (XI1712_I165_XG_p1 I1712_G14_7 I1712_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I165_XG_MP0 (VDD I1712_P14_7 XI1712_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I165_XG_MP1 (XI1712_I165_XG_p1 I1712_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I175_XG_MP2 (XI1712_I175_XG_p1 I1712_G24_17 I1712_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I175_XG_MP0 (VDD I1712_P24_17 XI1712_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I175_XG_MP1 (XI1712_I175_XG_p1 I1712_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I110_XG_MP2 (XI1712_I110_XG_p1 I1712_G14_13 I1712_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I110_XG_MP0 (VDD I1712_P14_13 XI1712_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I110_XG_MP1 (XI1712_I110_XG_p1 I1712_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I107_XG_MP2 (XI1712_I107_XG_p1 I1712_G11_10 I1712_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I107_XG_MP0 (VDD I1712_P11_10 XI1712_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I107_XG_MP1 (XI1712_I107_XG_p1 I1712_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I168_XG_MP2 (XI1712_I168_XG_p1 I1712_G17_10 I1712_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I168_XG_MP0 (VDD I1712_P17_10 XI1712_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I168_XG_MP1 (XI1712_I168_XG_p1 I1712_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I162_XG_MP2 (XI1712_I162_XG_p1 I1712_G11_4 I1712_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I162_XG_MP0 (VDD I1712_P11_4 XI1712_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I162_XG_MP1 (XI1712_I162_XG_p1 I1712_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I110_XG_MP2 (XI1758_I110_XG_p1 I1758_G14_13 I1758_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I110_XG_MP0 (VDD I1758_P14_13 XI1758_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I110_XG_MP1 (XI1758_I110_XG_p1 I1758_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I175_XG_MP2 (XI1758_I175_XG_p1 I1758_G24_17 I1758_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I175_XG_MP0 (VDD I1758_P24_17 XI1758_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I175_XG_MP1 (XI1758_I175_XG_p1 I1758_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I163_XG_MP2 (XI1758_I163_XG_p1 I1758_G12_5 I1758_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I163_XG_MP0 (VDD I1758_P12_5 XI1758_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I163_XG_MP1 (XI1758_I163_XG_p1 I1758_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I107_XG_MP2 (XI1758_I107_XG_p1 I1758_G11_10 I1758_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I107_XG_MP0 (VDD I1758_P11_10 XI1758_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I107_XG_MP1 (XI1758_I107_XG_p1 I1758_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I109_XG_MP2 (XI1758_I109_XG_p1 I1758_G13_12 I1758_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I109_XG_MP0 (VDD I1758_P13_12 XI1758_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I109_XG_MP1 (XI1758_I109_XG_p1 I1758_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I176_XG_MP2 (XI1758_I176_XG_p1 I1758_G25_18 I1758_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I176_XG_MP0 (VDD I1758_P25_18 XI1758_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I176_XG_MP1 (XI1758_I176_XG_p1 I1758_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I162_XG_MP2 (XI1758_I162_XG_p1 I1758_G11_4 I1758_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I162_XG_MP0 (VDD I1758_P11_4 XI1758_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I162_XG_MP1 (XI1758_I162_XG_p1 I1758_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I109_XG_MP2 (XI1804_I109_XG_p1 I1804_G13_12 I1804_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I109_XG_MP0 (VDD I1804_P13_12 XI1804_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I109_XG_MP1 (XI1804_I109_XG_p1 I1804_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I170_XG_MP2 (XI1804_I170_XG_p1 I1804_G19_12 I1804_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I170_XG_MP0 (VDD I1804_P19_12 XI1804_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I170_XG_MP1 (XI1804_I170_XG_p1 I1804_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I112_XG_MP2 (XI1804_I112_XG_p1 I1804_G16_15 I1804_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I112_XG_MP0 (VDD I1804_P16_15 XI1804_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I112_XG_MP1 (XI1804_I112_XG_p1 I1804_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I114_XG_MP2 (XI1804_I114_XG_p1 I1804_G18_17 I1804_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I114_XG_MP0 (VDD I1804_P18_17 XI1804_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I114_XG_MP1 (XI1804_I114_XG_p1 I1804_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I179_XG_MP2 (XI1804_I179_XG_p1 I1804_G28_21 I1804_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I179_XG_MP0 (VDD I1804_P28_21 XI1804_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I179_XG_MP1 (XI1804_I179_XG_p1 I1804_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I123_XG_MP2 (XI746_I123_XG_p1 I746_G27_26 I746_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I123_XG_MP0 (VDD I746_P27_26 XI746_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I123_XG_MP1 (XI746_I123_XG_p1 I746_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I118_XG_MP2 (XI746_I118_XG_p1 I746_G22_21 I746_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I118_XG_MP0 (VDD I746_P22_21 XI746_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I118_XG_MP1 (XI746_I118_XG_p1 I746_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I116_XG_MP2 (XI746_I116_XG_p1 I746_G20_19 I746_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I116_XG_MP0 (VDD I746_P20_19 XI746_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I116_XG_MP1 (XI746_I116_XG_p1 I746_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I171_XG_MP2 (XI746_I171_XG_p1 I746_G20_13 I746_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I171_XG_MP0 (VDD I746_P20_13 XI746_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I171_XG_MP1 (XI746_I171_XG_p1 I746_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I175_XG_MP2 (XI746_I175_XG_p1 I746_G24_17 I746_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I175_XG_MP0 (VDD I746_P24_17 XI746_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I175_XG_MP1 (XI746_I175_XG_p1 I746_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I169_XG_MP2 (XI746_I169_XG_p1 I746_G18_11 I746_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I169_XG_MP0 (VDD I746_P18_11 XI746_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I169_XG_MP1 (XI746_I169_XG_p1 I746_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I115_XG_MP2 (XI792_I115_XG_p1 I792_G19_18 I792_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I115_XG_MP0 (VDD I792_P19_18 XI792_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I115_XG_MP1 (XI792_I115_XG_p1 I792_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I113_XG_MP2 (XI792_I113_XG_p1 I792_G17_16 I792_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I113_XG_MP0 (VDD I792_P17_16 XI792_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I113_XG_MP1 (XI792_I113_XG_p1 I792_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I170_XG_MP2 (XI792_I170_XG_p1 I792_G19_12 I792_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I170_XG_MP0 (VDD I792_P19_12 XI792_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I170_XG_MP1 (XI792_I170_XG_p1 I792_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I164_XG_MP2 (XI792_I164_XG_p1 I792_G13_6 I792_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I164_XG_MP0 (VDD I792_P13_6 XI792_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I164_XG_MP1 (XI792_I164_XG_p1 I792_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I116_XG_MP2 (XI792_I116_XG_p1 I792_G20_19 I792_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I116_XG_MP0 (VDD I792_P20_19 XI792_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I116_XG_MP1 (XI792_I116_XG_p1 I792_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I114_XG_MP2 (XI792_I114_XG_p1 I792_G18_17 I792_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I114_XG_MP0 (VDD I792_P18_17 XI792_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I114_XG_MP1 (XI792_I114_XG_p1 I792_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I171_XG_MP2 (XI792_I171_XG_p1 I792_G20_13 I792_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I171_XG_MP0 (VDD I792_P20_13 XI792_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I171_XG_MP1 (XI792_I171_XG_p1 I792_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I175_XG_MP2 (XI792_I175_XG_p1 I792_G24_17 I792_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I175_XG_MP0 (VDD I792_P24_17 XI792_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I175_XG_MP1 (XI792_I175_XG_p1 I792_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I113_XG_MP2 (XI838_I113_XG_p1 I838_G17_16 I838_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I113_XG_MP0 (VDD I838_P17_16 XI838_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I113_XG_MP1 (XI838_I113_XG_p1 I838_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I170_XG_MP2 (XI838_I170_XG_p1 I838_G19_12 I838_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I170_XG_MP0 (VDD I838_P19_12 XI838_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I170_XG_MP1 (XI838_I170_XG_p1 I838_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I180_XG_MP2 (XI838_I180_XG_p1 I838_G29_22 I838_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I180_XG_MP0 (VDD I838_P29_22 XI838_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I180_XG_MP1 (XI838_I180_XG_p1 I838_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I112_XG_MP2 (XI838_I112_XG_p1 I838_G16_15 I838_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I112_XG_MP0 (VDD I838_P16_15 XI838_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I112_XG_MP1 (XI838_I112_XG_p1 I838_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I177_XG_MP2 (XI838_I177_XG_p1 I838_G26_19 I838_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I177_XG_MP0 (VDD I838_P26_19 XI838_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I177_XG_MP1 (XI838_I177_XG_p1 I838_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I112_XG_MP2 (XI884_I112_XG_p1 I884_G16_15 I884_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I112_XG_MP0 (VDD I884_P16_15 XI884_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I112_XG_MP1 (XI884_I112_XG_p1 I884_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I165_XG_MP2 (XI884_I165_XG_p1 I884_G14_7 I884_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I165_XG_MP0 (VDD I884_P14_7 XI884_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I165_XG_MP1 (XI884_I165_XG_p1 I884_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I177_XG_MP2 (XI884_I177_XG_p1 I884_G26_19 I884_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I177_XG_MP0 (VDD I884_P26_19 XI884_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I177_XG_MP1 (XI884_I177_XG_p1 I884_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I171_XG_MP2 (XI884_I171_XG_p1 I884_G20_13 I884_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I171_XG_MP0 (VDD I884_P20_13 XI884_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I171_XG_MP1 (XI884_I171_XG_p1 I884_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I111_XG_MP2 (XI884_I111_XG_p1 I884_G15_14 I884_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I111_XG_MP0 (VDD I884_P15_14 XI884_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I111_XG_MP1 (XI884_I111_XG_p1 I884_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I173_XG_MP2 (XI1712_I173_XG_p1 I1712_G22_15 I1712_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I173_XG_MP0 (VDD I1712_P22_15 XI1712_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I173_XG_MP1 (XI1712_I173_XG_p1 I1712_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I112_XG_MP2 (XI1712_I112_XG_p1 I1712_G16_15 I1712_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I112_XG_MP0 (VDD I1712_P16_15 XI1712_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I112_XG_MP1 (XI1712_I112_XG_p1 I1712_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I109_XG_MP2 (XI1712_I109_XG_p1 I1712_G13_12 I1712_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I109_XG_MP0 (VDD I1712_P13_12 XI1712_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I109_XG_MP1 (XI1712_I109_XG_p1 I1712_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I176_XG_MP2 (XI1712_I176_XG_p1 I1712_G25_18 I1712_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I176_XG_MP0 (VDD I1712_P25_18 XI1712_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I176_XG_MP1 (XI1712_I176_XG_p1 I1712_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I170_XG_MP2 (XI1712_I170_XG_p1 I1712_G19_12 I1712_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I170_XG_MP0 (VDD I1712_P19_12 XI1712_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I170_XG_MP1 (XI1712_I170_XG_p1 I1712_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I112_XG_MP2 (XI1758_I112_XG_p1 I1758_G16_15 I1758_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I112_XG_MP0 (VDD I1758_P16_15 XI1758_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I112_XG_MP1 (XI1758_I112_XG_p1 I1758_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I171_XG_MP2 (XI1758_I171_XG_p1 I1758_G20_13 I1758_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I171_XG_MP0 (VDD I1758_P20_13 XI1758_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I171_XG_MP1 (XI1758_I171_XG_p1 I1758_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I177_XG_MP2 (XI1758_I177_XG_p1 I1758_G26_19 I1758_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I177_XG_MP0 (VDD I1758_P26_19 XI1758_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I177_XG_MP1 (XI1758_I177_XG_p1 I1758_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I111_XG_MP2 (XI1758_I111_XG_p1 I1758_G15_14 I1758_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I111_XG_MP0 (VDD I1758_P15_14 XI1758_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I111_XG_MP1 (XI1758_I111_XG_p1 I1758_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I164_XG_MP2 (XI1758_I164_XG_p1 I1758_G13_6 I1758_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I164_XG_MP0 (VDD I1758_P13_6 XI1758_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I164_XG_MP1 (XI1758_I164_XG_p1 I1758_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I170_XG_MP2 (XI1758_I170_XG_p1 I1758_G19_12 I1758_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I170_XG_MP0 (VDD I1758_P19_12 XI1758_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I170_XG_MP1 (XI1758_I170_XG_p1 I1758_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I111_XG_MP2 (XI1804_I111_XG_p1 I1804_G15_14 I1804_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I111_XG_MP0 (VDD I1804_P15_14 XI1804_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I111_XG_MP1 (XI1804_I111_XG_p1 I1804_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I164_XG_MP2 (XI1804_I164_XG_p1 I1804_G13_6 I1804_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I164_XG_MP0 (VDD I1804_P13_6 XI1804_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I164_XG_MP1 (XI1804_I164_XG_p1 I1804_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I116_XG_MP2 (XI1804_I116_XG_p1 I1804_G20_19 I1804_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I116_XG_MP0 (VDD I1804_P20_19 XI1804_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I116_XG_MP1 (XI1804_I116_XG_p1 I1804_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I181_XG_MP2 (XI1804_I181_XG_p1 I1804_G30_23 I1804_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I181_XG_MP0 (VDD I1804_P30_23 XI1804_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I181_XG_MP1 (XI1804_I181_XG_p1 I1804_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I127_XG_MP2 (XI746_I127_XG_p1 I746_G31_30 I746_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I127_XG_MP0 (VDD I746_P31_30 XI746_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I127_XG_MP1 (XI746_I127_XG_p1 I746_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I125_XG_MP2 (XI746_I125_XG_p1 I746_G29_28 I746_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I125_XG_MP0 (VDD I746_P29_28 XI746_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I125_XG_MP1 (XI746_I125_XG_p1 I746_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I120_XG_MP2 (XI746_I120_XG_p1 I746_G24_23 I746_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I120_XG_MP0 (VDD I746_P24_23 XI746_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I120_XG_MP1 (XI746_I120_XG_p1 I746_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I179_XG_MP2 (XI746_I179_XG_p1 I746_G28_21 I746_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I179_XG_MP0 (VDD I746_P28_21 XI746_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I179_XG_MP1 (XI746_I179_XG_p1 I746_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I173_XG_MP2 (XI746_I173_XG_p1 I746_G22_15 I746_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I173_XG_MP0 (VDD I746_P22_15 XI746_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I173_XG_MP1 (XI746_I173_XG_p1 I746_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I165_XG_MP2 (XI746_I165_XG_p1 I746_G14_7 I746_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I165_XG_MP0 (VDD I746_P14_7 XI746_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I165_XG_MP1 (XI746_I165_XG_p1 I746_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I117_XG_MP2 (XI792_I117_XG_p1 I792_G21_20 I792_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I117_XG_MP0 (VDD I792_P21_20 XI792_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I117_XG_MP1 (XI792_I117_XG_p1 I792_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I176_XG_MP2 (XI792_I176_XG_p1 I792_G25_18 I792_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I176_XG_MP0 (VDD I792_P25_18 XI792_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I176_XG_MP1 (XI792_I176_XG_p1 I792_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I172_XG_MP2 (XI792_I172_XG_p1 I792_G21_14 I792_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I172_XG_MP0 (VDD I792_P21_14 XI792_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I172_XG_MP1 (XI792_I172_XG_p1 I792_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I179_XG_MP2 (XI792_I179_XG_p1 I792_G28_21 I792_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I179_XG_MP0 (VDD I792_P28_21 XI792_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I179_XG_MP1 (XI792_I179_XG_p1 I792_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I165_XG_MP2 (XI792_I165_XG_p1 I792_G14_7 I792_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I165_XG_MP0 (VDD I792_P14_7 XI792_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I165_XG_MP1 (XI792_I165_XG_p1 I792_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I115_XG_MP2 (XI838_I115_XG_p1 I838_G19_18 I838_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I115_XG_MP0 (VDD I838_P19_18 XI838_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I115_XG_MP1 (XI838_I115_XG_p1 I838_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I178_XG_MP2 (XI838_I178_XG_p1 I838_G27_20 I838_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I178_XG_MP0 (VDD I838_P27_20 XI838_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I178_XG_MP1 (XI838_I178_XG_p1 I838_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I166_XG_MP2 (XI838_I166_XG_p1 I838_G15_8 I838_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I166_XG_MP0 (VDD I838_P15_8 XI838_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I166_XG_MP1 (XI838_I166_XG_p1 I838_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I117_XG_MP2 (XI838_I117_XG_p1 I838_G21_20 I838_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I117_XG_MP0 (VDD I838_P21_20 XI838_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I117_XG_MP1 (XI838_I117_XG_p1 I838_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I114_XG_MP2 (XI838_I114_XG_p1 I838_G18_17 I838_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I114_XG_MP0 (VDD I838_P18_17 XI838_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I114_XG_MP1 (XI838_I114_XG_p1 I838_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I116_XG_MP2 (XI838_I116_XG_p1 I838_G20_19 I838_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I116_XG_MP0 (VDD I838_P20_19 XI838_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I116_XG_MP1 (XI838_I116_XG_p1 I838_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I179_XG_MP2 (XI838_I179_XG_p1 I838_G28_21 I838_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I179_XG_MP0 (VDD I838_P28_21 XI838_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I179_XG_MP1 (XI838_I179_XG_p1 I838_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I165_XG_MP2 (XI838_I165_XG_p1 I838_G14_7 I838_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I165_XG_MP0 (VDD I838_P14_7 XI838_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I165_XG_MP1 (XI838_I165_XG_p1 I838_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I114_XG_MP2 (XI884_I114_XG_p1 I884_G18_17 I884_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I114_XG_MP0 (VDD I884_P18_17 XI884_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I114_XG_MP1 (XI884_I114_XG_p1 I884_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I116_XG_MP2 (XI884_I116_XG_p1 I884_G20_19 I884_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I116_XG_MP0 (VDD I884_P20_19 XI884_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I116_XG_MP1 (XI884_I116_XG_p1 I884_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I173_XG_MP2 (XI884_I173_XG_p1 I884_G22_15 I884_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I173_XG_MP0 (VDD I884_P22_15 XI884_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I173_XG_MP1 (XI884_I173_XG_p1 I884_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I113_XG_MP2 (XI884_I113_XG_p1 I884_G17_16 I884_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I113_XG_MP0 (VDD I884_P17_16 XI884_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I113_XG_MP1 (XI884_I113_XG_p1 I884_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I172_XG_MP2 (XI884_I172_XG_p1 I884_G21_14 I884_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I172_XG_MP0 (VDD I884_P21_14 XI884_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I172_XG_MP1 (XI884_I172_XG_p1 I884_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I177_XG_MP2 (XI1712_I177_XG_p1 I1712_G26_19 I1712_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I177_XG_MP0 (VDD I1712_P26_19 XI1712_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I177_XG_MP1 (XI1712_I177_XG_p1 I1712_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I179_XG_MP2 (XI1712_I179_XG_p1 I1712_G28_21 I1712_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I179_XG_MP0 (VDD I1712_P28_21 XI1712_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I179_XG_MP1 (XI1712_I179_XG_p1 I1712_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I111_XG_MP2 (XI1712_I111_XG_p1 I1712_G15_14 I1712_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I111_XG_MP0 (VDD I1712_P15_14 XI1712_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I111_XG_MP1 (XI1712_I111_XG_p1 I1712_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I164_XG_MP2 (XI1712_I164_XG_p1 I1712_G13_6 I1712_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I164_XG_MP0 (VDD I1712_P13_6 XI1712_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I164_XG_MP1 (XI1712_I164_XG_p1 I1712_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I114_XG_MP2 (XI1758_I114_XG_p1 I1758_G18_17 I1758_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I114_XG_MP0 (VDD I1758_P18_17 XI1758_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I114_XG_MP1 (XI1758_I114_XG_p1 I1758_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I179_XG_MP2 (XI1758_I179_XG_p1 I1758_G28_21 I1758_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I179_XG_MP0 (VDD I1758_P28_21 XI1758_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I179_XG_MP1 (XI1758_I179_XG_p1 I1758_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I165_XG_MP2 (XI1758_I165_XG_p1 I1758_G14_7 I1758_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I165_XG_MP0 (VDD I1758_P14_7 XI1758_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I165_XG_MP1 (XI1758_I165_XG_p1 I1758_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I113_XG_MP2 (XI1758_I113_XG_p1 I1758_G17_16 I1758_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I113_XG_MP0 (VDD I1758_P17_16 XI1758_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I113_XG_MP1 (XI1758_I113_XG_p1 I1758_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I172_XG_MP2 (XI1758_I172_XG_p1 I1758_G21_14 I1758_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I172_XG_MP0 (VDD I1758_P21_14 XI1758_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I172_XG_MP1 (XI1758_I172_XG_p1 I1758_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I166_XG_MP2 (XI1804_I166_XG_p1 I1804_G15_8 I1804_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I166_XG_MP0 (VDD I1804_P15_8 XI1804_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I166_XG_MP1 (XI1804_I166_XG_p1 I1804_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I113_XG_MP2 (XI1804_I113_XG_p1 I1804_G17_16 I1804_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I113_XG_MP0 (VDD I1804_P17_16 XI1804_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I113_XG_MP1 (XI1804_I113_XG_p1 I1804_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I178_XG_MP2 (XI1804_I178_XG_p1 I1804_G27_20 I1804_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I178_XG_MP0 (VDD I1804_P27_20 XI1804_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I178_XG_MP1 (XI1804_I178_XG_p1 I1804_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I176_XG_MP2 (XI1804_I176_XG_p1 I1804_G25_18 I1804_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I176_XG_MP0 (VDD I1804_P25_18 XI1804_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I176_XG_MP1 (XI1804_I176_XG_p1 I1804_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I172_XG_MP2 (XI1804_I172_XG_p1 I1804_G21_14 I1804_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I172_XG_MP0 (VDD I1804_P21_14 XI1804_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I172_XG_MP1 (XI1804_I172_XG_p1 I1804_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I180_XG_MP2 (XI1804_I180_XG_p1 I1804_G29_22 I1804_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I180_XG_MP0 (VDD I1804_P29_22 XI1804_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I180_XG_MP1 (XI1804_I180_XG_p1 I1804_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I118_XG_MP2 (XI1804_I118_XG_p1 I1804_G22_21 I1804_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I118_XG_MP0 (VDD I1804_P22_21 XI1804_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I118_XG_MP1 (XI1804_I118_XG_p1 I1804_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I122_XG_MP2 (XI746_I122_XG_p1 I746_G26_25 I746_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I122_XG_MP0 (VDD I746_P26_25 XI746_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I122_XG_MP1 (XI746_I122_XG_p1 I746_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I124_XG_MP2 (XI746_I124_XG_p1 I746_G28_27 I746_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I124_XG_MP0 (VDD I746_P28_27 XI746_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I124_XG_MP1 (XI746_I124_XG_p1 I746_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I177_XG_MP2 (XI746_I177_XG_p1 I746_G26_19 I746_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I177_XG_MP0 (VDD I746_P26_19 XI746_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I177_XG_MP1 (XI746_I177_XG_p1 I746_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I119_XG_MP2 (XI792_I119_XG_p1 I792_G23_22 I792_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I119_XG_MP0 (VDD I792_P23_22 XI792_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I119_XG_MP1 (XI792_I119_XG_p1 I792_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I180_XG_MP2 (XI792_I180_XG_p1 I792_G29_22 I792_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I180_XG_MP0 (VDD I792_P29_22 XI792_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I180_XG_MP1 (XI792_I180_XG_p1 I792_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I118_XG_MP2 (XI792_I118_XG_p1 I792_G22_21 I792_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I118_XG_MP0 (VDD I792_P22_21 XI792_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I118_XG_MP1 (XI792_I118_XG_p1 I792_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I120_XG_MP2 (XI792_I120_XG_p1 I792_G24_23 I792_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I120_XG_MP0 (VDD I792_P24_23 XI792_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I120_XG_MP1 (XI792_I120_XG_p1 I792_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I173_XG_MP2 (XI792_I173_XG_p1 I792_G22_15 I792_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I173_XG_MP0 (VDD I792_P22_15 XI792_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I173_XG_MP1 (XI792_I173_XG_p1 I792_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I174_XG_MP2 (XI838_I174_XG_p1 I838_G23_16 I838_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I174_XG_MP0 (VDD I838_P23_16 XI838_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I174_XG_MP1 (XI838_I174_XG_p1 I838_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I118_XG_MP2 (XI838_I118_XG_p1 I838_G22_21 I838_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I118_XG_MP0 (VDD I838_P22_21 XI838_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I118_XG_MP1 (XI838_I118_XG_p1 I838_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I173_XG_MP2 (XI838_I173_XG_p1 I838_G22_15 I838_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I173_XG_MP0 (VDD I838_P22_15 XI838_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I173_XG_MP1 (XI838_I173_XG_p1 I838_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I179_XG_MP2 (XI884_I179_XG_p1 I884_G28_21 I884_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I179_XG_MP0 (VDD I884_P28_21 XI884_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I179_XG_MP1 (XI884_I179_XG_p1 I884_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I115_XG_MP2 (XI884_I115_XG_p1 I884_G19_18 I884_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I115_XG_MP0 (VDD I884_P19_18 XI884_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I115_XG_MP1 (XI884_I115_XG_p1 I884_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I117_XG_MP2 (XI884_I117_XG_p1 I884_G21_20 I884_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I117_XG_MP0 (VDD I884_P21_20 XI884_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I117_XG_MP1 (XI884_I117_XG_p1 I884_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I162_XG_MP2 (XI884_I162_XG_p1 I884_G11_4 I884_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I162_XG_MP0 (VDD I884_P11_4 XI884_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I162_XG_MP1 (XI884_I162_XG_p1 I884_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I170_XG_MP2 (XI884_I170_XG_p1 I884_G19_12 I884_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I170_XG_MP0 (VDD I884_P19_12 XI884_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I170_XG_MP1 (XI884_I170_XG_p1 I884_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I114_XG_MP2 (XI1712_I114_XG_p1 I1712_G18_17 I1712_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I114_XG_MP0 (VDD I1712_P18_17 XI1712_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I114_XG_MP1 (XI1712_I114_XG_p1 I1712_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I113_XG_MP2 (XI1712_I113_XG_p1 I1712_G17_16 I1712_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I113_XG_MP0 (VDD I1712_P17_16 XI1712_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I113_XG_MP1 (XI1712_I113_XG_p1 I1712_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I172_XG_MP2 (XI1712_I172_XG_p1 I1712_G21_14 I1712_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I172_XG_MP0 (VDD I1712_P21_14 XI1712_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I172_XG_MP1 (XI1712_I172_XG_p1 I1712_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I178_XG_MP2 (XI1712_I178_XG_p1 I1712_G27_20 I1712_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I178_XG_MP0 (VDD I1712_P27_20 XI1712_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I178_XG_MP1 (XI1712_I178_XG_p1 I1712_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I166_XG_MP2 (XI1712_I166_XG_p1 I1712_G15_8 I1712_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I166_XG_MP0 (VDD I1712_P15_8 XI1712_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I166_XG_MP1 (XI1712_I166_XG_p1 I1712_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I116_XG_MP2 (XI1758_I116_XG_p1 I1758_G20_19 I1758_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I116_XG_MP0 (VDD I1758_P20_19 XI1758_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I116_XG_MP1 (XI1758_I116_XG_p1 I1758_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I173_XG_MP2 (XI1758_I173_XG_p1 I1758_G22_15 I1758_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I173_XG_MP0 (VDD I1758_P22_15 XI1758_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I173_XG_MP1 (XI1758_I173_XG_p1 I1758_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I115_XG_MP2 (XI1758_I115_XG_p1 I1758_G19_18 I1758_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I115_XG_MP0 (VDD I1758_P19_18 XI1758_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I115_XG_MP1 (XI1758_I115_XG_p1 I1758_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I117_XG_MP2 (XI1758_I117_XG_p1 I1758_G21_20 I1758_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I117_XG_MP0 (VDD I1758_P21_20 XI1758_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I117_XG_MP1 (XI1758_I117_XG_p1 I1758_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I178_XG_MP2 (XI1758_I178_XG_p1 I1758_G27_20 I1758_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I178_XG_MP0 (VDD I1758_P27_20 XI1758_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I178_XG_MP1 (XI1758_I178_XG_p1 I1758_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I166_XG_MP2 (XI1758_I166_XG_p1 I1758_G15_8 I1758_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I166_XG_MP0 (VDD I1758_P15_8 XI1758_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I166_XG_MP1 (XI1758_I166_XG_p1 I1758_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I174_XG_MP2 (XI1804_I174_XG_p1 I1804_G23_16 I1804_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I174_XG_MP0 (VDD I1804_P23_16 XI1804_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I174_XG_MP1 (XI1804_I174_XG_p1 I1804_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I115_XG_MP2 (XI1804_I115_XG_p1 I1804_G19_18 I1804_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I115_XG_MP0 (VDD I1804_P19_18 XI1804_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I115_XG_MP1 (XI1804_I115_XG_p1 I1804_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I117_XG_MP2 (XI1804_I117_XG_p1 I1804_G21_20 I1804_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I117_XG_MP0 (VDD I1804_P21_20 XI1804_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I117_XG_MP1 (XI1804_I117_XG_p1 I1804_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I120_XG_MP2 (XI1804_I120_XG_p1 I1804_G24_23 I1804_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I120_XG_MP0 (VDD I1804_P24_23 XI1804_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I120_XG_MP1 (XI1804_I120_XG_p1 I1804_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I124_XG_MP2 (XI1804_I124_XG_p1 I1804_G28_27 I1804_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I124_XG_MP0 (VDD I1804_P28_27 XI1804_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I124_XG_MP1 (XI1804_I124_XG_p1 I1804_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I122_XG_MP2 (XI1804_I122_XG_p1 I1804_G26_25 I1804_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I122_XG_MP0 (VDD I1804_P26_25 XI1804_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I122_XG_MP1 (XI1804_I122_XG_p1 I1804_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I126_XG_MP2 (XI746_I126_XG_p1 I746_G30_29 I746_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I126_XG_MP0 (VDD I746_P30_29 XI746_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I126_XG_MP1 (XI746_I126_XG_p1 I746_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I181_XG_MP2 (XI746_I181_XG_p1 I746_G30_23 I746_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I181_XG_MP0 (VDD I746_P30_23 XI746_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I181_XG_MP1 (XI746_I181_XG_p1 I746_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I121_XG_MP2 (XI792_I121_XG_p1 I792_G25_24 I792_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I121_XG_MP0 (VDD I792_P25_24 XI792_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I121_XG_MP1 (XI792_I121_XG_p1 I792_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I123_XG_MP2 (XI792_I123_XG_p1 I792_G27_26 I792_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I123_XG_MP0 (VDD I792_P27_26 XI792_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I123_XG_MP1 (XI792_I123_XG_p1 I792_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I178_XG_MP2 (XI792_I178_XG_p1 I792_G27_20 I792_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I178_XG_MP0 (VDD I792_P27_20 XI792_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I178_XG_MP1 (XI792_I178_XG_p1 I792_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I166_XG_MP2 (XI792_I166_XG_p1 I792_G15_8 I792_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I166_XG_MP0 (VDD I792_P15_8 XI792_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I166_XG_MP1 (XI792_I166_XG_p1 I792_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I124_XG_MP2 (XI792_I124_XG_p1 I792_G28_27 I792_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I124_XG_MP0 (VDD I792_P28_27 XI792_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I124_XG_MP1 (XI792_I124_XG_p1 I792_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I122_XG_MP2 (XI792_I122_XG_p1 I792_G26_25 I792_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I122_XG_MP0 (VDD I792_P26_25 XI792_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I122_XG_MP1 (XI792_I122_XG_p1 I792_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I177_XG_MP2 (XI792_I177_XG_p1 I792_G26_19 I792_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I177_XG_MP0 (VDD I792_P26_19 XI792_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I177_XG_MP1 (XI792_I177_XG_p1 I792_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I182_XG_MP2 (XI838_I182_XG_p1 I838_G31_24 I838_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I182_XG_MP0 (VDD I838_P31_24 XI838_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I182_XG_MP1 (XI838_I182_XG_p1 I838_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I119_XG_MP2 (XI838_I119_XG_p1 I838_G23_22 I838_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I119_XG_MP0 (VDD I838_P23_22 XI838_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I119_XG_MP1 (XI838_I119_XG_p1 I838_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I181_XG_MP2 (XI838_I181_XG_p1 I838_G30_23 I838_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I181_XG_MP0 (VDD I838_P30_23 XI838_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I181_XG_MP1 (XI838_I181_XG_p1 I838_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I118_XG_MP2 (XI884_I118_XG_p1 I884_G22_21 I884_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I118_XG_MP0 (VDD I884_P22_21 XI884_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I118_XG_MP1 (XI884_I118_XG_p1 I884_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I181_XG_MP2 (XI884_I181_XG_p1 I884_G30_23 I884_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I181_XG_MP0 (VDD I884_P30_23 XI884_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I181_XG_MP1 (XI884_I181_XG_p1 I884_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I120_XG_MP2 (XI884_I120_XG_p1 I884_G24_23 I884_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I120_XG_MP0 (VDD I884_P24_23 XI884_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I120_XG_MP1 (XI884_I120_XG_p1 I884_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I180_XG_MP2 (XI884_I180_XG_p1 I884_G29_22 I884_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I180_XG_MP0 (VDD I884_P29_22 XI884_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I180_XG_MP1 (XI884_I180_XG_p1 I884_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I178_XG_MP2 (XI884_I178_XG_p1 I884_G27_20 I884_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I178_XG_MP0 (VDD I884_P27_20 XI884_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I178_XG_MP1 (XI884_I178_XG_p1 I884_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I181_XG_MP2 (XI1712_I181_XG_p1 I1712_G30_23 I1712_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I181_XG_MP0 (VDD I1712_P30_23 XI1712_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I181_XG_MP1 (XI1712_I181_XG_p1 I1712_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I118_XG_MP2 (XI1712_I118_XG_p1 I1712_G22_21 I1712_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I118_XG_MP0 (VDD I1712_P22_21 XI1712_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I118_XG_MP1 (XI1712_I118_XG_p1 I1712_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I116_XG_MP2 (XI1712_I116_XG_p1 I1712_G20_19 I1712_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I116_XG_MP0 (VDD I1712_P20_19 XI1712_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I116_XG_MP1 (XI1712_I116_XG_p1 I1712_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I115_XG_MP2 (XI1712_I115_XG_p1 I1712_G19_18 I1712_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I115_XG_MP0 (VDD I1712_P19_18 XI1712_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I115_XG_MP1 (XI1712_I115_XG_p1 I1712_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I117_XG_MP2 (XI1712_I117_XG_p1 I1712_G21_20 I1712_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I117_XG_MP0 (VDD I1712_P21_20 XI1712_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I117_XG_MP1 (XI1712_I117_XG_p1 I1712_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I180_XG_MP2 (XI1712_I180_XG_p1 I1712_G29_22 I1712_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I180_XG_MP0 (VDD I1712_P29_22 XI1712_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I180_XG_MP1 (XI1712_I180_XG_p1 I1712_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I118_XG_MP2 (XI1758_I118_XG_p1 I1758_G22_21 I1758_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I118_XG_MP0 (VDD I1758_P22_21 XI1758_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I118_XG_MP1 (XI1758_I118_XG_p1 I1758_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I120_XG_MP2 (XI1758_I120_XG_p1 I1758_G24_23 I1758_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I120_XG_MP0 (VDD I1758_P24_23 XI1758_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I120_XG_MP1 (XI1758_I120_XG_p1 I1758_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I181_XG_MP2 (XI1758_I181_XG_p1 I1758_G30_23 I1758_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I181_XG_MP0 (VDD I1758_P30_23 XI1758_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I181_XG_MP1 (XI1758_I181_XG_p1 I1758_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I119_XG_MP2 (XI1758_I119_XG_p1 I1758_G23_22 I1758_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I119_XG_MP0 (VDD I1758_P23_22 XI1758_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I119_XG_MP1 (XI1758_I119_XG_p1 I1758_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I180_XG_MP2 (XI1758_I180_XG_p1 I1758_G29_22 I1758_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I180_XG_MP0 (VDD I1758_P29_22 XI1758_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I180_XG_MP1 (XI1758_I180_XG_p1 I1758_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I174_XG_MP2 (XI1758_I174_XG_p1 I1758_G23_16 I1758_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I174_XG_MP0 (VDD I1758_P23_16 XI1758_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I174_XG_MP1 (XI1758_I174_XG_p1 I1758_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I119_XG_MP2 (XI1804_I119_XG_p1 I1804_G23_22 I1804_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I119_XG_MP0 (VDD I1804_P23_22 XI1804_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I119_XG_MP1 (XI1804_I119_XG_p1 I1804_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I126_XG_MP2 (XI1804_I126_XG_p1 I1804_G30_29 I1804_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I126_XG_MP0 (VDD I1804_P30_29 XI1804_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I126_XG_MP1 (XI1804_I126_XG_p1 I1804_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I127_XG_MP2 (XI792_I127_XG_p1 I792_G31_30 I792_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I127_XG_MP0 (VDD I792_P31_30 XI792_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I127_XG_MP1 (XI792_I127_XG_p1 I792_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I125_XG_MP2 (XI792_I125_XG_p1 I792_G29_28 I792_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I125_XG_MP0 (VDD I792_P29_28 XI792_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I125_XG_MP1 (XI792_I125_XG_p1 I792_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I182_XG_MP2 (XI792_I182_XG_p1 I792_G31_24 I792_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I182_XG_MP0 (VDD I792_P31_24 XI792_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I182_XG_MP1 (XI792_I182_XG_p1 I792_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I174_XG_MP2 (XI792_I174_XG_p1 I792_G23_16 I792_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I174_XG_MP0 (VDD I792_P23_16 XI792_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I174_XG_MP1 (XI792_I174_XG_p1 I792_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I126_XG_MP2 (XI792_I126_XG_p1 I792_G30_29 I792_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I126_XG_MP0 (VDD I792_P30_29 XI792_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I126_XG_MP1 (XI792_I126_XG_p1 I792_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I181_XG_MP2 (XI792_I181_XG_p1 I792_G30_23 I792_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I181_XG_MP0 (VDD I792_P30_23 XI792_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I181_XG_MP1 (XI792_I181_XG_p1 I792_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I127_XG_MP2 (XI838_I127_XG_p1 I838_G31_30 I838_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I127_XG_MP0 (VDD I838_P31_30 XI838_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I127_XG_MP1 (XI838_I127_XG_p1 I838_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I125_XG_MP2 (XI838_I125_XG_p1 I838_G29_28 I838_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I125_XG_MP0 (VDD I838_P29_28 XI838_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I125_XG_MP1 (XI838_I125_XG_p1 I838_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I123_XG_MP2 (XI838_I123_XG_p1 I838_G27_26 I838_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I123_XG_MP0 (VDD I838_P27_26 XI838_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I123_XG_MP1 (XI838_I123_XG_p1 I838_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I121_XG_MP2 (XI838_I121_XG_p1 I838_G25_24 I838_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I121_XG_MP0 (VDD I838_P25_24 XI838_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I121_XG_MP1 (XI838_I121_XG_p1 I838_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I120_XG_MP2 (XI838_I120_XG_p1 I838_G24_23 I838_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I120_XG_MP0 (VDD I838_P24_23 XI838_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I120_XG_MP1 (XI838_I120_XG_p1 I838_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I122_XG_MP2 (XI838_I122_XG_p1 I838_G26_25 I838_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I122_XG_MP0 (VDD I838_P26_25 XI838_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I122_XG_MP1 (XI838_I122_XG_p1 I838_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I122_XG_MP2 (XI884_I122_XG_p1 I884_G26_25 I884_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I122_XG_MP0 (VDD I884_P26_25 XI884_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I122_XG_MP1 (XI884_I122_XG_p1 I884_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I119_XG_MP2 (XI884_I119_XG_p1 I884_G23_22 I884_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I119_XG_MP0 (VDD I884_P23_22 XI884_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I119_XG_MP1 (XI884_I119_XG_p1 I884_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I121_XG_MP2 (XI884_I121_XG_p1 I884_G25_24 I884_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I121_XG_MP0 (VDD I884_P25_24 XI884_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I121_XG_MP1 (XI884_I121_XG_p1 I884_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I122_XG_MP2 (XI1712_I122_XG_p1 I1712_G26_25 I1712_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I122_XG_MP0 (VDD I1712_P26_25 XI1712_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I122_XG_MP1 (XI1712_I122_XG_p1 I1712_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I120_XG_MP2 (XI1712_I120_XG_p1 I1712_G24_23 I1712_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I120_XG_MP0 (VDD I1712_P24_23 XI1712_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I120_XG_MP1 (XI1712_I120_XG_p1 I1712_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I119_XG_MP2 (XI1712_I119_XG_p1 I1712_G23_22 I1712_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I119_XG_MP0 (VDD I1712_P23_22 XI1712_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I119_XG_MP1 (XI1712_I119_XG_p1 I1712_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I182_XG_MP2 (XI1712_I182_XG_p1 I1712_G31_24 I1712_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I182_XG_MP0 (VDD I1712_P31_24 XI1712_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I182_XG_MP1 (XI1712_I182_XG_p1 I1712_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I174_XG_MP2 (XI1712_I174_XG_p1 I1712_G23_16 I1712_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I174_XG_MP0 (VDD I1712_P23_16 XI1712_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I174_XG_MP1 (XI1712_I174_XG_p1 I1712_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I122_XG_MP2 (XI1758_I122_XG_p1 I1758_G26_25 I1758_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I122_XG_MP0 (VDD I1758_P26_25 XI1758_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I122_XG_MP1 (XI1758_I122_XG_p1 I1758_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I121_XG_MP2 (XI1758_I121_XG_p1 I1758_G25_24 I1758_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I121_XG_MP0 (VDD I1758_P25_24 XI1758_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I121_XG_MP1 (XI1758_I121_XG_p1 I1758_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I123_XG_MP2 (XI1758_I123_XG_p1 I1758_G27_26 I1758_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I123_XG_MP0 (VDD I1758_P27_26 XI1758_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I123_XG_MP1 (XI1758_I123_XG_p1 I1758_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I125_XG_MP2 (XI1758_I125_XG_p1 I1758_G29_28 I1758_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I125_XG_MP0 (VDD I1758_P29_28 XI1758_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I125_XG_MP1 (XI1758_I125_XG_p1 I1758_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I182_XG_MP2 (XI1758_I182_XG_p1 I1758_G31_24 I1758_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I182_XG_MP0 (VDD I1758_P31_24 XI1758_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I182_XG_MP1 (XI1758_I182_XG_p1 I1758_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I182_XG_MP2 (XI1804_I182_XG_p1 I1804_G31_24 I1804_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I182_XG_MP0 (VDD I1804_P31_24 XI1804_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I182_XG_MP1 (XI1804_I182_XG_p1 I1804_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I121_XG_MP2 (XI1804_I121_XG_p1 I1804_G25_24 I1804_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I121_XG_MP0 (VDD I1804_P25_24 XI1804_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I121_XG_MP1 (XI1804_I121_XG_p1 I1804_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I125_XG_MP2 (XI1804_I125_XG_p1 I1804_G29_28 I1804_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I125_XG_MP0 (VDD I1804_P29_28 XI1804_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I125_XG_MP1 (XI1804_I125_XG_p1 I1804_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I123_XG_MP2 (XI1804_I123_XG_p1 I1804_G27_26 I1804_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I123_XG_MP0 (VDD I1804_P27_26 XI1804_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I123_XG_MP1 (XI1804_I123_XG_p1 I1804_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2153_MP2 (XI2153_p1 nqk25 nqkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2153_MP0 (VDD sq_b3_4 XI2153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2153_MP1 (XI2153_p1 qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2156_MP2 (XI2156_p1 nqk26 nqkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2156_MP0 (VDD sq_b3_4 XI2156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2156_MP1 (XI2156_p1 qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I124_XG_MP2 (XI838_I124_XG_p1 I838_G28_27 I838_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I124_XG_MP0 (VDD I838_P28_27 XI838_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I124_XG_MP1 (XI838_I124_XG_p1 I838_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I126_XG_MP2 (XI838_I126_XG_p1 I838_G30_29 I838_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I126_XG_MP0 (VDD I838_P30_29 XI838_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I126_XG_MP1 (XI838_I126_XG_p1 I838_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I124_XG_MP2 (XI884_I124_XG_p1 I884_G28_27 I884_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I124_XG_MP0 (VDD I884_P28_27 XI884_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I124_XG_MP1 (XI884_I124_XG_p1 I884_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I123_XG_MP2 (XI884_I123_XG_p1 I884_G27_26 I884_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I123_XG_MP0 (VDD I884_P27_26 XI884_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I123_XG_MP1 (XI884_I123_XG_p1 I884_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I182_XG_MP2 (XI884_I182_XG_p1 I884_G31_24 I884_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I182_XG_MP0 (VDD I884_P31_24 XI884_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I182_XG_MP1 (XI884_I182_XG_p1 I884_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I174_XG_MP2 (XI884_I174_XG_p1 I884_G23_16 I884_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I174_XG_MP0 (VDD I884_P23_16 XI884_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I174_XG_MP1 (XI884_I174_XG_p1 I884_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I166_XG_MP2 (XI884_I166_XG_p1 I884_G15_8 I884_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I166_XG_MP0 (VDD I884_P15_8 XI884_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I166_XG_MP1 (XI884_I166_XG_p1 I884_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I124_XG_MP2 (XI1712_I124_XG_p1 I1712_G28_27 I1712_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I124_XG_MP0 (VDD I1712_P28_27 XI1712_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I124_XG_MP1 (XI1712_I124_XG_p1 I1712_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I126_XG_MP2 (XI1712_I126_XG_p1 I1712_G30_29 I1712_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I126_XG_MP0 (VDD I1712_P30_29 XI1712_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I126_XG_MP1 (XI1712_I126_XG_p1 I1712_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I121_XG_MP2 (XI1712_I121_XG_p1 I1712_G25_24 I1712_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I121_XG_MP0 (VDD I1712_P25_24 XI1712_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I121_XG_MP1 (XI1712_I121_XG_p1 I1712_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I123_XG_MP2 (XI1712_I123_XG_p1 I1712_G27_26 I1712_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I123_XG_MP0 (VDD I1712_P27_26 XI1712_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I123_XG_MP1 (XI1712_I123_XG_p1 I1712_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I125_XG_MP2 (XI1712_I125_XG_p1 I1712_G29_28 I1712_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I125_XG_MP0 (VDD I1712_P29_28 XI1712_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I125_XG_MP1 (XI1712_I125_XG_p1 I1712_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I127_XG_MP2 (XI1712_I127_XG_p1 I1712_G31_30 I1712_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I127_XG_MP0 (VDD I1712_P31_30 XI1712_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I127_XG_MP1 (XI1712_I127_XG_p1 I1712_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I124_XG_MP2 (XI1758_I124_XG_p1 I1758_G28_27 I1758_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I124_XG_MP0 (VDD I1758_P28_27 XI1758_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I124_XG_MP1 (XI1758_I124_XG_p1 I1758_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I126_XG_MP2 (XI1758_I126_XG_p1 I1758_G30_29 I1758_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I126_XG_MP0 (VDD I1758_P30_29 XI1758_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I126_XG_MP1 (XI1758_I126_XG_p1 I1758_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I127_XG_MP2 (XI1758_I127_XG_p1 I1758_G31_30 I1758_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I127_XG_MP0 (VDD I1758_P31_30 XI1758_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I127_XG_MP1 (XI1758_I127_XG_p1 I1758_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I127_XG_MP2 (XI1804_I127_XG_p1 I1804_G31_30 I1804_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I127_XG_MP0 (VDD I1804_P31_30 XI1804_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I127_XG_MP1 (XI1804_I127_XG_p1 I1804_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I180_XG_MP2 (XI1068_I180_XG_p1 I1068_G29_22 I1068_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I180_XG_MP0 (VDD I1068_P29_22 XI1068_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I180_XG_MP1 (XI1068_I180_XG_p1 I1068_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I176_XG_MP2 (XI1068_I176_XG_p1 I1068_G25_18 I1068_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I176_XG_MP0 (VDD I1068_P25_18 XI1068_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I176_XG_MP1 (XI1068_I176_XG_p1 I1068_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I172_XG_MP2 (XI1068_I172_XG_p1 I1068_G21_14 I1068_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I172_XG_MP0 (VDD I1068_P21_14 XI1068_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I172_XG_MP1 (XI1068_I172_XG_p1 I1068_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I164_XG_MP2 (XI1068_I164_XG_p1 I1068_G13_6 I1068_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I164_XG_MP0 (VDD I1068_P13_6 XI1068_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I164_XG_MP1 (XI1068_I164_XG_p1 I1068_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I168_XG_MP2 (XI1068_I168_XG_p1 I1068_G17_10 I1068_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I168_XG_MP0 (VDD I1068_P17_10 XI1068_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I168_XG_MP1 (XI1068_I168_XG_p1 I1068_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I158_XG_MP2 (XI1068_I158_XG_p1 I1068_G9_2 I1068_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I158_XG_MP0 (VDD I1068_P9_2 XI1068_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I158_XG_MP1 (XI1068_I158_XG_p1 I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I101_XG_MP2 (XI1068_I101_XG_p1 I1068_G5_4 I1068_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I101_XG_MP0 (VDD I1068_P5_4 XI1068_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I101_XG_MP1 (XI1068_I101_XG_p1 I1068_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I99_XG_MP2 (XI1068_I99_XG_p1 I1068_G3_2 I1068_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I99_XG_MP0 (VDD I1068_P3_2 XI1068_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I99_XG_MP1 (XI1068_I99_XG_p1 I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2150_MP2 (XI2150_p1 nqk24 nqkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2150_MP0 (VDD sq_b3_4 XI2150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2150_MP1 (XI2150_p1 qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI99_MP2 (XI99_p1 nak21 nakn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI99_MP0 (VDD A_31_b3_3 XI99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI99_MP1 (XI99_p1 A_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI102_MP2 (XI102_p1 nak22 nakn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI102_MP0 (VDD A_31_b3_3 XI102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI102_MP1 (XI102_p1 A_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I126_XG_MP2 (XI884_I126_XG_p1 I884_G30_29 I884_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I126_XG_MP0 (VDD I884_P30_29 XI884_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I126_XG_MP1 (XI884_I126_XG_p1 I884_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I125_XG_MP2 (XI884_I125_XG_p1 I884_G29_28 I884_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I125_XG_MP0 (VDD I884_P29_28 XI884_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I125_XG_MP1 (XI884_I125_XG_p1 I884_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I127_XG_MP2 (XI884_I127_XG_p1 I884_G31_30 I884_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I127_XG_MP0 (VDD I884_P31_30 XI884_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I127_XG_MP1 (XI884_I127_XG_p1 I884_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2096_MP2 (XI2096_p1 nqk6 nqkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2096_MP0 (VDD sq_b3_1 XI2096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2096_MP1 (XI2096_p1 qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2099_MP2 (XI2099_p1 nqk7 nqkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2099_MP0 (VDD sq_b3_1 XI2099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2099_MP1 (XI2099_p1 qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I170_XG_MP2 (XI1068_I170_XG_p1 I1068_G19_12 I1068_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I170_XG_MP0 (VDD I1068_P19_12 XI1068_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I170_XG_MP1 (XI1068_I170_XG_p1 I1068_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I162_XG_MP2 (XI1068_I162_XG_p1 I1068_G11_4 I1068_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I162_XG_MP0 (VDD I1068_P11_4 XI1068_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I162_XG_MP1 (XI1068_I162_XG_p1 I1068_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I105_XG_MP2 (XI1068_I105_XG_p1 I1068_G9_8 I1068_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I105_XG_MP0 (VDD I1068_P9_8 XI1068_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I105_XG_MP1 (XI1068_I105_XG_p1 I1068_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I103_XG_MP2 (XI1068_I103_XG_p1 I1068_G7_6 I1068_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I103_XG_MP0 (VDD I1068_P7_6 XI1068_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I103_XG_MP1 (XI1068_I103_XG_p1 I1068_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2147_MP2 (XI2147_p1 nqk23 nqkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2147_MP0 (VDD sq_b3_4 XI2147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2147_MP1 (XI2147_p1 qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI105_MP2 (XI105_p1 nak23 nakn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI105_MP0 (VDD A_31_b3_3 XI105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI105_MP1 (XI105_p1 A_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI57_MP2 (XI57_p1 nak7 nakn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI57_MP0 (VDD A_31_b3_1 XI57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI57_MP1 (XI57_p1 A_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI60_MP2 (XI60_p1 nak8 nakn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI60_MP0 (VDD A_31_b3_1 XI60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI60_MP1 (XI60_p1 A_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I127_XG_MP2 (XI1068_I127_XG_p1 I1068_G31_30 I1068_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I127_XG_MP0 (VDD I1068_P31_30 XI1068_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I127_XG_MP1 (XI1068_I127_XG_p1 I1068_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I125_XG_MP2 (XI1068_I125_XG_p1 I1068_G29_28 I1068_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I125_XG_MP0 (VDD I1068_P29_28 XI1068_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I125_XG_MP1 (XI1068_I125_XG_p1 I1068_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I178_XG_MP2 (XI1068_I178_XG_p1 I1068_G27_20 I1068_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I178_XG_MP0 (VDD I1068_P27_20 XI1068_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I178_XG_MP1 (XI1068_I178_XG_p1 I1068_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I182_XG_MP2 (XI1068_I182_XG_p1 I1068_G31_24 I1068_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I182_XG_MP0 (VDD I1068_P31_24 XI1068_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I182_XG_MP1 (XI1068_I182_XG_p1 I1068_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I174_XG_MP2 (XI1068_I174_XG_p1 I1068_G23_16 I1068_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I174_XG_MP0 (VDD I1068_P23_16 XI1068_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I174_XG_MP1 (XI1068_I174_XG_p1 I1068_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I166_XG_MP2 (XI1068_I166_XG_p1 I1068_G15_8 I1068_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I166_XG_MP0 (VDD I1068_P15_8 XI1068_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I166_XG_MP1 (XI1068_I166_XG_p1 I1068_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I113_XG_MP2 (XI1068_I113_XG_p1 I1068_G17_16 I1068_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I113_XG_MP0 (VDD I1068_P17_16 XI1068_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I113_XG_MP1 (XI1068_I113_XG_p1 I1068_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I111_XG_MP2 (XI1068_I111_XG_p1 I1068_G15_14 I1068_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I111_XG_MP0 (VDD I1068_P15_14 XI1068_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I111_XG_MP1 (XI1068_I111_XG_p1 I1068_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I109_XG_MP2 (XI1068_I109_XG_p1 I1068_G13_12 I1068_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I109_XG_MP0 (VDD I1068_P13_12 XI1068_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I109_XG_MP1 (XI1068_I109_XG_p1 I1068_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I107_XG_MP2 (XI1068_I107_XG_p1 I1068_G11_10 I1068_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I107_XG_MP0 (VDD I1068_P11_10 XI1068_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I107_XG_MP1 (XI1068_I107_XG_p1 I1068_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I98_XG_MP2 (XI1666_I98_XG_p1 I1666_G2_1 I1666_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I98_XG_MP0 (VDD I1666_P2_1 XI1666_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I98_XG_MP1 (XI1666_I98_XG_p1 I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2102_MP2 (XI2102_p1 nqk8 nqkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2102_MP0 (VDD sq_b3_1 XI2102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2102_MP1 (XI2102_p1 qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I98_XG_MP2 (XI1574_I98_XG_p1 I1574_G2_1 I1574_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I98_XG_MP0 (VDD I1574_P2_1 XI1574_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I98_XG_MP1 (XI1574_I98_XG_p1 I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I100_XG_MP2 (XI1574_I100_XG_p1 I1574_G4_3 I1574_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I100_XG_MP0 (VDD I1574_P4_3 XI1574_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I100_XG_MP1 (XI1574_I100_XG_p1 I1574_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I123_XG_MP2 (XI1068_I123_XG_p1 I1068_G27_26 I1068_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I123_XG_MP0 (VDD I1068_P27_26 XI1068_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I123_XG_MP1 (XI1068_I123_XG_p1 I1068_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I121_XG_MP2 (XI1068_I121_XG_p1 I1068_G25_24 I1068_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I121_XG_MP0 (VDD I1068_P25_24 XI1068_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I121_XG_MP1 (XI1068_I121_XG_p1 I1068_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I119_XG_MP2 (XI1068_I119_XG_p1 I1068_G23_22 I1068_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I119_XG_MP0 (VDD I1068_P23_22 XI1068_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I119_XG_MP1 (XI1068_I119_XG_p1 I1068_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I117_XG_MP2 (XI1068_I117_XG_p1 I1068_G21_20 I1068_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I117_XG_MP0 (VDD I1068_P21_20 XI1068_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I117_XG_MP1 (XI1068_I117_XG_p1 I1068_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I115_XG_MP2 (XI1068_I115_XG_p1 I1068_G19_18 I1068_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I115_XG_MP0 (VDD I1068_P19_18 XI1068_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I115_XG_MP1 (XI1068_I115_XG_p1 I1068_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I169_XG_MP2 (XI1068_I169_XG_p1 I1068_G18_11 I1068_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I169_XG_MP0 (VDD I1068_P18_11 XI1068_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I169_XG_MP1 (XI1068_I169_XG_p1 I1068_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I160_XG_MP2 (XI1068_I160_XG_p1 I1068_G10_3 I1068_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I160_XG_MP0 (VDD I1068_P10_3 XI1068_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I160_XG_MP1 (XI1068_I160_XG_p1 I1068_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I106_XG_MP2 (XI1068_I106_XG_p1 I1068_G10_9 I1068_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I106_XG_MP0 (VDD I1068_P10_9 XI1068_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I106_XG_MP1 (XI1068_I106_XG_p1 I1068_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I104_XG_MP2 (XI1068_I104_XG_p1 I1068_G8_7 I1068_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I104_XG_MP0 (VDD I1068_P8_7 XI1068_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I104_XG_MP1 (XI1068_I104_XG_p1 I1068_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I102_XG_MP2 (XI1068_I102_XG_p1 I1068_G6_5 I1068_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I102_XG_MP0 (VDD I1068_P6_5 XI1068_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I102_XG_MP1 (XI1068_I102_XG_p1 I1068_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I100_XG_MP2 (XI1068_I100_XG_p1 I1068_G4_3 I1068_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I100_XG_MP0 (VDD I1068_P4_3 XI1068_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I100_XG_MP1 (XI1068_I100_XG_p1 I1068_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I98_XG_MP2 (XI1068_I98_XG_p1 I1068_G2_1 I1068_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I98_XG_MP0 (VDD I1068_P2_1 XI1068_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I98_XG_MP1 (XI1068_I98_XG_p1 I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I99_XG_MP2 (XI1022_I99_XG_p1 I1022_G3_2 I1022_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I99_XG_MP0 (VDD I1022_P3_2 XI1022_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I99_XG_MP1 (XI1022_I99_XG_p1 I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2144_MP2 (XI2144_p1 nqk22 nqkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2144_MP0 (VDD sq_b3_4 XI2144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2144_MP1 (XI2144_p1 qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I98_XG_MP2 (XI1022_I98_XG_p1 I1022_G2_1 I1022_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I98_XG_MP0 (VDD I1022_P2_1 XI1022_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I98_XG_MP1 (XI1022_I98_XG_p1 I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I100_XG_MP2 (XI1022_I100_XG_p1 I1022_G4_3 I1022_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I100_XG_MP0 (VDD I1022_P4_3 XI1022_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I100_XG_MP1 (XI1022_I100_XG_p1 I1022_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I103_XG_MP2 (XI930_I103_XG_p1 I930_G7_6 I930_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I103_XG_MP0 (VDD I930_P7_6 XI930_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I103_XG_MP1 (XI930_I103_XG_p1 I930_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I99_XG_MP2 (XI930_I99_XG_p1 I930_G3_2 I930_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I99_XG_MP0 (VDD I930_P3_2 XI930_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I99_XG_MP1 (XI930_I99_XG_p1 I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I101_XG_MP2 (XI930_I101_XG_p1 I930_G5_4 I930_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I101_XG_MP0 (VDD I930_P5_4 XI930_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I101_XG_MP1 (XI930_I101_XG_p1 I930_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I100_XG_MP2 (XI1666_I100_XG_p1 I1666_G4_3 I1666_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I100_XG_MP0 (VDD I1666_P4_3 XI1666_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I100_XG_MP1 (XI1666_I100_XG_p1 I1666_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I99_XG_MP2 (XI1666_I99_XG_p1 I1666_G3_2 I1666_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I99_XG_MP0 (VDD I1666_P3_2 XI1666_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I99_XG_MP1 (XI1666_I99_XG_p1 I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I99_XG_MP2 (XI1620_I99_XG_p1 I1620_G3_2 I1620_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I99_XG_MP0 (VDD I1620_P3_2 XI1620_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I99_XG_MP1 (XI1620_I99_XG_p1 I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I98_XG_MP2 (XI1620_I98_XG_p1 I1620_G2_1 I1620_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I98_XG_MP0 (VDD I1620_P2_1 XI1620_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I98_XG_MP1 (XI1620_I98_XG_p1 I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I100_XG_MP2 (XI1620_I100_XG_p1 I1620_G4_3 I1620_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I100_XG_MP0 (VDD I1620_P4_3 XI1620_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I100_XG_MP1 (XI1620_I100_XG_p1 I1620_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2105_MP2 (XI2105_p1 nqk9 nqkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2105_MP0 (VDD sq_b3_1 XI2105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2105_MP1 (XI2105_p1 qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I99_XG_MP2 (XI1574_I99_XG_p1 I1574_G3_2 I1574_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I99_XG_MP0 (VDD I1574_P3_2 XI1574_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I99_XG_MP1 (XI1574_I99_XG_p1 I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I102_XG_MP2 (XI1574_I102_XG_p1 I1574_G6_5 I1574_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I102_XG_MP0 (VDD I1574_P6_5 XI1574_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I102_XG_MP1 (XI1574_I102_XG_p1 I1574_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I104_XG_MP2 (XI1574_I104_XG_p1 I1574_G8_7 I1574_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I104_XG_MP0 (VDD I1574_P8_7 XI1574_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I104_XG_MP1 (XI1574_I104_XG_p1 I1574_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I157_XG_MP2 (XI1574_I157_XG_p1 I1574_G8_1 I1574_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I157_XG_MP0 (VDD I1574_P8_1 XI1574_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I157_XG_MP1 (XI1574_I157_XG_p1 I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I167_XG_MP2 (XI1574_I167_XG_p1 I1574_G16_9 I1574_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I167_XG_MP0 (VDD I1574_P16_9 XI1574_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I167_XG_MP1 (XI1574_I167_XG_p1 I1574_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I181_XG_MP2 (XI1068_I181_XG_p1 I1068_G30_23 I1068_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I181_XG_MP0 (VDD I1068_P30_23 XI1068_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I181_XG_MP1 (XI1068_I181_XG_p1 I1068_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I177_XG_MP2 (XI1068_I177_XG_p1 I1068_G26_19 I1068_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I177_XG_MP0 (VDD I1068_P26_19 XI1068_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I177_XG_MP1 (XI1068_I177_XG_p1 I1068_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I173_XG_MP2 (XI1068_I173_XG_p1 I1068_G22_15 I1068_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I173_XG_MP0 (VDD I1068_P22_15 XI1068_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I173_XG_MP1 (XI1068_I173_XG_p1 I1068_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I165_XG_MP2 (XI1068_I165_XG_p1 I1068_G14_7 I1068_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I165_XG_MP0 (VDD I1068_P14_7 XI1068_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I165_XG_MP1 (XI1068_I165_XG_p1 I1068_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I101_XG_MP2 (XI1022_I101_XG_p1 I1022_G5_4 I1022_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I101_XG_MP0 (VDD I1022_P5_4 XI1022_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I101_XG_MP1 (XI1022_I101_XG_p1 I1022_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I102_XG_MP2 (XI1022_I102_XG_p1 I1022_G6_5 I1022_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I102_XG_MP0 (VDD I1022_P6_5 XI1022_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I102_XG_MP1 (XI1022_I102_XG_p1 I1022_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I98_XG_MP2 (XI976_I98_XG_p1 I976_G2_1 I976_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I98_XG_MP0 (VDD I976_P2_1 XI976_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I98_XG_MP1 (XI976_I98_XG_p1 I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I100_XG_MP2 (XI976_I100_XG_p1 I976_G4_3 I976_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I100_XG_MP0 (VDD I976_P4_3 XI976_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I100_XG_MP1 (XI976_I100_XG_p1 I976_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I99_XG_MP2 (XI976_I99_XG_p1 I976_G3_2 I976_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I99_XG_MP0 (VDD I976_P3_2 XI976_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I99_XG_MP1 (XI976_I99_XG_p1 I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I101_XG_MP2 (XI976_I101_XG_p1 I976_G5_4 I976_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I101_XG_MP0 (VDD I976_P5_4 XI976_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I101_XG_MP1 (XI976_I101_XG_p1 I976_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I98_XG_MP2 (XI930_I98_XG_p1 I930_G2_1 I930_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I98_XG_MP0 (VDD I930_P2_1 XI930_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I98_XG_MP1 (XI930_I98_XG_p1 I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I100_XG_MP2 (XI930_I100_XG_p1 I930_G4_3 I930_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I100_XG_MP0 (VDD I930_P4_3 XI930_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I100_XG_MP1 (XI930_I100_XG_p1 I930_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I102_XG_MP2 (XI930_I102_XG_p1 I930_G6_5 I930_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I102_XG_MP0 (VDD I930_P6_5 XI930_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I102_XG_MP1 (XI930_I102_XG_p1 I930_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I104_XG_MP2 (XI930_I104_XG_p1 I930_G8_7 I930_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I104_XG_MP0 (VDD I930_P8_7 XI930_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I104_XG_MP1 (XI930_I104_XG_p1 I930_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I167_XG_MP2 (XI1666_I167_XG_p1 I1666_G16_9 I1666_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I167_XG_MP0 (VDD I1666_P16_9 XI1666_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I167_XG_MP1 (XI1666_I167_XG_p1 I1666_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I157_XG_MP2 (XI1666_I157_XG_p1 I1666_G8_1 I1666_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I157_XG_MP0 (VDD I1666_P8_1 XI1666_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I157_XG_MP1 (XI1666_I157_XG_p1 I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I104_XG_MP2 (XI1666_I104_XG_p1 I1666_G8_7 I1666_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I104_XG_MP0 (VDD I1666_P8_7 XI1666_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I104_XG_MP1 (XI1666_I104_XG_p1 I1666_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I102_XG_MP2 (XI1666_I102_XG_p1 I1666_G6_5 I1666_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I102_XG_MP0 (VDD I1666_P6_5 XI1666_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I102_XG_MP1 (XI1666_I102_XG_p1 I1666_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I103_XG_MP2 (XI1666_I103_XG_p1 I1666_G7_6 I1666_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I103_XG_MP0 (VDD I1666_P7_6 XI1666_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I103_XG_MP1 (XI1666_I103_XG_p1 I1666_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I101_XG_MP2 (XI1666_I101_XG_p1 I1666_G5_4 I1666_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I101_XG_MP0 (VDD I1666_P5_4 XI1666_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I101_XG_MP1 (XI1666_I101_XG_p1 I1666_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I101_XG_MP2 (XI1620_I101_XG_p1 I1620_G5_4 I1620_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I101_XG_MP0 (VDD I1620_P5_4 XI1620_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I101_XG_MP1 (XI1620_I101_XG_p1 I1620_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I102_XG_MP2 (XI1620_I102_XG_p1 I1620_G6_5 I1620_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I102_XG_MP0 (VDD I1620_P6_5 XI1620_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I102_XG_MP1 (XI1620_I102_XG_p1 I1620_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI63_MP2 (XI63_p1 nak9 nakn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI63_MP0 (VDD A_31_b3_1 XI63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI63_MP1 (XI63_p1 A_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2108_MP2 (XI2108_p1 nqk10 nqkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2108_MP0 (VDD sq_b3_1 XI2108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2108_MP1 (XI2108_p1 qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I101_XG_MP2 (XI1574_I101_XG_p1 I1574_G5_4 I1574_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I101_XG_MP0 (VDD I1574_P5_4 XI1574_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I101_XG_MP1 (XI1574_I101_XG_p1 I1574_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I103_XG_MP2 (XI1574_I103_XG_p1 I1574_G7_6 I1574_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I103_XG_MP0 (VDD I1574_P7_6 XI1574_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I103_XG_MP1 (XI1574_I103_XG_p1 I1574_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I163_XG_MP2 (XI1574_I163_XG_p1 I1574_G12_5 I1574_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I163_XG_MP0 (VDD I1574_P12_5 XI1574_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I163_XG_MP1 (XI1574_I163_XG_p1 I1574_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I126_XG_MP2 (XI1068_I126_XG_p1 I1068_G30_29 I1068_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I126_XG_MP0 (VDD I1068_P30_29 XI1068_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I126_XG_MP1 (XI1068_I126_XG_p1 I1068_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I124_XG_MP2 (XI1068_I124_XG_p1 I1068_G28_27 I1068_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I124_XG_MP0 (VDD I1068_P28_27 XI1068_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I124_XG_MP1 (XI1068_I124_XG_p1 I1068_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I122_XG_MP2 (XI1068_I122_XG_p1 I1068_G26_25 I1068_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I122_XG_MP0 (VDD I1068_P26_25 XI1068_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I122_XG_MP1 (XI1068_I122_XG_p1 I1068_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I120_XG_MP2 (XI1068_I120_XG_p1 I1068_G24_23 I1068_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I120_XG_MP0 (VDD I1068_P24_23 XI1068_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I120_XG_MP1 (XI1068_I120_XG_p1 I1068_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I118_XG_MP2 (XI1068_I118_XG_p1 I1068_G22_21 I1068_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I118_XG_MP0 (VDD I1068_P22_21 XI1068_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I118_XG_MP1 (XI1068_I118_XG_p1 I1068_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I179_XG_MP2 (XI1068_I179_XG_p1 I1068_G28_21 I1068_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I179_XG_MP0 (VDD I1068_P28_21 XI1068_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I179_XG_MP1 (XI1068_I179_XG_p1 I1068_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I171_XG_MP2 (XI1068_I171_XG_p1 I1068_G20_13 I1068_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I171_XG_MP0 (VDD I1068_P20_13 XI1068_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I171_XG_MP1 (XI1068_I171_XG_p1 I1068_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I175_XG_MP2 (XI1068_I175_XG_p1 I1068_G24_17 I1068_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I175_XG_MP0 (VDD I1068_P24_17 XI1068_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I175_XG_MP1 (XI1068_I175_XG_p1 I1068_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I163_XG_MP2 (XI1068_I163_XG_p1 I1068_G12_5 I1068_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I163_XG_MP0 (VDD I1068_P12_5 XI1068_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I163_XG_MP1 (XI1068_I163_XG_p1 I1068_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I108_XG_MP2 (XI1068_I108_XG_p1 I1068_G12_11 I1068_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I108_XG_MP0 (VDD I1068_P12_11 XI1068_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I108_XG_MP1 (XI1068_I108_XG_p1 I1068_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I167_XG_MP2 (XI1068_I167_XG_p1 I1068_G16_9 I1068_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I167_XG_MP0 (VDD I1068_P16_9 XI1068_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I167_XG_MP1 (XI1068_I167_XG_p1 I1068_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I157_XG_MP2 (XI1068_I157_XG_p1 I1068_G8_1 I1068_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I157_XG_MP0 (VDD I1068_P8_1 XI1068_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I157_XG_MP1 (XI1068_I157_XG_p1 I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I158_XG_MP2 (XI1022_I158_XG_p1 I1022_G9_2 I1022_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I158_XG_MP0 (VDD I1022_P9_2 XI1022_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I158_XG_MP1 (XI1022_I158_XG_p1 I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I103_XG_MP2 (XI1022_I103_XG_p1 I1022_G7_6 I1022_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I103_XG_MP0 (VDD I1022_P7_6 XI1022_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I103_XG_MP1 (XI1022_I103_XG_p1 I1022_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I105_XG_MP2 (XI1022_I105_XG_p1 I1022_G9_8 I1022_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I105_XG_MP0 (VDD I1022_P9_8 XI1022_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I105_XG_MP1 (XI1022_I105_XG_p1 I1022_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I157_XG_MP2 (XI1022_I157_XG_p1 I1022_G8_1 I1022_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I157_XG_MP0 (VDD I1022_P8_1 XI1022_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I157_XG_MP1 (XI1022_I157_XG_p1 I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I167_XG_MP2 (XI1022_I167_XG_p1 I1022_G16_9 I1022_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I167_XG_MP0 (VDD I1022_P16_9 XI1022_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I167_XG_MP1 (XI1022_I167_XG_p1 I1022_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I104_XG_MP2 (XI1022_I104_XG_p1 I1022_G8_7 I1022_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I104_XG_MP0 (VDD I1022_P8_7 XI1022_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I104_XG_MP1 (XI1022_I104_XG_p1 I1022_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I104_XG_MP2 (XI976_I104_XG_p1 I976_G8_7 I976_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I104_XG_MP0 (VDD I976_P8_7 XI976_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I104_XG_MP1 (XI976_I104_XG_p1 I976_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I102_XG_MP2 (XI976_I102_XG_p1 I976_G6_5 I976_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I102_XG_MP0 (VDD I976_P6_5 XI976_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I102_XG_MP1 (XI976_I102_XG_p1 I976_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I103_XG_MP2 (XI976_I103_XG_p1 I976_G7_6 I976_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I103_XG_MP0 (VDD I976_P7_6 XI976_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I103_XG_MP1 (XI976_I103_XG_p1 I976_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I157_XG_MP2 (XI930_I157_XG_p1 I930_G8_1 I930_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I157_XG_MP0 (VDD I930_P8_1 XI930_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I157_XG_MP1 (XI930_I157_XG_p1 I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I167_XG_MP2 (XI930_I167_XG_p1 I930_G16_9 I930_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I167_XG_MP0 (VDD I930_P16_9 XI930_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I167_XG_MP1 (XI930_I167_XG_p1 I930_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I106_XG_MP2 (XI930_I106_XG_p1 I930_G10_9 I930_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I106_XG_MP0 (VDD I930_P10_9 XI930_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I106_XG_MP1 (XI930_I106_XG_p1 I930_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I105_XG_MP2 (XI930_I105_XG_p1 I930_G9_8 I930_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I105_XG_MP0 (VDD I930_P9_8 XI930_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I105_XG_MP1 (XI930_I105_XG_p1 I930_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I175_XG_MP2 (XI1666_I175_XG_p1 I1666_G24_17 I1666_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I175_XG_MP0 (VDD I1666_P24_17 XI1666_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I175_XG_MP1 (XI1666_I175_XG_p1 I1666_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I169_XG_MP2 (XI1666_I169_XG_p1 I1666_G18_11 I1666_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I169_XG_MP0 (VDD I1666_P18_11 XI1666_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I169_XG_MP1 (XI1666_I169_XG_p1 I1666_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I160_XG_MP2 (XI1666_I160_XG_p1 I1666_G10_3 I1666_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I160_XG_MP0 (VDD I1666_P10_3 XI1666_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I160_XG_MP1 (XI1666_I160_XG_p1 I1666_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I106_XG_MP2 (XI1666_I106_XG_p1 I1666_G10_9 I1666_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I106_XG_MP0 (VDD I1666_P10_9 XI1666_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I106_XG_MP1 (XI1666_I106_XG_p1 I1666_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I158_XG_MP2 (XI1666_I158_XG_p1 I1666_G9_2 I1666_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I158_XG_MP0 (VDD I1666_P9_2 XI1666_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I158_XG_MP1 (XI1666_I158_XG_p1 I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I105_XG_MP2 (XI1666_I105_XG_p1 I1666_G9_8 I1666_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I105_XG_MP0 (VDD I1666_P9_8 XI1666_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I105_XG_MP1 (XI1666_I105_XG_p1 I1666_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I103_XG_MP2 (XI1620_I103_XG_p1 I1620_G7_6 I1620_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I103_XG_MP0 (VDD I1620_P7_6 XI1620_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I103_XG_MP1 (XI1620_I103_XG_p1 I1620_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I157_XG_MP2 (XI1620_I157_XG_p1 I1620_G8_1 I1620_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I157_XG_MP0 (VDD I1620_P8_1 XI1620_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I157_XG_MP1 (XI1620_I157_XG_p1 I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I104_XG_MP2 (XI1620_I104_XG_p1 I1620_G8_7 I1620_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I104_XG_MP0 (VDD I1620_P8_7 XI1620_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I104_XG_MP1 (XI1620_I104_XG_p1 I1620_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I106_XG_MP2 (XI1620_I106_XG_p1 I1620_G10_9 I1620_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I106_XG_MP0 (VDD I1620_P10_9 XI1620_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I106_XG_MP1 (XI1620_I106_XG_p1 I1620_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I158_XG_MP2 (XI1574_I158_XG_p1 I1574_G9_2 I1574_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I158_XG_MP0 (VDD I1574_P9_2 XI1574_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I158_XG_MP1 (XI1574_I158_XG_p1 I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I105_XG_MP2 (XI1574_I105_XG_p1 I1574_G9_8 I1574_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I105_XG_MP0 (VDD I1574_P9_8 XI1574_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I105_XG_MP1 (XI1574_I105_XG_p1 I1574_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I106_XG_MP2 (XI1574_I106_XG_p1 I1574_G10_9 I1574_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I106_XG_MP0 (VDD I1574_P10_9 XI1574_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I106_XG_MP1 (XI1574_I106_XG_p1 I1574_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I108_XG_MP2 (XI1574_I108_XG_p1 I1574_G12_11 I1574_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I108_XG_MP0 (VDD I1574_P12_11 XI1574_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I108_XG_MP1 (XI1574_I108_XG_p1 I1574_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I160_XG_MP2 (XI1574_I160_XG_p1 I1574_G10_3 I1574_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I160_XG_MP0 (VDD I1574_P10_3 XI1574_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I160_XG_MP1 (XI1574_I160_XG_p1 I1574_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I171_XG_MP2 (XI1574_I171_XG_p1 I1574_G20_13 I1574_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I171_XG_MP0 (VDD I1574_P20_13 XI1574_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I171_XG_MP1 (XI1574_I171_XG_p1 I1574_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I116_XG_MP2 (XI1068_I116_XG_p1 I1068_G20_19 I1068_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I116_XG_MP0 (VDD I1068_P20_19 XI1068_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I116_XG_MP1 (XI1068_I116_XG_p1 I1068_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I114_XG_MP2 (XI1068_I114_XG_p1 I1068_G18_17 I1068_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I114_XG_MP0 (VDD I1068_P18_17 XI1068_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I114_XG_MP1 (XI1068_I114_XG_p1 I1068_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I112_XG_MP2 (XI1068_I112_XG_p1 I1068_G16_15 I1068_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I112_XG_MP0 (VDD I1068_P16_15 XI1068_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I112_XG_MP1 (XI1068_I112_XG_p1 I1068_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1068_I110_XG_MP2 (XI1068_I110_XG_p1 I1068_G14_13 I1068_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1068_I110_XG_MP0 (VDD I1068_P14_13 XI1068_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1068_I110_XG_MP1 (XI1068_I110_XG_p1 I1068_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I168_XG_MP2 (XI1022_I168_XG_p1 I1022_G17_10 I1022_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I168_XG_MP0 (VDD I1022_P17_10 XI1022_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I168_XG_MP1 (XI1022_I168_XG_p1 I1022_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I107_XG_MP2 (XI1022_I107_XG_p1 I1022_G11_10 I1022_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I107_XG_MP0 (VDD I1022_P11_10 XI1022_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I107_XG_MP1 (XI1022_I107_XG_p1 I1022_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I160_XG_MP2 (XI1022_I160_XG_p1 I1022_G10_3 I1022_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I160_XG_MP0 (VDD I1022_P10_3 XI1022_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I160_XG_MP1 (XI1022_I160_XG_p1 I1022_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I175_XG_MP2 (XI1022_I175_XG_p1 I1022_G24_17 I1022_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I175_XG_MP0 (VDD I1022_P24_17 XI1022_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I175_XG_MP1 (XI1022_I175_XG_p1 I1022_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I106_XG_MP2 (XI1022_I106_XG_p1 I1022_G10_9 I1022_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I106_XG_MP0 (VDD I1022_P10_9 XI1022_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I106_XG_MP1 (XI1022_I106_XG_p1 I1022_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I157_XG_MP2 (XI976_I157_XG_p1 I976_G8_1 I976_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I157_XG_MP0 (VDD I976_P8_1 XI976_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I157_XG_MP1 (XI976_I157_XG_p1 I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I175_XG_MP2 (XI930_I175_XG_p1 I930_G24_17 I930_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I175_XG_MP0 (VDD I930_P24_17 XI930_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I175_XG_MP1 (XI930_I175_XG_p1 I930_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I108_XG_MP2 (XI930_I108_XG_p1 I930_G12_11 I930_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I108_XG_MP0 (VDD I930_P12_11 XI930_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I108_XG_MP1 (XI930_I108_XG_p1 I930_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I158_XG_MP2 (XI930_I158_XG_p1 I930_G9_2 I930_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I158_XG_MP0 (VDD I930_P9_2 XI930_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I158_XG_MP1 (XI930_I158_XG_p1 I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I171_XG_MP2 (XI1666_I171_XG_p1 I1666_G20_13 I1666_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I171_XG_MP0 (VDD I1666_P20_13 XI1666_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I171_XG_MP1 (XI1666_I171_XG_p1 I1666_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I163_XG_MP2 (XI1666_I163_XG_p1 I1666_G12_5 I1666_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I163_XG_MP0 (VDD I1666_P12_5 XI1666_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I163_XG_MP1 (XI1666_I163_XG_p1 I1666_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I108_XG_MP2 (XI1666_I108_XG_p1 I1666_G12_11 I1666_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I108_XG_MP0 (VDD I1666_P12_11 XI1666_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I108_XG_MP1 (XI1666_I108_XG_p1 I1666_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I168_XG_MP2 (XI1666_I168_XG_p1 I1666_G17_10 I1666_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I168_XG_MP0 (VDD I1666_P17_10 XI1666_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I168_XG_MP1 (XI1666_I168_XG_p1 I1666_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I162_XG_MP2 (XI1666_I162_XG_p1 I1666_G11_4 I1666_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I162_XG_MP0 (VDD I1666_P11_4 XI1666_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I162_XG_MP1 (XI1666_I162_XG_p1 I1666_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I107_XG_MP2 (XI1666_I107_XG_p1 I1666_G11_10 I1666_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I107_XG_MP0 (VDD I1666_P11_10 XI1666_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I107_XG_MP1 (XI1666_I107_XG_p1 I1666_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I158_XG_MP2 (XI1620_I158_XG_p1 I1620_G9_2 I1620_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I158_XG_MP0 (VDD I1620_P9_2 XI1620_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I158_XG_MP1 (XI1620_I158_XG_p1 I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I105_XG_MP2 (XI1620_I105_XG_p1 I1620_G9_8 I1620_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I105_XG_MP0 (VDD I1620_P9_8 XI1620_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I105_XG_MP1 (XI1620_I105_XG_p1 I1620_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I160_XG_MP2 (XI1620_I160_XG_p1 I1620_G10_3 I1620_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I160_XG_MP0 (VDD I1620_P10_3 XI1620_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I160_XG_MP1 (XI1620_I160_XG_p1 I1620_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I167_XG_MP2 (XI1620_I167_XG_p1 I1620_G16_9 I1620_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I167_XG_MP0 (VDD I1620_P16_9 XI1620_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I167_XG_MP1 (XI1620_I167_XG_p1 I1620_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I168_XG_MP2 (XI1574_I168_XG_p1 I1574_G17_10 I1574_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I168_XG_MP0 (VDD I1574_P17_10 XI1574_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I168_XG_MP1 (XI1574_I168_XG_p1 I1574_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I107_XG_MP2 (XI1574_I107_XG_p1 I1574_G11_10 I1574_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I107_XG_MP0 (VDD I1574_P11_10 XI1574_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I107_XG_MP1 (XI1574_I107_XG_p1 I1574_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I169_XG_MP2 (XI1574_I169_XG_p1 I1574_G18_11 I1574_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I169_XG_MP0 (VDD I1574_P18_11 XI1574_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I169_XG_MP1 (XI1574_I169_XG_p1 I1574_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I175_XG_MP2 (XI1574_I175_XG_p1 I1574_G24_17 I1574_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I175_XG_MP0 (VDD I1574_P24_17 XI1574_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I175_XG_MP1 (XI1574_I175_XG_p1 I1574_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I162_XG_MP2 (XI1022_I162_XG_p1 I1022_G11_4 I1022_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I162_XG_MP0 (VDD I1022_P11_4 XI1022_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I162_XG_MP1 (XI1022_I162_XG_p1 I1022_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I109_XG_MP2 (XI1022_I109_XG_p1 I1022_G13_12 I1022_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I109_XG_MP0 (VDD I1022_P13_12 XI1022_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I109_XG_MP1 (XI1022_I109_XG_p1 I1022_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I163_XG_MP2 (XI1022_I163_XG_p1 I1022_G12_5 I1022_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I163_XG_MP0 (VDD I1022_P12_5 XI1022_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I163_XG_MP1 (XI1022_I163_XG_p1 I1022_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I169_XG_MP2 (XI1022_I169_XG_p1 I1022_G18_11 I1022_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I169_XG_MP0 (VDD I1022_P18_11 XI1022_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I169_XG_MP1 (XI1022_I169_XG_p1 I1022_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I108_XG_MP2 (XI1022_I108_XG_p1 I1022_G12_11 I1022_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I108_XG_MP0 (VDD I1022_P12_11 XI1022_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I108_XG_MP1 (XI1022_I108_XG_p1 I1022_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I167_XG_MP2 (XI976_I167_XG_p1 I976_G16_9 I976_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I167_XG_MP0 (VDD I976_P16_9 XI976_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I167_XG_MP1 (XI976_I167_XG_p1 I976_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I106_XG_MP2 (XI976_I106_XG_p1 I976_G10_9 I976_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I106_XG_MP0 (VDD I976_P10_9 XI976_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I106_XG_MP1 (XI976_I106_XG_p1 I976_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I158_XG_MP2 (XI976_I158_XG_p1 I976_G9_2 I976_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I158_XG_MP0 (VDD I976_P9_2 XI976_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I158_XG_MP1 (XI976_I158_XG_p1 I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I105_XG_MP2 (XI976_I105_XG_p1 I976_G9_8 I976_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I105_XG_MP0 (VDD I976_P9_8 XI976_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I105_XG_MP1 (XI976_I105_XG_p1 I976_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I163_XG_MP2 (XI930_I163_XG_p1 I930_G12_5 I930_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I163_XG_MP0 (VDD I930_P12_5 XI930_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I163_XG_MP1 (XI930_I163_XG_p1 I930_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I171_XG_MP2 (XI930_I171_XG_p1 I930_G20_13 I930_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I171_XG_MP0 (VDD I930_P20_13 XI930_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I171_XG_MP1 (XI930_I171_XG_p1 I930_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I107_XG_MP2 (XI930_I107_XG_p1 I930_G11_10 I930_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I107_XG_MP0 (VDD I930_P11_10 XI930_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I107_XG_MP1 (XI930_I107_XG_p1 I930_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I109_XG_MP2 (XI930_I109_XG_p1 I930_G13_12 I930_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I109_XG_MP0 (VDD I930_P13_12 XI930_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I109_XG_MP1 (XI930_I109_XG_p1 I930_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I162_XG_MP2 (XI930_I162_XG_p1 I930_G11_4 I930_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I162_XG_MP0 (VDD I930_P11_4 XI930_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I162_XG_MP1 (XI930_I162_XG_p1 I930_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I168_XG_MP2 (XI930_I168_XG_p1 I930_G17_10 I930_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I168_XG_MP0 (VDD I930_P17_10 XI930_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I168_XG_MP1 (XI930_I168_XG_p1 I930_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I110_XG_MP2 (XI1666_I110_XG_p1 I1666_G14_13 I1666_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I110_XG_MP0 (VDD I1666_P14_13 XI1666_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I110_XG_MP1 (XI1666_I110_XG_p1 I1666_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I170_XG_MP2 (XI1666_I170_XG_p1 I1666_G19_12 I1666_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I170_XG_MP0 (VDD I1666_P19_12 XI1666_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I170_XG_MP1 (XI1666_I170_XG_p1 I1666_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I109_XG_MP2 (XI1666_I109_XG_p1 I1666_G13_12 I1666_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I109_XG_MP0 (VDD I1666_P13_12 XI1666_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I109_XG_MP1 (XI1666_I109_XG_p1 I1666_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I107_XG_MP2 (XI1620_I107_XG_p1 I1620_G11_10 I1620_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I107_XG_MP0 (VDD I1620_P11_10 XI1620_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I107_XG_MP1 (XI1620_I107_XG_p1 I1620_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I168_XG_MP2 (XI1620_I168_XG_p1 I1620_G17_10 I1620_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I168_XG_MP0 (VDD I1620_P17_10 XI1620_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I168_XG_MP1 (XI1620_I168_XG_p1 I1620_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I169_XG_MP2 (XI1620_I169_XG_p1 I1620_G18_11 I1620_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I169_XG_MP0 (VDD I1620_P18_11 XI1620_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I169_XG_MP1 (XI1620_I169_XG_p1 I1620_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I175_XG_MP2 (XI1620_I175_XG_p1 I1620_G24_17 I1620_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I175_XG_MP0 (VDD I1620_P24_17 XI1620_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I175_XG_MP1 (XI1620_I175_XG_p1 I1620_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I108_XG_MP2 (XI1620_I108_XG_p1 I1620_G12_11 I1620_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I108_XG_MP0 (VDD I1620_P12_11 XI1620_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I108_XG_MP1 (XI1620_I108_XG_p1 I1620_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I162_XG_MP2 (XI1574_I162_XG_p1 I1574_G11_4 I1574_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I162_XG_MP0 (VDD I1574_P11_4 XI1574_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I162_XG_MP1 (XI1574_I162_XG_p1 I1574_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I170_XG_MP2 (XI1574_I170_XG_p1 I1574_G19_12 I1574_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I170_XG_MP0 (VDD I1574_P19_12 XI1574_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I170_XG_MP1 (XI1574_I170_XG_p1 I1574_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I109_XG_MP2 (XI1574_I109_XG_p1 I1574_G13_12 I1574_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I109_XG_MP0 (VDD I1574_P13_12 XI1574_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I109_XG_MP1 (XI1574_I109_XG_p1 I1574_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I110_XG_MP2 (XI1574_I110_XG_p1 I1574_G14_13 I1574_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I110_XG_MP0 (VDD I1574_P14_13 XI1574_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I110_XG_MP1 (XI1574_I110_XG_p1 I1574_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I177_XG_MP2 (XI1574_I177_XG_p1 I1574_G26_19 I1574_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I177_XG_MP0 (VDD I1574_P26_19 XI1574_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I177_XG_MP1 (XI1574_I177_XG_p1 I1574_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I164_XG_MP2 (XI1022_I164_XG_p1 I1022_G13_6 I1022_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I164_XG_MP0 (VDD I1022_P13_6 XI1022_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I164_XG_MP1 (XI1022_I164_XG_p1 I1022_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I176_XG_MP2 (XI1022_I176_XG_p1 I1022_G25_18 I1022_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I176_XG_MP0 (VDD I1022_P25_18 XI1022_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I176_XG_MP1 (XI1022_I176_XG_p1 I1022_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I170_XG_MP2 (XI1022_I170_XG_p1 I1022_G19_12 I1022_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I170_XG_MP0 (VDD I1022_P19_12 XI1022_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I170_XG_MP1 (XI1022_I170_XG_p1 I1022_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I171_XG_MP2 (XI1022_I171_XG_p1 I1022_G20_13 I1022_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I171_XG_MP0 (VDD I1022_P20_13 XI1022_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I171_XG_MP1 (XI1022_I171_XG_p1 I1022_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I110_XG_MP2 (XI1022_I110_XG_p1 I1022_G14_13 I1022_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I110_XG_MP0 (VDD I1022_P14_13 XI1022_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I110_XG_MP1 (XI1022_I110_XG_p1 I1022_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I160_XG_MP2 (XI976_I160_XG_p1 I976_G10_3 I976_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I160_XG_MP0 (VDD I976_P10_3 XI976_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I160_XG_MP1 (XI976_I160_XG_p1 I976_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I108_XG_MP2 (XI976_I108_XG_p1 I976_G12_11 I976_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I108_XG_MP0 (VDD I976_P12_11 XI976_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I108_XG_MP1 (XI976_I108_XG_p1 I976_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I168_XG_MP2 (XI976_I168_XG_p1 I976_G17_10 I976_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I168_XG_MP0 (VDD I976_P17_10 XI976_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I168_XG_MP1 (XI976_I168_XG_p1 I976_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I107_XG_MP2 (XI976_I107_XG_p1 I976_G11_10 I976_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I107_XG_MP0 (VDD I976_P11_10 XI976_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I107_XG_MP1 (XI976_I107_XG_p1 I976_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I112_XG_MP2 (XI930_I112_XG_p1 I930_G16_15 I930_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I112_XG_MP0 (VDD I930_P16_15 XI930_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I112_XG_MP1 (XI930_I112_XG_p1 I930_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I110_XG_MP2 (XI930_I110_XG_p1 I930_G14_13 I930_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I110_XG_MP0 (VDD I930_P14_13 XI930_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I110_XG_MP1 (XI930_I110_XG_p1 I930_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I160_XG_MP2 (XI930_I160_XG_p1 I930_G10_3 I930_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I160_XG_MP0 (VDD I930_P10_3 XI930_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I160_XG_MP1 (XI930_I160_XG_p1 I930_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I111_XG_MP2 (XI930_I111_XG_p1 I930_G15_14 I930_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I111_XG_MP0 (VDD I930_P15_14 XI930_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I111_XG_MP1 (XI930_I111_XG_p1 I930_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I170_XG_MP2 (XI930_I170_XG_p1 I930_G19_12 I930_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I170_XG_MP0 (VDD I930_P19_12 XI930_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I170_XG_MP1 (XI930_I170_XG_p1 I930_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I179_XG_MP2 (XI1666_I179_XG_p1 I1666_G28_21 I1666_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I179_XG_MP0 (VDD I1666_P28_21 XI1666_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I179_XG_MP1 (XI1666_I179_XG_p1 I1666_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I177_XG_MP2 (XI1666_I177_XG_p1 I1666_G26_19 I1666_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I177_XG_MP0 (VDD I1666_P26_19 XI1666_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I177_XG_MP1 (XI1666_I177_XG_p1 I1666_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I165_XG_MP2 (XI1666_I165_XG_p1 I1666_G14_7 I1666_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I165_XG_MP0 (VDD I1666_P14_7 XI1666_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I165_XG_MP1 (XI1666_I165_XG_p1 I1666_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I112_XG_MP2 (XI1666_I112_XG_p1 I1666_G16_15 I1666_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I112_XG_MP0 (VDD I1666_P16_15 XI1666_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I112_XG_MP1 (XI1666_I112_XG_p1 I1666_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I176_XG_MP2 (XI1666_I176_XG_p1 I1666_G25_18 I1666_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I176_XG_MP0 (VDD I1666_P25_18 XI1666_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I176_XG_MP1 (XI1666_I176_XG_p1 I1666_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I164_XG_MP2 (XI1666_I164_XG_p1 I1666_G13_6 I1666_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I164_XG_MP0 (VDD I1666_P13_6 XI1666_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I164_XG_MP1 (XI1666_I164_XG_p1 I1666_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I113_XG_MP2 (XI1666_I113_XG_p1 I1666_G17_16 I1666_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I113_XG_MP0 (VDD I1666_P17_16 XI1666_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I113_XG_MP1 (XI1666_I113_XG_p1 I1666_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I111_XG_MP2 (XI1666_I111_XG_p1 I1666_G15_14 I1666_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I111_XG_MP0 (VDD I1666_P15_14 XI1666_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I111_XG_MP1 (XI1666_I111_XG_p1 I1666_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I162_XG_MP2 (XI1620_I162_XG_p1 I1620_G11_4 I1620_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I162_XG_MP0 (VDD I1620_P11_4 XI1620_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I162_XG_MP1 (XI1620_I162_XG_p1 I1620_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I109_XG_MP2 (XI1620_I109_XG_p1 I1620_G13_12 I1620_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I109_XG_MP0 (VDD I1620_P13_12 XI1620_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I109_XG_MP1 (XI1620_I109_XG_p1 I1620_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I111_XG_MP2 (XI1620_I111_XG_p1 I1620_G15_14 I1620_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I111_XG_MP0 (VDD I1620_P15_14 XI1620_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I111_XG_MP1 (XI1620_I111_XG_p1 I1620_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I163_XG_MP2 (XI1620_I163_XG_p1 I1620_G12_5 I1620_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I163_XG_MP0 (VDD I1620_P12_5 XI1620_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I163_XG_MP1 (XI1620_I163_XG_p1 I1620_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I110_XG_MP2 (XI1620_I110_XG_p1 I1620_G14_13 I1620_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I110_XG_MP0 (VDD I1620_P14_13 XI1620_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I110_XG_MP1 (XI1620_I110_XG_p1 I1620_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I112_XG_MP2 (XI1620_I112_XG_p1 I1620_G16_15 I1620_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I112_XG_MP0 (VDD I1620_P16_15 XI1620_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I112_XG_MP1 (XI1620_I112_XG_p1 I1620_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I164_XG_MP2 (XI1574_I164_XG_p1 I1574_G13_6 I1574_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I164_XG_MP0 (VDD I1574_P13_6 XI1574_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I164_XG_MP1 (XI1574_I164_XG_p1 I1574_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I176_XG_MP2 (XI1574_I176_XG_p1 I1574_G25_18 I1574_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I176_XG_MP0 (VDD I1574_P25_18 XI1574_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I176_XG_MP1 (XI1574_I176_XG_p1 I1574_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I111_XG_MP2 (XI1574_I111_XG_p1 I1574_G15_14 I1574_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I111_XG_MP0 (VDD I1574_P15_14 XI1574_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I111_XG_MP1 (XI1574_I111_XG_p1 I1574_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I112_XG_MP2 (XI1574_I112_XG_p1 I1574_G16_15 I1574_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I112_XG_MP0 (VDD I1574_P16_15 XI1574_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I112_XG_MP1 (XI1574_I112_XG_p1 I1574_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I165_XG_MP2 (XI1574_I165_XG_p1 I1574_G14_7 I1574_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I165_XG_MP0 (VDD I1574_P14_7 XI1574_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I165_XG_MP1 (XI1574_I165_XG_p1 I1574_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I172_XG_MP2 (XI1022_I172_XG_p1 I1022_G21_14 I1022_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I172_XG_MP0 (VDD I1022_P21_14 XI1022_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I172_XG_MP1 (XI1022_I172_XG_p1 I1022_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I113_XG_MP2 (XI1022_I113_XG_p1 I1022_G17_16 I1022_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I113_XG_MP0 (VDD I1022_P17_16 XI1022_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I113_XG_MP1 (XI1022_I113_XG_p1 I1022_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I111_XG_MP2 (XI1022_I111_XG_p1 I1022_G15_14 I1022_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I111_XG_MP0 (VDD I1022_P15_14 XI1022_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I111_XG_MP1 (XI1022_I111_XG_p1 I1022_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I112_XG_MP2 (XI1022_I112_XG_p1 I1022_G16_15 I1022_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I112_XG_MP0 (VDD I1022_P16_15 XI1022_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I112_XG_MP1 (XI1022_I112_XG_p1 I1022_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I163_XG_MP2 (XI976_I163_XG_p1 I976_G12_5 I976_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I163_XG_MP0 (VDD I976_P12_5 XI976_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I163_XG_MP1 (XI976_I163_XG_p1 I976_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I109_XG_MP2 (XI976_I109_XG_p1 I976_G13_12 I976_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I109_XG_MP0 (VDD I976_P13_12 XI976_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I109_XG_MP1 (XI976_I109_XG_p1 I976_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I111_XG_MP2 (XI976_I111_XG_p1 I976_G15_14 I976_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I111_XG_MP0 (VDD I976_P15_14 XI976_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I111_XG_MP1 (XI976_I111_XG_p1 I976_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I114_XG_MP2 (XI930_I114_XG_p1 I930_G18_17 I930_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I114_XG_MP0 (VDD I930_P18_17 XI930_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I114_XG_MP1 (XI930_I114_XG_p1 I930_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I169_XG_MP2 (XI930_I169_XG_p1 I930_G18_11 I930_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I169_XG_MP0 (VDD I930_P18_11 XI930_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I169_XG_MP1 (XI930_I169_XG_p1 I930_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I113_XG_MP2 (XI930_I113_XG_p1 I930_G17_16 I930_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I113_XG_MP0 (VDD I930_P17_16 XI930_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I113_XG_MP1 (XI930_I113_XG_p1 I930_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I166_XG_MP2 (XI930_I166_XG_p1 I930_G15_8 I930_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I166_XG_MP0 (VDD I930_P15_8 XI930_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I166_XG_MP1 (XI930_I166_XG_p1 I930_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I176_XG_MP2 (XI930_I176_XG_p1 I930_G25_18 I930_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I176_XG_MP0 (VDD I930_P25_18 XI930_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I176_XG_MP1 (XI930_I176_XG_p1 I930_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I164_XG_MP2 (XI930_I164_XG_p1 I930_G13_6 I930_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I164_XG_MP0 (VDD I930_P13_6 XI930_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I164_XG_MP1 (XI930_I164_XG_p1 I930_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I173_XG_MP2 (XI1666_I173_XG_p1 I1666_G22_15 I1666_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I173_XG_MP0 (VDD I1666_P22_15 XI1666_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I173_XG_MP1 (XI1666_I173_XG_p1 I1666_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I116_XG_MP2 (XI1666_I116_XG_p1 I1666_G20_19 I1666_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I116_XG_MP0 (VDD I1666_P20_19 XI1666_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I116_XG_MP1 (XI1666_I116_XG_p1 I1666_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I114_XG_MP2 (XI1666_I114_XG_p1 I1666_G18_17 I1666_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I114_XG_MP0 (VDD I1666_P18_17 XI1666_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I114_XG_MP1 (XI1666_I114_XG_p1 I1666_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I172_XG_MP2 (XI1666_I172_XG_p1 I1666_G21_14 I1666_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I172_XG_MP0 (VDD I1666_P21_14 XI1666_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I172_XG_MP1 (XI1666_I172_XG_p1 I1666_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I115_XG_MP2 (XI1666_I115_XG_p1 I1666_G19_18 I1666_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I115_XG_MP0 (VDD I1666_P19_18 XI1666_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I115_XG_MP1 (XI1666_I115_XG_p1 I1666_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I170_XG_MP2 (XI1620_I170_XG_p1 I1620_G19_12 I1620_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I170_XG_MP0 (VDD I1620_P19_12 XI1620_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I170_XG_MP1 (XI1620_I170_XG_p1 I1620_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I164_XG_MP2 (XI1620_I164_XG_p1 I1620_G13_6 I1620_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I164_XG_MP0 (VDD I1620_P13_6 XI1620_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I164_XG_MP1 (XI1620_I164_XG_p1 I1620_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I113_XG_MP2 (XI1620_I113_XG_p1 I1620_G17_16 I1620_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I113_XG_MP0 (VDD I1620_P17_16 XI1620_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I113_XG_MP1 (XI1620_I113_XG_p1 I1620_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I165_XG_MP2 (XI1620_I165_XG_p1 I1620_G14_7 I1620_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I165_XG_MP0 (VDD I1620_P14_7 XI1620_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I165_XG_MP1 (XI1620_I165_XG_p1 I1620_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I171_XG_MP2 (XI1620_I171_XG_p1 I1620_G20_13 I1620_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I171_XG_MP0 (VDD I1620_P20_13 XI1620_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I171_XG_MP1 (XI1620_I171_XG_p1 I1620_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I114_XG_MP2 (XI1620_I114_XG_p1 I1620_G18_17 I1620_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I114_XG_MP0 (VDD I1620_P18_17 XI1620_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I114_XG_MP1 (XI1620_I114_XG_p1 I1620_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I172_XG_MP2 (XI1574_I172_XG_p1 I1574_G21_14 I1574_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I172_XG_MP0 (VDD I1574_P21_14 XI1574_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I172_XG_MP1 (XI1574_I172_XG_p1 I1574_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I113_XG_MP2 (XI1574_I113_XG_p1 I1574_G17_16 I1574_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I113_XG_MP0 (VDD I1574_P17_16 XI1574_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I113_XG_MP1 (XI1574_I113_XG_p1 I1574_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I114_XG_MP2 (XI1574_I114_XG_p1 I1574_G18_17 I1574_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I114_XG_MP0 (VDD I1574_P18_17 XI1574_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I114_XG_MP1 (XI1574_I114_XG_p1 I1574_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I173_XG_MP2 (XI1574_I173_XG_p1 I1574_G22_15 I1574_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I173_XG_MP0 (VDD I1574_P22_15 XI1574_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I173_XG_MP1 (XI1574_I173_XG_p1 I1574_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I179_XG_MP2 (XI1574_I179_XG_p1 I1574_G28_21 I1574_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I179_XG_MP0 (VDD I1574_P28_21 XI1574_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I179_XG_MP1 (XI1574_I179_XG_p1 I1574_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I180_XG_MP2 (XI1022_I180_XG_p1 I1022_G29_22 I1022_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I180_XG_MP0 (VDD I1022_P29_22 XI1022_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I180_XG_MP1 (XI1022_I180_XG_p1 I1022_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I115_XG_MP2 (XI1022_I115_XG_p1 I1022_G19_18 I1022_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I115_XG_MP0 (VDD I1022_P19_18 XI1022_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I115_XG_MP1 (XI1022_I115_XG_p1 I1022_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I165_XG_MP2 (XI1022_I165_XG_p1 I1022_G14_7 I1022_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I165_XG_MP0 (VDD I1022_P14_7 XI1022_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I165_XG_MP1 (XI1022_I165_XG_p1 I1022_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I177_XG_MP2 (XI1022_I177_XG_p1 I1022_G26_19 I1022_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I177_XG_MP0 (VDD I1022_P26_19 XI1022_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I177_XG_MP1 (XI1022_I177_XG_p1 I1022_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I116_XG_MP2 (XI1022_I116_XG_p1 I1022_G20_19 I1022_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I116_XG_MP0 (VDD I1022_P20_19 XI1022_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I116_XG_MP1 (XI1022_I116_XG_p1 I1022_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I114_XG_MP2 (XI1022_I114_XG_p1 I1022_G18_17 I1022_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I114_XG_MP0 (VDD I1022_P18_17 XI1022_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I114_XG_MP1 (XI1022_I114_XG_p1 I1022_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I169_XG_MP2 (XI976_I169_XG_p1 I976_G18_11 I976_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I169_XG_MP0 (VDD I976_P18_11 XI976_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I169_XG_MP1 (XI976_I169_XG_p1 I976_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I110_XG_MP2 (XI976_I110_XG_p1 I976_G14_13 I976_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I110_XG_MP0 (VDD I976_P14_13 XI976_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I110_XG_MP1 (XI976_I110_XG_p1 I976_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I112_XG_MP2 (XI976_I112_XG_p1 I976_G16_15 I976_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I112_XG_MP0 (VDD I976_P16_15 XI976_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I112_XG_MP1 (XI976_I112_XG_p1 I976_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I162_XG_MP2 (XI976_I162_XG_p1 I976_G11_4 I976_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I162_XG_MP0 (VDD I976_P11_4 XI976_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I162_XG_MP1 (XI976_I162_XG_p1 I976_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I113_XG_MP2 (XI976_I113_XG_p1 I976_G17_16 I976_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I113_XG_MP0 (VDD I976_P17_16 XI976_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I113_XG_MP1 (XI976_I113_XG_p1 I976_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I116_XG_MP2 (XI930_I116_XG_p1 I930_G20_19 I930_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I116_XG_MP0 (VDD I930_P20_19 XI930_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I116_XG_MP1 (XI930_I116_XG_p1 I930_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I173_XG_MP2 (XI930_I173_XG_p1 I930_G22_15 I930_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I173_XG_MP0 (VDD I930_P22_15 XI930_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I173_XG_MP1 (XI930_I173_XG_p1 I930_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I165_XG_MP2 (XI930_I165_XG_p1 I930_G14_7 I930_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I165_XG_MP0 (VDD I930_P14_7 XI930_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I165_XG_MP1 (XI930_I165_XG_p1 I930_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I177_XG_MP2 (XI930_I177_XG_p1 I930_G26_19 I930_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I177_XG_MP0 (VDD I930_P26_19 XI930_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I177_XG_MP1 (XI930_I177_XG_p1 I930_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I115_XG_MP2 (XI930_I115_XG_p1 I930_G19_18 I930_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I115_XG_MP0 (VDD I930_P19_18 XI930_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I115_XG_MP1 (XI930_I115_XG_p1 I930_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I174_XG_MP2 (XI930_I174_XG_p1 I930_G23_16 I930_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I174_XG_MP0 (VDD I930_P23_16 XI930_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I174_XG_MP1 (XI930_I174_XG_p1 I930_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I172_XG_MP2 (XI930_I172_XG_p1 I930_G21_14 I930_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I172_XG_MP0 (VDD I930_P21_14 XI930_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I172_XG_MP1 (XI930_I172_XG_p1 I930_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I118_XG_MP2 (XI1666_I118_XG_p1 I1666_G22_21 I1666_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I118_XG_MP0 (VDD I1666_P22_21 XI1666_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I118_XG_MP1 (XI1666_I118_XG_p1 I1666_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I180_XG_MP2 (XI1666_I180_XG_p1 I1666_G29_22 I1666_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I180_XG_MP0 (VDD I1666_P29_22 XI1666_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I180_XG_MP1 (XI1666_I180_XG_p1 I1666_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I117_XG_MP2 (XI1666_I117_XG_p1 I1666_G21_20 I1666_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I117_XG_MP0 (VDD I1666_P21_20 XI1666_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I117_XG_MP1 (XI1666_I117_XG_p1 I1666_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I166_XG_MP2 (XI1666_I166_XG_p1 I1666_G15_8 I1666_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I166_XG_MP0 (VDD I1666_P15_8 XI1666_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I166_XG_MP1 (XI1666_I166_XG_p1 I1666_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I172_XG_MP2 (XI1620_I172_XG_p1 I1620_G21_14 I1620_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I172_XG_MP0 (VDD I1620_P21_14 XI1620_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I172_XG_MP1 (XI1620_I172_XG_p1 I1620_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I115_XG_MP2 (XI1620_I115_XG_p1 I1620_G19_18 I1620_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I115_XG_MP0 (VDD I1620_P19_18 XI1620_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I115_XG_MP1 (XI1620_I115_XG_p1 I1620_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I177_XG_MP2 (XI1620_I177_XG_p1 I1620_G26_19 I1620_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I177_XG_MP0 (VDD I1620_P26_19 XI1620_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I177_XG_MP1 (XI1620_I177_XG_p1 I1620_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I116_XG_MP2 (XI1620_I116_XG_p1 I1620_G20_19 I1620_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I116_XG_MP0 (VDD I1620_P20_19 XI1620_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I116_XG_MP1 (XI1620_I116_XG_p1 I1620_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I166_XG_MP2 (XI1574_I166_XG_p1 I1574_G15_8 I1574_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I166_XG_MP0 (VDD I1574_P15_8 XI1574_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I166_XG_MP1 (XI1574_I166_XG_p1 I1574_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I117_XG_MP2 (XI1574_I117_XG_p1 I1574_G21_20 I1574_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I117_XG_MP0 (VDD I1574_P21_20 XI1574_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I117_XG_MP1 (XI1574_I117_XG_p1 I1574_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I115_XG_MP2 (XI1574_I115_XG_p1 I1574_G19_18 I1574_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I115_XG_MP0 (VDD I1574_P19_18 XI1574_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I115_XG_MP1 (XI1574_I115_XG_p1 I1574_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I116_XG_MP2 (XI1574_I116_XG_p1 I1574_G20_19 I1574_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I116_XG_MP0 (VDD I1574_P20_19 XI1574_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I116_XG_MP1 (XI1574_I116_XG_p1 I1574_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I166_XG_MP2 (XI1022_I166_XG_p1 I1022_G15_8 I1022_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I166_XG_MP0 (VDD I1022_P15_8 XI1022_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I166_XG_MP1 (XI1022_I166_XG_p1 I1022_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I178_XG_MP2 (XI1022_I178_XG_p1 I1022_G27_20 I1022_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I178_XG_MP0 (VDD I1022_P27_20 XI1022_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I178_XG_MP1 (XI1022_I178_XG_p1 I1022_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I117_XG_MP2 (XI1022_I117_XG_p1 I1022_G21_20 I1022_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I117_XG_MP0 (VDD I1022_P21_20 XI1022_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I117_XG_MP1 (XI1022_I117_XG_p1 I1022_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I173_XG_MP2 (XI1022_I173_XG_p1 I1022_G22_15 I1022_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I173_XG_MP0 (VDD I1022_P22_15 XI1022_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I173_XG_MP1 (XI1022_I173_XG_p1 I1022_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I118_XG_MP2 (XI1022_I118_XG_p1 I1022_G22_21 I1022_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I118_XG_MP0 (VDD I1022_P22_21 XI1022_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I118_XG_MP1 (XI1022_I118_XG_p1 I1022_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I114_XG_MP2 (XI976_I114_XG_p1 I976_G18_17 I976_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I114_XG_MP0 (VDD I976_P18_17 XI976_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I114_XG_MP1 (XI976_I114_XG_p1 I976_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I164_XG_MP2 (XI976_I164_XG_p1 I976_G13_6 I976_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I164_XG_MP0 (VDD I976_P13_6 XI976_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I164_XG_MP1 (XI976_I164_XG_p1 I976_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I170_XG_MP2 (XI976_I170_XG_p1 I976_G19_12 I976_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I170_XG_MP0 (VDD I976_P19_12 XI976_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I170_XG_MP1 (XI976_I170_XG_p1 I976_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I176_XG_MP2 (XI976_I176_XG_p1 I976_G25_18 I976_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I176_XG_MP0 (VDD I976_P25_18 XI976_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I176_XG_MP1 (XI976_I176_XG_p1 I976_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I115_XG_MP2 (XI976_I115_XG_p1 I976_G19_18 I976_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I115_XG_MP0 (VDD I976_P19_18 XI976_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I115_XG_MP1 (XI976_I115_XG_p1 I976_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I118_XG_MP2 (XI930_I118_XG_p1 I930_G22_21 I930_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I118_XG_MP0 (VDD I930_P22_21 XI930_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I118_XG_MP1 (XI930_I118_XG_p1 I930_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I117_XG_MP2 (XI930_I117_XG_p1 I930_G21_20 I930_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I117_XG_MP0 (VDD I930_P21_20 XI930_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I117_XG_MP1 (XI930_I117_XG_p1 I930_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I182_XG_MP2 (XI930_I182_XG_p1 I930_G31_24 I930_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I182_XG_MP0 (VDD I930_P31_24 XI930_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I182_XG_MP1 (XI930_I182_XG_p1 I930_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I178_XG_MP2 (XI930_I178_XG_p1 I930_G27_20 I930_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I178_XG_MP0 (VDD I930_P27_20 XI930_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I178_XG_MP1 (XI930_I178_XG_p1 I930_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I120_XG_MP2 (XI1666_I120_XG_p1 I1666_G24_23 I1666_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I120_XG_MP0 (VDD I1666_P24_23 XI1666_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I120_XG_MP1 (XI1666_I120_XG_p1 I1666_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I181_XG_MP2 (XI1666_I181_XG_p1 I1666_G30_23 I1666_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I181_XG_MP0 (VDD I1666_P30_23 XI1666_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I181_XG_MP1 (XI1666_I181_XG_p1 I1666_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I178_XG_MP2 (XI1666_I178_XG_p1 I1666_G27_20 I1666_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I178_XG_MP0 (VDD I1666_P27_20 XI1666_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I178_XG_MP1 (XI1666_I178_XG_p1 I1666_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I174_XG_MP2 (XI1666_I174_XG_p1 I1666_G23_16 I1666_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I174_XG_MP0 (VDD I1666_P23_16 XI1666_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I174_XG_MP1 (XI1666_I174_XG_p1 I1666_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I166_XG_MP2 (XI1620_I166_XG_p1 I1620_G15_8 I1620_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I166_XG_MP0 (VDD I1620_P15_8 XI1620_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I166_XG_MP1 (XI1620_I166_XG_p1 I1620_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I176_XG_MP2 (XI1620_I176_XG_p1 I1620_G25_18 I1620_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I176_XG_MP0 (VDD I1620_P25_18 XI1620_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I176_XG_MP1 (XI1620_I176_XG_p1 I1620_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I117_XG_MP2 (XI1620_I117_XG_p1 I1620_G21_20 I1620_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I117_XG_MP0 (VDD I1620_P21_20 XI1620_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I117_XG_MP1 (XI1620_I117_XG_p1 I1620_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I173_XG_MP2 (XI1620_I173_XG_p1 I1620_G22_15 I1620_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I173_XG_MP0 (VDD I1620_P22_15 XI1620_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I173_XG_MP1 (XI1620_I173_XG_p1 I1620_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I179_XG_MP2 (XI1620_I179_XG_p1 I1620_G28_21 I1620_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I179_XG_MP0 (VDD I1620_P28_21 XI1620_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I179_XG_MP1 (XI1620_I179_XG_p1 I1620_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I118_XG_MP2 (XI1620_I118_XG_p1 I1620_G22_21 I1620_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I118_XG_MP0 (VDD I1620_P22_21 XI1620_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I118_XG_MP1 (XI1620_I118_XG_p1 I1620_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I174_XG_MP2 (XI1574_I174_XG_p1 I1574_G23_16 I1574_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I174_XG_MP0 (VDD I1574_P23_16 XI1574_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I174_XG_MP1 (XI1574_I174_XG_p1 I1574_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I180_XG_MP2 (XI1574_I180_XG_p1 I1574_G29_22 I1574_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I180_XG_MP0 (VDD I1574_P29_22 XI1574_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I180_XG_MP1 (XI1574_I180_XG_p1 I1574_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I118_XG_MP2 (XI1574_I118_XG_p1 I1574_G22_21 I1574_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I118_XG_MP0 (VDD I1574_P22_21 XI1574_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I118_XG_MP1 (XI1574_I118_XG_p1 I1574_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I181_XG_MP2 (XI1574_I181_XG_p1 I1574_G30_23 I1574_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I181_XG_MP0 (VDD I1574_P30_23 XI1574_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I181_XG_MP1 (XI1574_I181_XG_p1 I1574_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I120_XG_MP2 (XI1574_I120_XG_p1 I1574_G24_23 I1574_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I120_XG_MP0 (VDD I1574_P24_23 XI1574_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I120_XG_MP1 (XI1574_I120_XG_p1 I1574_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I118_XG_MP2 (XI1114_I118_XG_p1 I1114_G22_21 I1114_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I118_XG_MP0 (VDD I1114_P22_21 XI1114_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I118_XG_MP1 (XI1114_I118_XG_p1 I1114_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I116_XG_MP2 (XI1114_I116_XG_p1 I1114_G20_19 I1114_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I116_XG_MP0 (VDD I1114_P20_19 XI1114_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I116_XG_MP1 (XI1114_I116_XG_p1 I1114_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I114_XG_MP2 (XI1114_I114_XG_p1 I1114_G18_17 I1114_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I114_XG_MP0 (VDD I1114_P18_17 XI1114_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I114_XG_MP1 (XI1114_I114_XG_p1 I1114_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I112_XG_MP2 (XI1114_I112_XG_p1 I1114_G16_15 I1114_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I112_XG_MP0 (VDD I1114_P16_15 XI1114_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I112_XG_MP1 (XI1114_I112_XG_p1 I1114_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I174_XG_MP2 (XI1022_I174_XG_p1 I1022_G23_16 I1022_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I174_XG_MP0 (VDD I1022_P23_16 XI1022_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I174_XG_MP1 (XI1022_I174_XG_p1 I1022_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I119_XG_MP2 (XI1022_I119_XG_p1 I1022_G23_22 I1022_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I119_XG_MP0 (VDD I1022_P23_22 XI1022_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I119_XG_MP1 (XI1022_I119_XG_p1 I1022_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I121_XG_MP2 (XI1022_I121_XG_p1 I1022_G25_24 I1022_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I121_XG_MP0 (VDD I1022_P25_24 XI1022_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I121_XG_MP1 (XI1022_I121_XG_p1 I1022_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I179_XG_MP2 (XI1022_I179_XG_p1 I1022_G28_21 I1022_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I179_XG_MP0 (VDD I1022_P28_21 XI1022_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I179_XG_MP1 (XI1022_I179_XG_p1 I1022_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I120_XG_MP2 (XI1022_I120_XG_p1 I1022_G24_23 I1022_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I120_XG_MP0 (VDD I1022_P24_23 XI1022_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I120_XG_MP1 (XI1022_I120_XG_p1 I1022_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I171_XG_MP2 (XI976_I171_XG_p1 I976_G20_13 I976_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I171_XG_MP0 (VDD I976_P20_13 XI976_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I171_XG_MP1 (XI976_I171_XG_p1 I976_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I175_XG_MP2 (XI976_I175_XG_p1 I976_G24_17 I976_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I175_XG_MP0 (VDD I976_P24_17 XI976_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I175_XG_MP1 (XI976_I175_XG_p1 I976_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I116_XG_MP2 (XI976_I116_XG_p1 I976_G20_19 I976_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I116_XG_MP0 (VDD I976_P20_19 XI976_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I116_XG_MP1 (XI976_I116_XG_p1 I976_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I172_XG_MP2 (XI976_I172_XG_p1 I976_G21_14 I976_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I172_XG_MP0 (VDD I976_P21_14 XI976_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I172_XG_MP1 (XI976_I172_XG_p1 I976_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I117_XG_MP2 (XI976_I117_XG_p1 I976_G21_20 I976_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I117_XG_MP0 (VDD I976_P21_20 XI976_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I117_XG_MP1 (XI976_I117_XG_p1 I976_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I179_XG_MP2 (XI930_I179_XG_p1 I930_G28_21 I930_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I179_XG_MP0 (VDD I930_P28_21 XI930_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I179_XG_MP1 (XI930_I179_XG_p1 I930_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I119_XG_MP2 (XI930_I119_XG_p1 I930_G23_22 I930_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I119_XG_MP0 (VDD I930_P23_22 XI930_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I119_XG_MP1 (XI930_I119_XG_p1 I930_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I180_XG_MP2 (XI930_I180_XG_p1 I930_G29_22 I930_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I180_XG_MP0 (VDD I930_P29_22 XI930_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I180_XG_MP1 (XI930_I180_XG_p1 I930_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I122_XG_MP2 (XI1666_I122_XG_p1 I1666_G26_25 I1666_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I122_XG_MP0 (VDD I1666_P26_25 XI1666_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I122_XG_MP1 (XI1666_I122_XG_p1 I1666_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I124_XG_MP2 (XI1666_I124_XG_p1 I1666_G28_27 I1666_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I124_XG_MP0 (VDD I1666_P28_27 XI1666_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I124_XG_MP1 (XI1666_I124_XG_p1 I1666_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I126_XG_MP2 (XI1666_I126_XG_p1 I1666_G30_29 I1666_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I126_XG_MP0 (VDD I1666_P30_29 XI1666_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I126_XG_MP1 (XI1666_I126_XG_p1 I1666_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I123_XG_MP2 (XI1666_I123_XG_p1 I1666_G27_26 I1666_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I123_XG_MP0 (VDD I1666_P27_26 XI1666_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I123_XG_MP1 (XI1666_I123_XG_p1 I1666_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I121_XG_MP2 (XI1666_I121_XG_p1 I1666_G25_24 I1666_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I121_XG_MP0 (VDD I1666_P25_24 XI1666_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I121_XG_MP1 (XI1666_I121_XG_p1 I1666_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I119_XG_MP2 (XI1666_I119_XG_p1 I1666_G23_22 I1666_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I119_XG_MP0 (VDD I1666_P23_22 XI1666_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I119_XG_MP1 (XI1666_I119_XG_p1 I1666_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I174_XG_MP2 (XI1620_I174_XG_p1 I1620_G23_16 I1620_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I174_XG_MP0 (VDD I1620_P23_16 XI1620_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I174_XG_MP1 (XI1620_I174_XG_p1 I1620_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I180_XG_MP2 (XI1620_I180_XG_p1 I1620_G29_22 I1620_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I180_XG_MP0 (VDD I1620_P29_22 XI1620_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I180_XG_MP1 (XI1620_I180_XG_p1 I1620_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I119_XG_MP2 (XI1620_I119_XG_p1 I1620_G23_22 I1620_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I119_XG_MP0 (VDD I1620_P23_22 XI1620_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I119_XG_MP1 (XI1620_I119_XG_p1 I1620_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I120_XG_MP2 (XI1620_I120_XG_p1 I1620_G24_23 I1620_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I120_XG_MP0 (VDD I1620_P24_23 XI1620_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I120_XG_MP1 (XI1620_I120_XG_p1 I1620_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I178_XG_MP2 (XI1574_I178_XG_p1 I1574_G27_20 I1574_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I178_XG_MP0 (VDD I1574_P27_20 XI1574_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I178_XG_MP1 (XI1574_I178_XG_p1 I1574_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I119_XG_MP2 (XI1574_I119_XG_p1 I1574_G23_22 I1574_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I119_XG_MP0 (VDD I1574_P23_22 XI1574_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I119_XG_MP1 (XI1574_I119_XG_p1 I1574_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I122_XG_MP2 (XI1574_I122_XG_p1 I1574_G26_25 I1574_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I122_XG_MP0 (VDD I1574_P26_25 XI1574_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I122_XG_MP1 (XI1574_I122_XG_p1 I1574_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I126_XG_MP2 (XI1114_I126_XG_p1 I1114_G30_29 I1114_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I126_XG_MP0 (VDD I1114_P30_29 XI1114_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I126_XG_MP1 (XI1114_I126_XG_p1 I1114_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I124_XG_MP2 (XI1114_I124_XG_p1 I1114_G28_27 I1114_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I124_XG_MP0 (VDD I1114_P28_27 XI1114_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I124_XG_MP1 (XI1114_I124_XG_p1 I1114_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I122_XG_MP2 (XI1114_I122_XG_p1 I1114_G26_25 I1114_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I122_XG_MP0 (VDD I1114_P26_25 XI1114_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I122_XG_MP1 (XI1114_I122_XG_p1 I1114_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I120_XG_MP2 (XI1114_I120_XG_p1 I1114_G24_23 I1114_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I120_XG_MP0 (VDD I1114_P24_23 XI1114_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I120_XG_MP1 (XI1114_I120_XG_p1 I1114_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I177_XG_MP2 (XI1114_I177_XG_p1 I1114_G26_19 I1114_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I177_XG_MP0 (VDD I1114_P26_19 XI1114_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I177_XG_MP1 (XI1114_I177_XG_p1 I1114_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I110_XG_MP2 (XI1114_I110_XG_p1 I1114_G14_13 I1114_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I110_XG_MP0 (VDD I1114_P14_13 XI1114_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I110_XG_MP1 (XI1114_I110_XG_p1 I1114_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I108_XG_MP2 (XI1114_I108_XG_p1 I1114_G12_11 I1114_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I108_XG_MP0 (VDD I1114_P12_11 XI1114_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I108_XG_MP1 (XI1114_I108_XG_p1 I1114_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I106_XG_MP2 (XI1114_I106_XG_p1 I1114_G10_9 I1114_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I106_XG_MP0 (VDD I1114_P10_9 XI1114_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I106_XG_MP1 (XI1114_I106_XG_p1 I1114_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I182_XG_MP2 (XI1022_I182_XG_p1 I1022_G31_24 I1022_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I182_XG_MP0 (VDD I1022_P31_24 XI1022_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I182_XG_MP1 (XI1022_I182_XG_p1 I1022_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I123_XG_MP2 (XI1022_I123_XG_p1 I1022_G27_26 I1022_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I123_XG_MP0 (VDD I1022_P27_26 XI1022_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I123_XG_MP1 (XI1022_I123_XG_p1 I1022_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I181_XG_MP2 (XI1022_I181_XG_p1 I1022_G30_23 I1022_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I181_XG_MP0 (VDD I1022_P30_23 XI1022_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I181_XG_MP1 (XI1022_I181_XG_p1 I1022_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I122_XG_MP2 (XI1022_I122_XG_p1 I1022_G26_25 I1022_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I122_XG_MP0 (VDD I1022_P26_25 XI1022_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I122_XG_MP1 (XI1022_I122_XG_p1 I1022_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I173_XG_MP2 (XI976_I173_XG_p1 I976_G22_15 I976_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I173_XG_MP0 (VDD I976_P22_15 XI976_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I173_XG_MP1 (XI976_I173_XG_p1 I976_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I165_XG_MP2 (XI976_I165_XG_p1 I976_G14_7 I976_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I165_XG_MP0 (VDD I976_P14_7 XI976_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I165_XG_MP1 (XI976_I165_XG_p1 I976_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I118_XG_MP2 (XI976_I118_XG_p1 I976_G22_21 I976_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I118_XG_MP0 (VDD I976_P22_21 XI976_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I118_XG_MP1 (XI976_I118_XG_p1 I976_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I166_XG_MP2 (XI976_I166_XG_p1 I976_G15_8 I976_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I166_XG_MP0 (VDD I976_P15_8 XI976_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I166_XG_MP1 (XI976_I166_XG_p1 I976_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I174_XG_MP2 (XI976_I174_XG_p1 I976_G23_16 I976_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I174_XG_MP0 (VDD I976_P23_16 XI976_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I174_XG_MP1 (XI976_I174_XG_p1 I976_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I120_XG_MP2 (XI930_I120_XG_p1 I930_G24_23 I930_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I120_XG_MP0 (VDD I930_P24_23 XI930_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I120_XG_MP1 (XI930_I120_XG_p1 I930_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I122_XG_MP2 (XI930_I122_XG_p1 I930_G26_25 I930_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I122_XG_MP0 (VDD I930_P26_25 XI930_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I122_XG_MP1 (XI930_I122_XG_p1 I930_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I123_XG_MP2 (XI930_I123_XG_p1 I930_G27_26 I930_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I123_XG_MP0 (VDD I930_P27_26 XI930_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I123_XG_MP1 (XI930_I123_XG_p1 I930_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I121_XG_MP2 (XI930_I121_XG_p1 I930_G25_24 I930_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I121_XG_MP0 (VDD I930_P25_24 XI930_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I121_XG_MP1 (XI930_I121_XG_p1 I930_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I125_XG_MP2 (XI1666_I125_XG_p1 I1666_G29_28 I1666_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I125_XG_MP0 (VDD I1666_P29_28 XI1666_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I125_XG_MP1 (XI1666_I125_XG_p1 I1666_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I182_XG_MP2 (XI1666_I182_XG_p1 I1666_G31_24 I1666_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I182_XG_MP0 (VDD I1666_P31_24 XI1666_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I182_XG_MP1 (XI1666_I182_XG_p1 I1666_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I178_XG_MP2 (XI1620_I178_XG_p1 I1620_G27_20 I1620_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I178_XG_MP0 (VDD I1620_P27_20 XI1620_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I178_XG_MP1 (XI1620_I178_XG_p1 I1620_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I182_XG_MP2 (XI1620_I182_XG_p1 I1620_G31_24 I1620_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I182_XG_MP0 (VDD I1620_P31_24 XI1620_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I182_XG_MP1 (XI1620_I182_XG_p1 I1620_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I123_XG_MP2 (XI1620_I123_XG_p1 I1620_G27_26 I1620_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I123_XG_MP0 (VDD I1620_P27_26 XI1620_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I123_XG_MP1 (XI1620_I123_XG_p1 I1620_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I121_XG_MP2 (XI1620_I121_XG_p1 I1620_G25_24 I1620_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I121_XG_MP0 (VDD I1620_P25_24 XI1620_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I121_XG_MP1 (XI1620_I121_XG_p1 I1620_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I181_XG_MP2 (XI1620_I181_XG_p1 I1620_G30_23 I1620_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I181_XG_MP0 (VDD I1620_P30_23 XI1620_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I181_XG_MP1 (XI1620_I181_XG_p1 I1620_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I124_XG_MP2 (XI1620_I124_XG_p1 I1620_G28_27 I1620_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I124_XG_MP0 (VDD I1620_P28_27 XI1620_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I124_XG_MP1 (XI1620_I124_XG_p1 I1620_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I122_XG_MP2 (XI1620_I122_XG_p1 I1620_G26_25 I1620_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I122_XG_MP0 (VDD I1620_P26_25 XI1620_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I122_XG_MP1 (XI1620_I122_XG_p1 I1620_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I182_XG_MP2 (XI1574_I182_XG_p1 I1574_G31_24 I1574_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I182_XG_MP0 (VDD I1574_P31_24 XI1574_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I182_XG_MP1 (XI1574_I182_XG_p1 I1574_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I123_XG_MP2 (XI1574_I123_XG_p1 I1574_G27_26 I1574_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I123_XG_MP0 (VDD I1574_P27_26 XI1574_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I123_XG_MP1 (XI1574_I123_XG_p1 I1574_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I121_XG_MP2 (XI1574_I121_XG_p1 I1574_G25_24 I1574_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I121_XG_MP0 (VDD I1574_P25_24 XI1574_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I121_XG_MP1 (XI1574_I121_XG_p1 I1574_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I124_XG_MP2 (XI1574_I124_XG_p1 I1574_G28_27 I1574_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I124_XG_MP0 (VDD I1574_P28_27 XI1574_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I124_XG_MP1 (XI1574_I124_XG_p1 I1574_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I181_XG_MP2 (XI1114_I181_XG_p1 I1114_G30_23 I1114_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I181_XG_MP0 (VDD I1114_P30_23 XI1114_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I181_XG_MP1 (XI1114_I181_XG_p1 I1114_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I179_XG_MP2 (XI1114_I179_XG_p1 I1114_G28_21 I1114_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I179_XG_MP0 (VDD I1114_P28_21 XI1114_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I179_XG_MP1 (XI1114_I179_XG_p1 I1114_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I173_XG_MP2 (XI1114_I173_XG_p1 I1114_G22_15 I1114_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I173_XG_MP0 (VDD I1114_P22_15 XI1114_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I173_XG_MP1 (XI1114_I173_XG_p1 I1114_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I165_XG_MP2 (XI1114_I165_XG_p1 I1114_G14_7 I1114_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I165_XG_MP0 (VDD I1114_P14_7 XI1114_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I165_XG_MP1 (XI1114_I165_XG_p1 I1114_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I171_XG_MP2 (XI1114_I171_XG_p1 I1114_G20_13 I1114_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I171_XG_MP0 (VDD I1114_P20_13 XI1114_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I171_XG_MP1 (XI1114_I171_XG_p1 I1114_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I175_XG_MP2 (XI1114_I175_XG_p1 I1114_G24_17 I1114_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I175_XG_MP0 (VDD I1114_P24_17 XI1114_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I175_XG_MP1 (XI1114_I175_XG_p1 I1114_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I163_XG_MP2 (XI1114_I163_XG_p1 I1114_G12_5 I1114_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I163_XG_MP0 (VDD I1114_P12_5 XI1114_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I163_XG_MP1 (XI1114_I163_XG_p1 I1114_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I169_XG_MP2 (XI1114_I169_XG_p1 I1114_G18_11 I1114_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I169_XG_MP0 (VDD I1114_P18_11 XI1114_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I169_XG_MP1 (XI1114_I169_XG_p1 I1114_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I104_XG_MP2 (XI1114_I104_XG_p1 I1114_G8_7 I1114_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I104_XG_MP0 (VDD I1114_P8_7 XI1114_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I104_XG_MP1 (XI1114_I104_XG_p1 I1114_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I102_XG_MP2 (XI1114_I102_XG_p1 I1114_G6_5 I1114_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I102_XG_MP0 (VDD I1114_P6_5 XI1114_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I102_XG_MP1 (XI1114_I102_XG_p1 I1114_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2141_MP2 (XI2141_p1 nqk21 nqkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2141_MP0 (VDD sq_b3_3 XI2141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2141_MP1 (XI2141_p1 qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I125_XG_MP2 (XI1022_I125_XG_p1 I1022_G29_28 I1022_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I125_XG_MP0 (VDD I1022_P29_28 XI1022_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I125_XG_MP1 (XI1022_I125_XG_p1 I1022_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I127_XG_MP2 (XI1022_I127_XG_p1 I1022_G31_30 I1022_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I127_XG_MP0 (VDD I1022_P31_30 XI1022_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I127_XG_MP1 (XI1022_I127_XG_p1 I1022_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I126_XG_MP2 (XI1022_I126_XG_p1 I1022_G30_29 I1022_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I126_XG_MP0 (VDD I1022_P30_29 XI1022_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I126_XG_MP1 (XI1022_I126_XG_p1 I1022_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1022_I124_XG_MP2 (XI1022_I124_XG_p1 I1022_G28_27 I1022_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1022_I124_XG_MP0 (VDD I1022_P28_27 XI1022_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1022_I124_XG_MP1 (XI1022_I124_XG_p1 I1022_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I177_XG_MP2 (XI976_I177_XG_p1 I976_G26_19 I976_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I177_XG_MP0 (VDD I976_P26_19 XI976_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I177_XG_MP1 (XI976_I177_XG_p1 I976_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I120_XG_MP2 (XI976_I120_XG_p1 I976_G24_23 I976_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I120_XG_MP0 (VDD I976_P24_23 XI976_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I120_XG_MP1 (XI976_I120_XG_p1 I976_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I178_XG_MP2 (XI976_I178_XG_p1 I976_G27_20 I976_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I178_XG_MP0 (VDD I976_P27_20 XI976_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I178_XG_MP1 (XI976_I178_XG_p1 I976_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I119_XG_MP2 (XI976_I119_XG_p1 I976_G23_22 I976_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I119_XG_MP0 (VDD I976_P23_22 XI976_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I119_XG_MP1 (XI976_I119_XG_p1 I976_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I181_XG_MP2 (XI930_I181_XG_p1 I930_G30_23 I930_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I181_XG_MP0 (VDD I930_P30_23 XI930_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I181_XG_MP1 (XI930_I181_XG_p1 I930_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I124_XG_MP2 (XI930_I124_XG_p1 I930_G28_27 I930_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I124_XG_MP0 (VDD I930_P28_27 XI930_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I124_XG_MP1 (XI930_I124_XG_p1 I930_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I125_XG_MP2 (XI930_I125_XG_p1 I930_G29_28 I930_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I125_XG_MP0 (VDD I930_P29_28 XI930_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I125_XG_MP1 (XI930_I125_XG_p1 I930_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1666_I127_XG_MP2 (XI1666_I127_XG_p1 I1666_G31_30 I1666_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1666_I127_XG_MP0 (VDD I1666_P31_30 XI1666_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1666_I127_XG_MP1 (XI1666_I127_XG_p1 I1666_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I125_XG_MP2 (XI1620_I125_XG_p1 I1620_G29_28 I1620_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I125_XG_MP0 (VDD I1620_P29_28 XI1620_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I125_XG_MP1 (XI1620_I125_XG_p1 I1620_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I126_XG_MP2 (XI1620_I126_XG_p1 I1620_G30_29 I1620_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I126_XG_MP0 (VDD I1620_P30_29 XI1620_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I126_XG_MP1 (XI1620_I126_XG_p1 I1620_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I127_XG_MP2 (XI1574_I127_XG_p1 I1574_G31_30 I1574_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I127_XG_MP0 (VDD I1574_P31_30 XI1574_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I127_XG_MP1 (XI1574_I127_XG_p1 I1574_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I125_XG_MP2 (XI1574_I125_XG_p1 I1574_G29_28 I1574_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I125_XG_MP0 (VDD I1574_P29_28 XI1574_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I125_XG_MP1 (XI1574_I125_XG_p1 I1574_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1574_I126_XG_MP2 (XI1574_I126_XG_p1 I1574_G30_29 I1574_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1574_I126_XG_MP0 (VDD I1574_P30_29 XI1574_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1574_I126_XG_MP1 (XI1574_I126_XG_p1 I1574_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I119_XG_MP2 (XI1114_I119_XG_p1 I1114_G23_22 I1114_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I119_XG_MP0 (VDD I1114_P23_22 XI1114_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I119_XG_MP1 (XI1114_I119_XG_p1 I1114_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I160_XG_MP2 (XI1114_I160_XG_p1 I1114_G10_3 I1114_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I160_XG_MP0 (VDD I1114_P10_3 XI1114_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I160_XG_MP1 (XI1114_I160_XG_p1 I1114_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I167_XG_MP2 (XI1114_I167_XG_p1 I1114_G16_9 I1114_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I167_XG_MP0 (VDD I1114_P16_9 XI1114_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I167_XG_MP1 (XI1114_I167_XG_p1 I1114_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I100_XG_MP2 (XI1114_I100_XG_p1 I1114_G4_3 I1114_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I100_XG_MP0 (VDD I1114_P4_3 XI1114_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I100_XG_MP1 (XI1114_I100_XG_p1 I1114_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2138_MP2 (XI2138_p1 nqk20 nqkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2138_MP0 (VDD sq_b3_3 XI2138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2138_MP1 (XI2138_p1 qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI96_MP2 (XI96_p1 nak20 nakn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI96_MP0 (VDD A_31_b3_3 XI96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI96_MP1 (XI96_p1 A_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I179_XG_MP2 (XI976_I179_XG_p1 I976_G28_21 I976_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I179_XG_MP0 (VDD I976_P28_21 XI976_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I179_XG_MP1 (XI976_I179_XG_p1 I976_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I124_XG_MP2 (XI976_I124_XG_p1 I976_G28_27 I976_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I124_XG_MP0 (VDD I976_P28_27 XI976_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I124_XG_MP1 (XI976_I124_XG_p1 I976_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I122_XG_MP2 (XI976_I122_XG_p1 I976_G26_25 I976_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I122_XG_MP0 (VDD I976_P26_25 XI976_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I122_XG_MP1 (XI976_I122_XG_p1 I976_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I180_XG_MP2 (XI976_I180_XG_p1 I976_G29_22 I976_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I180_XG_MP0 (VDD I976_P29_22 XI976_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I180_XG_MP1 (XI976_I180_XG_p1 I976_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I123_XG_MP2 (XI976_I123_XG_p1 I976_G27_26 I976_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I123_XG_MP0 (VDD I976_P27_26 XI976_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I123_XG_MP1 (XI976_I123_XG_p1 I976_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I121_XG_MP2 (XI976_I121_XG_p1 I976_G25_24 I976_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I121_XG_MP0 (VDD I976_P25_24 XI976_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I121_XG_MP1 (XI976_I121_XG_p1 I976_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I126_XG_MP2 (XI930_I126_XG_p1 I930_G30_29 I930_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I126_XG_MP0 (VDD I930_P30_29 XI930_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I126_XG_MP1 (XI930_I126_XG_p1 I930_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_I127_XG_MP2 (XI1620_I127_XG_p1 I1620_G31_30 I1620_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_I127_XG_MP0 (VDD I1620_P31_30 XI1620_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_I127_XG_MP1 (XI1620_I127_XG_p1 I1620_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI66_MP2 (XI66_p1 nak10 nakn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI66_MP0 (VDD A_31_b3_1 XI66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI66_MP1 (XI66_p1 A_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I127_XG_MP2 (XI1114_I127_XG_p1 I1114_G31_30 I1114_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I127_XG_MP0 (VDD I1114_P31_30 XI1114_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I127_XG_MP1 (XI1114_I127_XG_p1 I1114_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I125_XG_MP2 (XI1114_I125_XG_p1 I1114_G29_28 I1114_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I125_XG_MP0 (VDD I1114_P29_28 XI1114_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I125_XG_MP1 (XI1114_I125_XG_p1 I1114_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I123_XG_MP2 (XI1114_I123_XG_p1 I1114_G27_26 I1114_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I123_XG_MP0 (VDD I1114_P27_26 XI1114_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I123_XG_MP1 (XI1114_I123_XG_p1 I1114_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I121_XG_MP2 (XI1114_I121_XG_p1 I1114_G25_24 I1114_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I121_XG_MP0 (VDD I1114_P25_24 XI1114_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I121_XG_MP1 (XI1114_I121_XG_p1 I1114_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I117_XG_MP2 (XI1114_I117_XG_p1 I1114_G21_20 I1114_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I117_XG_MP0 (VDD I1114_P21_20 XI1114_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I117_XG_MP1 (XI1114_I117_XG_p1 I1114_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I176_XG_MP2 (XI1114_I176_XG_p1 I1114_G25_18 I1114_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I176_XG_MP0 (VDD I1114_P25_18 XI1114_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I176_XG_MP1 (XI1114_I176_XG_p1 I1114_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I115_XG_MP2 (XI1114_I115_XG_p1 I1114_G19_18 I1114_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I115_XG_MP0 (VDD I1114_P19_18 XI1114_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I115_XG_MP1 (XI1114_I115_XG_p1 I1114_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I113_XG_MP2 (XI1114_I113_XG_p1 I1114_G17_16 I1114_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I113_XG_MP0 (VDD I1114_P17_16 XI1114_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I113_XG_MP1 (XI1114_I113_XG_p1 I1114_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I111_XG_MP2 (XI1114_I111_XG_p1 I1114_G15_14 I1114_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I111_XG_MP0 (VDD I1114_P15_14 XI1114_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I111_XG_MP1 (XI1114_I111_XG_p1 I1114_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I109_XG_MP2 (XI1114_I109_XG_p1 I1114_G13_12 I1114_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I109_XG_MP0 (VDD I1114_P13_12 XI1114_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I109_XG_MP1 (XI1114_I109_XG_p1 I1114_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I107_XG_MP2 (XI1114_I107_XG_p1 I1114_G11_10 I1114_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I107_XG_MP0 (VDD I1114_P11_10 XI1114_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I107_XG_MP1 (XI1114_I107_XG_p1 I1114_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I105_XG_MP2 (XI1114_I105_XG_p1 I1114_G9_8 I1114_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I105_XG_MP0 (VDD I1114_P9_8 XI1114_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I105_XG_MP1 (XI1114_I105_XG_p1 I1114_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I157_XG_MP2 (XI1114_I157_XG_p1 I1114_G8_1 I1114_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I157_XG_MP0 (VDD I1114_P8_1 XI1114_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I157_XG_MP1 (XI1114_I157_XG_p1 I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I98_XG_MP2 (XI1114_I98_XG_p1 I1114_G2_1 I1114_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I98_XG_MP0 (VDD I1114_P2_1 XI1114_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I98_XG_MP1 (XI1114_I98_XG_p1 I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI93_MP2 (XI93_p1 nak19 nakn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI93_MP0 (VDD A_31_b3_3 XI93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI93_MP1 (XI93_p1 A_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I181_XG_MP2 (XI976_I181_XG_p1 I976_G30_23 I976_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I181_XG_MP0 (VDD I976_P30_23 XI976_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I181_XG_MP1 (XI976_I181_XG_p1 I976_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I182_XG_MP2 (XI976_I182_XG_p1 I976_G31_24 I976_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I182_XG_MP0 (VDD I976_P31_24 XI976_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I182_XG_MP1 (XI976_I182_XG_p1 I976_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I127_XG_MP2 (XI976_I127_XG_p1 I976_G31_30 I976_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I127_XG_MP0 (VDD I976_P31_30 XI976_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I127_XG_MP1 (XI976_I127_XG_p1 I976_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I125_XG_MP2 (XI976_I125_XG_p1 I976_G29_28 I976_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I125_XG_MP0 (VDD I976_P29_28 XI976_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I125_XG_MP1 (XI976_I125_XG_p1 I976_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_I127_XG_MP2 (XI930_I127_XG_p1 I930_G31_30 I930_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_I127_XG_MP0 (VDD I930_P31_30 XI930_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI930_I127_XG_MP1 (XI930_I127_XG_p1 I930_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI78_MP2 (XI78_p1 nak14 nakn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI78_MP0 (VDD A_31_b3_2 XI78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI78_MP1 (XI78_p1 A_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI75_MP2 (XI75_p1 nak13 nakn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI75_MP0 (VDD A_31_b3_2 XI75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI75_MP1 (XI75_p1 A_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI72_MP2 (XI72_p1 nak12 nakn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI72_MP0 (VDD A_31_b3_2 XI72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI72_MP1 (XI72_p1 A_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI69_MP2 (XI69_p1 nak11 nakn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI69_MP0 (VDD A_31_b3_1 XI69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI69_MP1 (XI69_p1 A_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2111_MP2 (XI2111_p1 nqk11 nqkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2111_MP0 (VDD sq_b3_2 XI2111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2111_MP1 (XI2111_p1 qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I180_XG_MP2 (XI1114_I180_XG_p1 I1114_G29_22 I1114_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I180_XG_MP0 (VDD I1114_P29_22 XI1114_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I180_XG_MP1 (XI1114_I180_XG_p1 I1114_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I172_XG_MP2 (XI1114_I172_XG_p1 I1114_G21_14 I1114_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I172_XG_MP0 (VDD I1114_P21_14 XI1114_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I172_XG_MP1 (XI1114_I172_XG_p1 I1114_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I164_XG_MP2 (XI1114_I164_XG_p1 I1114_G13_6 I1114_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I164_XG_MP0 (VDD I1114_P13_6 XI1114_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I164_XG_MP1 (XI1114_I164_XG_p1 I1114_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I168_XG_MP2 (XI1114_I168_XG_p1 I1114_G17_10 I1114_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I168_XG_MP0 (VDD I1114_P17_10 XI1114_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I168_XG_MP1 (XI1114_I168_XG_p1 I1114_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I158_XG_MP2 (XI1114_I158_XG_p1 I1114_G9_2 I1114_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I158_XG_MP0 (VDD I1114_P9_2 XI1114_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I158_XG_MP1 (XI1114_I158_XG_p1 I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I103_XG_MP2 (XI1114_I103_XG_p1 I1114_G7_6 I1114_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I103_XG_MP0 (VDD I1114_P7_6 XI1114_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I103_XG_MP1 (XI1114_I103_XG_p1 I1114_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I101_XG_MP2 (XI1114_I101_XG_p1 I1114_G5_4 I1114_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I101_XG_MP0 (VDD I1114_P5_4 XI1114_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I101_XG_MP1 (XI1114_I101_XG_p1 I1114_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I99_XG_MP2 (XI1114_I99_XG_p1 I1114_G3_2 I1114_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I99_XG_MP0 (VDD I1114_P3_2 XI1114_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I99_XG_MP1 (XI1114_I99_XG_p1 I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI90_MP2 (XI90_p1 nak18 nakn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI90_MP0 (VDD A_31_b3_3 XI90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI90_MP1 (XI90_p1 A_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI87_MP2 (XI87_p1 nak17 nakn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI87_MP0 (VDD A_31_b3_2 XI87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI87_MP1 (XI87_p1 A_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI84_MP2 (XI84_p1 nak16 nakn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI84_MP0 (VDD A_31_b3_2 XI84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI84_MP1 (XI84_p1 A_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI976_I126_XG_MP2 (XI976_I126_XG_p1 I976_G30_29 I976_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI976_I126_XG_MP0 (VDD I976_P30_29 XI976_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI976_I126_XG_MP1 (XI976_I126_XG_p1 I976_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI81_MP2 (XI81_p1 nak15 nakn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI81_MP0 (VDD A_31_b3_2 XI81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI81_MP1 (XI81_p1 A_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2123_MP2 (XI2123_p1 nqk15 nqkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2123_MP0 (VDD sq_b3_2 XI2123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2123_MP1 (XI2123_p1 qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2120_MP2 (XI2120_p1 nqk14 nqkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2120_MP0 (VDD sq_b3_2 XI2120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2120_MP1 (XI2120_p1 qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2117_MP2 (XI2117_p1 nqk13 nqkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2117_MP0 (VDD sq_b3_2 XI2117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2117_MP1 (XI2117_p1 qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2114_MP2 (XI2114_p1 nqk12 nqkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2114_MP0 (VDD sq_b3_2 XI2114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2114_MP1 (XI2114_p1 qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I98_XG_MP2 (XI1528_I98_XG_p1 I1528_G2_1 I1528_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I98_XG_MP0 (VDD I1528_P2_1 XI1528_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I98_XG_MP1 (XI1528_I98_XG_p1 I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I100_XG_MP2 (XI1528_I100_XG_p1 I1528_G4_3 I1528_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I100_XG_MP0 (VDD I1528_P4_3 XI1528_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I100_XG_MP1 (XI1528_I100_XG_p1 I1528_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I157_XG_MP2 (XI1528_I157_XG_p1 I1528_G8_1 I1528_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I157_XG_MP0 (VDD I1528_P8_1 XI1528_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I157_XG_MP1 (XI1528_I157_XG_p1 I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I99_XG_MP2 (XI1528_I99_XG_p1 I1528_G3_2 I1528_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I99_XG_MP0 (VDD I1528_P3_2 XI1528_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I99_XG_MP1 (XI1528_I99_XG_p1 I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I101_XG_MP2 (XI1528_I101_XG_p1 I1528_G5_4 I1528_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I101_XG_MP0 (VDD I1528_P5_4 XI1528_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I101_XG_MP1 (XI1528_I101_XG_p1 I1528_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I182_XG_MP2 (XI1114_I182_XG_p1 I1114_G31_24 I1114_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I182_XG_MP0 (VDD I1114_P31_24 XI1114_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I182_XG_MP1 (XI1114_I182_XG_p1 I1114_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I178_XG_MP2 (XI1114_I178_XG_p1 I1114_G27_20 I1114_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I178_XG_MP0 (VDD I1114_P27_20 XI1114_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I178_XG_MP1 (XI1114_I178_XG_p1 I1114_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I174_XG_MP2 (XI1114_I174_XG_p1 I1114_G23_16 I1114_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I174_XG_MP0 (VDD I1114_P23_16 XI1114_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I174_XG_MP1 (XI1114_I174_XG_p1 I1114_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I166_XG_MP2 (XI1114_I166_XG_p1 I1114_G15_8 I1114_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I166_XG_MP0 (VDD I1114_P15_8 XI1114_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I166_XG_MP1 (XI1114_I166_XG_p1 I1114_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I170_XG_MP2 (XI1114_I170_XG_p1 I1114_G19_12 I1114_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I170_XG_MP0 (VDD I1114_P19_12 XI1114_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I170_XG_MP1 (XI1114_I170_XG_p1 I1114_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1114_I162_XG_MP2 (XI1114_I162_XG_p1 I1114_G11_4 I1114_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1114_I162_XG_MP0 (VDD I1114_P11_4 XI1114_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1114_I162_XG_MP1 (XI1114_I162_XG_p1 I1114_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2135_MP2 (XI2135_p1 nqk19 nqkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2135_MP0 (VDD sq_b3_3 XI2135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2135_MP1 (XI2135_p1 qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2132_MP2 (XI2132_p1 nqk18 nqkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2132_MP0 (VDD sq_b3_3 XI2132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2132_MP1 (XI2132_p1 qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2129_MP2 (XI2129_p1 nqk17 nqkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2129_MP0 (VDD sq_b3_3 XI2129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2129_MP1 (XI2129_p1 qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I98_XG_MP2 (XI1390_I98_XG_p1 I1390_G2_1 I1390_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I98_XG_MP0 (VDD I1390_P2_1 XI1390_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I98_XG_MP1 (XI1390_I98_XG_p1 I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I98_XG_MP2 (XI1436_I98_XG_p1 I1436_G2_1 I1436_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I98_XG_MP0 (VDD I1436_P2_1 XI1436_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I98_XG_MP1 (XI1436_I98_XG_p1 I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I99_XG_MP2 (XI1482_I99_XG_p1 I1482_G3_2 I1482_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I99_XG_MP0 (VDD I1482_P3_2 XI1482_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I99_XG_MP1 (XI1482_I99_XG_p1 I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I102_XG_MP2 (XI1528_I102_XG_p1 I1528_G6_5 I1528_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I102_XG_MP0 (VDD I1528_P6_5 XI1528_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I102_XG_MP1 (XI1528_I102_XG_p1 I1528_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I167_XG_MP2 (XI1528_I167_XG_p1 I1528_G16_9 I1528_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I167_XG_MP0 (VDD I1528_P16_9 XI1528_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I167_XG_MP1 (XI1528_I167_XG_p1 I1528_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I175_XG_MP2 (XI1528_I175_XG_p1 I1528_G24_17 I1528_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I175_XG_MP0 (VDD I1528_P24_17 XI1528_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I175_XG_MP1 (XI1528_I175_XG_p1 I1528_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I103_XG_MP2 (XI1528_I103_XG_p1 I1528_G7_6 I1528_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I103_XG_MP0 (VDD I1528_P7_6 XI1528_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I103_XG_MP1 (XI1528_I103_XG_p1 I1528_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I158_XG_MP2 (XI1528_I158_XG_p1 I1528_G9_2 I1528_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I158_XG_MP0 (VDD I1528_P9_2 XI1528_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I158_XG_MP1 (XI1528_I158_XG_p1 I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I168_XG_MP2 (XI1528_I168_XG_p1 I1528_G17_10 I1528_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I168_XG_MP0 (VDD I1528_P17_10 XI1528_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I168_XG_MP1 (XI1528_I168_XG_p1 I1528_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2126_MP2 (XI2126_p1 nqk16 nqkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2126_MP0 (VDD sq_b3_3 XI2126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2126_MP1 (XI2126_p1 qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I100_XG_MP2 (XI1298_I100_XG_p1 I1298_G4_3 I1298_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I100_XG_MP0 (VDD I1298_P4_3 XI1298_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I100_XG_MP1 (XI1298_I100_XG_p1 I1298_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I98_XG_MP2 (XI1298_I98_XG_p1 I1298_G2_1 I1298_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I98_XG_MP0 (VDD I1298_P2_1 XI1298_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I98_XG_MP1 (XI1298_I98_XG_p1 I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I99_XG_MP2 (XI1298_I99_XG_p1 I1298_G3_2 I1298_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I99_XG_MP0 (VDD I1298_P3_2 XI1298_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I99_XG_MP1 (XI1298_I99_XG_p1 I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I102_XG_MP2 (XI1344_I102_XG_p1 I1344_G6_5 I1344_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I102_XG_MP0 (VDD I1344_P6_5 XI1344_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I102_XG_MP1 (XI1344_I102_XG_p1 I1344_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I100_XG_MP2 (XI1344_I100_XG_p1 I1344_G4_3 I1344_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I100_XG_MP0 (VDD I1344_P4_3 XI1344_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I100_XG_MP1 (XI1344_I100_XG_p1 I1344_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I98_XG_MP2 (XI1344_I98_XG_p1 I1344_G2_1 I1344_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I98_XG_MP0 (VDD I1344_P2_1 XI1344_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I98_XG_MP1 (XI1344_I98_XG_p1 I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I101_XG_MP2 (XI1344_I101_XG_p1 I1344_G5_4 I1344_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I101_XG_MP0 (VDD I1344_P5_4 XI1344_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I101_XG_MP1 (XI1344_I101_XG_p1 I1344_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I99_XG_MP2 (XI1344_I99_XG_p1 I1344_G3_2 I1344_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I99_XG_MP0 (VDD I1344_P3_2 XI1344_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I99_XG_MP1 (XI1344_I99_XG_p1 I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I102_XG_MP2 (XI1390_I102_XG_p1 I1390_G6_5 I1390_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I102_XG_MP0 (VDD I1390_P6_5 XI1390_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I102_XG_MP1 (XI1390_I102_XG_p1 I1390_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I100_XG_MP2 (XI1390_I100_XG_p1 I1390_G4_3 I1390_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I100_XG_MP0 (VDD I1390_P4_3 XI1390_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I100_XG_MP1 (XI1390_I100_XG_p1 I1390_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I99_XG_MP2 (XI1390_I99_XG_p1 I1390_G3_2 I1390_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I99_XG_MP0 (VDD I1390_P3_2 XI1390_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I99_XG_MP1 (XI1390_I99_XG_p1 I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I101_XG_MP2 (XI1390_I101_XG_p1 I1390_G5_4 I1390_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I101_XG_MP0 (VDD I1390_P5_4 XI1390_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I101_XG_MP1 (XI1390_I101_XG_p1 I1390_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I100_XG_MP2 (XI1436_I100_XG_p1 I1436_G4_3 I1436_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I100_XG_MP0 (VDD I1436_P4_3 XI1436_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I100_XG_MP1 (XI1436_I100_XG_p1 I1436_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I99_XG_MP2 (XI1436_I99_XG_p1 I1436_G3_2 I1436_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I99_XG_MP0 (VDD I1436_P3_2 XI1436_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I99_XG_MP1 (XI1436_I99_XG_p1 I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I101_XG_MP2 (XI1436_I101_XG_p1 I1436_G5_4 I1436_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I101_XG_MP0 (VDD I1436_P5_4 XI1436_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I101_XG_MP1 (XI1436_I101_XG_p1 I1436_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I101_XG_MP2 (XI1482_I101_XG_p1 I1482_G5_4 I1482_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I101_XG_MP0 (VDD I1482_P5_4 XI1482_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I101_XG_MP1 (XI1482_I101_XG_p1 I1482_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I98_XG_MP2 (XI1482_I98_XG_p1 I1482_G2_1 I1482_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I98_XG_MP0 (VDD I1482_P2_1 XI1482_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I98_XG_MP1 (XI1482_I98_XG_p1 I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I100_XG_MP2 (XI1482_I100_XG_p1 I1482_G4_3 I1482_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I100_XG_MP0 (VDD I1482_P4_3 XI1482_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I100_XG_MP1 (XI1482_I100_XG_p1 I1482_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I104_XG_MP2 (XI1528_I104_XG_p1 I1528_G8_7 I1528_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I104_XG_MP0 (VDD I1528_P8_7 XI1528_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I104_XG_MP1 (XI1528_I104_XG_p1 I1528_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I163_XG_MP2 (XI1528_I163_XG_p1 I1528_G12_5 I1528_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I163_XG_MP0 (VDD I1528_P12_5 XI1528_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I163_XG_MP1 (XI1528_I163_XG_p1 I1528_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I171_XG_MP2 (XI1528_I171_XG_p1 I1528_G20_13 I1528_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I171_XG_MP0 (VDD I1528_P20_13 XI1528_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I171_XG_MP1 (XI1528_I171_XG_p1 I1528_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I105_XG_MP2 (XI1528_I105_XG_p1 I1528_G9_8 I1528_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I105_XG_MP0 (VDD I1528_P9_8 XI1528_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I105_XG_MP1 (XI1528_I105_XG_p1 I1528_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I100_XG_MP2 (XI1252_I100_XG_p1 I1252_G4_3 I1252_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I100_XG_MP0 (VDD I1252_P4_3 XI1252_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I100_XG_MP1 (XI1252_I100_XG_p1 I1252_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I98_XG_MP2 (XI1252_I98_XG_p1 I1252_G2_1 I1252_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I98_XG_MP0 (VDD I1252_P2_1 XI1252_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I98_XG_MP1 (XI1252_I98_XG_p1 I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I99_XG_MP2 (XI1252_I99_XG_p1 I1252_G3_2 I1252_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I99_XG_MP0 (VDD I1252_P3_2 XI1252_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I99_XG_MP1 (XI1252_I99_XG_p1 I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I102_XG_MP2 (XI1298_I102_XG_p1 I1298_G6_5 I1298_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I102_XG_MP0 (VDD I1298_P6_5 XI1298_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I102_XG_MP1 (XI1298_I102_XG_p1 I1298_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I101_XG_MP2 (XI1298_I101_XG_p1 I1298_G5_4 I1298_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I101_XG_MP0 (VDD I1298_P5_4 XI1298_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I101_XG_MP1 (XI1298_I101_XG_p1 I1298_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I104_XG_MP2 (XI1344_I104_XG_p1 I1344_G8_7 I1344_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I104_XG_MP0 (VDD I1344_P8_7 XI1344_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I104_XG_MP1 (XI1344_I104_XG_p1 I1344_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I157_XG_MP2 (XI1344_I157_XG_p1 I1344_G8_1 I1344_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I157_XG_MP0 (VDD I1344_P8_1 XI1344_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I157_XG_MP1 (XI1344_I157_XG_p1 I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I103_XG_MP2 (XI1344_I103_XG_p1 I1344_G7_6 I1344_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I103_XG_MP0 (VDD I1344_P7_6 XI1344_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I103_XG_MP1 (XI1344_I103_XG_p1 I1344_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I105_XG_MP2 (XI1344_I105_XG_p1 I1344_G9_8 I1344_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I105_XG_MP0 (VDD I1344_P9_8 XI1344_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I105_XG_MP1 (XI1344_I105_XG_p1 I1344_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I104_XG_MP2 (XI1390_I104_XG_p1 I1390_G8_7 I1390_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I104_XG_MP0 (VDD I1390_P8_7 XI1390_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I104_XG_MP1 (XI1390_I104_XG_p1 I1390_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I157_XG_MP2 (XI1390_I157_XG_p1 I1390_G8_1 I1390_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I157_XG_MP0 (VDD I1390_P8_1 XI1390_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I157_XG_MP1 (XI1390_I157_XG_p1 I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I103_XG_MP2 (XI1390_I103_XG_p1 I1390_G7_6 I1390_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I103_XG_MP0 (VDD I1390_P7_6 XI1390_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I103_XG_MP1 (XI1390_I103_XG_p1 I1390_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I102_XG_MP2 (XI1436_I102_XG_p1 I1436_G6_5 I1436_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I102_XG_MP0 (VDD I1436_P6_5 XI1436_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I102_XG_MP1 (XI1436_I102_XG_p1 I1436_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I104_XG_MP2 (XI1436_I104_XG_p1 I1436_G8_7 I1436_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I104_XG_MP0 (VDD I1436_P8_7 XI1436_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I104_XG_MP1 (XI1436_I104_XG_p1 I1436_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I157_XG_MP2 (XI1436_I157_XG_p1 I1436_G8_1 I1436_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I157_XG_MP0 (VDD I1436_P8_1 XI1436_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I157_XG_MP1 (XI1436_I157_XG_p1 I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I103_XG_MP2 (XI1436_I103_XG_p1 I1436_G7_6 I1436_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I103_XG_MP0 (VDD I1436_P7_6 XI1436_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I103_XG_MP1 (XI1436_I103_XG_p1 I1436_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I103_XG_MP2 (XI1482_I103_XG_p1 I1482_G7_6 I1482_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I103_XG_MP0 (VDD I1482_P7_6 XI1482_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I103_XG_MP1 (XI1482_I103_XG_p1 I1482_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I102_XG_MP2 (XI1482_I102_XG_p1 I1482_G6_5 I1482_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I102_XG_MP0 (VDD I1482_P6_5 XI1482_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I102_XG_MP1 (XI1482_I102_XG_p1 I1482_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I106_XG_MP2 (XI1528_I106_XG_p1 I1528_G10_9 I1528_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I106_XG_MP0 (VDD I1528_P10_9 XI1528_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I106_XG_MP1 (XI1528_I106_XG_p1 I1528_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I108_XG_MP2 (XI1528_I108_XG_p1 I1528_G12_11 I1528_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I108_XG_MP0 (VDD I1528_P12_11 XI1528_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I108_XG_MP1 (XI1528_I108_XG_p1 I1528_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I160_XG_MP2 (XI1528_I160_XG_p1 I1528_G10_3 I1528_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I160_XG_MP0 (VDD I1528_P10_3 XI1528_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I160_XG_MP1 (XI1528_I160_XG_p1 I1528_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I107_XG_MP2 (XI1528_I107_XG_p1 I1528_G11_10 I1528_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I107_XG_MP0 (VDD I1528_P11_10 XI1528_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I107_XG_MP1 (XI1528_I107_XG_p1 I1528_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I162_XG_MP2 (XI1528_I162_XG_p1 I1528_G11_4 I1528_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I162_XG_MP0 (VDD I1528_P11_4 XI1528_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I162_XG_MP1 (XI1528_I162_XG_p1 I1528_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I176_XG_MP2 (XI1528_I176_XG_p1 I1528_G25_18 I1528_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I176_XG_MP0 (VDD I1528_P25_18 XI1528_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I176_XG_MP1 (XI1528_I176_XG_p1 I1528_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I99_XG_MP2 (XI1206_I99_XG_p1 I1206_G3_2 I1206_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I99_XG_MP0 (VDD I1206_P3_2 XI1206_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I99_XG_MP1 (XI1206_I99_XG_p1 I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I98_XG_MP2 (XI1206_I98_XG_p1 I1206_G2_1 I1206_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I98_XG_MP0 (VDD I1206_P2_1 XI1206_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I98_XG_MP1 (XI1206_I98_XG_p1 I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I102_XG_MP2 (XI1252_I102_XG_p1 I1252_G6_5 I1252_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I102_XG_MP0 (VDD I1252_P6_5 XI1252_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I102_XG_MP1 (XI1252_I102_XG_p1 I1252_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I103_XG_MP2 (XI1252_I103_XG_p1 I1252_G7_6 I1252_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I103_XG_MP0 (VDD I1252_P7_6 XI1252_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I103_XG_MP1 (XI1252_I103_XG_p1 I1252_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I101_XG_MP2 (XI1252_I101_XG_p1 I1252_G5_4 I1252_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I101_XG_MP0 (VDD I1252_P5_4 XI1252_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I101_XG_MP1 (XI1252_I101_XG_p1 I1252_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I104_XG_MP2 (XI1298_I104_XG_p1 I1298_G8_7 I1298_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I104_XG_MP0 (VDD I1298_P8_7 XI1298_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I104_XG_MP1 (XI1298_I104_XG_p1 I1298_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I157_XG_MP2 (XI1298_I157_XG_p1 I1298_G8_1 I1298_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I157_XG_MP0 (VDD I1298_P8_1 XI1298_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I157_XG_MP1 (XI1298_I157_XG_p1 I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I103_XG_MP2 (XI1298_I103_XG_p1 I1298_G7_6 I1298_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I103_XG_MP0 (VDD I1298_P7_6 XI1298_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I103_XG_MP1 (XI1298_I103_XG_p1 I1298_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I106_XG_MP2 (XI1344_I106_XG_p1 I1344_G10_9 I1344_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I106_XG_MP0 (VDD I1344_P10_9 XI1344_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I106_XG_MP1 (XI1344_I106_XG_p1 I1344_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I167_XG_MP2 (XI1344_I167_XG_p1 I1344_G16_9 I1344_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I167_XG_MP0 (VDD I1344_P16_9 XI1344_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I167_XG_MP1 (XI1344_I167_XG_p1 I1344_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I158_XG_MP2 (XI1344_I158_XG_p1 I1344_G9_2 I1344_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I158_XG_MP0 (VDD I1344_P9_2 XI1344_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I158_XG_MP1 (XI1344_I158_XG_p1 I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I167_XG_MP2 (XI1390_I167_XG_p1 I1390_G16_9 I1390_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I167_XG_MP0 (VDD I1390_P16_9 XI1390_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I167_XG_MP1 (XI1390_I167_XG_p1 I1390_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I105_XG_MP2 (XI1390_I105_XG_p1 I1390_G9_8 I1390_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I105_XG_MP0 (VDD I1390_P9_8 XI1390_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I105_XG_MP1 (XI1390_I105_XG_p1 I1390_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I158_XG_MP2 (XI1390_I158_XG_p1 I1390_G9_2 I1390_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I158_XG_MP0 (VDD I1390_P9_2 XI1390_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I158_XG_MP1 (XI1390_I158_XG_p1 I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I167_XG_MP2 (XI1436_I167_XG_p1 I1436_G16_9 I1436_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I167_XG_MP0 (VDD I1436_P16_9 XI1436_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I167_XG_MP1 (XI1436_I167_XG_p1 I1436_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I104_XG_MP2 (XI1482_I104_XG_p1 I1482_G8_7 I1482_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I104_XG_MP0 (VDD I1482_P8_7 XI1482_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I104_XG_MP1 (XI1482_I104_XG_p1 I1482_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I157_XG_MP2 (XI1482_I157_XG_p1 I1482_G8_1 I1482_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I157_XG_MP0 (VDD I1482_P8_1 XI1482_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I157_XG_MP1 (XI1482_I157_XG_p1 I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I169_XG_MP2 (XI1528_I169_XG_p1 I1528_G18_11 I1528_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I169_XG_MP0 (VDD I1528_P18_11 XI1528_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I169_XG_MP1 (XI1528_I169_XG_p1 I1528_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I109_XG_MP2 (XI1528_I109_XG_p1 I1528_G13_12 I1528_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I109_XG_MP0 (VDD I1528_P13_12 XI1528_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I109_XG_MP1 (XI1528_I109_XG_p1 I1528_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I170_XG_MP2 (XI1528_I170_XG_p1 I1528_G19_12 I1528_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I170_XG_MP0 (VDD I1528_P19_12 XI1528_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I170_XG_MP1 (XI1528_I170_XG_p1 I1528_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I164_XG_MP2 (XI1528_I164_XG_p1 I1528_G13_6 I1528_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I164_XG_MP0 (VDD I1528_P13_6 XI1528_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I164_XG_MP1 (XI1528_I164_XG_p1 I1528_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I119_XG_MP2 (XI1160_I119_XG_p1 I1160_G23_22 I1160_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I119_XG_MP0 (VDD I1160_P23_22 XI1160_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I119_XG_MP1 (XI1160_I119_XG_p1 I1160_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I174_XG_MP2 (XI1160_I174_XG_p1 I1160_G23_16 I1160_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I174_XG_MP0 (VDD I1160_P23_16 XI1160_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I174_XG_MP1 (XI1160_I174_XG_p1 I1160_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I117_XG_MP2 (XI1160_I117_XG_p1 I1160_G21_20 I1160_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I117_XG_MP0 (VDD I1160_P21_20 XI1160_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I117_XG_MP1 (XI1160_I117_XG_p1 I1160_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I166_XG_MP2 (XI1160_I166_XG_p1 I1160_G15_8 I1160_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I166_XG_MP0 (VDD I1160_P15_8 XI1160_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I166_XG_MP1 (XI1160_I166_XG_p1 I1160_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I115_XG_MP2 (XI1160_I115_XG_p1 I1160_G19_18 I1160_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I115_XG_MP0 (VDD I1160_P19_18 XI1160_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I115_XG_MP1 (XI1160_I115_XG_p1 I1160_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I113_XG_MP2 (XI1160_I113_XG_p1 I1160_G17_16 I1160_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I113_XG_MP0 (VDD I1160_P17_16 XI1160_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I113_XG_MP1 (XI1160_I113_XG_p1 I1160_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I111_XG_MP2 (XI1160_I111_XG_p1 I1160_G15_14 I1160_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I111_XG_MP0 (VDD I1160_P15_14 XI1160_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I111_XG_MP1 (XI1160_I111_XG_p1 I1160_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I109_XG_MP2 (XI1160_I109_XG_p1 I1160_G13_12 I1160_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I109_XG_MP0 (VDD I1160_P13_12 XI1160_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I109_XG_MP1 (XI1160_I109_XG_p1 I1160_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I107_XG_MP2 (XI1160_I107_XG_p1 I1160_G11_10 I1160_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I107_XG_MP0 (VDD I1160_P11_10 XI1160_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I107_XG_MP1 (XI1160_I107_XG_p1 I1160_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I105_XG_MP2 (XI1160_I105_XG_p1 I1160_G9_8 I1160_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I105_XG_MP0 (VDD I1160_P9_8 XI1160_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I105_XG_MP1 (XI1160_I105_XG_p1 I1160_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I103_XG_MP2 (XI1160_I103_XG_p1 I1160_G7_6 I1160_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I103_XG_MP0 (VDD I1160_P7_6 XI1160_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I103_XG_MP1 (XI1160_I103_XG_p1 I1160_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I101_XG_MP2 (XI1160_I101_XG_p1 I1160_G5_4 I1160_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I101_XG_MP0 (VDD I1160_P5_4 XI1160_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I101_XG_MP1 (XI1160_I101_XG_p1 I1160_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I99_XG_MP2 (XI1160_I99_XG_p1 I1160_G3_2 I1160_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I99_XG_MP0 (VDD I1160_P3_2 XI1160_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I99_XG_MP1 (XI1160_I99_XG_p1 I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I100_XG_MP2 (XI1206_I100_XG_p1 I1206_G4_3 I1206_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I100_XG_MP0 (VDD I1206_P4_3 XI1206_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I100_XG_MP1 (XI1206_I100_XG_p1 I1206_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I104_XG_MP2 (XI1252_I104_XG_p1 I1252_G8_7 I1252_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I104_XG_MP0 (VDD I1252_P8_7 XI1252_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I104_XG_MP1 (XI1252_I104_XG_p1 I1252_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I157_XG_MP2 (XI1252_I157_XG_p1 I1252_G8_1 I1252_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I157_XG_MP0 (VDD I1252_P8_1 XI1252_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I157_XG_MP1 (XI1252_I157_XG_p1 I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I105_XG_MP2 (XI1252_I105_XG_p1 I1252_G9_8 I1252_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I105_XG_MP0 (VDD I1252_P9_8 XI1252_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I105_XG_MP1 (XI1252_I105_XG_p1 I1252_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I158_XG_MP2 (XI1252_I158_XG_p1 I1252_G9_2 I1252_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I158_XG_MP0 (VDD I1252_P9_2 XI1252_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I158_XG_MP1 (XI1252_I158_XG_p1 I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I167_XG_MP2 (XI1298_I167_XG_p1 I1298_G16_9 I1298_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I167_XG_MP0 (VDD I1298_P16_9 XI1298_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I167_XG_MP1 (XI1298_I167_XG_p1 I1298_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I105_XG_MP2 (XI1298_I105_XG_p1 I1298_G9_8 I1298_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I105_XG_MP0 (VDD I1298_P9_8 XI1298_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I105_XG_MP1 (XI1298_I105_XG_p1 I1298_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I158_XG_MP2 (XI1298_I158_XG_p1 I1298_G9_2 I1298_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I158_XG_MP0 (VDD I1298_P9_2 XI1298_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I158_XG_MP1 (XI1298_I158_XG_p1 I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I160_XG_MP2 (XI1344_I160_XG_p1 I1344_G10_3 I1344_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I160_XG_MP0 (VDD I1344_P10_3 XI1344_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I160_XG_MP1 (XI1344_I160_XG_p1 I1344_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I108_XG_MP2 (XI1344_I108_XG_p1 I1344_G12_11 I1344_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I108_XG_MP0 (VDD I1344_P12_11 XI1344_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I108_XG_MP1 (XI1344_I108_XG_p1 I1344_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I107_XG_MP2 (XI1344_I107_XG_p1 I1344_G11_10 I1344_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I107_XG_MP0 (VDD I1344_P11_10 XI1344_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I107_XG_MP1 (XI1344_I107_XG_p1 I1344_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I168_XG_MP2 (XI1344_I168_XG_p1 I1344_G17_10 I1344_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I168_XG_MP0 (VDD I1344_P17_10 XI1344_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I168_XG_MP1 (XI1344_I168_XG_p1 I1344_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I106_XG_MP2 (XI1390_I106_XG_p1 I1390_G10_9 I1390_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I106_XG_MP0 (VDD I1390_P10_9 XI1390_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I106_XG_MP1 (XI1390_I106_XG_p1 I1390_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I160_XG_MP2 (XI1390_I160_XG_p1 I1390_G10_3 I1390_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I160_XG_MP0 (VDD I1390_P10_3 XI1390_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I160_XG_MP1 (XI1390_I160_XG_p1 I1390_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I168_XG_MP2 (XI1390_I168_XG_p1 I1390_G17_10 I1390_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I168_XG_MP0 (VDD I1390_P17_10 XI1390_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I168_XG_MP1 (XI1390_I168_XG_p1 I1390_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I106_XG_MP2 (XI1436_I106_XG_p1 I1436_G10_9 I1436_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I106_XG_MP0 (VDD I1436_P10_9 XI1436_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I106_XG_MP1 (XI1436_I106_XG_p1 I1436_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I160_XG_MP2 (XI1436_I160_XG_p1 I1436_G10_3 I1436_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I160_XG_MP0 (VDD I1436_P10_3 XI1436_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I160_XG_MP1 (XI1436_I160_XG_p1 I1436_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I105_XG_MP2 (XI1436_I105_XG_p1 I1436_G9_8 I1436_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I105_XG_MP0 (VDD I1436_P9_8 XI1436_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I105_XG_MP1 (XI1436_I105_XG_p1 I1436_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I158_XG_MP2 (XI1436_I158_XG_p1 I1436_G9_2 I1436_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I158_XG_MP0 (VDD I1436_P9_2 XI1436_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I158_XG_MP1 (XI1436_I158_XG_p1 I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I105_XG_MP2 (XI1482_I105_XG_p1 I1482_G9_8 I1482_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I105_XG_MP0 (VDD I1482_P9_8 XI1482_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I105_XG_MP1 (XI1482_I105_XG_p1 I1482_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I158_XG_MP2 (XI1482_I158_XG_p1 I1482_G9_2 I1482_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I158_XG_MP0 (VDD I1482_P9_2 XI1482_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I158_XG_MP1 (XI1482_I158_XG_p1 I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I106_XG_MP2 (XI1482_I106_XG_p1 I1482_G10_9 I1482_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I106_XG_MP0 (VDD I1482_P10_9 XI1482_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I106_XG_MP1 (XI1482_I106_XG_p1 I1482_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I167_XG_MP2 (XI1482_I167_XG_p1 I1482_G16_9 I1482_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I167_XG_MP0 (VDD I1482_P16_9 XI1482_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I167_XG_MP1 (XI1482_I167_XG_p1 I1482_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I110_XG_MP2 (XI1528_I110_XG_p1 I1528_G14_13 I1528_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I110_XG_MP0 (VDD I1528_P14_13 XI1528_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I110_XG_MP1 (XI1528_I110_XG_p1 I1528_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I177_XG_MP2 (XI1528_I177_XG_p1 I1528_G26_19 I1528_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I177_XG_MP0 (VDD I1528_P26_19 XI1528_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I177_XG_MP1 (XI1528_I177_XG_p1 I1528_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I172_XG_MP2 (XI1528_I172_XG_p1 I1528_G21_14 I1528_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I172_XG_MP0 (VDD I1528_P21_14 XI1528_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I172_XG_MP1 (XI1528_I172_XG_p1 I1528_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I182_XG_MP2 (XI1160_I182_XG_p1 I1160_G31_24 I1160_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I182_XG_MP0 (VDD I1160_P31_24 XI1160_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I182_XG_MP1 (XI1160_I182_XG_p1 I1160_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I178_XG_MP2 (XI1160_I178_XG_p1 I1160_G27_20 I1160_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I178_XG_MP0 (VDD I1160_P27_20 XI1160_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I178_XG_MP1 (XI1160_I178_XG_p1 I1160_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I176_XG_MP2 (XI1160_I176_XG_p1 I1160_G25_18 I1160_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I176_XG_MP0 (VDD I1160_P25_18 XI1160_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I176_XG_MP1 (XI1160_I176_XG_p1 I1160_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I170_XG_MP2 (XI1160_I170_XG_p1 I1160_G19_12 I1160_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I170_XG_MP0 (VDD I1160_P19_12 XI1160_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I170_XG_MP1 (XI1160_I170_XG_p1 I1160_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I168_XG_MP2 (XI1160_I168_XG_p1 I1160_G17_10 I1160_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I168_XG_MP0 (VDD I1160_P17_10 XI1160_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I168_XG_MP1 (XI1160_I168_XG_p1 I1160_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I162_XG_MP2 (XI1160_I162_XG_p1 I1160_G11_4 I1160_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I162_XG_MP0 (VDD I1160_P11_4 XI1160_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I162_XG_MP1 (XI1160_I162_XG_p1 I1160_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I158_XG_MP2 (XI1160_I158_XG_p1 I1160_G9_2 I1160_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I158_XG_MP0 (VDD I1160_P9_2 XI1160_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I158_XG_MP1 (XI1160_I158_XG_p1 I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I102_XG_MP2 (XI1160_I102_XG_p1 I1160_G6_5 I1160_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I102_XG_MP0 (VDD I1160_P6_5 XI1160_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I102_XG_MP1 (XI1160_I102_XG_p1 I1160_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I100_XG_MP2 (XI1160_I100_XG_p1 I1160_G4_3 I1160_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I100_XG_MP0 (VDD I1160_P4_3 XI1160_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I100_XG_MP1 (XI1160_I100_XG_p1 I1160_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I98_XG_MP2 (XI1160_I98_XG_p1 I1160_G2_1 I1160_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I98_XG_MP0 (VDD I1160_P2_1 XI1160_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I98_XG_MP1 (XI1160_I98_XG_p1 I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I106_XG_MP2 (XI1252_I106_XG_p1 I1252_G10_9 I1252_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I106_XG_MP0 (VDD I1252_P10_9 XI1252_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I106_XG_MP1 (XI1252_I106_XG_p1 I1252_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I169_XG_MP2 (XI1252_I169_XG_p1 I1252_G18_11 I1252_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I169_XG_MP0 (VDD I1252_P18_11 XI1252_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I169_XG_MP1 (XI1252_I169_XG_p1 I1252_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I160_XG_MP2 (XI1252_I160_XG_p1 I1252_G10_3 I1252_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I160_XG_MP0 (VDD I1252_P10_3 XI1252_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I160_XG_MP1 (XI1252_I160_XG_p1 I1252_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I167_XG_MP2 (XI1252_I167_XG_p1 I1252_G16_9 I1252_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I167_XG_MP0 (VDD I1252_P16_9 XI1252_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I167_XG_MP1 (XI1252_I167_XG_p1 I1252_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I168_XG_MP2 (XI1252_I168_XG_p1 I1252_G17_10 I1252_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I168_XG_MP0 (VDD I1252_P17_10 XI1252_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I168_XG_MP1 (XI1252_I168_XG_p1 I1252_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I106_XG_MP2 (XI1298_I106_XG_p1 I1298_G10_9 I1298_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I106_XG_MP0 (VDD I1298_P10_9 XI1298_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I106_XG_MP1 (XI1298_I106_XG_p1 I1298_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I160_XG_MP2 (XI1298_I160_XG_p1 I1298_G10_3 I1298_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I160_XG_MP0 (VDD I1298_P10_3 XI1298_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I160_XG_MP1 (XI1298_I160_XG_p1 I1298_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I107_XG_MP2 (XI1298_I107_XG_p1 I1298_G11_10 I1298_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I107_XG_MP0 (VDD I1298_P11_10 XI1298_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I107_XG_MP1 (XI1298_I107_XG_p1 I1298_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I168_XG_MP2 (XI1298_I168_XG_p1 I1298_G17_10 I1298_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I168_XG_MP0 (VDD I1298_P17_10 XI1298_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I168_XG_MP1 (XI1298_I168_XG_p1 I1298_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I175_XG_MP2 (XI1344_I175_XG_p1 I1344_G24_17 I1344_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I175_XG_MP0 (VDD I1344_P24_17 XI1344_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I175_XG_MP1 (XI1344_I175_XG_p1 I1344_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I163_XG_MP2 (XI1344_I163_XG_p1 I1344_G12_5 I1344_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I163_XG_MP0 (VDD I1344_P12_5 XI1344_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I163_XG_MP1 (XI1344_I163_XG_p1 I1344_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I170_XG_MP2 (XI1344_I170_XG_p1 I1344_G19_12 I1344_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I170_XG_MP0 (VDD I1344_P19_12 XI1344_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I170_XG_MP1 (XI1344_I170_XG_p1 I1344_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I162_XG_MP2 (XI1344_I162_XG_p1 I1344_G11_4 I1344_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I162_XG_MP0 (VDD I1344_P11_4 XI1344_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I162_XG_MP1 (XI1344_I162_XG_p1 I1344_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I108_XG_MP2 (XI1390_I108_XG_p1 I1390_G12_11 I1390_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I108_XG_MP0 (VDD I1390_P12_11 XI1390_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I108_XG_MP1 (XI1390_I108_XG_p1 I1390_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I169_XG_MP2 (XI1390_I169_XG_p1 I1390_G18_11 I1390_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I169_XG_MP0 (VDD I1390_P18_11 XI1390_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I169_XG_MP1 (XI1390_I169_XG_p1 I1390_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I109_XG_MP2 (XI1390_I109_XG_p1 I1390_G13_12 I1390_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I109_XG_MP0 (VDD I1390_P13_12 XI1390_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I109_XG_MP1 (XI1390_I109_XG_p1 I1390_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I107_XG_MP2 (XI1390_I107_XG_p1 I1390_G11_10 I1390_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I107_XG_MP0 (VDD I1390_P11_10 XI1390_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I107_XG_MP1 (XI1390_I107_XG_p1 I1390_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I108_XG_MP2 (XI1436_I108_XG_p1 I1436_G12_11 I1436_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I108_XG_MP0 (VDD I1436_P12_11 XI1436_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I108_XG_MP1 (XI1436_I108_XG_p1 I1436_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I169_XG_MP2 (XI1436_I169_XG_p1 I1436_G18_11 I1436_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I169_XG_MP0 (VDD I1436_P18_11 XI1436_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I169_XG_MP1 (XI1436_I169_XG_p1 I1436_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I107_XG_MP2 (XI1436_I107_XG_p1 I1436_G11_10 I1436_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I107_XG_MP0 (VDD I1436_P11_10 XI1436_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I107_XG_MP1 (XI1436_I107_XG_p1 I1436_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I168_XG_MP2 (XI1436_I168_XG_p1 I1436_G17_10 I1436_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I168_XG_MP0 (VDD I1436_P17_10 XI1436_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I168_XG_MP1 (XI1436_I168_XG_p1 I1436_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I107_XG_MP2 (XI1482_I107_XG_p1 I1482_G11_10 I1482_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I107_XG_MP0 (VDD I1482_P11_10 XI1482_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I107_XG_MP1 (XI1482_I107_XG_p1 I1482_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I108_XG_MP2 (XI1482_I108_XG_p1 I1482_G12_11 I1482_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I108_XG_MP0 (VDD I1482_P12_11 XI1482_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I108_XG_MP1 (XI1482_I108_XG_p1 I1482_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I112_XG_MP2 (XI1528_I112_XG_p1 I1528_G16_15 I1528_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I112_XG_MP0 (VDD I1528_P16_15 XI1528_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I112_XG_MP1 (XI1528_I112_XG_p1 I1528_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I165_XG_MP2 (XI1528_I165_XG_p1 I1528_G14_7 I1528_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I165_XG_MP0 (VDD I1528_P14_7 XI1528_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I165_XG_MP1 (XI1528_I165_XG_p1 I1528_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I179_XG_MP2 (XI1528_I179_XG_p1 I1528_G28_21 I1528_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I179_XG_MP0 (VDD I1528_P28_21 XI1528_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I179_XG_MP1 (XI1528_I179_XG_p1 I1528_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I111_XG_MP2 (XI1528_I111_XG_p1 I1528_G15_14 I1528_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I111_XG_MP0 (VDD I1528_P15_14 XI1528_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I111_XG_MP1 (XI1528_I111_XG_p1 I1528_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I178_XG_MP2 (XI1528_I178_XG_p1 I1528_G27_20 I1528_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I178_XG_MP0 (VDD I1528_P27_20 XI1528_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I178_XG_MP1 (XI1528_I178_XG_p1 I1528_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I127_XG_MP2 (XI1160_I127_XG_p1 I1160_G31_30 I1160_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I127_XG_MP0 (VDD I1160_P31_30 XI1160_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I127_XG_MP1 (XI1160_I127_XG_p1 I1160_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I121_XG_MP2 (XI1160_I121_XG_p1 I1160_G25_24 I1160_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I121_XG_MP0 (VDD I1160_P25_24 XI1160_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I121_XG_MP1 (XI1160_I121_XG_p1 I1160_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I180_XG_MP2 (XI1160_I180_XG_p1 I1160_G29_22 I1160_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I180_XG_MP0 (VDD I1160_P29_22 XI1160_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I180_XG_MP1 (XI1160_I180_XG_p1 I1160_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I172_XG_MP2 (XI1160_I172_XG_p1 I1160_G21_14 I1160_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I172_XG_MP0 (VDD I1160_P21_14 XI1160_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I172_XG_MP1 (XI1160_I172_XG_p1 I1160_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I164_XG_MP2 (XI1160_I164_XG_p1 I1160_G13_6 I1160_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I164_XG_MP0 (VDD I1160_P13_6 XI1160_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I164_XG_MP1 (XI1160_I164_XG_p1 I1160_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I110_XG_MP2 (XI1160_I110_XG_p1 I1160_G14_13 I1160_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I110_XG_MP0 (VDD I1160_P14_13 XI1160_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I110_XG_MP1 (XI1160_I110_XG_p1 I1160_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I108_XG_MP2 (XI1160_I108_XG_p1 I1160_G12_11 I1160_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I108_XG_MP0 (VDD I1160_P12_11 XI1160_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I108_XG_MP1 (XI1160_I108_XG_p1 I1160_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I106_XG_MP2 (XI1160_I106_XG_p1 I1160_G10_9 I1160_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I106_XG_MP0 (VDD I1160_P10_9 XI1160_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I106_XG_MP1 (XI1160_I106_XG_p1 I1160_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I104_XG_MP2 (XI1160_I104_XG_p1 I1160_G8_7 I1160_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I104_XG_MP0 (VDD I1160_P8_7 XI1160_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I104_XG_MP1 (XI1160_I104_XG_p1 I1160_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I101_XG_MP2 (XI1206_I101_XG_p1 I1206_G5_4 I1206_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I101_XG_MP0 (VDD I1206_P5_4 XI1206_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I101_XG_MP1 (XI1206_I101_XG_p1 I1206_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I102_XG_MP2 (XI1206_I102_XG_p1 I1206_G6_5 I1206_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I102_XG_MP0 (VDD I1206_P6_5 XI1206_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I102_XG_MP1 (XI1206_I102_XG_p1 I1206_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I108_XG_MP2 (XI1252_I108_XG_p1 I1252_G12_11 I1252_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I108_XG_MP0 (VDD I1252_P12_11 XI1252_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I108_XG_MP1 (XI1252_I108_XG_p1 I1252_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I107_XG_MP2 (XI1252_I107_XG_p1 I1252_G11_10 I1252_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I107_XG_MP0 (VDD I1252_P11_10 XI1252_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I107_XG_MP1 (XI1252_I107_XG_p1 I1252_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I162_XG_MP2 (XI1252_I162_XG_p1 I1252_G11_4 I1252_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I162_XG_MP0 (VDD I1252_P11_4 XI1252_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I162_XG_MP1 (XI1252_I162_XG_p1 I1252_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I108_XG_MP2 (XI1298_I108_XG_p1 I1298_G12_11 I1298_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I108_XG_MP0 (VDD I1298_P12_11 XI1298_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I108_XG_MP1 (XI1298_I108_XG_p1 I1298_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I175_XG_MP2 (XI1298_I175_XG_p1 I1298_G24_17 I1298_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I175_XG_MP0 (VDD I1298_P24_17 XI1298_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I175_XG_MP1 (XI1298_I175_XG_p1 I1298_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I169_XG_MP2 (XI1298_I169_XG_p1 I1298_G18_11 I1298_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I169_XG_MP0 (VDD I1298_P18_11 XI1298_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I169_XG_MP1 (XI1298_I169_XG_p1 I1298_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I109_XG_MP2 (XI1298_I109_XG_p1 I1298_G13_12 I1298_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I109_XG_MP0 (VDD I1298_P13_12 XI1298_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I109_XG_MP1 (XI1298_I109_XG_p1 I1298_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I162_XG_MP2 (XI1298_I162_XG_p1 I1298_G11_4 I1298_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I162_XG_MP0 (VDD I1298_P11_4 XI1298_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I162_XG_MP1 (XI1298_I162_XG_p1 I1298_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I169_XG_MP2 (XI1344_I169_XG_p1 I1344_G18_11 I1344_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I169_XG_MP0 (VDD I1344_P18_11 XI1344_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I169_XG_MP1 (XI1344_I169_XG_p1 I1344_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I171_XG_MP2 (XI1344_I171_XG_p1 I1344_G20_13 I1344_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I171_XG_MP0 (VDD I1344_P20_13 XI1344_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I171_XG_MP1 (XI1344_I171_XG_p1 I1344_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I110_XG_MP2 (XI1344_I110_XG_p1 I1344_G14_13 I1344_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I110_XG_MP0 (VDD I1344_P14_13 XI1344_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I110_XG_MP1 (XI1344_I110_XG_p1 I1344_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I109_XG_MP2 (XI1344_I109_XG_p1 I1344_G13_12 I1344_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I109_XG_MP0 (VDD I1344_P13_12 XI1344_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I109_XG_MP1 (XI1344_I109_XG_p1 I1344_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I110_XG_MP2 (XI1390_I110_XG_p1 I1390_G14_13 I1390_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I110_XG_MP0 (VDD I1390_P14_13 XI1390_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I110_XG_MP1 (XI1390_I110_XG_p1 I1390_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I175_XG_MP2 (XI1390_I175_XG_p1 I1390_G24_17 I1390_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I175_XG_MP0 (VDD I1390_P24_17 XI1390_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I175_XG_MP1 (XI1390_I175_XG_p1 I1390_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I163_XG_MP2 (XI1390_I163_XG_p1 I1390_G12_5 I1390_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I163_XG_MP0 (VDD I1390_P12_5 XI1390_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I163_XG_MP1 (XI1390_I163_XG_p1 I1390_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I170_XG_MP2 (XI1390_I170_XG_p1 I1390_G19_12 I1390_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I170_XG_MP0 (VDD I1390_P19_12 XI1390_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I170_XG_MP1 (XI1390_I170_XG_p1 I1390_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I162_XG_MP2 (XI1390_I162_XG_p1 I1390_G11_4 I1390_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I162_XG_MP0 (VDD I1390_P11_4 XI1390_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I162_XG_MP1 (XI1390_I162_XG_p1 I1390_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I175_XG_MP2 (XI1436_I175_XG_p1 I1436_G24_17 I1436_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I175_XG_MP0 (VDD I1436_P24_17 XI1436_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I175_XG_MP1 (XI1436_I175_XG_p1 I1436_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I163_XG_MP2 (XI1436_I163_XG_p1 I1436_G12_5 I1436_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I163_XG_MP0 (VDD I1436_P12_5 XI1436_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I163_XG_MP1 (XI1436_I163_XG_p1 I1436_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I109_XG_MP2 (XI1436_I109_XG_p1 I1436_G13_12 I1436_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I109_XG_MP0 (VDD I1436_P13_12 XI1436_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I109_XG_MP1 (XI1436_I109_XG_p1 I1436_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I162_XG_MP2 (XI1436_I162_XG_p1 I1436_G11_4 I1436_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I162_XG_MP0 (VDD I1436_P11_4 XI1436_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I162_XG_MP1 (XI1436_I162_XG_p1 I1436_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I109_XG_MP2 (XI1482_I109_XG_p1 I1482_G13_12 I1482_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I109_XG_MP0 (VDD I1482_P13_12 XI1482_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I109_XG_MP1 (XI1482_I109_XG_p1 I1482_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I162_XG_MP2 (XI1482_I162_XG_p1 I1482_G11_4 I1482_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I162_XG_MP0 (VDD I1482_P11_4 XI1482_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I162_XG_MP1 (XI1482_I162_XG_p1 I1482_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I168_XG_MP2 (XI1482_I168_XG_p1 I1482_G17_10 I1482_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I168_XG_MP0 (VDD I1482_P17_10 XI1482_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I168_XG_MP1 (XI1482_I168_XG_p1 I1482_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I110_XG_MP2 (XI1482_I110_XG_p1 I1482_G14_13 I1482_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I110_XG_MP0 (VDD I1482_P14_13 XI1482_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I110_XG_MP1 (XI1482_I110_XG_p1 I1482_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I163_XG_MP2 (XI1482_I163_XG_p1 I1482_G12_5 I1482_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I163_XG_MP0 (VDD I1482_P12_5 XI1482_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I163_XG_MP1 (XI1482_I163_XG_p1 I1482_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I160_XG_MP2 (XI1482_I160_XG_p1 I1482_G10_3 I1482_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I160_XG_MP0 (VDD I1482_P10_3 XI1482_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I160_XG_MP1 (XI1482_I160_XG_p1 I1482_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I114_XG_MP2 (XI1528_I114_XG_p1 I1528_G18_17 I1528_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I114_XG_MP0 (VDD I1528_P18_17 XI1528_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I114_XG_MP1 (XI1528_I114_XG_p1 I1528_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I116_XG_MP2 (XI1528_I116_XG_p1 I1528_G20_19 I1528_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I116_XG_MP0 (VDD I1528_P20_19 XI1528_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I116_XG_MP1 (XI1528_I116_XG_p1 I1528_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I173_XG_MP2 (XI1528_I173_XG_p1 I1528_G22_15 I1528_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I173_XG_MP0 (VDD I1528_P22_15 XI1528_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I173_XG_MP1 (XI1528_I173_XG_p1 I1528_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I166_XG_MP2 (XI1528_I166_XG_p1 I1528_G15_8 I1528_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I166_XG_MP0 (VDD I1528_P15_8 XI1528_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I166_XG_MP1 (XI1528_I166_XG_p1 I1528_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I113_XG_MP2 (XI1528_I113_XG_p1 I1528_G17_16 I1528_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I113_XG_MP0 (VDD I1528_P17_16 XI1528_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I113_XG_MP1 (XI1528_I113_XG_p1 I1528_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I180_XG_MP2 (XI1528_I180_XG_p1 I1528_G29_22 I1528_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I180_XG_MP0 (VDD I1528_P29_22 XI1528_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I180_XG_MP1 (XI1528_I180_XG_p1 I1528_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I125_XG_MP2 (XI1160_I125_XG_p1 I1160_G29_28 I1160_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I125_XG_MP0 (VDD I1160_P29_28 XI1160_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I125_XG_MP1 (XI1160_I125_XG_p1 I1160_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I123_XG_MP2 (XI1160_I123_XG_p1 I1160_G27_26 I1160_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I123_XG_MP0 (VDD I1160_P27_26 XI1160_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I123_XG_MP1 (XI1160_I123_XG_p1 I1160_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I118_XG_MP2 (XI1160_I118_XG_p1 I1160_G22_21 I1160_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I118_XG_MP0 (VDD I1160_P22_21 XI1160_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I118_XG_MP1 (XI1160_I118_XG_p1 I1160_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I116_XG_MP2 (XI1160_I116_XG_p1 I1160_G20_19 I1160_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I116_XG_MP0 (VDD I1160_P20_19 XI1160_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I116_XG_MP1 (XI1160_I116_XG_p1 I1160_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I114_XG_MP2 (XI1160_I114_XG_p1 I1160_G18_17 I1160_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I114_XG_MP0 (VDD I1160_P18_17 XI1160_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I114_XG_MP1 (XI1160_I114_XG_p1 I1160_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I112_XG_MP2 (XI1160_I112_XG_p1 I1160_G16_15 I1160_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I112_XG_MP0 (VDD I1160_P16_15 XI1160_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I112_XG_MP1 (XI1160_I112_XG_p1 I1160_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I167_XG_MP2 (XI1160_I167_XG_p1 I1160_G16_9 I1160_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I167_XG_MP0 (VDD I1160_P16_9 XI1160_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I167_XG_MP1 (XI1160_I167_XG_p1 I1160_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I157_XG_MP2 (XI1160_I157_XG_p1 I1160_G8_1 I1160_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I157_XG_MP0 (VDD I1160_P8_1 XI1160_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I157_XG_MP1 (XI1160_I157_XG_p1 I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I103_XG_MP2 (XI1206_I103_XG_p1 I1206_G7_6 I1206_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I103_XG_MP0 (VDD I1206_P7_6 XI1206_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I103_XG_MP1 (XI1206_I103_XG_p1 I1206_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I104_XG_MP2 (XI1206_I104_XG_p1 I1206_G8_7 I1206_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I104_XG_MP0 (VDD I1206_P8_7 XI1206_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I104_XG_MP1 (XI1206_I104_XG_p1 I1206_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I157_XG_MP2 (XI1206_I157_XG_p1 I1206_G8_1 I1206_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I157_XG_MP0 (VDD I1206_P8_1 XI1206_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I157_XG_MP1 (XI1206_I157_XG_p1 I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I175_XG_MP2 (XI1252_I175_XG_p1 I1252_G24_17 I1252_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I175_XG_MP0 (VDD I1252_P24_17 XI1252_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I175_XG_MP1 (XI1252_I175_XG_p1 I1252_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I163_XG_MP2 (XI1252_I163_XG_p1 I1252_G12_5 I1252_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I163_XG_MP0 (VDD I1252_P12_5 XI1252_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I163_XG_MP1 (XI1252_I163_XG_p1 I1252_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I109_XG_MP2 (XI1252_I109_XG_p1 I1252_G13_12 I1252_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I109_XG_MP0 (VDD I1252_P13_12 XI1252_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I109_XG_MP1 (XI1252_I109_XG_p1 I1252_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I170_XG_MP2 (XI1252_I170_XG_p1 I1252_G19_12 I1252_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I170_XG_MP0 (VDD I1252_P19_12 XI1252_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I170_XG_MP1 (XI1252_I170_XG_p1 I1252_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I112_XG_MP2 (XI1298_I112_XG_p1 I1298_G16_15 I1298_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I112_XG_MP0 (VDD I1298_P16_15 XI1298_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I112_XG_MP1 (XI1298_I112_XG_p1 I1298_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I110_XG_MP2 (XI1298_I110_XG_p1 I1298_G14_13 I1298_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I110_XG_MP0 (VDD I1298_P14_13 XI1298_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I110_XG_MP1 (XI1298_I110_XG_p1 I1298_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I163_XG_MP2 (XI1298_I163_XG_p1 I1298_G12_5 I1298_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I163_XG_MP0 (VDD I1298_P12_5 XI1298_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I163_XG_MP1 (XI1298_I163_XG_p1 I1298_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I111_XG_MP2 (XI1298_I111_XG_p1 I1298_G15_14 I1298_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I111_XG_MP0 (VDD I1298_P15_14 XI1298_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I111_XG_MP1 (XI1298_I111_XG_p1 I1298_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I170_XG_MP2 (XI1298_I170_XG_p1 I1298_G19_12 I1298_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I170_XG_MP0 (VDD I1298_P19_12 XI1298_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I170_XG_MP1 (XI1298_I170_XG_p1 I1298_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I177_XG_MP2 (XI1344_I177_XG_p1 I1344_G26_19 I1344_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I177_XG_MP0 (VDD I1344_P26_19 XI1344_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I177_XG_MP1 (XI1344_I177_XG_p1 I1344_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I112_XG_MP2 (XI1344_I112_XG_p1 I1344_G16_15 I1344_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I112_XG_MP0 (VDD I1344_P16_15 XI1344_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I112_XG_MP1 (XI1344_I112_XG_p1 I1344_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I111_XG_MP2 (XI1344_I111_XG_p1 I1344_G15_14 I1344_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I111_XG_MP0 (VDD I1344_P15_14 XI1344_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I111_XG_MP1 (XI1344_I111_XG_p1 I1344_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I176_XG_MP2 (XI1344_I176_XG_p1 I1344_G25_18 I1344_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I176_XG_MP0 (VDD I1344_P25_18 XI1344_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I176_XG_MP1 (XI1344_I176_XG_p1 I1344_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I112_XG_MP2 (XI1390_I112_XG_p1 I1390_G16_15 I1390_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I112_XG_MP0 (VDD I1390_P16_15 XI1390_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I112_XG_MP1 (XI1390_I112_XG_p1 I1390_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I171_XG_MP2 (XI1390_I171_XG_p1 I1390_G20_13 I1390_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I171_XG_MP0 (VDD I1390_P20_13 XI1390_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I171_XG_MP1 (XI1390_I171_XG_p1 I1390_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I111_XG_MP2 (XI1390_I111_XG_p1 I1390_G15_14 I1390_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I111_XG_MP0 (VDD I1390_P15_14 XI1390_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I111_XG_MP1 (XI1390_I111_XG_p1 I1390_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I176_XG_MP2 (XI1390_I176_XG_p1 I1390_G25_18 I1390_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I176_XG_MP0 (VDD I1390_P25_18 XI1390_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I176_XG_MP1 (XI1390_I176_XG_p1 I1390_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I110_XG_MP2 (XI1436_I110_XG_p1 I1436_G14_13 I1436_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I110_XG_MP0 (VDD I1436_P14_13 XI1436_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I110_XG_MP1 (XI1436_I110_XG_p1 I1436_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I112_XG_MP2 (XI1436_I112_XG_p1 I1436_G16_15 I1436_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I112_XG_MP0 (VDD I1436_P16_15 XI1436_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I112_XG_MP1 (XI1436_I112_XG_p1 I1436_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I171_XG_MP2 (XI1436_I171_XG_p1 I1436_G20_13 I1436_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I171_XG_MP0 (VDD I1436_P20_13 XI1436_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I171_XG_MP1 (XI1436_I171_XG_p1 I1436_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I111_XG_MP2 (XI1436_I111_XG_p1 I1436_G15_14 I1436_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I111_XG_MP0 (VDD I1436_P15_14 XI1436_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I111_XG_MP1 (XI1436_I111_XG_p1 I1436_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I170_XG_MP2 (XI1436_I170_XG_p1 I1436_G19_12 I1436_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I170_XG_MP0 (VDD I1436_P19_12 XI1436_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I170_XG_MP1 (XI1436_I170_XG_p1 I1436_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I111_XG_MP2 (XI1482_I111_XG_p1 I1482_G15_14 I1482_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I111_XG_MP0 (VDD I1482_P15_14 XI1482_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I111_XG_MP1 (XI1482_I111_XG_p1 I1482_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I169_XG_MP2 (XI1482_I169_XG_p1 I1482_G18_11 I1482_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I169_XG_MP0 (VDD I1482_P18_11 XI1482_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I169_XG_MP1 (XI1482_I169_XG_p1 I1482_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I115_XG_MP2 (XI1528_I115_XG_p1 I1528_G19_18 I1528_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I115_XG_MP0 (VDD I1528_P19_18 XI1528_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I115_XG_MP1 (XI1528_I115_XG_p1 I1528_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I117_XG_MP2 (XI1528_I117_XG_p1 I1528_G21_20 I1528_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I117_XG_MP0 (VDD I1528_P21_20 XI1528_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I117_XG_MP1 (XI1528_I117_XG_p1 I1528_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I174_XG_MP2 (XI1528_I174_XG_p1 I1528_G23_16 I1528_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I174_XG_MP0 (VDD I1528_P23_16 XI1528_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I174_XG_MP1 (XI1528_I174_XG_p1 I1528_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I120_XG_MP2 (XI1160_I120_XG_p1 I1160_G24_23 I1160_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I120_XG_MP0 (VDD I1160_P24_23 XI1160_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I120_XG_MP1 (XI1160_I120_XG_p1 I1160_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I179_XG_MP2 (XI1160_I179_XG_p1 I1160_G28_21 I1160_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I179_XG_MP0 (VDD I1160_P28_21 XI1160_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I179_XG_MP1 (XI1160_I179_XG_p1 I1160_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I175_XG_MP2 (XI1160_I175_XG_p1 I1160_G24_17 I1160_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
