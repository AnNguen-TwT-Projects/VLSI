    I_MXI1206_I4_MN1 (XI1206_I4_n1 b14_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I4_MN0 (I1206_gn4 p13_3 XI1206_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I100_XP_MN1 (XI1206_I100_XP_n1 I1206_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I100_XP_MN0 (I1206_P4_1n I1206_P4_3 XI1206_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I8_MN1 (XI1252_I8_n1 b15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I8_MN0 (I1252_gn8 p14_7 XI1252_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I7_MN1 (XI1252_I7_n1 b15_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I7_MN0 (I1252_gn7 p14_6 XI1252_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I106_XP_MN1 (XI1252_I106_XP_n1 I1252_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I106_XP_MN0 (I1252_P10_7n I1252_P10_9 XI1252_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I167_XP_MN1 (XI1252_I167_XP_n1 I1252_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I167_XP_MN0 (I1252_P16_1n I1252_P16_9 XI1252_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I105_XP_MN1 (XI1252_I105_XP_n1 I1252_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I105_XP_MN0 (I1252_P9_6n I1252_P9_8 XI1252_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I9_MN1 (XI1298_I9_n1 b16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I9_MN0 (I1298_gn9 p15_8 XI1298_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I106_XP_MN1 (XI1298_I106_XP_n1 I1298_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I106_XP_MN0 (I1298_P10_7n I1298_P10_9 XI1298_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I167_XP_MN1 (XI1298_I167_XP_n1 I1298_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I167_XP_MN0 (I1298_P16_1n I1298_P16_9 XI1298_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I107_XP_MN1 (XI1298_I107_XP_n1 I1298_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I107_XP_MN0 (I1298_P11_8n I1298_P11_10 XI1298_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I108_XP_MN1 (XI1344_I108_XP_n1 I1344_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I108_XP_MN0 (I1344_P12_9n I1344_P12_11 XI1344_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I11_MN1 (XI1344_I11_n1 b17_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I11_MN0 (I1344_gn11 p16_10 XI1344_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I107_XP_MN1 (XI1344_I107_XP_n1 I1344_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I107_XP_MN0 (I1344_P11_8n I1344_P11_10 XI1344_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I12_MN1 (XI1390_I12_n1 b18_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I12_MN0 (I1390_gn12 p17_11 XI1390_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I11_MN1 (XI1390_I11_n1 b18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I11_MN0 (I1390_gn11 p17_10 XI1390_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I108_XP_MN1 (XI1390_I108_XP_n1 I1390_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I108_XP_MN0 (I1390_P12_9n I1390_P12_11 XI1390_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I107_XP_MN1 (XI1390_I107_XP_n1 I1390_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I107_XP_MN0 (I1390_P11_8n I1390_P11_10 XI1390_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I168_XP_MN1 (XI1390_I168_XP_n1 I1390_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I168_XP_MN0 (I1390_P17_2n I1390_P17_10 XI1390_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I11_MN1 (XI1436_I11_n1 b19_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I11_MN0 (I1436_gn11 p18_10 XI1436_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I10_MN1 (XI1436_I10_n1 b19_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I10_MN0 (I1436_gn10 p18_9 XI1436_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I108_XP_MN1 (XI1436_I108_XP_n1 I1436_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I108_XP_MN0 (I1436_P12_9n I1436_P12_11 XI1436_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I107_XP_MN1 (XI1436_I107_XP_n1 I1436_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I107_XP_MN0 (I1436_P11_8n I1436_P11_10 XI1436_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I168_XP_MN1 (XI1436_I168_XP_n1 I1436_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I168_XP_MN0 (I1436_P17_2n I1436_P17_10 XI1436_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I11_MN1 (XI1482_I11_n1 b20_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I11_MN0 (I1482_gn11 p19_10 XI1482_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I106_XP_MN1 (XI1482_I106_XP_n1 I1482_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I106_XP_MN0 (I1482_P10_7n I1482_P10_9 XI1482_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I13_MN1 (XI1528_I13_n1 b21_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I13_MN0 (I1528_gn13 p20_12 XI1528_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I112_XP_MN1 (XI1528_I112_XP_n1 I1528_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I112_XP_MN0 (I1528_P16_13n I1528_P16_15 XI1528_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I177_XP_MN1 (XI1528_I177_XP_n1 I1528_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I177_XP_MN0 (I1528_P26_11n I1528_P26_19 XI1528_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I111_XP_MN1 (XI1528_I111_XP_n1 I1528_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I111_XP_MN0 (I1528_P15_12n I1528_P15_14 XI1528_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I178_XP_MN1 (XI1528_I178_XP_n1 I1528_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I178_XP_MN0 (I1528_P27_12n I1528_P27_20 XI1528_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I172_XP_MN1 (XI1528_I172_XP_n1 I1528_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I172_XP_MN0 (I1528_P21_6n I1528_P21_14 XI1528_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I178_XP_MN1 (XI1160_I178_XP_n1 I1160_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I178_XP_MN0 (I1160_P27_12n I1160_P27_20 XI1160_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I176_XP_MN1 (XI1160_I176_XP_n1 I1160_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I176_XP_MN0 (I1160_P25_10n I1160_P25_18 XI1160_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I170_XP_MN1 (XI1160_I170_XP_n1 I1160_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I170_XP_MN0 (I1160_P19_4n I1160_P19_12 XI1160_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I168_XP_MN1 (XI1160_I168_XP_n1 I1160_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I168_XP_MN0 (I1160_P17_2n I1160_P17_10 XI1160_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I100_XP_MN1 (XI1160_I100_XP_n1 I1160_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I100_XP_MN0 (I1160_P4_1n I1160_P4_3 XI1160_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I9_MN1 (XI1206_I9_n1 b14_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I9_MN0 (I1206_gn9 p13_8 XI1206_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I7_MN1 (XI1206_I7_n1 b14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I7_MN0 (I1206_gn7 p13_6 XI1206_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I5_MN1 (XI1206_I5_n1 b14_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I5_MN0 (I1206_gn5 p13_4 XI1206_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I101_XP_MN1 (XI1206_I101_XP_n1 I1206_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I101_XP_MN0 (I1206_P5_2n I1206_P5_4 XI1206_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I11_MN1 (XI1252_I11_n1 b15_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I11_MN0 (I1252_gn11 p14_10 XI1252_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I9_MN1 (XI1252_I9_n1 b15_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I9_MN0 (I1252_gn9 p14_8 XI1252_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I10_MN1 (XI1252_I10_n1 b15_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I10_MN0 (I1252_gn10 p14_9 XI1252_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I169_XP_MN1 (XI1252_I169_XP_n1 I1252_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I169_XP_MN0 (I1252_P18_3n I1252_P18_11 XI1252_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I107_XP_MN1 (XI1252_I107_XP_n1 I1252_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I107_XP_MN0 (I1252_P11_8n I1252_P11_10 XI1252_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I168_XP_MN1 (XI1252_I168_XP_n1 I1252_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I168_XP_MN0 (I1252_P17_2n I1252_P17_10 XI1252_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I11_MN1 (XI1298_I11_n1 b16_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I11_MN0 (I1298_gn11 p15_10 XI1298_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I10_MN1 (XI1298_I10_n1 b16_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I10_MN0 (I1298_gn10 p15_9 XI1298_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I108_XP_MN1 (XI1298_I108_XP_n1 I1298_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I108_XP_MN0 (I1298_P12_9n I1298_P12_11 XI1298_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I169_XP_MN1 (XI1298_I169_XP_n1 I1298_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I169_XP_MN0 (I1298_P18_3n I1298_P18_11 XI1298_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I168_XP_MN1 (XI1298_I168_XP_n1 I1298_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I168_XP_MN0 (I1298_P17_2n I1298_P17_10 XI1298_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I169_XP_MN1 (XI1344_I169_XP_n1 I1344_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I169_XP_MN0 (I1344_P18_3n I1344_P18_11 XI1344_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I175_XP_MN1 (XI1344_I175_XP_n1 I1344_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I175_XP_MN0 (I1344_P24_9n I1344_P24_17 XI1344_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I13_MN1 (XI1344_I13_n1 b17_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I13_MN0 (I1344_gn13 p16_12 XI1344_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I12_MN1 (XI1344_I12_n1 b17_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I12_MN0 (I1344_gn12 p16_11 XI1344_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I109_XP_MN1 (XI1344_I109_XP_n1 I1344_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I109_XP_MN0 (I1344_P13_10n I1344_P13_12 XI1344_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I170_XP_MN1 (XI1344_I170_XP_n1 I1344_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I170_XP_MN0 (I1344_P19_4n I1344_P19_12 XI1344_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I13_MN1 (XI1390_I13_n1 b18_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I13_MN0 (I1390_gn13 p17_12 XI1390_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I169_XP_MN1 (XI1390_I169_XP_n1 I1390_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I169_XP_MN0 (I1390_P18_3n I1390_P18_11 XI1390_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I175_XP_MN1 (XI1390_I175_XP_n1 I1390_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I175_XP_MN0 (I1390_P24_9n I1390_P24_17 XI1390_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I109_XP_MN1 (XI1390_I109_XP_n1 I1390_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I109_XP_MN0 (I1390_P13_10n I1390_P13_12 XI1390_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I12_MN1 (XI1436_I12_n1 b19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I12_MN0 (I1436_gn12 p18_11 XI1436_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I169_XP_MN1 (XI1436_I169_XP_n1 I1436_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I169_XP_MN0 (I1436_P18_3n I1436_P18_11 XI1436_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I13_MN1 (XI1482_I13_n1 b20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I13_MN0 (I1482_gn13 p19_12 XI1482_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I12_MN1 (XI1482_I12_n1 b20_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I12_MN0 (I1482_gn12 p19_11 XI1482_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I107_XP_MN1 (XI1482_I107_XP_n1 I1482_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I107_XP_MN0 (I1482_P11_8n I1482_P11_10 XI1482_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I168_XP_MN1 (XI1482_I168_XP_n1 I1482_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I168_XP_MN0 (I1482_P17_2n I1482_P17_10 XI1482_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I108_XP_MN1 (XI1482_I108_XP_n1 I1482_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I108_XP_MN0 (I1482_P12_9n I1482_P12_11 XI1482_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I14_MN1 (XI1528_I14_n1 b21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I14_MN0 (I1528_gn14 p20_13 XI1528_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I15_MN1 (XI1528_I15_n1 b21_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I15_MN0 (I1528_gn15 p20_14 XI1528_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I114_XP_MN1 (XI1528_I114_XP_n1 I1528_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I114_XP_MN0 (I1528_P18_15n I1528_P18_17 XI1528_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I116_XP_MN1 (XI1528_I116_XP_n1 I1528_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I116_XP_MN0 (I1528_P20_17n I1528_P20_19 XI1528_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I113_XP_MN1 (XI1528_I113_XP_n1 I1528_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I113_XP_MN0 (I1528_P17_14n I1528_P17_16 XI1528_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I127_XP_MN1 (XI1160_I127_XP_n1 I1160_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I127_XP_MN0 (I1160_P31_28n I1160_P31_30 XI1160_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I125_XP_MN1 (XI1160_I125_XP_n1 I1160_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I125_XP_MN0 (I1160_P29_26n I1160_P29_28 XI1160_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I123_XP_MN1 (XI1160_I123_XP_n1 I1160_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I123_XP_MN0 (I1160_P27_24n I1160_P27_26 XI1160_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I121_XP_MN1 (XI1160_I121_XP_n1 I1160_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I121_XP_MN0 (I1160_P25_22n I1160_P25_24 XI1160_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I180_XP_MN1 (XI1160_I180_XP_n1 I1160_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I180_XP_MN0 (I1160_P29_14n I1160_P29_22 XI1160_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I172_XP_MN1 (XI1160_I172_XP_n1 I1160_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I172_XP_MN0 (I1160_P21_6n I1160_P21_14 XI1160_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I104_XP_MN1 (XI1160_I104_XP_n1 I1160_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I104_XP_MN0 (I1160_P8_5n I1160_P8_7 XI1160_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I102_XP_MN1 (XI1160_I102_XP_n1 I1160_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I102_XP_MN0 (I1160_P6_3n I1160_P6_5 XI1160_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I11_MN1 (XI1206_I11_n1 b14_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I11_MN0 (I1206_gn11 p13_10 XI1206_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I8_MN1 (XI1206_I8_n1 b14_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I8_MN0 (I1206_gn8 p13_7 XI1206_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I6_MN1 (XI1206_I6_n1 b14_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I6_MN0 (I1206_gn6 p13_5 XI1206_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I104_XP_MN1 (XI1206_I104_XP_n1 I1206_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I104_XP_MN0 (I1206_P8_5n I1206_P8_7 XI1206_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I102_XP_MN1 (XI1206_I102_XP_n1 I1206_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I102_XP_MN0 (I1206_P6_3n I1206_P6_5 XI1206_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I12_MN1 (XI1252_I12_n1 b15_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I12_MN0 (I1252_gn12 p14_11 XI1252_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I108_XP_MN1 (XI1252_I108_XP_n1 I1252_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I108_XP_MN0 (I1252_P12_9n I1252_P12_11 XI1252_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I109_XP_MN1 (XI1252_I109_XP_n1 I1252_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I109_XP_MN0 (I1252_P13_10n I1252_P13_12 XI1252_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I13_MN1 (XI1298_I13_n1 b16_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I13_MN0 (I1298_gn13 p15_12 XI1298_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I12_MN1 (XI1298_I12_n1 b16_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I12_MN0 (I1298_gn12 p15_11 XI1298_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I110_XP_MN1 (XI1298_I110_XP_n1 I1298_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I110_XP_MN0 (I1298_P14_11n I1298_P14_13 XI1298_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I175_XP_MN1 (XI1298_I175_XP_n1 I1298_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I175_XP_MN0 (I1298_P24_9n I1298_P24_17 XI1298_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I109_XP_MN1 (XI1298_I109_XP_n1 I1298_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I109_XP_MN0 (I1298_P13_10n I1298_P13_12 XI1298_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I170_XP_MN1 (XI1298_I170_XP_n1 I1298_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I170_XP_MN0 (I1298_P19_4n I1298_P19_12 XI1298_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I171_XP_MN1 (XI1344_I171_XP_n1 I1344_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I171_XP_MN0 (I1344_P20_5n I1344_P20_13 XI1344_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I112_XP_MN1 (XI1344_I112_XP_n1 I1344_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I112_XP_MN0 (I1344_P16_13n I1344_P16_15 XI1344_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I110_XP_MN1 (XI1344_I110_XP_n1 I1344_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I110_XP_MN0 (I1344_P14_11n I1344_P14_13 XI1344_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I14_MN1 (XI1344_I14_n1 b17_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I14_MN0 (I1344_gn14 p16_13 XI1344_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I176_XP_MN1 (XI1344_I176_XP_n1 I1344_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I176_XP_MN0 (I1344_P25_10n I1344_P25_18 XI1344_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I14_MN1 (XI1390_I14_n1 b18_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I14_MN0 (I1390_gn14 p17_13 XI1390_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I112_XP_MN1 (XI1390_I112_XP_n1 I1390_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I112_XP_MN0 (I1390_P16_13n I1390_P16_15 XI1390_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I110_XP_MN1 (XI1390_I110_XP_n1 I1390_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I110_XP_MN0 (I1390_P14_11n I1390_P14_13 XI1390_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I170_XP_MN1 (XI1390_I170_XP_n1 I1390_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I170_XP_MN0 (I1390_P19_4n I1390_P19_12 XI1390_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I14_MN1 (XI1436_I14_n1 b19_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I14_MN0 (I1436_gn14 p18_13 XI1436_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I13_MN1 (XI1436_I13_n1 b19_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I13_MN0 (I1436_gn13 p18_12 XI1436_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I110_XP_MN1 (XI1436_I110_XP_n1 I1436_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I110_XP_MN0 (I1436_P14_11n I1436_P14_13 XI1436_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I175_XP_MN1 (XI1436_I175_XP_n1 I1436_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I175_XP_MN0 (I1436_P24_9n I1436_P24_17 XI1436_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I109_XP_MN1 (XI1436_I109_XP_n1 I1436_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I109_XP_MN0 (I1436_P13_10n I1436_P13_12 XI1436_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I170_XP_MN1 (XI1436_I170_XP_n1 I1436_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I170_XP_MN0 (I1436_P19_4n I1436_P19_12 XI1436_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I14_MN1 (XI1482_I14_n1 b20_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I14_MN0 (I1482_gn14 p19_13 XI1482_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I109_XP_MN1 (XI1482_I109_XP_n1 I1482_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I109_XP_MN0 (I1482_P13_10n I1482_P13_12 XI1482_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I110_XP_MN1 (XI1482_I110_XP_n1 I1482_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I110_XP_MN0 (I1482_P14_11n I1482_P14_13 XI1482_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I16_MN1 (XI1528_I16_n1 b21_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I16_MN0 (I1528_gn16 p20_15 XI1528_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I173_XP_MN1 (XI1528_I173_XP_n1 I1528_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I173_XP_MN0 (I1528_P22_7n I1528_P22_15 XI1528_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I115_XP_MN1 (XI1528_I115_XP_n1 I1528_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I115_XP_MN0 (I1528_P19_16n I1528_P19_18 XI1528_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I180_XP_MN1 (XI1528_I180_XP_n1 I1528_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I180_XP_MN0 (I1528_P29_14n I1528_P29_22 XI1528_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I24_MN1 (XI1160_I24_n1 b13_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I24_MN0 (I1160_gn24 p12_23 XI1160_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I118_XP_MN1 (XI1160_I118_XP_n1 I1160_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I118_XP_MN0 (I1160_P22_19n I1160_P22_21 XI1160_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I116_XP_MN1 (XI1160_I116_XP_n1 I1160_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I116_XP_MN0 (I1160_P20_17n I1160_P20_19 XI1160_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I114_XP_MN1 (XI1160_I114_XP_n1 I1160_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I114_XP_MN0 (I1160_P18_15n I1160_P18_17 XI1160_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I112_XP_MN1 (XI1160_I112_XP_n1 I1160_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I112_XP_MN0 (I1160_P16_13n I1160_P16_15 XI1160_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I110_XP_MN1 (XI1160_I110_XP_n1 I1160_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I110_XP_MN0 (I1160_P14_11n I1160_P14_13 XI1160_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I108_XP_MN1 (XI1160_I108_XP_n1 I1160_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I108_XP_MN0 (I1160_P12_9n I1160_P12_11 XI1160_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I106_XP_MN1 (XI1160_I106_XP_n1 I1160_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I106_XP_MN0 (I1160_P10_7n I1160_P10_9 XI1160_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I167_XP_MN1 (XI1160_I167_XP_n1 I1160_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I167_XP_MN0 (I1160_P16_1n I1160_P16_9 XI1160_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I10_MN1 (XI1206_I10_n1 b14_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I10_MN0 (I1206_gn10 p13_9 XI1206_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I103_XP_MN1 (XI1206_I103_XP_n1 I1206_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I103_XP_MN0 (I1206_P7_4n I1206_P7_6 XI1206_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I106_XP_MN1 (XI1206_I106_XP_n1 I1206_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I106_XP_MN0 (I1206_P10_7n I1206_P10_9 XI1206_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I167_XP_MN1 (XI1206_I167_XP_n1 I1206_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I167_XP_MN0 (I1206_P16_1n I1206_P16_9 XI1206_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I13_MN1 (XI1252_I13_n1 b15_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I13_MN0 (I1252_gn13 p14_12 XI1252_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I110_XP_MN1 (XI1252_I110_XP_n1 I1252_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I110_XP_MN0 (I1252_P14_11n I1252_P14_13 XI1252_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I171_XP_MN1 (XI1252_I171_XP_n1 I1252_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I171_XP_MN0 (I1252_P20_5n I1252_P20_13 XI1252_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I175_XP_MN1 (XI1252_I175_XP_n1 I1252_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I175_XP_MN0 (I1252_P24_9n I1252_P24_17 XI1252_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I170_XP_MN1 (XI1252_I170_XP_n1 I1252_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I170_XP_MN0 (I1252_P19_4n I1252_P19_12 XI1252_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I14_MN1 (XI1298_I14_n1 b16_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I14_MN0 (I1298_gn14 p15_13 XI1298_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I15_MN1 (XI1298_I15_n1 b16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I15_MN0 (I1298_gn15 p15_14 XI1298_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I112_XP_MN1 (XI1298_I112_XP_n1 I1298_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I112_XP_MN0 (I1298_P16_13n I1298_P16_15 XI1298_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I171_XP_MN1 (XI1298_I171_XP_n1 I1298_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I171_XP_MN0 (I1298_P20_5n I1298_P20_13 XI1298_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I111_XP_MN1 (XI1298_I111_XP_n1 I1298_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I111_XP_MN0 (I1298_P15_12n I1298_P15_14 XI1298_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I177_XP_MN1 (XI1344_I177_XP_n1 I1344_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I177_XP_MN0 (I1344_P26_11n I1344_P26_19 XI1344_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I15_MN1 (XI1344_I15_n1 b17_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I15_MN0 (I1344_gn15 p16_14 XI1344_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I113_XP_MN1 (XI1344_I113_XP_n1 I1344_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I113_XP_MN0 (I1344_P17_14n I1344_P17_16 XI1344_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I111_XP_MN1 (XI1344_I111_XP_n1 I1344_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I111_XP_MN0 (I1344_P15_12n I1344_P15_14 XI1344_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I15_MN1 (XI1390_I15_n1 b18_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I15_MN0 (I1390_gn15 p17_14 XI1390_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I114_XP_MN1 (XI1390_I114_XP_n1 I1390_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I114_XP_MN0 (I1390_P18_15n I1390_P18_17 XI1390_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I171_XP_MN1 (XI1390_I171_XP_n1 I1390_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I171_XP_MN0 (I1390_P20_5n I1390_P20_13 XI1390_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I111_XP_MN1 (XI1390_I111_XP_n1 I1390_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I111_XP_MN0 (I1390_P15_12n I1390_P15_14 XI1390_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I176_XP_MN1 (XI1390_I176_XP_n1 I1390_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I176_XP_MN0 (I1390_P25_10n I1390_P25_18 XI1390_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I15_MN1 (XI1436_I15_n1 b19_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I15_MN0 (I1436_gn15 p18_14 XI1436_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I112_XP_MN1 (XI1436_I112_XP_n1 I1436_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I112_XP_MN0 (I1436_P16_13n I1436_P16_15 XI1436_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I171_XP_MN1 (XI1436_I171_XP_n1 I1436_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I171_XP_MN0 (I1436_P20_5n I1436_P20_13 XI1436_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I111_XP_MN1 (XI1436_I111_XP_n1 I1436_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I111_XP_MN0 (I1436_P15_12n I1436_P15_14 XI1436_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I111_XP_MN1 (XI1482_I111_XP_n1 I1482_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I111_XP_MN0 (I1482_P15_12n I1482_P15_14 XI1482_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I112_XP_MN1 (XI1482_I112_XP_n1 I1482_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I112_XP_MN0 (I1482_P16_13n I1482_P16_15 XI1482_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I171_XP_MN1 (XI1482_I171_XP_n1 I1482_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I171_XP_MN0 (I1482_P20_5n I1482_P20_13 XI1482_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I169_XP_MN1 (XI1482_I169_XP_n1 I1482_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I169_XP_MN0 (I1482_P18_3n I1482_P18_11 XI1482_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I17_MN1 (XI1528_I17_n1 b21_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I17_MN0 (I1528_gn17 p20_16 XI1528_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I18_MN1 (XI1528_I18_n1 b21_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I18_MN0 (I1528_gn18 p20_17 XI1528_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I118_XP_MN1 (XI1528_I118_XP_n1 I1528_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I118_XP_MN0 (I1528_P22_19n I1528_P22_21 XI1528_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I174_XP_MN1 (XI1528_I174_XP_n1 I1528_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I174_XP_MN0 (I1528_P23_8n I1528_P23_16 XI1528_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I117_XP_MN1 (XI1528_I117_XP_n1 I1528_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I117_XP_MN0 (I1528_P21_18n I1528_P21_20 XI1528_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I29_MN1 (XI1160_I29_n1 b13_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I29_MN0 (I1160_gn29 p12_28 XI1160_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I25_MN1 (XI1160_I25_n1 b13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I25_MN0 (I1160_gn25 p12_24 XI1160_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I120_XP_MN1 (XI1160_I120_XP_n1 I1160_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I120_XP_MN0 (I1160_P24_21n I1160_P24_23 XI1160_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I179_XP_MN1 (XI1160_I179_XP_n1 I1160_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I179_XP_MN0 (I1160_P28_13n I1160_P28_21 XI1160_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I175_XP_MN1 (XI1160_I175_XP_n1 I1160_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I175_XP_MN0 (I1160_P24_9n I1160_P24_17 XI1160_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I171_XP_MN1 (XI1160_I171_XP_n1 I1160_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I171_XP_MN0 (I1160_P20_5n I1160_P20_13 XI1160_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I13_MN1 (XI1206_I13_n1 b14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I13_MN0 (I1206_gn13 p13_12 XI1206_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I107_XP_MN1 (XI1206_I107_XP_n1 I1206_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I107_XP_MN0 (I1206_P11_8n I1206_P11_10 XI1206_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I105_XP_MN1 (XI1206_I105_XP_n1 I1206_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I105_XP_MN0 (I1206_P9_6n I1206_P9_8 XI1206_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I108_XP_MN1 (XI1206_I108_XP_n1 I1206_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I108_XP_MN0 (I1206_P12_9n I1206_P12_11 XI1206_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I14_MN1 (XI1252_I14_n1 b15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I14_MN0 (I1252_gn14 p14_13 XI1252_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I112_XP_MN1 (XI1252_I112_XP_n1 I1252_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I112_XP_MN0 (I1252_P16_13n I1252_P16_15 XI1252_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I111_XP_MN1 (XI1252_I111_XP_n1 I1252_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I111_XP_MN0 (I1252_P15_12n I1252_P15_14 XI1252_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I176_XP_MN1 (XI1252_I176_XP_n1 I1252_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I176_XP_MN0 (I1252_P25_10n I1252_P25_18 XI1252_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I16_MN1 (XI1298_I16_n1 b16_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I16_MN0 (I1298_gn16 p15_15 XI1298_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I114_XP_MN1 (XI1298_I114_XP_n1 I1298_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I114_XP_MN0 (I1298_P18_15n I1298_P18_17 XI1298_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I177_XP_MN1 (XI1298_I177_XP_n1 I1298_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I177_XP_MN0 (I1298_P26_11n I1298_P26_19 XI1298_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I113_XP_MN1 (XI1298_I113_XP_n1 I1298_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I113_XP_MN0 (I1298_P17_14n I1298_P17_16 XI1298_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I114_XP_MN1 (XI1344_I114_XP_n1 I1344_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I114_XP_MN0 (I1344_P18_15n I1344_P18_17 XI1344_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I16_MN1 (XI1344_I16_n1 b17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I16_MN0 (I1344_gn16 p16_15 XI1344_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I17_MN1 (XI1344_I17_n1 b17_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I17_MN0 (I1344_gn17 p16_16 XI1344_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I115_XP_MN1 (XI1344_I115_XP_n1 I1344_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I115_XP_MN0 (I1344_P19_16n I1344_P19_18 XI1344_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I17_MN1 (XI1390_I17_n1 b18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I17_MN0 (I1390_gn17 p17_16 XI1390_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I16_MN1 (XI1390_I16_n1 b18_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I16_MN0 (I1390_gn16 p17_15 XI1390_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I116_XP_MN1 (XI1390_I116_XP_n1 I1390_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I116_XP_MN0 (I1390_P20_17n I1390_P20_19 XI1390_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I177_XP_MN1 (XI1390_I177_XP_n1 I1390_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I177_XP_MN0 (I1390_P26_11n I1390_P26_19 XI1390_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I113_XP_MN1 (XI1390_I113_XP_n1 I1390_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I113_XP_MN0 (I1390_P17_14n I1390_P17_16 XI1390_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I16_MN1 (XI1436_I16_n1 b19_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I16_MN0 (I1436_gn16 p18_15 XI1436_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I114_XP_MN1 (XI1436_I114_XP_n1 I1436_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I114_XP_MN0 (I1436_P18_15n I1436_P18_17 XI1436_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I177_XP_MN1 (XI1436_I177_XP_n1 I1436_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I177_XP_MN0 (I1436_P26_11n I1436_P26_19 XI1436_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I113_XP_MN1 (XI1436_I113_XP_n1 I1436_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I113_XP_MN0 (I1436_P17_14n I1436_P17_16 XI1436_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I16_MN1 (XI1482_I16_n1 b20_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I16_MN0 (I1482_gn16 p19_15 XI1482_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I15_MN1 (XI1482_I15_n1 b20_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I15_MN0 (I1482_gn15 p19_14 XI1482_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I17_MN1 (XI1482_I17_n1 b20_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I17_MN0 (I1482_gn17 p19_16 XI1482_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I113_XP_MN1 (XI1482_I113_XP_n1 I1482_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I113_XP_MN0 (I1482_P17_14n I1482_P17_16 XI1482_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I114_XP_MN1 (XI1482_I114_XP_n1 I1482_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I114_XP_MN0 (I1482_P18_15n I1482_P18_17 XI1482_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I19_MN1 (XI1528_I19_n1 b21_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I19_MN0 (I1528_gn19 p20_18 XI1528_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I20_MN1 (XI1528_I20_n1 b21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I20_MN0 (I1528_gn20 p20_19 XI1528_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I120_XP_MN1 (XI1528_I120_XP_n1 I1528_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I120_XP_MN0 (I1528_P24_21n I1528_P24_23 XI1528_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I181_XP_MN1 (XI1528_I181_XP_n1 I1528_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I181_XP_MN0 (I1528_P30_15n I1528_P30_23 XI1528_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I119_XP_MN1 (XI1528_I119_XP_n1 I1528_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I119_XP_MN0 (I1528_P23_20n I1528_P23_22 XI1528_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I28_MN1 (XI1160_I28_n1 b13_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I28_MN0 (I1160_gn28 p12_27 XI1160_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I124_XP_MN1 (XI1160_I124_XP_n1 I1160_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I124_XP_MN0 (I1160_P28_25n I1160_P28_27 XI1160_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I122_XP_MN1 (XI1160_I122_XP_n1 I1160_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I122_XP_MN0 (I1160_P26_23n I1160_P26_25 XI1160_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I17_MN1 (XI1206_I17_n1 b14_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I17_MN0 (I1206_gn17 p13_16 XI1206_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I14_MN1 (XI1206_I14_n1 b14_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I14_MN0 (I1206_gn14 p13_13 XI1206_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I12_MN1 (XI1206_I12_n1 b14_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I12_MN0 (I1206_gn12 p13_11 XI1206_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I109_XP_MN1 (XI1206_I109_XP_n1 I1206_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I109_XP_MN0 (I1206_P13_10n I1206_P13_12 XI1206_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I168_XP_MN1 (XI1206_I168_XP_n1 I1206_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I168_XP_MN0 (I1206_P17_2n I1206_P17_10 XI1206_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I110_XP_MN1 (XI1206_I110_XP_n1 I1206_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I110_XP_MN0 (I1206_P14_11n I1206_P14_13 XI1206_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I16_MN1 (XI1252_I16_n1 b15_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I16_MN0 (I1252_gn16 p14_15 XI1252_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I15_MN1 (XI1252_I15_n1 b15_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I15_MN0 (I1252_gn15 p14_14 XI1252_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I116_XP_MN1 (XI1252_I116_XP_n1 I1252_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I116_XP_MN0 (I1252_P20_17n I1252_P20_19 XI1252_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I114_XP_MN1 (XI1252_I114_XP_n1 I1252_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I114_XP_MN0 (I1252_P18_15n I1252_P18_17 XI1252_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I177_XP_MN1 (XI1252_I177_XP_n1 I1252_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I177_XP_MN0 (I1252_P26_11n I1252_P26_19 XI1252_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I113_XP_MN1 (XI1252_I113_XP_n1 I1252_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I113_XP_MN0 (I1252_P17_14n I1252_P17_16 XI1252_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I17_MN1 (XI1298_I17_n1 b16_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I17_MN0 (I1298_gn17 p15_16 XI1298_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I18_MN1 (XI1298_I18_n1 b16_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I18_MN0 (I1298_gn18 p15_17 XI1298_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I116_XP_MN1 (XI1298_I116_XP_n1 I1298_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I116_XP_MN0 (I1298_P20_17n I1298_P20_19 XI1298_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I173_XP_MN1 (XI1298_I173_XP_n1 I1298_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I173_XP_MN0 (I1298_P22_7n I1298_P22_15 XI1298_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I115_XP_MN1 (XI1298_I115_XP_n1 I1298_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I115_XP_MN0 (I1298_P19_16n I1298_P19_18 XI1298_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I172_XP_MN1 (XI1298_I172_XP_n1 I1298_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I172_XP_MN0 (I1298_P21_6n I1298_P21_14 XI1298_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I173_XP_MN1 (XI1344_I173_XP_n1 I1344_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I173_XP_MN0 (I1344_P22_7n I1344_P22_15 XI1344_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I116_XP_MN1 (XI1344_I116_XP_n1 I1344_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I116_XP_MN0 (I1344_P20_17n I1344_P20_19 XI1344_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I18_MN1 (XI1344_I18_n1 b17_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I18_MN0 (I1344_gn18 p16_17 XI1344_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I172_XP_MN1 (XI1344_I172_XP_n1 I1344_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I172_XP_MN0 (I1344_P21_6n I1344_P21_14 XI1344_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I18_MN1 (XI1390_I18_n1 b18_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I18_MN0 (I1390_gn18 p17_17 XI1390_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I19_MN1 (XI1390_I19_n1 b18_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I19_MN0 (I1390_gn19 p17_18 XI1390_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I173_XP_MN1 (XI1390_I173_XP_n1 I1390_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I173_XP_MN0 (I1390_P22_7n I1390_P22_15 XI1390_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I117_XP_MN1 (XI1390_I117_XP_n1 I1390_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I117_XP_MN0 (I1390_P21_18n I1390_P21_20 XI1390_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I115_XP_MN1 (XI1390_I115_XP_n1 I1390_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I115_XP_MN0 (I1390_P19_16n I1390_P19_18 XI1390_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I172_XP_MN1 (XI1390_I172_XP_n1 I1390_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I172_XP_MN0 (I1390_P21_6n I1390_P21_14 XI1390_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I17_MN1 (XI1436_I17_n1 b19_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I17_MN0 (I1436_gn17 p18_16 XI1436_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I18_MN1 (XI1436_I18_n1 b19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I18_MN0 (I1436_gn18 p18_17 XI1436_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I19_MN1 (XI1436_I19_n1 b19_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I19_MN0 (I1436_gn19 p18_18 XI1436_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I116_XP_MN1 (XI1436_I116_XP_n1 I1436_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I116_XP_MN0 (I1436_P20_17n I1436_P20_19 XI1436_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I173_XP_MN1 (XI1436_I173_XP_n1 I1436_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I173_XP_MN0 (I1436_P22_7n I1436_P22_15 XI1436_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I115_XP_MN1 (XI1436_I115_XP_n1 I1436_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I115_XP_MN0 (I1436_P19_16n I1436_P19_18 XI1436_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I172_XP_MN1 (XI1436_I172_XP_n1 I1436_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I172_XP_MN0 (I1436_P21_6n I1436_P21_14 XI1436_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I18_MN1 (XI1482_I18_n1 b20_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I18_MN0 (I1482_gn18 p19_17 XI1482_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I115_XP_MN1 (XI1482_I115_XP_n1 I1482_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I115_XP_MN0 (I1482_P19_16n I1482_P19_18 XI1482_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I170_XP_MN1 (XI1482_I170_XP_n1 I1482_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I170_XP_MN0 (I1482_P19_4n I1482_P19_12 XI1482_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I172_XP_MN1 (XI1482_I172_XP_n1 I1482_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I172_XP_MN0 (I1482_P21_6n I1482_P21_14 XI1482_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I116_XP_MN1 (XI1482_I116_XP_n1 I1482_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I116_XP_MN0 (I1482_P20_17n I1482_P20_19 XI1482_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I175_XP_MN1 (XI1482_I175_XP_n1 I1482_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I175_XP_MN0 (I1482_P24_9n I1482_P24_17 XI1482_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I177_XP_MN1 (XI1482_I177_XP_n1 I1482_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I177_XP_MN0 (I1482_P26_11n I1482_P26_19 XI1482_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I21_MN1 (XI1528_I21_n1 b21_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I21_MN0 (I1528_gn21 p20_20 XI1528_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I122_XP_MN1 (XI1528_I122_XP_n1 I1528_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I122_XP_MN0 (I1528_P26_23n I1528_P26_25 XI1528_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I182_XP_MN1 (XI1528_I182_XP_n1 I1528_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I182_XP_MN0 (I1528_P31_16n I1528_P31_24 XI1528_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I121_XP_MN1 (XI1528_I121_XP_n1 I1528_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I121_XP_MN0 (I1528_P25_22n I1528_P25_24 XI1528_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I126_XP_MN1 (XI1160_I126_XP_n1 I1160_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I126_XP_MN0 (I1160_P30_27n I1160_P30_29 XI1160_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I26_MN1 (XI1160_I26_n1 b13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I26_MN0 (I1160_gn26 p12_25 XI1160_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I181_XP_MN1 (XI1160_I181_XP_n1 I1160_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I181_XP_MN0 (I1160_P30_15n I1160_P30_23 XI1160_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I173_XP_MN1 (XI1160_I173_XP_n1 I1160_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I173_XP_MN0 (I1160_P22_7n I1160_P22_15 XI1160_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I177_XP_MN1 (XI1160_I177_XP_n1 I1160_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I177_XP_MN0 (I1160_P26_11n I1160_P26_19 XI1160_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I169_XP_MN1 (XI1160_I169_XP_n1 I1160_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I169_XP_MN0 (I1160_P18_3n I1160_P18_11 XI1160_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I15_MN1 (XI1206_I15_n1 b14_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I15_MN0 (I1206_gn15 p13_14 XI1206_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I111_XP_MN1 (XI1206_I111_XP_n1 I1206_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I111_XP_MN0 (I1206_P15_12n I1206_P15_14 XI1206_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I112_XP_MN1 (XI1206_I112_XP_n1 I1206_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I112_XP_MN0 (I1206_P16_13n I1206_P16_15 XI1206_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I169_XP_MN1 (XI1206_I169_XP_n1 I1206_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I169_XP_MN0 (I1206_P18_3n I1206_P18_11 XI1206_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I17_MN1 (XI1252_I17_n1 b15_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I17_MN0 (I1252_gn17 p14_16 XI1252_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I19_MN1 (XI1252_I19_n1 b15_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I19_MN0 (I1252_gn19 p14_18 XI1252_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I18_MN1 (XI1252_I18_n1 b15_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I18_MN0 (I1252_gn18 p14_17 XI1252_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I173_XP_MN1 (XI1252_I173_XP_n1 I1252_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I173_XP_MN0 (I1252_P22_7n I1252_P22_15 XI1252_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I117_XP_MN1 (XI1252_I117_XP_n1 I1252_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I117_XP_MN0 (I1252_P21_18n I1252_P21_20 XI1252_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I115_XP_MN1 (XI1252_I115_XP_n1 I1252_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I115_XP_MN0 (I1252_P19_16n I1252_P19_18 XI1252_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I172_XP_MN1 (XI1252_I172_XP_n1 I1252_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I172_XP_MN0 (I1252_P21_6n I1252_P21_14 XI1252_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I19_MN1 (XI1298_I19_n1 b16_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I19_MN0 (I1298_gn19 p15_18 XI1298_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I118_XP_MN1 (XI1298_I118_XP_n1 I1298_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I118_XP_MN0 (I1298_P22_19n I1298_P22_21 XI1298_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I117_XP_MN1 (XI1298_I117_XP_n1 I1298_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I117_XP_MN0 (I1298_P21_18n I1298_P21_20 XI1298_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I176_XP_MN1 (XI1298_I176_XP_n1 I1298_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I176_XP_MN0 (I1298_P25_10n I1298_P25_18 XI1298_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I179_XP_MN1 (XI1344_I179_XP_n1 I1344_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I179_XP_MN0 (I1344_P28_13n I1344_P28_21 XI1344_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I118_XP_MN1 (XI1344_I118_XP_n1 I1344_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I118_XP_MN0 (I1344_P22_19n I1344_P22_21 XI1344_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I19_MN1 (XI1344_I19_n1 b17_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I19_MN0 (I1344_gn19 p16_18 XI1344_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I20_MN1 (XI1344_I20_n1 b17_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I20_MN0 (I1344_gn20 p16_19 XI1344_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I117_XP_MN1 (XI1344_I117_XP_n1 I1344_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I117_XP_MN0 (I1344_P21_18n I1344_P21_20 XI1344_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I178_XP_MN1 (XI1344_I178_XP_n1 I1344_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I178_XP_MN0 (I1344_P27_12n I1344_P27_20 XI1344_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I20_MN1 (XI1390_I20_n1 b18_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I20_MN0 (I1390_gn20 p17_19 XI1390_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I118_XP_MN1 (XI1390_I118_XP_n1 I1390_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I118_XP_MN0 (I1390_P22_19n I1390_P22_21 XI1390_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I179_XP_MN1 (XI1390_I179_XP_n1 I1390_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I179_XP_MN0 (I1390_P28_13n I1390_P28_21 XI1390_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I178_XP_MN1 (XI1390_I178_XP_n1 I1390_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I178_XP_MN0 (I1390_P27_12n I1390_P27_20 XI1390_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I20_MN1 (XI1436_I20_n1 b19_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I20_MN0 (I1436_gn20 p18_19 XI1436_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I118_XP_MN1 (XI1436_I118_XP_n1 I1436_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I118_XP_MN0 (I1436_P22_19n I1436_P22_21 XI1436_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I117_XP_MN1 (XI1436_I117_XP_n1 I1436_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I117_XP_MN0 (I1436_P21_18n I1436_P21_20 XI1436_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I176_XP_MN1 (XI1436_I176_XP_n1 I1436_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I176_XP_MN0 (I1436_P25_10n I1436_P25_18 XI1436_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I20_MN1 (XI1482_I20_n1 b20_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I20_MN0 (I1482_gn20 p19_19 XI1482_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I19_MN1 (XI1482_I19_n1 b20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I19_MN0 (I1482_gn19 p19_18 XI1482_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I117_XP_MN1 (XI1482_I117_XP_n1 I1482_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I117_XP_MN0 (I1482_P21_18n I1482_P21_20 XI1482_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I118_XP_MN1 (XI1482_I118_XP_n1 I1482_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I118_XP_MN0 (I1482_P22_19n I1482_P22_21 XI1482_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I173_XP_MN1 (XI1482_I173_XP_n1 I1482_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I173_XP_MN0 (I1482_P22_7n I1482_P22_15 XI1482_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I22_MN1 (XI1528_I22_n1 b21_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I22_MN0 (I1528_gn22 p20_21 XI1528_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I124_XP_MN1 (XI1528_I124_XP_n1 I1528_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I124_XP_MN0 (I1528_P28_25n I1528_P28_27 XI1528_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I123_XP_MN1 (XI1528_I123_XP_n1 I1528_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I123_XP_MN0 (I1528_P27_24n I1528_P27_26 XI1528_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I27_MN1 (XI1160_I27_n1 b13_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I27_MN0 (I1160_gn27 p12_26 XI1160_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I18_MN1 (XI1206_I18_n1 b14_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I18_MN0 (I1206_gn18 p13_17 XI1206_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I16_MN1 (XI1206_I16_n1 b14_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I16_MN0 (I1206_gn16 p13_15 XI1206_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I113_XP_MN1 (XI1206_I113_XP_n1 I1206_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I113_XP_MN0 (I1206_P17_14n I1206_P17_16 XI1206_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I170_XP_MN1 (XI1206_I170_XP_n1 I1206_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I170_XP_MN0 (I1206_P19_4n I1206_P19_12 XI1206_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I114_XP_MN1 (XI1206_I114_XP_n1 I1206_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I114_XP_MN0 (I1206_P18_15n I1206_P18_17 XI1206_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I171_XP_MN1 (XI1206_I171_XP_n1 I1206_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I171_XP_MN0 (I1206_P20_5n I1206_P20_13 XI1206_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I20_MN1 (XI1252_I20_n1 b15_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I20_MN0 (I1252_gn20 p14_19 XI1252_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I118_XP_MN1 (XI1252_I118_XP_n1 I1252_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I118_XP_MN0 (I1252_P22_19n I1252_P22_21 XI1252_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I179_XP_MN1 (XI1252_I179_XP_n1 I1252_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I179_XP_MN0 (I1252_P28_13n I1252_P28_21 XI1252_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I178_XP_MN1 (XI1252_I178_XP_n1 I1252_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I178_XP_MN0 (I1252_P27_12n I1252_P27_20 XI1252_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I21_MN1 (XI1298_I21_n1 b16_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I21_MN0 (I1298_gn21 p15_20 XI1298_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I20_MN1 (XI1298_I20_n1 b16_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I20_MN0 (I1298_gn20 p15_19 XI1298_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I120_XP_MN1 (XI1298_I120_XP_n1 I1298_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I120_XP_MN0 (I1298_P24_21n I1298_P24_23 XI1298_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I179_XP_MN1 (XI1298_I179_XP_n1 I1298_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I179_XP_MN0 (I1298_P28_13n I1298_P28_21 XI1298_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I181_XP_MN1 (XI1298_I181_XP_n1 I1298_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I181_XP_MN0 (I1298_P30_15n I1298_P30_23 XI1298_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I119_XP_MN1 (XI1298_I119_XP_n1 I1298_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I119_XP_MN0 (I1298_P23_20n I1298_P23_22 XI1298_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I174_XP_MN1 (XI1298_I174_XP_n1 I1298_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I174_XP_MN0 (I1298_P23_8n I1298_P23_16 XI1298_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I181_XP_MN1 (XI1344_I181_XP_n1 I1344_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I181_XP_MN0 (I1344_P30_15n I1344_P30_23 XI1344_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I120_XP_MN1 (XI1344_I120_XP_n1 I1344_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I120_XP_MN0 (I1344_P24_21n I1344_P24_23 XI1344_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I22_MN1 (XI1344_I22_n1 b17_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I22_MN0 (I1344_gn22 p16_21 XI1344_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I21_MN1 (XI1344_I21_n1 b17_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I21_MN0 (I1344_gn21 p16_20 XI1344_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I119_XP_MN1 (XI1344_I119_XP_n1 I1344_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I119_XP_MN0 (I1344_P23_20n I1344_P23_22 XI1344_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I174_XP_MN1 (XI1344_I174_XP_n1 I1344_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I174_XP_MN0 (I1344_P23_8n I1344_P23_16 XI1344_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I21_MN1 (XI1390_I21_n1 b18_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I21_MN0 (I1390_gn21 p17_20 XI1390_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I120_XP_MN1 (XI1390_I120_XP_n1 I1390_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I120_XP_MN0 (I1390_P24_21n I1390_P24_23 XI1390_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I181_XP_MN1 (XI1390_I181_XP_n1 I1390_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I181_XP_MN0 (I1390_P30_15n I1390_P30_23 XI1390_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I119_XP_MN1 (XI1390_I119_XP_n1 I1390_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I119_XP_MN0 (I1390_P23_20n I1390_P23_22 XI1390_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I174_XP_MN1 (XI1390_I174_XP_n1 I1390_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I174_XP_MN0 (I1390_P23_8n I1390_P23_16 XI1390_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I21_MN1 (XI1436_I21_n1 b19_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I21_MN0 (I1436_gn21 p18_20 XI1436_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I120_XP_MN1 (XI1436_I120_XP_n1 I1436_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I120_XP_MN0 (I1436_P24_21n I1436_P24_23 XI1436_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I179_XP_MN1 (XI1436_I179_XP_n1 I1436_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I179_XP_MN0 (I1436_P28_13n I1436_P28_21 XI1436_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I119_XP_MN1 (XI1436_I119_XP_n1 I1436_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I119_XP_MN0 (I1436_P23_20n I1436_P23_22 XI1436_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I174_XP_MN1 (XI1436_I174_XP_n1 I1436_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I174_XP_MN0 (I1436_P23_8n I1436_P23_16 XI1436_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I22_MN1 (XI1482_I22_n1 b20_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I22_MN0 (I1482_gn22 p19_21 XI1482_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I21_MN1 (XI1482_I21_n1 b20_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I21_MN0 (I1482_gn21 p19_20 XI1482_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I176_XP_MN1 (XI1482_I176_XP_n1 I1482_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I176_XP_MN0 (I1482_P25_10n I1482_P25_18 XI1482_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I120_XP_MN1 (XI1482_I120_XP_n1 I1482_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I120_XP_MN0 (I1482_P24_21n I1482_P24_23 XI1482_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I179_XP_MN1 (XI1482_I179_XP_n1 I1482_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I179_XP_MN0 (I1482_P28_13n I1482_P28_21 XI1482_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I181_XP_MN1 (XI1482_I181_XP_n1 I1482_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I181_XP_MN0 (I1482_P30_15n I1482_P30_23 XI1482_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I24_MN1 (XI1528_I24_n1 b21_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I24_MN0 (I1528_gn24 p20_23 XI1528_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I23_MN1 (XI1528_I23_n1 b21_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I23_MN0 (I1528_gn23 p20_22 XI1528_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I126_XP_MN1 (XI1528_I126_XP_n1 I1528_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I126_XP_MN0 (I1528_P30_27n I1528_P30_29 XI1528_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I127_XP_MN1 (XI1528_I127_XP_n1 I1528_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I127_XP_MN0 (I1528_P31_28n I1528_P31_30 XI1528_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I125_XP_MN1 (XI1528_I125_XP_n1 I1528_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I125_XP_MN0 (I1528_P29_26n I1528_P29_28 XI1528_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I22_MN1 (XI1206_I22_n1 b14_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I22_MN0 (I1206_gn22 p13_21 XI1206_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I21_MN1 (XI1206_I21_n1 b14_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I21_MN0 (I1206_gn21 p13_20 XI1206_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I20_MN1 (XI1206_I20_n1 b14_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I20_MN0 (I1206_gn20 p13_19 XI1206_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I19_MN1 (XI1206_I19_n1 b14_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I19_MN0 (I1206_gn19 p13_18 XI1206_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I117_XP_MN1 (XI1206_I117_XP_n1 I1206_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I117_XP_MN0 (I1206_P21_18n I1206_P21_20 XI1206_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I115_XP_MN1 (XI1206_I115_XP_n1 I1206_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I115_XP_MN0 (I1206_P19_16n I1206_P19_18 XI1206_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I172_XP_MN1 (XI1206_I172_XP_n1 I1206_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I172_XP_MN0 (I1206_P21_6n I1206_P21_14 XI1206_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I116_XP_MN1 (XI1206_I116_XP_n1 I1206_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I116_XP_MN0 (I1206_P20_17n I1206_P20_19 XI1206_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I175_XP_MN1 (XI1206_I175_XP_n1 I1206_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I175_XP_MN0 (I1206_P24_9n I1206_P24_17 XI1206_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I22_MN1 (XI1252_I22_n1 b15_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I22_MN0 (I1252_gn22 p14_21 XI1252_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I21_MN1 (XI1252_I21_n1 b15_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I21_MN0 (I1252_gn21 p14_20 XI1252_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I120_XP_MN1 (XI1252_I120_XP_n1 I1252_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I120_XP_MN0 (I1252_P24_21n I1252_P24_23 XI1252_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I119_XP_MN1 (XI1252_I119_XP_n1 I1252_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I119_XP_MN0 (I1252_P23_20n I1252_P23_22 XI1252_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I174_XP_MN1 (XI1252_I174_XP_n1 I1252_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I174_XP_MN0 (I1252_P23_8n I1252_P23_16 XI1252_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I23_MN1 (XI1298_I23_n1 b16_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I23_MN0 (I1298_gn23 p15_22 XI1298_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I22_MN1 (XI1298_I22_n1 b16_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I22_MN0 (I1298_gn22 p15_21 XI1298_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I122_XP_MN1 (XI1298_I122_XP_n1 I1298_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I122_XP_MN0 (I1298_P26_23n I1298_P26_25 XI1298_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I178_XP_MN1 (XI1298_I178_XP_n1 I1298_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I178_XP_MN0 (I1298_P27_12n I1298_P27_20 XI1298_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I122_XP_MN1 (XI1344_I122_XP_n1 I1344_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I122_XP_MN0 (I1344_P26_23n I1344_P26_25 XI1344_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I124_XP_MN1 (XI1344_I124_XP_n1 I1344_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I124_XP_MN0 (I1344_P28_25n I1344_P28_27 XI1344_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I23_MN1 (XI1344_I23_n1 b17_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I23_MN0 (I1344_gn23 p16_22 XI1344_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I121_XP_MN1 (XI1344_I121_XP_n1 I1344_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I121_XP_MN0 (I1344_P25_22n I1344_P25_24 XI1344_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I180_XP_MN1 (XI1344_I180_XP_n1 I1344_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I180_XP_MN0 (I1344_P29_14n I1344_P29_22 XI1344_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I22_MN1 (XI1390_I22_n1 b18_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I22_MN0 (I1390_gn22 p17_21 XI1390_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I23_MN1 (XI1390_I23_n1 b18_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I23_MN0 (I1390_gn23 p17_22 XI1390_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I122_XP_MN1 (XI1390_I122_XP_n1 I1390_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I122_XP_MN0 (I1390_P26_23n I1390_P26_25 XI1390_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I121_XP_MN1 (XI1390_I121_XP_n1 I1390_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I121_XP_MN0 (I1390_P25_22n I1390_P25_24 XI1390_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I180_XP_MN1 (XI1390_I180_XP_n1 I1390_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I180_XP_MN0 (I1390_P29_14n I1390_P29_22 XI1390_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I23_MN1 (XI1436_I23_n1 b19_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I23_MN0 (I1436_gn23 p18_22 XI1436_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I22_MN1 (XI1436_I22_n1 b19_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I22_MN0 (I1436_gn22 p18_21 XI1436_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I122_XP_MN1 (XI1436_I122_XP_n1 I1436_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I122_XP_MN0 (I1436_P26_23n I1436_P26_25 XI1436_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I181_XP_MN1 (XI1436_I181_XP_n1 I1436_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I181_XP_MN0 (I1436_P30_15n I1436_P30_23 XI1436_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I180_XP_MN1 (XI1436_I180_XP_n1 I1436_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I180_XP_MN0 (I1436_P29_14n I1436_P29_22 XI1436_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I23_MN1 (XI1482_I23_n1 b20_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I23_MN0 (I1482_gn23 p19_22 XI1482_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I174_XP_MN1 (XI1482_I174_XP_n1 I1482_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I174_XP_MN0 (I1482_P23_8n I1482_P23_16 XI1482_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I178_XP_MN1 (XI1482_I178_XP_n1 I1482_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I178_XP_MN0 (I1482_P27_12n I1482_P27_20 XI1482_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I180_XP_MN1 (XI1482_I180_XP_n1 I1482_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I180_XP_MN0 (I1482_P29_14n I1482_P29_22 XI1482_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I122_XP_MN1 (XI1482_I122_XP_n1 I1482_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I122_XP_MN0 (I1482_P26_23n I1482_P26_25 XI1482_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I25_MN1 (XI1528_I25_n1 b21_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I25_MN0 (I1528_gn25 p20_24 XI1528_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I26_MN1 (XI1528_I26_n1 b21_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I26_MN0 (I1528_gn26 p20_25 XI1528_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I27_MN1 (XI1528_I27_n1 b21_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I27_MN0 (I1528_gn27 p20_26 XI1528_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I23_MN1 (XI1206_I23_n1 b14_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I23_MN0 (I1206_gn23 p13_22 XI1206_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I24_MN1 (XI1206_I24_n1 b14_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I24_MN0 (I1206_gn24 p13_23 XI1206_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I182_XP_MN1 (XI1206_I182_XP_n1 I1206_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I182_XP_MN0 (I1206_P31_16n I1206_P31_24 XI1206_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I119_XP_MN1 (XI1206_I119_XP_n1 I1206_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I119_XP_MN0 (I1206_P23_20n I1206_P23_22 XI1206_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I176_XP_MN1 (XI1206_I176_XP_n1 I1206_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I176_XP_MN0 (I1206_P25_10n I1206_P25_18 XI1206_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I120_XP_MN1 (XI1206_I120_XP_n1 I1206_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I120_XP_MN0 (I1206_P24_21n I1206_P24_23 XI1206_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I118_XP_MN1 (XI1206_I118_XP_n1 I1206_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I118_XP_MN0 (I1206_P22_19n I1206_P22_21 XI1206_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I173_XP_MN1 (XI1206_I173_XP_n1 I1206_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I173_XP_MN0 (I1206_P22_7n I1206_P22_15 XI1206_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I23_MN1 (XI1252_I23_n1 b15_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I23_MN0 (I1252_gn23 p14_22 XI1252_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I122_XP_MN1 (XI1252_I122_XP_n1 I1252_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I122_XP_MN0 (I1252_P26_23n I1252_P26_25 XI1252_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I124_XP_MN1 (XI1252_I124_XP_n1 I1252_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I124_XP_MN0 (I1252_P28_25n I1252_P28_27 XI1252_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I181_XP_MN1 (XI1252_I181_XP_n1 I1252_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I181_XP_MN0 (I1252_P30_15n I1252_P30_23 XI1252_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I121_XP_MN1 (XI1252_I121_XP_n1 I1252_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I121_XP_MN0 (I1252_P25_22n I1252_P25_24 XI1252_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I180_XP_MN1 (XI1252_I180_XP_n1 I1252_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I180_XP_MN0 (I1252_P29_14n I1252_P29_22 XI1252_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I24_MN1 (XI1298_I24_n1 b16_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I24_MN0 (I1298_gn24 p15_23 XI1298_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I124_XP_MN1 (XI1298_I124_XP_n1 I1298_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I124_XP_MN0 (I1298_P28_25n I1298_P28_27 XI1298_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I121_XP_MN1 (XI1298_I121_XP_n1 I1298_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I121_XP_MN0 (I1298_P25_22n I1298_P25_24 XI1298_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I123_XP_MN1 (XI1298_I123_XP_n1 I1298_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I123_XP_MN0 (I1298_P27_24n I1298_P27_26 XI1298_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I180_XP_MN1 (XI1298_I180_XP_n1 I1298_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I180_XP_MN0 (I1298_P29_14n I1298_P29_22 XI1298_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I126_XP_MN1 (XI1344_I126_XP_n1 I1344_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I126_XP_MN0 (I1344_P30_27n I1344_P30_29 XI1344_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I24_MN1 (XI1344_I24_n1 b17_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I24_MN0 (I1344_gn24 p16_23 XI1344_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I123_XP_MN1 (XI1344_I123_XP_n1 I1344_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I123_XP_MN0 (I1344_P27_24n I1344_P27_26 XI1344_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I182_XP_MN1 (XI1344_I182_XP_n1 I1344_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I182_XP_MN0 (I1344_P31_16n I1344_P31_24 XI1344_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I24_MN1 (XI1390_I24_n1 b18_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I24_MN0 (I1390_gn24 p17_23 XI1390_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I124_XP_MN1 (XI1390_I124_XP_n1 I1390_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I124_XP_MN0 (I1390_P28_25n I1390_P28_27 XI1390_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I123_XP_MN1 (XI1390_I123_XP_n1 I1390_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I123_XP_MN0 (I1390_P27_24n I1390_P27_26 XI1390_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I182_XP_MN1 (XI1390_I182_XP_n1 I1390_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I182_XP_MN0 (I1390_P31_16n I1390_P31_24 XI1390_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I24_MN1 (XI1436_I24_n1 b19_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I24_MN0 (I1436_gn24 p18_23 XI1436_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I124_XP_MN1 (XI1436_I124_XP_n1 I1436_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I124_XP_MN0 (I1436_P28_25n I1436_P28_27 XI1436_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I126_XP_MN1 (XI1436_I126_XP_n1 I1436_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I126_XP_MN0 (I1436_P30_27n I1436_P30_29 XI1436_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I121_XP_MN1 (XI1436_I121_XP_n1 I1436_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I121_XP_MN0 (I1436_P25_22n I1436_P25_24 XI1436_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I178_XP_MN1 (XI1436_I178_XP_n1 I1436_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I178_XP_MN0 (I1436_P27_12n I1436_P27_20 XI1436_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I119_XP_MN1 (XI1482_I119_XP_n1 I1482_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I119_XP_MN0 (I1482_P23_20n I1482_P23_22 XI1482_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I121_XP_MN1 (XI1482_I121_XP_n1 I1482_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I121_XP_MN0 (I1482_P25_22n I1482_P25_24 XI1482_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I24_MN1 (XI1482_I24_n1 b20_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I24_MN0 (I1482_gn24 p19_23 XI1482_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I25_MN1 (XI1482_I25_n1 b20_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I25_MN0 (I1482_gn25 p19_24 XI1482_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I124_XP_MN1 (XI1482_I124_XP_n1 I1482_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I124_XP_MN0 (I1482_P28_25n I1482_P28_27 XI1482_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I126_XP_MN1 (XI1482_I126_XP_n1 I1482_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I126_XP_MN0 (I1482_P30_27n I1482_P30_29 XI1482_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I29_MN1 (XI1528_I29_n1 b21_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I29_MN0 (I1528_gn29 p20_28 XI1528_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I28_MN1 (XI1528_I28_n1 b21_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I28_MN0 (I1528_gn28 p20_27 XI1528_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I30_MN1 (XI1206_I30_n1 b14_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I30_MN0 (I1206_gn30 p13_29 XI1206_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I25_MN1 (XI1206_I25_n1 b14_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I25_MN0 (I1206_gn25 p13_24 XI1206_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I123_XP_MN1 (XI1206_I123_XP_n1 I1206_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I123_XP_MN0 (I1206_P27_24n I1206_P27_26 XI1206_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I121_XP_MN1 (XI1206_I121_XP_n1 I1206_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I121_XP_MN0 (I1206_P25_22n I1206_P25_24 XI1206_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I178_XP_MN1 (XI1206_I178_XP_n1 I1206_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I178_XP_MN0 (I1206_P27_12n I1206_P27_20 XI1206_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I174_XP_MN1 (XI1206_I174_XP_n1 I1206_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I174_XP_MN0 (I1206_P23_8n I1206_P23_16 XI1206_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I122_XP_MN1 (XI1206_I122_XP_n1 I1206_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I122_XP_MN0 (I1206_P26_23n I1206_P26_25 XI1206_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I177_XP_MN1 (XI1206_I177_XP_n1 I1206_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I177_XP_MN0 (I1206_P26_11n I1206_P26_19 XI1206_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I26_MN1 (XI1252_I26_n1 b15_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I26_MN0 (I1252_gn26 p14_25 XI1252_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I25_MN1 (XI1252_I25_n1 b15_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I25_MN0 (I1252_gn25 p14_24 XI1252_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I24_MN1 (XI1252_I24_n1 b15_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I24_MN0 (I1252_gn24 p14_23 XI1252_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I123_XP_MN1 (XI1252_I123_XP_n1 I1252_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I123_XP_MN0 (I1252_P27_24n I1252_P27_26 XI1252_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I125_XP_MN1 (XI1252_I125_XP_n1 I1252_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I125_XP_MN0 (I1252_P29_26n I1252_P29_28 XI1252_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I182_XP_MN1 (XI1252_I182_XP_n1 I1252_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I182_XP_MN0 (I1252_P31_16n I1252_P31_24 XI1252_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I25_MN1 (XI1298_I25_n1 b16_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I25_MN0 (I1298_gn25 p15_24 XI1298_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I26_MN1 (XI1298_I26_n1 b16_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I26_MN0 (I1298_gn26 p15_25 XI1298_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I126_XP_MN1 (XI1298_I126_XP_n1 I1298_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I126_XP_MN0 (I1298_P30_27n I1298_P30_29 XI1298_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I125_XP_MN1 (XI1298_I125_XP_n1 I1298_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I125_XP_MN0 (I1298_P29_26n I1298_P29_28 XI1298_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I182_XP_MN1 (XI1298_I182_XP_n1 I1298_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I182_XP_MN0 (I1298_P31_16n I1298_P31_24 XI1298_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I26_MN1 (XI1344_I26_n1 b17_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I26_MN0 (I1344_gn26 p16_25 XI1344_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I25_MN1 (XI1344_I25_n1 b17_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I25_MN0 (I1344_gn25 p16_24 XI1344_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I125_XP_MN1 (XI1344_I125_XP_n1 I1344_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I125_XP_MN0 (I1344_P29_26n I1344_P29_28 XI1344_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I127_XP_MN1 (XI1344_I127_XP_n1 I1344_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I127_XP_MN0 (I1344_P31_28n I1344_P31_30 XI1344_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I25_MN1 (XI1390_I25_n1 b18_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I25_MN0 (I1390_gn25 p17_24 XI1390_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I26_MN1 (XI1390_I26_n1 b18_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I26_MN0 (I1390_gn26 p17_25 XI1390_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I126_XP_MN1 (XI1390_I126_XP_n1 I1390_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I126_XP_MN0 (I1390_P30_27n I1390_P30_29 XI1390_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I125_XP_MN1 (XI1390_I125_XP_n1 I1390_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I125_XP_MN0 (I1390_P29_26n I1390_P29_28 XI1390_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I127_XP_MN1 (XI1390_I127_XP_n1 I1390_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I127_XP_MN0 (I1390_P31_28n I1390_P31_30 XI1390_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I25_MN1 (XI1436_I25_n1 b19_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I25_MN0 (I1436_gn25 p18_24 XI1436_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I27_MN1 (XI1436_I27_n1 b19_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I27_MN0 (I1436_gn27 p18_26 XI1436_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I26_MN1 (XI1436_I26_n1 b19_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I26_MN0 (I1436_gn26 p18_25 XI1436_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I123_XP_MN1 (XI1436_I123_XP_n1 I1436_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I123_XP_MN0 (I1436_P27_24n I1436_P27_26 XI1436_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I125_XP_MN1 (XI1436_I125_XP_n1 I1436_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I125_XP_MN0 (I1436_P29_26n I1436_P29_28 XI1436_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I182_XP_MN1 (XI1436_I182_XP_n1 I1436_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I182_XP_MN0 (I1436_P31_16n I1436_P31_24 XI1436_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I182_XP_MN1 (XI1482_I182_XP_n1 I1482_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I182_XP_MN0 (I1482_P31_16n I1482_P31_24 XI1482_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I123_XP_MN1 (XI1482_I123_XP_n1 I1482_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I123_XP_MN0 (I1482_P27_24n I1482_P27_26 XI1482_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I125_XP_MN1 (XI1482_I125_XP_n1 I1482_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I125_XP_MN0 (I1482_P29_26n I1482_P29_28 XI1482_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I26_MN1 (XI1482_I26_n1 b20_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I26_MN0 (I1482_gn26 p19_25 XI1482_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I31_MN1 (XI1528_I31_n1 b21_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I31_MN0 (I1528_gn31 p20_30 XI1528_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I30_MN1 (XI1528_I30_n1 b21_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I30_MN0 (I1528_gn30 p20_29 XI1528_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I31_MN1 (XI1206_I31_n1 b14_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I31_MN0 (I1206_gn31 p13_30 XI1206_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I27_MN1 (XI1206_I27_n1 b14_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I27_MN0 (I1206_gn27 p13_26 XI1206_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I29_MN1 (XI1206_I29_n1 b14_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I29_MN0 (I1206_gn29 p13_28 XI1206_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I26_MN1 (XI1206_I26_n1 b14_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I26_MN0 (I1206_gn26 p13_25 XI1206_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I127_XP_MN1 (XI1206_I127_XP_n1 I1206_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I127_XP_MN0 (I1206_P31_28n I1206_P31_30 XI1206_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I125_XP_MN1 (XI1206_I125_XP_n1 I1206_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I125_XP_MN0 (I1206_P29_26n I1206_P29_28 XI1206_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I180_XP_MN1 (XI1206_I180_XP_n1 I1206_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I180_XP_MN0 (I1206_P29_14n I1206_P29_22 XI1206_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I124_XP_MN1 (XI1206_I124_XP_n1 I1206_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I124_XP_MN0 (I1206_P28_25n I1206_P28_27 XI1206_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I181_XP_MN1 (XI1206_I181_XP_n1 I1206_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I181_XP_MN0 (I1206_P30_15n I1206_P30_23 XI1206_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I179_XP_MN1 (XI1206_I179_XP_n1 I1206_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I179_XP_MN0 (I1206_P28_13n I1206_P28_21 XI1206_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I27_MN1 (XI1252_I27_n1 b15_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I27_MN0 (I1252_gn27 p14_26 XI1252_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I126_XP_MN1 (XI1252_I126_XP_n1 I1252_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I126_XP_MN0 (I1252_P30_27n I1252_P30_29 XI1252_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I127_XP_MN1 (XI1252_I127_XP_n1 I1252_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I127_XP_MN0 (I1252_P31_28n I1252_P31_30 XI1252_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I27_MN1 (XI1298_I27_n1 b16_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I27_MN0 (I1298_gn27 p15_26 XI1298_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I29_MN1 (XI1298_I29_n1 b16_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I29_MN0 (I1298_gn29 p15_28 XI1298_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I28_MN1 (XI1298_I28_n1 b16_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I28_MN0 (I1298_gn28 p15_27 XI1298_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I127_XP_MN1 (XI1298_I127_XP_n1 I1298_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I127_XP_MN0 (I1298_P31_28n I1298_P31_30 XI1298_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I27_MN1 (XI1344_I27_n1 b17_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I27_MN0 (I1344_gn27 p16_26 XI1344_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I28_MN1 (XI1344_I28_n1 b17_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I28_MN0 (I1344_gn28 p16_27 XI1344_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I29_MN1 (XI1344_I29_n1 b17_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I29_MN0 (I1344_gn29 p16_28 XI1344_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I27_MN1 (XI1390_I27_n1 b18_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I27_MN0 (I1390_gn27 p17_26 XI1390_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I28_MN1 (XI1390_I28_n1 b18_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I28_MN0 (I1390_gn28 p17_27 XI1390_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I29_MN1 (XI1390_I29_n1 b18_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I29_MN0 (I1390_gn29 p17_28 XI1390_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I28_MN1 (XI1436_I28_n1 b19_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I28_MN0 (I1436_gn28 p18_27 XI1436_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I29_MN1 (XI1436_I29_n1 b19_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I29_MN0 (I1436_gn29 p18_28 XI1436_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I127_XP_MN1 (XI1436_I127_XP_n1 I1436_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I127_XP_MN0 (I1436_P31_28n I1436_P31_30 XI1436_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I31_MN1 (XI1482_I31_n1 b20_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I31_MN0 (I1482_gn31 p19_30 XI1482_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I127_XP_MN1 (XI1482_I127_XP_n1 I1482_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I127_XP_MN0 (I1482_P31_28n I1482_P31_30 XI1482_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I27_MN1 (XI1482_I27_n1 b20_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I27_MN0 (I1482_gn27 p19_26 XI1482_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I28_MN1 (XI1206_I28_n1 b14_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I28_MN0 (I1206_gn28 p13_27 XI1206_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I126_XP_MN1 (XI1206_I126_XP_n1 I1206_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I126_XP_MN0 (I1206_P30_27n I1206_P30_29 XI1206_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I29_MN1 (XI1252_I29_n1 b15_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I29_MN0 (I1252_gn29 p14_28 XI1252_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I28_MN1 (XI1252_I28_n1 b15_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I28_MN0 (I1252_gn28 p14_27 XI1252_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I30_MN1 (XI1252_I30_n1 b15_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I30_MN0 (I1252_gn30 p14_29 XI1252_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I31_MN1 (XI1252_I31_n1 b15_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I31_MN0 (I1252_gn31 p14_30 XI1252_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I31_MN1 (XI1298_I31_n1 b16_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I31_MN0 (I1298_gn31 p15_30 XI1298_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I30_MN1 (XI1298_I30_n1 b16_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I30_MN0 (I1298_gn30 p15_29 XI1298_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I30_MN1 (XI1344_I30_n1 b17_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I30_MN0 (I1344_gn30 p16_29 XI1344_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I31_MN1 (XI1344_I31_n1 b17_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I31_MN0 (I1344_gn31 p16_30 XI1344_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I30_MN1 (XI1390_I30_n1 b18_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I30_MN0 (I1390_gn30 p17_29 XI1390_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I31_MN1 (XI1390_I31_n1 b18_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I31_MN0 (I1390_gn31 p17_30 XI1390_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I30_MN1 (XI1436_I30_n1 b19_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I30_MN0 (I1436_gn30 p18_29 XI1436_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I31_MN1 (XI1436_I31_n1 b19_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I31_MN0 (I1436_gn31 p18_30 XI1436_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I30_MN1 (XI1482_I30_n1 b20_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I30_MN0 (I1482_gn30 p19_29 XI1482_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I29_MN1 (XI1482_I29_n1 b20_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I29_MN0 (I1482_gn29 p19_28 XI1482_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I28_MN1 (XI1482_I28_n1 b20_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I28_MN0 (I1482_gn28 p19_27 XI1482_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I97_XP_MN0 (I654_P31_30 I654_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I97_XP_MN1 (VSS I654_pn30 I654_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I97_XP_MN0 (I1942_P31_30 I1942_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I97_XP_MN1 (VSS I1942_pn30 I1942_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I95_XP_MN0 (I654_P29_28 I654_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I95_XP_MN1 (VSS I654_pn28 I654_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I96_XP_MN0 (I654_P30_29 I654_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I96_XP_MN1 (VSS I654_pn29 I654_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I97_XP_MN0 (I608_P31_30 I608_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I97_XP_MN1 (VSS I608_pn30 I608_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I96_XP_MN0 (I608_P30_29 I608_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I96_XP_MN1 (VSS I608_pn29 I608_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I97_XP_MN0 (I562_P31_30 I562_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I97_XP_MN1 (VSS I562_pn30 I562_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I97_XP_MN0 (I2066_P31_30 I2066_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I97_XP_MN1 (VSS I2066_pn30 I2066_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I96_XP_MN0 (I1988_P30_29 I1988_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I96_XP_MN1 (VSS I1988_pn29 I1988_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I97_XP_MN0 (I1988_P31_30 I1988_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I97_XP_MN1 (VSS I1988_pn30 I1988_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I95_XP_MN0 (I1988_P29_28 I1988_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I95_XP_MN1 (VSS I1988_pn28 I1988_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I96_XP_MN0 (I1942_P30_29 I1942_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I96_XP_MN1 (VSS I1942_pn29 I1942_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I94_XP_MN0 (I1942_P28_27 I1942_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I94_XP_MN1 (VSS I1942_pn27 I1942_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I95_XP_MN0 (I1942_P29_28 I1942_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I95_XP_MN1 (VSS I1942_pn28 I1942_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I155_XP_MN0 (I1896_P30_23 I1896_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I155_XP_MN1 (VSS I1896_P26_23n I1896_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I96_XP_MN0 (I1896_P30_29 I1896_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I96_XP_MN1 (VSS I1896_pn29 I1896_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I94_XP_MN0 (I1896_P28_27 I1896_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I94_XP_MN1 (VSS I1896_pn27 I1896_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I156_XP_MN0 (I654_P31_24 I654_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I156_XP_MN1 (VSS I654_P27_24n I654_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I93_XP_MN0 (I654_P27_26 I654_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I93_XP_MN1 (VSS I654_pn26 I654_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I94_XP_MN0 (I654_P28_27 I654_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I94_XP_MN1 (VSS I654_pn27 I654_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I156_XP_MN0 (I608_P31_24 I608_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I156_XP_MN1 (VSS I608_P27_24n I608_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I95_XP_MN0 (I608_P29_28 I608_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I95_XP_MN1 (VSS I608_pn28 I608_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I93_XP_MN0 (I608_P27_26 I608_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I93_XP_MN1 (VSS I608_pn26 I608_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I94_XP_MN0 (I608_P28_27 I608_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I94_XP_MN1 (VSS I608_pn27 I608_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I92_XP_MN0 (I608_P26_25 I608_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I92_XP_MN1 (VSS I608_pn25 I608_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I96_XP_MN0 (I562_P30_29 I562_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I96_XP_MN1 (VSS I562_pn29 I562_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I94_XP_MN0 (I562_P28_27 I562_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I94_XP_MN1 (VSS I562_pn27 I562_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I95_XP_MN0 (I562_P29_28 I562_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I95_XP_MN1 (VSS I562_pn28 I562_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I93_XP_MN0 (I2066_P27_26 I2066_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I93_XP_MN1 (VSS I2066_pn26 I2066_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I95_XP_MN0 (I2066_P29_28 I2066_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I95_XP_MN1 (VSS I2066_pn28 I2066_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I94_XP_MN0 (I2066_P28_27 I2066_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I94_XP_MN1 (VSS I2066_pn27 I2066_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I96_XP_MN0 (I2066_P30_29 I2066_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I96_XP_MN1 (VSS I2066_pn29 I2066_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I94_XP_MN0 (I1988_P28_27 I1988_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I94_XP_MN1 (VSS I1988_pn27 I1988_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I93_XP_MN0 (I1988_P27_26 I1988_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I93_XP_MN1 (VSS I1988_pn26 I1988_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I155_XP_MN0 (I1942_P30_23 I1942_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I155_XP_MN1 (VSS I1942_P26_23n I1942_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I92_XP_MN0 (I1942_P26_25 I1942_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I92_XP_MN1 (VSS I1942_pn25 I1942_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I156_XP_MN0 (I1942_P31_24 I1942_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I156_XP_MN1 (VSS I1942_P27_24n I1942_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I93_XP_MN0 (I1942_P27_26 I1942_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I93_XP_MN1 (VSS I1942_pn26 I1942_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I151_XP_MN0 (I1896_P26_19 I1896_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I151_XP_MN1 (VSS I1896_P22_19n I1896_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I153_XP_MN0 (I1896_P28_21 I1896_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I153_XP_MN1 (VSS I1896_P24_21n I1896_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I92_XP_MN0 (I1896_P26_25 I1896_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I92_XP_MN1 (VSS I1896_pn25 I1896_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I93_XP_MN0 (I1896_P27_26 I1896_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I93_XP_MN1 (VSS I1896_pn26 I1896_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I95_XP_MN0 (I1896_P29_28 I1896_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I95_XP_MN1 (VSS I1896_pn28 I1896_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I152_XP_MN0 (I654_P27_20 I654_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I152_XP_MN1 (VSS I654_P23_20n I654_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I91_XP_MN0 (I654_P25_24 I654_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I91_XP_MN1 (VSS I654_pn24 I654_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I155_XP_MN0 (I654_P30_23 I654_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I155_XP_MN1 (VSS I654_P26_23n I654_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I92_XP_MN0 (I654_P26_25 I654_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I92_XP_MN1 (VSS I654_pn25 I654_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I152_XP_MN0 (I608_P27_20 I608_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I152_XP_MN1 (VSS I608_P23_20n I608_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I91_XP_MN0 (I608_P25_24 I608_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I91_XP_MN1 (VSS I608_pn24 I608_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I155_XP_MN0 (I608_P30_23 I608_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I155_XP_MN1 (VSS I608_P26_23n I608_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I90_XP_MN0 (I608_P24_23 I608_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I90_XP_MN1 (VSS I608_pn23 I608_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I92_XP_MN0 (I562_P26_25 I562_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I92_XP_MN1 (VSS I562_pn25 I562_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I93_XP_MN0 (I562_P27_26 I562_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I93_XP_MN1 (VSS I562_pn26 I562_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I156_XP_MN0 (I2066_P31_24 I2066_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I156_XP_MN1 (VSS I2066_P27_24n I2066_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I91_XP_MN0 (I2066_P25_24 I2066_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I91_XP_MN1 (VSS I2066_pn24 I2066_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I92_XP_MN0 (I2066_P26_25 I2066_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I92_XP_MN1 (VSS I2066_pn25 I2066_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I92_XP_MN0 (I1988_P26_25 I1988_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I92_XP_MN1 (VSS I1988_pn25 I1988_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I156_XP_MN0 (I1988_P31_24 I1988_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I156_XP_MN1 (VSS I1988_P27_24n I1988_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I91_XP_MN0 (I1988_P25_24 I1988_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I91_XP_MN1 (VSS I1988_pn24 I1988_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I153_XP_MN0 (I1942_P28_21 I1942_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I153_XP_MN1 (VSS I1942_P24_21n I1942_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I90_XP_MN0 (I1942_P24_23 I1942_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I90_XP_MN1 (VSS I1942_pn23 I1942_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I154_XP_MN0 (I1942_P29_22 I1942_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I154_XP_MN1 (VSS I1942_P25_22n I1942_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I89_XP_MN0 (I1942_P23_22 I1942_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I89_XP_MN1 (VSS I1942_pn22 I1942_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I91_XP_MN0 (I1942_P25_24 I1942_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I91_XP_MN1 (VSS I1942_pn24 I1942_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I147_XP_MN0 (I1896_P22_15 I1896_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I147_XP_MN1 (VSS I1896_P18_15n I1896_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I149_XP_MN0 (I1896_P24_17 I1896_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I149_XP_MN1 (VSS I1896_P20_17n I1896_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I90_XP_MN0 (I1896_P24_23 I1896_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I90_XP_MN1 (VSS I1896_pn23 I1896_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I154_XP_MN0 (I1896_P29_22 I1896_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I154_XP_MN1 (VSS I1896_P25_22n I1896_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I91_XP_MN0 (I1896_P25_24 I1896_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I91_XP_MN1 (VSS I1896_pn24 I1896_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I97_XP_MN0 (I1896_P31_30 I1896_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I97_XP_MN1 (VSS I1896_pn30 I1896_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I148_XP_MN0 (I654_P23_16 I654_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I148_XP_MN1 (VSS I654_P19_16n I654_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I154_XP_MN0 (I654_P29_22 I654_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I154_XP_MN1 (VSS I654_P25_22n I654_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I89_XP_MN0 (I654_P23_22 I654_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I89_XP_MN1 (VSS I654_pn22 I654_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I153_XP_MN0 (I654_P28_21 I654_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I153_XP_MN1 (VSS I654_P24_21n I654_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I90_XP_MN0 (I654_P24_23 I654_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I90_XP_MN1 (VSS I654_pn23 I654_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I148_XP_MN0 (I608_P23_16 I608_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I148_XP_MN1 (VSS I608_P19_16n I608_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I154_XP_MN0 (I608_P29_22 I608_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I154_XP_MN1 (VSS I608_P25_22n I608_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I89_XP_MN0 (I608_P23_22 I608_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I89_XP_MN1 (VSS I608_pn22 I608_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I153_XP_MN0 (I608_P28_21 I608_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I153_XP_MN1 (VSS I608_P24_21n I608_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I89_XP_MN0 (I562_P23_22 I562_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I89_XP_MN1 (VSS I562_pn22 I562_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I90_XP_MN0 (I562_P24_23 I562_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I90_XP_MN1 (VSS I562_pn23 I562_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I155_XP_MN0 (I562_P30_23 I562_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I155_XP_MN1 (VSS I562_P26_23n I562_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I91_XP_MN0 (I562_P25_24 I562_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I91_XP_MN1 (VSS I562_pn24 I562_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I154_XP_MN0 (I562_P29_22 I562_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I154_XP_MN1 (VSS I562_P25_22n I562_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I156_XP_MN0 (I562_P31_24 I562_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I156_XP_MN1 (VSS I562_P27_24n I562_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I154_XP_MN0 (I2066_P29_22 I2066_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I154_XP_MN1 (VSS I2066_P25_22n I2066_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I90_XP_MN0 (I2066_P24_23 I2066_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I90_XP_MN1 (VSS I2066_pn23 I2066_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I155_XP_MN0 (I2066_P30_23 I2066_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I155_XP_MN1 (VSS I2066_P26_23n I2066_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I155_XP_MN0 (I1988_P30_23 I1988_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I155_XP_MN1 (VSS I1988_P26_23n I1988_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I90_XP_MN0 (I1988_P24_23 I1988_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I90_XP_MN1 (VSS I1988_pn23 I1988_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I154_XP_MN0 (I1988_P29_22 I1988_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I154_XP_MN1 (VSS I1988_P25_22n I1988_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I89_XP_MN0 (I1988_P23_22 I1988_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I89_XP_MN1 (VSS I1988_pn22 I1988_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I151_XP_MN0 (I1942_P26_19 I1942_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I151_XP_MN1 (VSS I1942_P22_19n I1942_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I152_XP_MN0 (I1942_P27_20 I1942_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I152_XP_MN1 (VSS I1942_P23_20n I1942_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I145_XP_MN0 (I1896_P20_13 I1896_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I145_XP_MN1 (VSS I1896_P16_13n I1896_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I88_XP_MN0 (I1896_P22_21 I1896_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I88_XP_MN1 (VSS I1896_pn21 I1896_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I150_XP_MN0 (I1896_P25_18 I1896_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I150_XP_MN1 (VSS I1896_P21_18n I1896_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I89_XP_MN0 (I1896_P23_22 I1896_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I89_XP_MN1 (VSS I1896_pn22 I1896_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I150_XP_MN0 (I654_P25_18 I654_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I150_XP_MN1 (VSS I654_P21_18n I654_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I87_XP_MN0 (I654_P21_20 I654_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I87_XP_MN1 (VSS I654_pn20 I654_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I147_XP_MN0 (I654_P22_15 I654_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I147_XP_MN1 (VSS I654_P18_15n I654_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I151_XP_MN0 (I654_P26_19 I654_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I151_XP_MN1 (VSS I654_P22_19n I654_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I88_XP_MN0 (I654_P22_21 I654_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I88_XP_MN1 (VSS I654_pn21 I654_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I87_XP_MN0 (I608_P21_20 I608_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I87_XP_MN1 (VSS I608_pn20 I608_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I151_XP_MN0 (I608_P26_19 I608_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I151_XP_MN1 (VSS I608_P22_19n I608_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I88_XP_MN0 (I608_P22_21 I608_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I88_XP_MN1 (VSS I608_pn21 I608_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I88_XP_MN0 (I562_P22_21 I562_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I88_XP_MN1 (VSS I562_pn21 I562_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I87_XP_MN0 (I562_P21_20 I562_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I87_XP_MN1 (VSS I562_pn20 I562_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I148_XP_MN0 (I2066_P23_16 I2066_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I148_XP_MN1 (VSS I2066_P19_16n I2066_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I152_XP_MN0 (I2066_P27_20 I2066_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I152_XP_MN1 (VSS I2066_P23_20n I2066_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I87_XP_MN0 (I2066_P21_20 I2066_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I87_XP_MN1 (VSS I2066_pn20 I2066_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I89_XP_MN0 (I2066_P23_22 I2066_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I89_XP_MN1 (VSS I2066_pn22 I2066_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I88_XP_MN0 (I2066_P22_21 I2066_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I88_XP_MN1 (VSS I2066_pn21 I2066_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I153_XP_MN0 (I1988_P28_21 I1988_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I153_XP_MN1 (VSS I1988_P24_21n I1988_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I88_XP_MN0 (I1988_P22_21 I1988_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I88_XP_MN1 (VSS I1988_pn21 I1988_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I87_XP_MN0 (I1988_P21_20 I1988_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I87_XP_MN1 (VSS I1988_pn20 I1988_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I147_XP_MN0 (I1942_P22_15 I1942_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I147_XP_MN1 (VSS I1942_P18_15n I1942_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I86_XP_MN0 (I1942_P20_19 I1942_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I86_XP_MN1 (VSS I1942_pn19 I1942_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I88_XP_MN0 (I1942_P22_21 I1942_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I88_XP_MN1 (VSS I1942_pn21 I1942_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I148_XP_MN0 (I1942_P23_16 I1942_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I148_XP_MN1 (VSS I1942_P19_16n I1942_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I150_XP_MN0 (I1942_P25_18 I1942_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I150_XP_MN1 (VSS I1942_P21_18n I1942_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I87_XP_MN0 (I1942_P21_20 I1942_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I87_XP_MN1 (VSS I1942_pn20 I1942_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I143_XP_MN0 (I1896_P18_11 I1896_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I143_XP_MN1 (VSS I1896_P14_11n I1896_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I85_XP_MN0 (I1896_P19_18 I1896_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I85_XP_MN1 (VSS I1896_pn18 I1896_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I146_XP_MN0 (I1896_P21_14 I1896_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I146_XP_MN1 (VSS I1896_P17_14n I1896_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I86_XP_MN0 (I1896_P20_19 I1896_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I86_XP_MN1 (VSS I1896_pn19 I1896_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I87_XP_MN0 (I1896_P21_20 I1896_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I87_XP_MN1 (VSS I1896_pn20 I1896_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I97_XP_MN0 (I700_P31_30 I700_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I97_XP_MN1 (VSS I700_pn30 I700_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I144_XP_MN0 (I654_P19_12 I654_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I144_XP_MN1 (VSS I654_P15_12n I654_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I146_XP_MN0 (I654_P21_14 I654_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I146_XP_MN1 (VSS I654_P17_14n I654_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I85_XP_MN0 (I654_P19_18 I654_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I85_XP_MN1 (VSS I654_pn18 I654_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I149_XP_MN0 (I654_P24_17 I654_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I149_XP_MN1 (VSS I654_P20_17n I654_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I86_XP_MN0 (I654_P20_19 I654_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I86_XP_MN1 (VSS I654_pn19 I654_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I146_XP_MN0 (I608_P21_14 I608_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I146_XP_MN1 (VSS I608_P17_14n I608_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I150_XP_MN0 (I608_P25_18 I608_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I150_XP_MN1 (VSS I608_P21_18n I608_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I85_XP_MN0 (I608_P19_18 I608_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I85_XP_MN1 (VSS I608_pn18 I608_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I147_XP_MN0 (I608_P22_15 I608_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I147_XP_MN1 (VSS I608_P18_15n I608_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I86_XP_MN0 (I608_P20_19 I608_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I86_XP_MN1 (VSS I608_pn19 I608_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I86_XP_MN0 (I562_P20_19 I562_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I86_XP_MN1 (VSS I562_pn19 I562_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I153_XP_MN0 (I562_P28_21 I562_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I153_XP_MN1 (VSS I562_P24_21n I562_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I151_XP_MN0 (I562_P26_19 I562_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I151_XP_MN1 (VSS I562_P22_19n I562_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I147_XP_MN0 (I562_P22_15 I562_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I147_XP_MN1 (VSS I562_P18_15n I562_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I146_XP_MN0 (I562_P21_14 I562_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I146_XP_MN1 (VSS I562_P17_14n I562_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I150_XP_MN0 (I562_P25_18 I562_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I150_XP_MN1 (VSS I562_P21_18n I562_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I152_XP_MN0 (I562_P27_20 I562_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I152_XP_MN1 (VSS I562_P23_20n I562_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I148_XP_MN0 (I562_P23_16 I562_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I148_XP_MN1 (VSS I562_P19_16n I562_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I146_XP_MN0 (I2066_P21_14 I2066_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I146_XP_MN1 (VSS I2066_P17_14n I2066_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I150_XP_MN0 (I2066_P25_18 I2066_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I150_XP_MN1 (VSS I2066_P21_18n I2066_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I85_XP_MN0 (I2066_P19_18 I2066_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I85_XP_MN1 (VSS I2066_pn18 I2066_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I147_XP_MN0 (I2066_P22_15 I2066_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I147_XP_MN1 (VSS I2066_P18_15n I2066_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I151_XP_MN0 (I2066_P26_19 I2066_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I151_XP_MN1 (VSS I2066_P22_19n I2066_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I153_XP_MN0 (I2066_P28_21 I2066_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I153_XP_MN1 (VSS I2066_P24_21n I2066_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I86_XP_MN0 (I2066_P20_19 I2066_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I86_XP_MN1 (VSS I2066_pn19 I2066_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I147_XP_MN0 (I1988_P22_15 I1988_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I147_XP_MN1 (VSS I1988_P18_15n I1988_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I151_XP_MN0 (I1988_P26_19 I1988_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I151_XP_MN1 (VSS I1988_P22_19n I1988_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I86_XP_MN0 (I1988_P20_19 I1988_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I86_XP_MN1 (VSS I1988_pn19 I1988_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I148_XP_MN0 (I1988_P23_16 I1988_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I148_XP_MN1 (VSS I1988_P19_16n I1988_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I152_XP_MN0 (I1988_P27_20 I1988_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I152_XP_MN1 (VSS I1988_P23_20n I1988_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I149_XP_MN0 (I1942_P24_17 I1942_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I149_XP_MN1 (VSS I1942_P20_17n I1942_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I144_XP_MN0 (I1942_P19_12 I1942_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I144_XP_MN1 (VSS I1942_P15_12n I1942_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I146_XP_MN0 (I1942_P21_14 I1942_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I146_XP_MN1 (VSS I1942_P17_14n I1942_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I85_XP_MN0 (I1942_P19_18 I1942_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I85_XP_MN1 (VSS I1942_pn18 I1942_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I135_XP_MN0 (I1896_P10_3 I1896_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I135_XP_MN1 (VSS I1896_P6_3n I1896_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I137_XP_MN0 (I1896_P12_5 I1896_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I137_XP_MN1 (VSS I1896_P8_5n I1896_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I141_XP_MN0 (I1896_P16_9 I1896_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I141_XP_MN1 (VSS I1896_P12_9n I1896_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I139_XP_MN0 (I1896_P14_7 I1896_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I139_XP_MN1 (VSS I1896_P10_7n I1896_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I84_XP_MN0 (I1896_P18_17 I1896_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I84_XP_MN1 (VSS I1896_pn17 I1896_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I152_XP_MN0 (I1896_P27_20 I1896_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I152_XP_MN1 (VSS I1896_P23_20n I1896_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I156_XP_MN0 (I1896_P31_24 I1896_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I156_XP_MN1 (VSS I1896_P27_24n I1896_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I95_XP_MN0 (I700_P29_28 I700_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I95_XP_MN1 (VSS I700_pn28 I700_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I156_XP_MN0 (I700_P31_24 I700_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I156_XP_MN1 (VSS I700_P27_24n I700_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I93_XP_MN0 (I700_P27_26 I700_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I93_XP_MN1 (VSS I700_pn26 I700_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I91_XP_MN0 (I700_P25_24 I700_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I91_XP_MN1 (VSS I700_pn24 I700_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I140_XP_MN0 (I654_P15_8 I654_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I140_XP_MN1 (VSS I654_P11_8n I654_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I136_XP_MN0 (I654_P11_4 I654_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I136_XP_MN1 (VSS I654_P7_4n I654_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I83_XP_MN0 (I654_P17_16 I654_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I83_XP_MN1 (VSS I654_pn16 I654_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I145_XP_MN0 (I654_P20_13 I654_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I145_XP_MN1 (VSS I654_P16_13n I654_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I84_XP_MN0 (I654_P18_17 I654_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I84_XP_MN1 (VSS I654_pn17 I654_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I140_XP_MN0 (I608_P15_8 I608_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I140_XP_MN1 (VSS I608_P11_8n I608_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I144_XP_MN0 (I608_P19_12 I608_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I144_XP_MN1 (VSS I608_P15_12n I608_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I83_XP_MN0 (I608_P17_16 I608_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I83_XP_MN1 (VSS I608_pn16 I608_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I149_XP_MN0 (I608_P24_17 I608_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I149_XP_MN1 (VSS I608_P20_17n I608_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I145_XP_MN0 (I608_P20_13 I608_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I145_XP_MN1 (VSS I608_P16_13n I608_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I84_XP_MN0 (I608_P18_17 I608_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I84_XP_MN1 (VSS I608_pn17 I608_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I85_XP_MN0 (I562_P19_18 I562_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I85_XP_MN1 (VSS I562_pn18 I562_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I144_XP_MN0 (I562_P19_12 I562_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I144_XP_MN1 (VSS I562_P15_12n I562_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I140_XP_MN0 (I2066_P15_8 I2066_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I140_XP_MN1 (VSS I2066_P11_8n I2066_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I144_XP_MN0 (I2066_P19_12 I2066_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I144_XP_MN1 (VSS I2066_P15_12n I2066_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I83_XP_MN0 (I2066_P17_16 I2066_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I83_XP_MN1 (VSS I2066_pn16 I2066_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I84_XP_MN0 (I2066_P18_17 I2066_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I84_XP_MN1 (VSS I2066_pn17 I2066_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I149_XP_MN0 (I1988_P24_17 I1988_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I149_XP_MN1 (VSS I1988_P20_17n I1988_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I84_XP_MN0 (I1988_P18_17 I1988_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I84_XP_MN1 (VSS I1988_pn17 I1988_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I150_XP_MN0 (I1988_P25_18 I1988_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I150_XP_MN1 (VSS I1988_P21_18n I1988_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I85_XP_MN0 (I1988_P19_18 I1988_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I85_XP_MN1 (VSS I1988_pn18 I1988_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I83_XP_MN0 (I1988_P17_16 I1988_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I83_XP_MN1 (VSS I1988_pn16 I1988_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I143_XP_MN0 (I1942_P18_11 I1942_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I143_XP_MN1 (VSS I1942_P14_11n I1942_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I145_XP_MN0 (I1942_P20_13 I1942_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I145_XP_MN1 (VSS I1942_P16_13n I1942_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I84_XP_MN0 (I1942_P18_17 I1942_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I84_XP_MN1 (VSS I1942_pn17 I1942_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I82_XP_MN0 (I1942_P16_15 I1942_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I82_XP_MN1 (VSS I1942_pn15 I1942_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I140_XP_MN0 (I1942_P15_8 I1942_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I140_XP_MN1 (VSS I1942_P11_8n I1942_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I142_XP_MN0 (I1942_P17_10 I1942_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I142_XP_MN1 (VSS I1942_P13_10n I1942_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I83_XP_MN0 (I1942_P17_16 I1942_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I83_XP_MN1 (VSS I1942_pn16 I1942_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I80_XP_MN0 (I1896_P14_13 I1896_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I80_XP_MN1 (VSS I1896_pn13 I1896_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I138_XP_MN0 (I1896_P13_6 I1896_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I138_XP_MN1 (VSS I1896_P9_6n I1896_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I142_XP_MN0 (I1896_P17_10 I1896_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I142_XP_MN1 (VSS I1896_P13_10n I1896_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I81_XP_MN0 (I1896_P15_14 I1896_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I81_XP_MN1 (VSS I1896_pn14 I1896_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I82_XP_MN0 (I1896_P16_15 I1896_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I82_XP_MN1 (VSS I1896_pn15 I1896_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I83_XP_MN0 (I1896_P17_16 I1896_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I83_XP_MN1 (VSS I1896_pn16 I1896_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I148_XP_MN0 (I1896_P23_16 I1896_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I148_XP_MN1 (VSS I1896_P19_16n I1896_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I144_XP_MN0 (I1896_P19_12 I1896_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I144_XP_MN1 (VSS I1896_P15_12n I1896_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I154_XP_MN0 (I700_P29_22 I700_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I154_XP_MN1 (VSS I700_P25_22n I700_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I89_XP_MN0 (I700_P23_22 I700_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I89_XP_MN1 (VSS I700_pn22 I700_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I87_XP_MN0 (I700_P21_20 I700_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I87_XP_MN1 (VSS I700_pn20 I700_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I142_XP_MN0 (I654_P17_10 I654_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I142_XP_MN1 (VSS I654_P13_10n I654_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I138_XP_MN0 (I654_P13_6 I654_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I138_XP_MN1 (VSS I654_P9_6n I654_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I81_XP_MN0 (I654_P15_14 I654_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I81_XP_MN1 (VSS I654_pn14 I654_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I139_XP_MN0 (I654_P14_7 I654_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I139_XP_MN1 (VSS I654_P10_7n I654_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I143_XP_MN0 (I654_P18_11 I654_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I143_XP_MN1 (VSS I654_P14_11n I654_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I82_XP_MN0 (I654_P16_15 I654_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I82_XP_MN1 (VSS I654_pn15 I654_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I81_XP_MN0 (I608_P15_14 I608_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I81_XP_MN1 (VSS I608_pn14 I608_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I139_XP_MN0 (I608_P14_7 I608_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I139_XP_MN1 (VSS I608_P10_7n I608_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I143_XP_MN0 (I608_P18_11 I608_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I143_XP_MN1 (VSS I608_P14_11n I608_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I82_XP_MN0 (I608_P16_15 I608_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I82_XP_MN1 (VSS I608_pn15 I608_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I84_XP_MN0 (I562_P18_17 I562_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I84_XP_MN1 (VSS I562_pn17 I562_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I83_XP_MN0 (I562_P17_16 I562_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I83_XP_MN1 (VSS I562_pn16 I562_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I81_XP_MN0 (I562_P15_14 I562_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I81_XP_MN1 (VSS I562_pn14 I562_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I140_XP_MN0 (I562_P15_8 I562_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I140_XP_MN1 (VSS I562_P11_8n I562_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I136_XP_MN0 (I2066_P11_4 I2066_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I136_XP_MN1 (VSS I2066_P7_4n I2066_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I142_XP_MN0 (I2066_P17_10 I2066_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I142_XP_MN1 (VSS I2066_P13_10n I2066_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I81_XP_MN0 (I2066_P15_14 I2066_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I81_XP_MN1 (VSS I2066_pn14 I2066_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I143_XP_MN0 (I2066_P18_11 I2066_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I143_XP_MN1 (VSS I2066_P14_11n I2066_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I145_XP_MN0 (I2066_P20_13 I2066_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I145_XP_MN1 (VSS I2066_P16_13n I2066_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I149_XP_MN0 (I2066_P24_17 I2066_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I149_XP_MN1 (VSS I2066_P20_17n I2066_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I82_XP_MN0 (I2066_P16_15 I2066_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I82_XP_MN1 (VSS I2066_pn15 I2066_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I82_XP_MN0 (I1988_P16_15 I1988_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I82_XP_MN1 (VSS I1988_pn15 I1988_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I140_XP_MN0 (I1988_P15_8 I1988_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I140_XP_MN1 (VSS I1988_P11_8n I1988_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I144_XP_MN0 (I1988_P19_12 I1988_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I144_XP_MN1 (VSS I1988_P15_12n I1988_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I146_XP_MN0 (I1988_P21_14 I1988_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I146_XP_MN1 (VSS I1988_P17_14n I1988_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I139_XP_MN0 (I1942_P14_7 I1942_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I139_XP_MN1 (VSS I1942_P10_7n I1942_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I141_XP_MN0 (I1942_P16_9 I1942_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I141_XP_MN1 (VSS I1942_P12_9n I1942_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I80_XP_MN0 (I1942_P14_13 I1942_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I80_XP_MN1 (VSS I1942_pn13 I1942_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I138_XP_MN0 (I1942_P13_6 I1942_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I138_XP_MN1 (VSS I1942_P9_6n I1942_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I81_XP_MN0 (I1942_P15_14 I1942_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I81_XP_MN1 (VSS I1942_pn14 I1942_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I134_XP_MN0 (I1896_P9_2 I1896_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I134_XP_MN1 (VSS I1896_P5_2n I1896_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I78_XP_MN0 (I1896_P12_11 I1896_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I78_XP_MN1 (VSS I1896_pn11 I1896_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I79_XP_MN0 (I1896_P13_12 I1896_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I79_XP_MN1 (VSS I1896_pn12 I1896_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I140_XP_MN0 (I1896_P15_8 I1896_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I140_XP_MN1 (VSS I1896_P11_8n I1896_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I152_XP_MN0 (I700_P27_20 I700_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I152_XP_MN1 (VSS I700_P23_20n I700_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I148_XP_MN0 (I700_P23_16 I700_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I148_XP_MN1 (VSS I700_P19_16n I700_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I85_XP_MN0 (I700_P19_18 I700_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I85_XP_MN1 (VSS I700_pn18 I700_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I83_XP_MN0 (I700_P17_16 I700_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I83_XP_MN1 (VSS I700_pn16 I700_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I79_XP_MN0 (I654_P13_12 I654_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I79_XP_MN1 (VSS I654_pn12 I654_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I137_XP_MN0 (I654_P12_5 I654_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I137_XP_MN1 (VSS I654_P8_5n I654_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I141_XP_MN0 (I654_P16_9 I654_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I141_XP_MN1 (VSS I654_P12_9n I654_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I80_XP_MN0 (I654_P14_13 I654_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I80_XP_MN1 (VSS I654_pn13 I654_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I142_XP_MN0 (I608_P17_10 I608_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I142_XP_MN1 (VSS I608_P13_10n I608_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I138_XP_MN0 (I608_P13_6 I608_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I138_XP_MN1 (VSS I608_P9_6n I608_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I79_XP_MN0 (I608_P13_12 I608_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I79_XP_MN1 (VSS I608_pn12 I608_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I80_XP_MN0 (I608_P14_13 I608_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I80_XP_MN1 (VSS I608_pn13 I608_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I149_XP_MN0 (I562_P24_17 I562_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I149_XP_MN1 (VSS I562_P20_17n I562_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I82_XP_MN0 (I562_P16_15 I562_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I82_XP_MN1 (VSS I562_pn15 I562_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I138_XP_MN0 (I562_P13_6 I562_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I138_XP_MN1 (VSS I562_P9_6n I562_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I142_XP_MN0 (I562_P17_10 I562_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I142_XP_MN1 (VSS I562_P13_10n I562_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I79_XP_MN0 (I562_P13_12 I562_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I79_XP_MN1 (VSS I562_pn12 I562_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I138_XP_MN0 (I2066_P13_6 I2066_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I138_XP_MN1 (VSS I2066_P9_6n I2066_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I79_XP_MN0 (I2066_P13_12 I2066_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I79_XP_MN1 (VSS I2066_pn12 I2066_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I139_XP_MN0 (I2066_P14_7 I2066_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I139_XP_MN1 (VSS I2066_P10_7n I2066_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I80_XP_MN0 (I2066_P14_13 I2066_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I80_XP_MN1 (VSS I2066_pn13 I2066_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I139_XP_MN0 (I1988_P14_7 I1988_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I139_XP_MN1 (VSS I1988_P10_7n I1988_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I143_XP_MN0 (I1988_P18_11 I1988_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I143_XP_MN1 (VSS I1988_P14_11n I1988_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I145_XP_MN0 (I1988_P20_13 I1988_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I145_XP_MN1 (VSS I1988_P16_13n I1988_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I142_XP_MN0 (I1988_P17_10 I1988_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I142_XP_MN1 (VSS I1988_P13_10n I1988_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I81_XP_MN0 (I1988_P15_14 I1988_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I81_XP_MN1 (VSS I1988_pn14 I1988_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I137_XP_MN0 (I1942_P12_5 I1942_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I137_XP_MN1 (VSS I1942_P8_5n I1942_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I78_XP_MN0 (I1942_P12_11 I1942_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I78_XP_MN1 (VSS I1942_pn11 I1942_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I79_XP_MN0 (I1942_P13_12 I1942_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I79_XP_MN1 (VSS I1942_pn12 I1942_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I133_XP_MN0 (I1896_P8_1 I1896_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I133_XP_MN1 (VSS I1896_P4_1n I1896_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I76_XP_MN0 (I1896_P10_9 I1896_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I76_XP_MN1 (VSS I1896_pn9 I1896_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I77_XP_MN0 (I1896_P11_10 I1896_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I77_XP_MN1 (VSS I1896_pn10 I1896_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I136_XP_MN0 (I1896_P11_4 I1896_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I136_XP_MN1 (VSS I1896_P7_4n I1896_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I150_XP_MN0 (I700_P25_18 I700_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I150_XP_MN1 (VSS I700_P21_18n I700_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I146_XP_MN0 (I700_P21_14 I700_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I146_XP_MN1 (VSS I700_P17_14n I700_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I144_XP_MN0 (I700_P19_12 I700_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I144_XP_MN1 (VSS I700_P15_12n I700_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I140_XP_MN0 (I700_P15_8 I700_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I140_XP_MN1 (VSS I700_P11_8n I700_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I81_XP_MN0 (I700_P15_14 I700_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I81_XP_MN1 (VSS I700_pn14 I700_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I134_XP_MN0 (I654_P9_2 I654_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I134_XP_MN1 (VSS I654_P5_2n I654_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I77_XP_MN0 (I654_P11_10 I654_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I77_XP_MN1 (VSS I654_pn10 I654_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I135_XP_MN0 (I654_P10_3 I654_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I135_XP_MN1 (VSS I654_P6_3n I654_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I78_XP_MN0 (I654_P12_11 I654_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I78_XP_MN1 (VSS I654_pn11 I654_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I136_XP_MN0 (I608_P11_4 I608_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I136_XP_MN1 (VSS I608_P7_4n I608_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I77_XP_MN0 (I608_P11_10 I608_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I77_XP_MN1 (VSS I608_pn10 I608_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I135_XP_MN0 (I608_P10_3 I608_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I135_XP_MN1 (VSS I608_P6_3n I608_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I141_XP_MN0 (I608_P16_9 I608_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I141_XP_MN1 (VSS I608_P12_9n I608_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I137_XP_MN0 (I608_P12_5 I608_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I137_XP_MN1 (VSS I608_P8_5n I608_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I78_XP_MN0 (I608_P12_11 I608_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I78_XP_MN1 (VSS I608_pn11 I608_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I145_XP_MN0 (I562_P20_13 I562_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I145_XP_MN1 (VSS I562_P16_13n I562_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I143_XP_MN0 (I562_P18_11 I562_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I143_XP_MN1 (VSS I562_P14_11n I562_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I139_XP_MN0 (I562_P14_7 I562_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I139_XP_MN1 (VSS I562_P10_7n I562_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I80_XP_MN0 (I562_P14_13 I562_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I80_XP_MN1 (VSS I562_pn13 I562_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I78_XP_MN0 (I562_P12_11 I562_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I78_XP_MN1 (VSS I562_pn11 I562_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I77_XP_MN0 (I2066_P11_10 I2066_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I77_XP_MN1 (VSS I2066_pn10 I2066_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I135_XP_MN0 (I2066_P10_3 I2066_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I135_XP_MN1 (VSS I2066_P6_3n I2066_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I137_XP_MN0 (I2066_P12_5 I2066_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I137_XP_MN1 (VSS I2066_P8_5n I2066_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I141_XP_MN0 (I2066_P16_9 I2066_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I141_XP_MN1 (VSS I2066_P12_9n I2066_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I78_XP_MN0 (I2066_P12_11 I2066_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I78_XP_MN1 (VSS I2066_pn11 I2066_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I141_XP_MN0 (I1988_P16_9 I1988_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I141_XP_MN1 (VSS I1988_P12_9n I1988_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I80_XP_MN0 (I1988_P14_13 I1988_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I80_XP_MN1 (VSS I1988_pn13 I1988_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I138_XP_MN0 (I1988_P13_6 I1988_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I138_XP_MN1 (VSS I1988_P9_6n I1988_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I79_XP_MN0 (I1988_P13_12 I1988_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I79_XP_MN1 (VSS I1988_pn12 I1988_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I135_XP_MN0 (I1942_P10_3 I1942_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I135_XP_MN1 (VSS I1942_P6_3n I1942_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I76_XP_MN0 (I1942_P10_9 I1942_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I76_XP_MN1 (VSS I1942_pn9 I1942_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I136_XP_MN0 (I1942_P11_4 I1942_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I136_XP_MN1 (VSS I1942_P7_4n I1942_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I77_XP_MN0 (I1942_P11_10 I1942_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I77_XP_MN1 (VSS I1942_pn10 I1942_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I74_XP_MN0 (I1896_P8_7 I1896_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I74_XP_MN1 (VSS I1896_pn7 I1896_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I75_XP_MN0 (I1896_P9_8 I1896_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I75_XP_MN1 (VSS I1896_pn8 I1896_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I96_XP_MN0 (I700_P30_29 I700_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I96_XP_MN1 (VSS I700_pn29 I700_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I94_XP_MN0 (I700_P28_27 I700_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I94_XP_MN1 (VSS I700_pn27 I700_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I142_XP_MN0 (I700_P17_10 I700_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I142_XP_MN1 (VSS I700_P13_10n I700_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I82_XP_MN0 (I700_P16_15 I700_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I82_XP_MN1 (VSS I700_pn15 I700_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I79_XP_MN0 (I700_P13_12 I700_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I79_XP_MN1 (VSS I700_pn12 I700_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I75_XP_MN0 (I654_P9_8 I654_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I75_XP_MN1 (VSS I654_pn8 I654_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I76_XP_MN0 (I654_P10_9 I654_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I76_XP_MN1 (VSS I654_pn9 I654_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I134_XP_MN0 (I608_P9_2 I608_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I134_XP_MN1 (VSS I608_P5_2n I608_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I75_XP_MN0 (I608_P9_8 I608_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I75_XP_MN1 (VSS I608_pn8 I608_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I76_XP_MN0 (I608_P10_9 I608_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I76_XP_MN1 (VSS I608_pn9 I608_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I137_XP_MN0 (I562_P12_5 I562_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I137_XP_MN1 (VSS I562_P8_5n I562_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I141_XP_MN0 (I562_P16_9 I562_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I141_XP_MN1 (VSS I562_P12_9n I562_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I134_XP_MN0 (I562_P9_2 I562_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I134_XP_MN1 (VSS I562_P5_2n I562_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I77_XP_MN0 (I562_P11_10 I562_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I77_XP_MN1 (VSS I562_pn10 I562_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I136_XP_MN0 (I562_P11_4 I562_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I136_XP_MN1 (VSS I562_P7_4n I562_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I134_XP_MN0 (I2066_P9_2 I2066_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I134_XP_MN1 (VSS I2066_P5_2n I2066_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I75_XP_MN0 (I2066_P9_8 I2066_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I75_XP_MN1 (VSS I2066_pn8 I2066_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I73_XP_MN0 (I2066_P7_6 I2066_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I73_XP_MN1 (VSS I2066_pn6 I2066_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I76_XP_MN0 (I2066_P10_9 I2066_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I76_XP_MN1 (VSS I2066_pn9 I2066_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I137_XP_MN0 (I1988_P12_5 I1988_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I137_XP_MN1 (VSS I1988_P8_5n I1988_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I78_XP_MN0 (I1988_P12_11 I1988_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I78_XP_MN1 (VSS I1988_pn11 I1988_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I136_XP_MN0 (I1988_P11_4 I1988_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I136_XP_MN1 (VSS I1988_P7_4n I1988_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I77_XP_MN0 (I1988_P11_10 I1988_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I77_XP_MN1 (VSS I1988_pn10 I1988_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I134_XP_MN0 (I1942_P9_2 I1942_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I134_XP_MN1 (VSS I1942_P5_2n I1942_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I75_XP_MN0 (I1942_P9_8 I1942_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I75_XP_MN1 (VSS I1942_pn8 I1942_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I71_XP_MN0 (I1896_P5_4 I1896_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I71_XP_MN1 (VSS I1896_pn4 I1896_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I72_XP_MN0 (I1896_P6_5 I1896_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I72_XP_MN1 (VSS I1896_pn5 I1896_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I73_XP_MN0 (I1896_P7_6 I1896_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I73_XP_MN1 (VSS I1896_pn6 I1896_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I136_XP_MN0 (I1850_P11_4 I1850_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I136_XP_MN1 (VSS I1850_P7_4n I1850_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I140_XP_MN0 (I1850_P15_8 I1850_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I140_XP_MN1 (VSS I1850_P11_8n I1850_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I144_XP_MN0 (I1850_P19_12 I1850_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I144_XP_MN1 (VSS I1850_P15_12n I1850_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I148_XP_MN0 (I1850_P23_16 I1850_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I148_XP_MN1 (VSS I1850_P19_16n I1850_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I152_XP_MN0 (I1850_P27_20 I1850_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I152_XP_MN1 (VSS I1850_P23_20n I1850_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I156_XP_MN0 (I1850_P31_24 I1850_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I156_XP_MN1 (VSS I1850_P27_24n I1850_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I92_XP_MN0 (I700_P26_25 I700_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I92_XP_MN1 (VSS I700_pn25 I700_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I90_XP_MN0 (I700_P24_23 I700_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I90_XP_MN1 (VSS I700_pn23 I700_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I138_XP_MN0 (I700_P13_6 I700_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I138_XP_MN1 (VSS I700_P9_6n I700_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I80_XP_MN0 (I700_P14_13 I700_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I80_XP_MN1 (VSS I700_pn13 I700_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I77_XP_MN0 (I700_P11_10 I700_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I77_XP_MN1 (VSS I700_pn10 I700_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I73_XP_MN0 (I654_P7_6 I654_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I73_XP_MN1 (VSS I654_pn6 I654_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I71_XP_MN0 (I654_P5_4 I654_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I71_XP_MN1 (VSS I654_pn4 I654_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I133_XP_MN0 (I654_P8_1 I654_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I133_XP_MN1 (VSS I654_P4_1n I654_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I72_XP_MN0 (I654_P6_5 I654_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I72_XP_MN1 (VSS I654_pn5 I654_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I74_XP_MN0 (I654_P8_7 I654_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I74_XP_MN1 (VSS I654_pn7 I654_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I73_XP_MN0 (I608_P7_6 I608_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I73_XP_MN1 (VSS I608_pn6 I608_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I133_XP_MN0 (I608_P8_1 I608_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I133_XP_MN1 (VSS I608_P4_1n I608_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I74_XP_MN0 (I608_P8_7 I608_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I74_XP_MN1 (VSS I608_pn7 I608_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I133_XP_MN0 (I562_P8_1 I562_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I133_XP_MN1 (VSS I562_P4_1n I562_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I135_XP_MN0 (I562_P10_3 I562_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I135_XP_MN1 (VSS I562_P6_3n I562_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I74_XP_MN0 (I562_P8_7 I562_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I74_XP_MN1 (VSS I562_pn7 I562_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I76_XP_MN0 (I562_P10_9 I562_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I76_XP_MN1 (VSS I562_pn9 I562_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I75_XP_MN0 (I562_P9_8 I562_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I75_XP_MN1 (VSS I562_pn8 I562_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I71_XP_MN0 (I2066_P5_4 I2066_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I71_XP_MN1 (VSS I2066_pn4 I2066_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I133_XP_MN0 (I2066_P8_1 I2066_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I133_XP_MN1 (VSS I2066_P4_1n I2066_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I74_XP_MN0 (I2066_P8_7 I2066_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I74_XP_MN1 (VSS I2066_pn7 I2066_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I135_XP_MN0 (I1988_P10_3 I1988_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I135_XP_MN1 (VSS I1988_P6_3n I1988_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I76_XP_MN0 (I1988_P10_9 I1988_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I76_XP_MN1 (VSS I1988_pn9 I1988_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I134_XP_MN0 (I1988_P9_2 I1988_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I134_XP_MN1 (VSS I1988_P5_2n I1988_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I75_XP_MN0 (I1988_P9_8 I1988_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I75_XP_MN1 (VSS I1988_pn8 I1988_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I133_XP_MN0 (I1942_P8_1 I1942_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I133_XP_MN1 (VSS I1942_P4_1n I1942_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I74_XP_MN0 (I1942_P8_7 I1942_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I74_XP_MN1 (VSS I1942_pn7 I1942_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I73_XP_MN0 (I1942_P7_6 I1942_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I73_XP_MN1 (VSS I1942_pn6 I1942_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I69_XP_MN0 (I1896_P3_2 I1896_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I69_XP_MN1 (VSS I1896_pn2 I1896_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I70_XP_MN0 (I1896_P4_3 I1896_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I70_XP_MN1 (VSS I1896_pn3 I1896_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I134_XP_MN0 (I1850_P9_2 I1850_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I134_XP_MN1 (VSS I1850_P5_2n I1850_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I138_XP_MN0 (I1850_P13_6 I1850_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I138_XP_MN1 (VSS I1850_P9_6n I1850_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I142_XP_MN0 (I1850_P17_10 I1850_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I142_XP_MN1 (VSS I1850_P13_10n I1850_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I146_XP_MN0 (I1850_P21_14 I1850_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I146_XP_MN1 (VSS I1850_P17_14n I1850_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I150_XP_MN0 (I1850_P25_18 I1850_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I150_XP_MN1 (VSS I1850_P21_18n I1850_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I154_XP_MN0 (I1850_P29_22 I1850_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I154_XP_MN1 (VSS I1850_P25_22n I1850_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I88_XP_MN0 (I700_P22_21 I700_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I88_XP_MN1 (VSS I700_pn21 I700_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I136_XP_MN0 (I700_P11_4 I700_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I136_XP_MN1 (VSS I700_P7_4n I700_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I78_XP_MN0 (I700_P12_11 I700_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I78_XP_MN1 (VSS I700_pn11 I700_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I75_XP_MN0 (I700_P9_8 I700_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I75_XP_MN1 (VSS I700_pn8 I700_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I70_XP_MN0 (I654_P4_3 I654_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I70_XP_MN1 (VSS I654_pn3 I654_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I69_XP_MN0 (I654_P3_2 I654_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I69_XP_MN1 (VSS I654_pn2 I654_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I69_XP_MN0 (I608_P3_2 I608_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I69_XP_MN1 (VSS I608_pn2 I608_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I71_XP_MN0 (I608_P5_4 I608_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I71_XP_MN1 (VSS I608_pn4 I608_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I70_XP_MN0 (I608_P4_3 I608_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I70_XP_MN1 (VSS I608_pn3 I608_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I72_XP_MN0 (I608_P6_5 I608_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I72_XP_MN1 (VSS I608_pn5 I608_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I70_XP_MN0 (I562_P4_3 I562_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I70_XP_MN1 (VSS I562_pn3 I562_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I72_XP_MN0 (I562_P6_5 I562_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I72_XP_MN1 (VSS I562_pn5 I562_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I73_XP_MN0 (I562_P7_6 I562_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I73_XP_MN1 (VSS I562_pn6 I562_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2295_MN0 (V vn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2295_MN1 (VSS DZ V VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2286_MN0 (z2_0 z1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2286_MN1 (VSS z1_1 z2_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2265_MN0 (z0_3 B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2265_MN1 (VSS B_7 z0_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2292_MN0 (DZ z3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2292_MN1 (VSS z3_1 DZ VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2287_MN0 (z2_1 z1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2287_MN1 (VSS z1_3 z2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I69_XP_MN0 (I2066_P3_2 I2066_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I69_XP_MN1 (VSS I2066_pn2 I2066_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I72_XP_MN0 (I2066_P6_5 I2066_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I72_XP_MN1 (VSS I2066_pn5 I2066_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I70_XP_MN0 (I2066_P4_3 I2066_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I70_XP_MN1 (VSS I2066_pn3 I2066_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I133_XP_MN0 (I1988_P8_1 I1988_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I133_XP_MN1 (VSS I1988_P4_1n I1988_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I74_XP_MN0 (I1988_P8_7 I1988_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I74_XP_MN1 (VSS I1988_pn7 I1988_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I73_XP_MN0 (I1988_P7_6 I1988_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I73_XP_MN1 (VSS I1988_pn6 I1988_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I72_XP_MN0 (I1942_P6_5 I1942_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I72_XP_MN1 (VSS I1942_pn5 I1942_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I71_XP_MN0 (I1942_P5_4 I1942_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I71_XP_MN1 (VSS I1942_pn4 I1942_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1896_I68_XP_MN0 (I1896_P2_1 I1896_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1896_I68_XP_MN1 (VSS I1896_pn1 I1896_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I75_XP_MN0 (I1850_P9_8 I1850_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I75_XP_MN1 (VSS I1850_pn8 I1850_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I77_XP_MN0 (I1850_P11_10 I1850_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I77_XP_MN1 (VSS I1850_pn10 I1850_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I79_XP_MN0 (I1850_P13_12 I1850_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I79_XP_MN1 (VSS I1850_pn12 I1850_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I81_XP_MN0 (I1850_P15_14 I1850_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I81_XP_MN1 (VSS I1850_pn14 I1850_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I83_XP_MN0 (I1850_P17_16 I1850_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I83_XP_MN1 (VSS I1850_pn16 I1850_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I85_XP_MN0 (I1850_P19_18 I1850_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I85_XP_MN1 (VSS I1850_pn18 I1850_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I87_XP_MN0 (I1850_P21_20 I1850_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I87_XP_MN1 (VSS I1850_pn20 I1850_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I89_XP_MN0 (I1850_P23_22 I1850_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I89_XP_MN1 (VSS I1850_pn22 I1850_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I93_XP_MN0 (I1850_P27_26 I1850_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I93_XP_MN1 (VSS I1850_pn26 I1850_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I155_XP_MN0 (I700_P30_23 I700_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I155_XP_MN1 (VSS I700_P26_23n I700_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I86_XP_MN0 (I700_P20_19 I700_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I86_XP_MN1 (VSS I700_pn19 I700_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I84_XP_MN0 (I700_P18_17 I700_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I84_XP_MN1 (VSS I700_pn17 I700_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I134_XP_MN0 (I700_P9_2 I700_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I134_XP_MN1 (VSS I700_P5_2n I700_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I73_XP_MN0 (I700_P7_6 I700_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I73_XP_MN1 (VSS I700_pn6 I700_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI654_I68_XP_MN0 (I654_P2_1 I654_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI654_I68_XP_MN1 (VSS I654_pn1 I654_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI608_I68_XP_MN0 (I608_P2_1 I608_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI608_I68_XP_MN1 (VSS I608_pn1 I608_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I68_XP_MN0 (I562_P2_1 I562_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I68_XP_MN1 (VSS I562_pn1 I562_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I69_XP_MN0 (I562_P3_2 I562_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I69_XP_MN1 (VSS I562_pn2 I562_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI562_I71_XP_MN0 (I562_P5_4 I562_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI562_I71_XP_MN1 (VSS I562_pn4 I562_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2264_MN0 (z0_2 B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2264_MN1 (VSS B_5 z0_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2263_MN0 (z0_1 B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2263_MN1 (VSS B_3 z0_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2266_MN0 (z0_4 B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2266_MN1 (VSS B_9 z0_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2066_I68_XP_MN0 (I2066_P2_1 I2066_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2066_I68_XP_MN1 (VSS I2066_pn1 I2066_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I72_XP_MN0 (I1988_P6_5 I1988_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I72_XP_MN1 (VSS I1988_pn5 I1988_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I71_XP_MN0 (I1988_P5_4 I1988_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I71_XP_MN1 (VSS I1988_pn4 I1988_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I70_XP_MN0 (I1942_P4_3 I1942_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I70_XP_MN1 (VSS I1942_pn3 I1942_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I69_XP_MN0 (I1942_P3_2 I1942_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I69_XP_MN1 (VSS I1942_pn2 I1942_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I69_XP_MN0 (I1850_P3_2 I1850_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I69_XP_MN1 (VSS I1850_pn2 I1850_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I71_XP_MN0 (I1850_P5_4 I1850_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I71_XP_MN1 (VSS I1850_pn4 I1850_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I73_XP_MN0 (I1850_P7_6 I1850_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I73_XP_MN1 (VSS I1850_pn6 I1850_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I91_XP_MN0 (I1850_P25_24 I1850_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I91_XP_MN1 (VSS I1850_pn24 I1850_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I95_XP_MN0 (I1850_P29_28 I1850_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I95_XP_MN1 (VSS I1850_pn28 I1850_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I97_XP_MN0 (I1850_P31_30 I1850_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I97_XP_MN1 (VSS I1850_pn30 I1850_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I153_XP_MN0 (I700_P28_21 I700_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I153_XP_MN1 (VSS I700_P24_21n I700_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I151_XP_MN0 (I700_P26_19 I700_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I151_XP_MN1 (VSS I700_P22_19n I700_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I147_XP_MN0 (I700_P22_15 I700_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I147_XP_MN1 (VSS I700_P18_15n I700_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I76_XP_MN0 (I700_P10_9 I700_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I76_XP_MN1 (VSS I700_pn9 I700_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I74_XP_MN0 (I700_P8_7 I700_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I74_XP_MN1 (VSS I700_pn7 I700_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I72_XP_MN0 (I700_P6_5 I700_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I72_XP_MN1 (VSS I700_pn5 I700_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2267_MN0 (z0_5 B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2267_MN1 (VSS B_11 z0_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2268_MN0 (z0_6 B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2268_MN1 (VSS B_13 z0_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2269_MN0 (z0_7 B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2269_MN1 (VSS B_15 z0_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2289_MN0 (z2_3 z1_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2289_MN1 (VSS z1_7 z2_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2288_MN0 (z2_2 z1_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2288_MN1 (VSS z1_5 z2_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2272_MN0 (z0_10 B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2272_MN1 (VSS B_21 z0_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I68_XP_MN0 (I1988_P2_1 I1988_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I68_XP_MN1 (VSS I1988_pn1 I1988_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I70_XP_MN0 (I1988_P4_3 I1988_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I70_XP_MN1 (VSS I1988_pn3 I1988_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1988_I69_XP_MN0 (I1988_P3_2 I1988_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1988_I69_XP_MN1 (VSS I1988_pn2 I1988_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1942_I68_XP_MN0 (I1942_P2_1 I1942_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1942_I68_XP_MN1 (VSS I1942_pn1 I1942_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I68_XP_MN0 (I1850_P2_1 I1850_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I68_XP_MN1 (VSS I1850_pn1 I1850_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I70_XP_MN0 (I1850_P4_3 I1850_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I70_XP_MN1 (VSS I1850_pn3 I1850_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I72_XP_MN0 (I1850_P6_5 I1850_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I72_XP_MN1 (VSS I1850_pn5 I1850_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I133_XP_MN0 (I1850_P8_1 I1850_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I133_XP_MN1 (VSS I1850_P4_1n I1850_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I135_XP_MN0 (I1850_P10_3 I1850_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I135_XP_MN1 (VSS I1850_P6_3n I1850_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I137_XP_MN0 (I1850_P12_5 I1850_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I137_XP_MN1 (VSS I1850_P8_5n I1850_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I141_XP_MN0 (I1850_P16_9 I1850_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I141_XP_MN1 (VSS I1850_P12_9n I1850_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I139_XP_MN0 (I1850_P14_7 I1850_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I139_XP_MN1 (VSS I1850_P10_7n I1850_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I143_XP_MN0 (I1850_P18_11 I1850_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I143_XP_MN1 (VSS I1850_P14_11n I1850_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I145_XP_MN0 (I1850_P20_13 I1850_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I145_XP_MN1 (VSS I1850_P16_13n I1850_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I149_XP_MN0 (I1850_P24_17 I1850_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I149_XP_MN1 (VSS I1850_P20_17n I1850_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I147_XP_MN0 (I1850_P22_15 I1850_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I147_XP_MN1 (VSS I1850_P18_15n I1850_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I151_XP_MN0 (I1850_P26_19 I1850_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I151_XP_MN1 (VSS I1850_P22_19n I1850_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I149_XP_MN0 (I700_P24_17 I700_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I149_XP_MN1 (VSS I700_P20_17n I700_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I145_XP_MN0 (I700_P20_13 I700_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I145_XP_MN1 (VSS I700_P16_13n I700_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I139_XP_MN0 (I700_P14_7 I700_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I139_XP_MN1 (VSS I700_P10_7n I700_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I143_XP_MN0 (I700_P18_11 I700_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I143_XP_MN1 (VSS I700_P14_11n I700_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I141_XP_MN0 (I700_P16_9 I700_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I141_XP_MN1 (VSS I700_P12_9n I700_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I135_XP_MN0 (I700_P10_3 I700_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I135_XP_MN1 (VSS I700_P6_3n I700_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I71_XP_MN0 (I700_P5_4 I700_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I71_XP_MN1 (VSS I700_pn4 I700_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I70_XP_MN0 (I700_P4_3 I700_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I70_XP_MN1 (VSS I700_pn3 I700_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I69_XP_MN0 (I700_P3_2 I700_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I69_XP_MN1 (VSS I700_pn2 I700_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2262_MN0 (z0_0 B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2262_MN1 (VSS B_1 z0_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2270_MN0 (z0_8 B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2270_MN1 (VSS B_17 z0_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2271_MN0 (z0_9 B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2271_MN1 (VSS B_19 z0_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I74_XP_MN0 (I1850_P8_7 I1850_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I74_XP_MN1 (VSS I1850_pn7 I1850_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I76_XP_MN0 (I1850_P10_9 I1850_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I76_XP_MN1 (VSS I1850_pn9 I1850_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I78_XP_MN0 (I1850_P12_11 I1850_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I78_XP_MN1 (VSS I1850_pn11 I1850_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I80_XP_MN0 (I1850_P14_13 I1850_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I80_XP_MN1 (VSS I1850_pn13 I1850_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I84_XP_MN0 (I1850_P18_17 I1850_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I84_XP_MN1 (VSS I1850_pn17 I1850_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I82_XP_MN0 (I1850_P16_15 I1850_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I82_XP_MN1 (VSS I1850_pn15 I1850_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I88_XP_MN0 (I1850_P22_21 I1850_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I88_XP_MN1 (VSS I1850_pn21 I1850_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I92_XP_MN0 (I1850_P26_25 I1850_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I92_XP_MN1 (VSS I1850_pn25 I1850_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I153_XP_MN0 (I1850_P28_21 I1850_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I153_XP_MN1 (VSS I1850_P24_21n I1850_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I155_XP_MN0 (I1850_P30_23 I1850_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I155_XP_MN1 (VSS I1850_P26_23n I1850_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I94_XP_MN0 (I1850_P28_27 I1850_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I94_XP_MN1 (VSS I1850_pn27 I1850_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I137_XP_MN0 (I700_P12_5 I700_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I137_XP_MN1 (VSS I700_P8_5n I700_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I133_XP_MN0 (I700_P8_1 I700_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I133_XP_MN1 (VSS I700_P4_1n I700_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI700_I68_XP_MN0 (I700_P2_1 I700_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI700_I68_XP_MN1 (VSS I700_pn1 I700_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2277_MN0 (z0_15 B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2277_MN1 (VSS B_31_b3_5 z0_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2273_MN0 (z0_11 B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2273_MN1 (VSS B_23 z0_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I86_XP_MN0 (I1850_P20_19 I1850_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I86_XP_MN1 (VSS I1850_pn19 I1850_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I90_XP_MN0 (I1850_P24_23 I1850_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I90_XP_MN1 (VSS I1850_pn23 I1850_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1850_I96_XP_MN0 (I1850_P30_29 I1850_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1850_I96_XP_MN1 (VSS I1850_pn29 I1850_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2276_MN0 (z0_14 B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2276_MN1 (VSS B_29 z0_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2274_MN0 (z0_12 B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2274_MN1 (VSS B_25 z0_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2275_MN0 (z0_13 B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2275_MN1 (VSS B_27 z0_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I72_XP_MN0 (I746_P6_5 I746_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I72_XP_MN1 (VSS I746_pn5 I746_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I71_XP_MN0 (I746_P5_4 I746_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I71_XP_MN1 (VSS I746_pn4 I746_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I70_XP_MN0 (I746_P4_3 I746_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I70_XP_MN1 (VSS I746_pn3 I746_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I69_XP_MN0 (I746_P3_2 I746_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I69_XP_MN1 (VSS I746_pn2 I746_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I71_XP_MN0 (I792_P5_4 I792_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I71_XP_MN1 (VSS I792_pn4 I792_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I72_XP_MN0 (I792_P6_5 I792_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I72_XP_MN1 (VSS I792_pn5 I792_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I70_XP_MN0 (I792_P4_3 I792_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I70_XP_MN1 (VSS I792_pn3 I792_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I69_XP_MN0 (I792_P3_2 I792_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I69_XP_MN1 (VSS I792_pn2 I792_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I68_XP_MN0 (I792_P2_1 I792_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I68_XP_MN1 (VSS I792_pn1 I792_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I69_XP_MN0 (I838_P3_2 I838_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I69_XP_MN1 (VSS I838_pn2 I838_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I70_XP_MN0 (I838_P4_3 I838_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I70_XP_MN1 (VSS I838_pn3 I838_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I68_XP_MN0 (I838_P2_1 I838_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I68_XP_MN1 (VSS I838_pn1 I838_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I68_XP_MN0 (I884_P2_1 I884_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I68_XP_MN1 (VSS I884_pn1 I884_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I69_XP_MN0 (I884_P3_2 I884_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I69_XP_MN1 (VSS I884_pn2 I884_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I68_XP_MN0 (I1712_P2_1 I1712_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I68_XP_MN1 (VSS I1712_pn1 I1712_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I68_XP_MN0 (I1758_P2_1 I1758_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I68_XP_MN1 (VSS I1758_pn1 I1758_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I69_XP_MN0 (I1758_P3_2 I1758_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I69_XP_MN1 (VSS I1758_pn2 I1758_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I68_XP_MN0 (I1804_P2_1 I1804_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I68_XP_MN1 (VSS I1804_pn1 I1804_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I69_XP_MN0 (I1804_P3_2 I1804_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I69_XP_MN1 (VSS I1804_pn2 I1804_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I70_XP_MN0 (I1804_P4_3 I1804_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I70_XP_MN1 (VSS I1804_pn3 I1804_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I75_XP_MN0 (I746_P9_8 I746_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I75_XP_MN1 (VSS I746_pn8 I746_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I74_XP_MN0 (I746_P8_7 I746_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I74_XP_MN1 (VSS I746_pn7 I746_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I73_XP_MN0 (I746_P7_6 I746_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I73_XP_MN1 (VSS I746_pn6 I746_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I68_XP_MN0 (I746_P2_1 I746_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I68_XP_MN1 (VSS I746_pn1 I746_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I73_XP_MN0 (I792_P7_6 I792_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I73_XP_MN1 (VSS I792_pn6 I792_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I74_XP_MN0 (I792_P8_7 I792_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I74_XP_MN1 (VSS I792_pn7 I792_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I133_XP_MN0 (I792_P8_1 I792_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I133_XP_MN1 (VSS I792_P4_1n I792_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I73_XP_MN0 (I838_P7_6 I838_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I73_XP_MN1 (VSS I838_pn6 I838_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I71_XP_MN0 (I838_P5_4 I838_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I71_XP_MN1 (VSS I838_pn4 I838_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I72_XP_MN0 (I838_P6_5 I838_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I72_XP_MN1 (VSS I838_pn5 I838_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I133_XP_MN0 (I838_P8_1 I838_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I133_XP_MN1 (VSS I838_P4_1n I838_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I72_XP_MN0 (I884_P6_5 I884_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I72_XP_MN1 (VSS I884_pn5 I884_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I70_XP_MN0 (I884_P4_3 I884_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I70_XP_MN1 (VSS I884_pn3 I884_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I71_XP_MN0 (I884_P5_4 I884_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I71_XP_MN1 (VSS I884_pn4 I884_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I133_XP_MN0 (I1712_P8_1 I1712_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I133_XP_MN1 (VSS I1712_P4_1n I1712_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I70_XP_MN0 (I1712_P4_3 I1712_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I70_XP_MN1 (VSS I1712_pn3 I1712_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I71_XP_MN0 (I1712_P5_4 I1712_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I71_XP_MN1 (VSS I1712_pn4 I1712_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I69_XP_MN0 (I1712_P3_2 I1712_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I69_XP_MN1 (VSS I1712_pn2 I1712_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I72_XP_MN0 (I1758_P6_5 I1758_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I72_XP_MN1 (VSS I1758_pn5 I1758_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I70_XP_MN0 (I1758_P4_3 I1758_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I70_XP_MN1 (VSS I1758_pn3 I1758_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I71_XP_MN0 (I1758_P5_4 I1758_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I71_XP_MN1 (VSS I1758_pn4 I1758_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I72_XP_MN0 (I1804_P6_5 I1804_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I72_XP_MN1 (VSS I1804_pn5 I1804_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I71_XP_MN0 (I1804_P5_4 I1804_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I71_XP_MN1 (VSS I1804_pn4 I1804_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I133_XP_MN0 (I1804_P8_1 I1804_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I133_XP_MN1 (VSS I1804_P4_1n I1804_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I135_XP_MN0 (I1804_P10_3 I1804_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I135_XP_MN1 (VSS I1804_P6_3n I1804_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I140_XP_MN0 (I746_P15_8 I746_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I140_XP_MN1 (VSS I746_P11_8n I746_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I136_XP_MN0 (I746_P11_4 I746_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I136_XP_MN1 (VSS I746_P7_4n I746_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I81_XP_MN0 (I746_P15_14 I746_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I81_XP_MN1 (VSS I746_pn14 I746_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I79_XP_MN0 (I746_P13_12 I746_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I79_XP_MN1 (VSS I746_pn12 I746_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I77_XP_MN0 (I746_P11_10 I746_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I77_XP_MN1 (VSS I746_pn10 I746_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I134_XP_MN0 (I746_P9_2 I746_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I134_XP_MN1 (VSS I746_P5_2n I746_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I76_XP_MN0 (I746_P10_9 I746_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I76_XP_MN1 (VSS I746_pn9 I746_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I75_XP_MN0 (I792_P9_8 I792_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I75_XP_MN1 (VSS I792_pn8 I792_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I134_XP_MN0 (I792_P9_2 I792_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I134_XP_MN1 (VSS I792_P5_2n I792_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I76_XP_MN0 (I792_P10_9 I792_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I76_XP_MN1 (VSS I792_pn9 I792_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I75_XP_MN0 (I838_P9_8 I838_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I75_XP_MN1 (VSS I838_pn8 I838_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I134_XP_MN0 (I838_P9_2 I838_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I134_XP_MN1 (VSS I838_P5_2n I838_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I74_XP_MN0 (I838_P8_7 I838_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I74_XP_MN1 (VSS I838_pn7 I838_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I76_XP_MN0 (I838_P10_9 I838_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I76_XP_MN1 (VSS I838_pn9 I838_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I74_XP_MN0 (I884_P8_7 I884_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I74_XP_MN1 (VSS I884_pn7 I884_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I133_XP_MN0 (I884_P8_1 I884_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I133_XP_MN1 (VSS I884_P4_1n I884_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I73_XP_MN0 (I884_P7_6 I884_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I73_XP_MN1 (VSS I884_pn6 I884_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I74_XP_MN0 (I1712_P8_7 I1712_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I74_XP_MN1 (VSS I1712_pn7 I1712_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I72_XP_MN0 (I1712_P6_5 I1712_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I72_XP_MN1 (VSS I1712_pn5 I1712_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I73_XP_MN0 (I1712_P7_6 I1712_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I73_XP_MN1 (VSS I1712_pn6 I1712_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I133_XP_MN0 (I1758_P8_1 I1758_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I133_XP_MN1 (VSS I1758_P4_1n I1758_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I73_XP_MN0 (I1758_P7_6 I1758_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I73_XP_MN1 (VSS I1758_pn6 I1758_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I73_XP_MN0 (I1804_P7_6 I1804_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I73_XP_MN1 (VSS I1804_pn6 I1804_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I76_XP_MN0 (I1804_P10_9 I1804_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I76_XP_MN1 (VSS I1804_pn9 I1804_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I74_XP_MN0 (I1804_P8_7 I1804_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I74_XP_MN1 (VSS I1804_pn7 I1804_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I137_XP_MN0 (I1804_P12_5 I1804_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I137_XP_MN1 (VSS I1804_P8_5n I1804_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I141_XP_MN0 (I1804_P16_9 I1804_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I141_XP_MN1 (VSS I1804_P12_9n I1804_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I148_XP_MN0 (I746_P23_16 I746_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I148_XP_MN1 (VSS I746_P19_16n I746_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I144_XP_MN0 (I746_P19_12 I746_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I144_XP_MN1 (VSS I746_P15_12n I746_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I87_XP_MN0 (I746_P21_20 I746_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I87_XP_MN1 (VSS I746_pn20 I746_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I85_XP_MN0 (I746_P19_18 I746_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I85_XP_MN1 (VSS I746_pn18 I746_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I83_XP_MN0 (I746_P17_16 I746_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I83_XP_MN1 (VSS I746_pn16 I746_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I142_XP_MN0 (I746_P17_10 I746_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I142_XP_MN1 (VSS I746_P13_10n I746_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I138_XP_MN0 (I746_P13_6 I746_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I138_XP_MN1 (VSS I746_P9_6n I746_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I78_XP_MN0 (I746_P12_11 I746_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I78_XP_MN1 (VSS I746_pn11 I746_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I133_XP_MN0 (I746_P8_1 I746_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I133_XP_MN1 (VSS I746_P4_1n I746_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I77_XP_MN0 (I792_P11_10 I792_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I77_XP_MN1 (VSS I792_pn10 I792_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I135_XP_MN0 (I792_P10_3 I792_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I135_XP_MN1 (VSS I792_P6_3n I792_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I77_XP_MN0 (I838_P11_10 I838_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I77_XP_MN1 (VSS I838_pn10 I838_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I138_XP_MN0 (I838_P13_6 I838_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I138_XP_MN1 (VSS I838_P9_6n I838_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I141_XP_MN0 (I838_P16_9 I838_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I141_XP_MN1 (VSS I838_P12_9n I838_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I137_XP_MN0 (I838_P12_5 I838_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I137_XP_MN1 (VSS I838_P8_5n I838_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I135_XP_MN0 (I838_P10_3 I838_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I135_XP_MN1 (VSS I838_P6_3n I838_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I76_XP_MN0 (I884_P10_9 I884_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I76_XP_MN1 (VSS I884_pn9 I884_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I135_XP_MN0 (I884_P10_3 I884_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I135_XP_MN1 (VSS I884_P6_3n I884_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I75_XP_MN0 (I884_P9_8 I884_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I75_XP_MN1 (VSS I884_pn8 I884_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I134_XP_MN0 (I884_P9_2 I884_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I134_XP_MN1 (VSS I884_P5_2n I884_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I137_XP_MN0 (I1712_P12_5 I1712_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I137_XP_MN1 (VSS I1712_P8_5n I1712_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I75_XP_MN0 (I1712_P9_8 I1712_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I75_XP_MN1 (VSS I1712_pn8 I1712_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I134_XP_MN0 (I1712_P9_2 I1712_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I134_XP_MN1 (VSS I1712_P5_2n I1712_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I74_XP_MN0 (I1758_P8_7 I1758_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I74_XP_MN1 (VSS I1758_pn7 I1758_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I135_XP_MN0 (I1758_P10_3 I1758_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I135_XP_MN1 (VSS I1758_P6_3n I1758_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I75_XP_MN0 (I1758_P9_8 I1758_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I75_XP_MN1 (VSS I1758_pn8 I1758_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I134_XP_MN0 (I1758_P9_2 I1758_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I134_XP_MN1 (VSS I1758_P5_2n I1758_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I75_XP_MN0 (I1804_P9_8 I1804_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I75_XP_MN1 (VSS I1804_pn8 I1804_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I77_XP_MN0 (I1804_P11_10 I1804_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I77_XP_MN1 (VSS I1804_pn10 I1804_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I134_XP_MN0 (I1804_P9_2 I1804_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I134_XP_MN1 (VSS I1804_P5_2n I1804_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I139_XP_MN0 (I1804_P14_7 I1804_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I139_XP_MN1 (VSS I1804_P10_7n I1804_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I143_XP_MN0 (I1804_P18_11 I1804_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I143_XP_MN1 (VSS I1804_P14_11n I1804_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I152_XP_MN0 (I746_P27_20 I746_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I152_XP_MN1 (VSS I746_P23_20n I746_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I89_XP_MN0 (I746_P23_22 I746_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I89_XP_MN1 (VSS I746_pn22 I746_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I150_XP_MN0 (I746_P25_18 I746_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I150_XP_MN1 (VSS I746_P21_18n I746_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I146_XP_MN0 (I746_P21_14 I746_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I146_XP_MN1 (VSS I746_P17_14n I746_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I80_XP_MN0 (I746_P14_13 I746_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I80_XP_MN1 (VSS I746_pn13 I746_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I84_XP_MN0 (I746_P18_17 I746_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I84_XP_MN1 (VSS I746_pn17 I746_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I137_XP_MN0 (I746_P12_5 I746_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I137_XP_MN1 (VSS I746_P8_5n I746_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I136_XP_MN0 (I792_P11_4 I792_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I136_XP_MN1 (VSS I792_P7_4n I792_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I79_XP_MN0 (I792_P13_12 I792_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I79_XP_MN1 (VSS I792_pn12 I792_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I78_XP_MN0 (I792_P12_11 I792_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I78_XP_MN1 (VSS I792_pn11 I792_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I141_XP_MN0 (I792_P16_9 I792_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I141_XP_MN1 (VSS I792_P12_9n I792_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I137_XP_MN0 (I792_P12_5 I792_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I137_XP_MN1 (VSS I792_P8_5n I792_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I79_XP_MN0 (I838_P13_12 I838_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I79_XP_MN1 (VSS I838_pn12 I838_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I136_XP_MN0 (I838_P11_4 I838_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I136_XP_MN1 (VSS I838_P7_4n I838_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I142_XP_MN0 (I838_P17_10 I838_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I142_XP_MN1 (VSS I838_P13_10n I838_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I78_XP_MN0 (I838_P12_11 I838_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I78_XP_MN1 (VSS I838_pn11 I838_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I139_XP_MN0 (I838_P14_7 I838_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I139_XP_MN1 (VSS I838_P10_7n I838_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I78_XP_MN0 (I884_P12_11 I884_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I78_XP_MN1 (VSS I884_pn11 I884_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I141_XP_MN0 (I884_P16_9 I884_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I141_XP_MN1 (VSS I884_P12_9n I884_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I137_XP_MN0 (I884_P12_5 I884_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I137_XP_MN1 (VSS I884_P8_5n I884_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I77_XP_MN0 (I884_P11_10 I884_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I77_XP_MN1 (VSS I884_pn10 I884_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I135_XP_MN0 (I1712_P10_3 I1712_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I135_XP_MN1 (VSS I1712_P6_3n I1712_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I141_XP_MN0 (I1712_P16_9 I1712_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I141_XP_MN1 (VSS I1712_P12_9n I1712_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I76_XP_MN0 (I1712_P10_9 I1712_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I76_XP_MN1 (VSS I1712_pn9 I1712_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I76_XP_MN0 (I1758_P10_9 I1758_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I76_XP_MN1 (VSS I1758_pn9 I1758_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I137_XP_MN0 (I1758_P12_5 I1758_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I137_XP_MN1 (VSS I1758_P8_5n I1758_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I141_XP_MN0 (I1758_P16_9 I1758_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I141_XP_MN1 (VSS I1758_P12_9n I1758_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I77_XP_MN0 (I1758_P11_10 I1758_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I77_XP_MN1 (VSS I1758_pn10 I1758_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I136_XP_MN0 (I1758_P11_4 I1758_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I136_XP_MN1 (VSS I1758_P7_4n I1758_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I78_XP_MN0 (I1804_P12_11 I1804_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I78_XP_MN1 (VSS I1804_pn11 I1804_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I136_XP_MN0 (I1804_P11_4 I1804_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I136_XP_MN1 (VSS I1804_P7_4n I1804_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I145_XP_MN0 (I1804_P20_13 I1804_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I145_XP_MN1 (VSS I1804_P16_13n I1804_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I156_XP_MN0 (I746_P31_24 I746_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I156_XP_MN1 (VSS I746_P27_24n I746_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I154_XP_MN0 (I746_P29_22 I746_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I154_XP_MN1 (VSS I746_P25_22n I746_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I86_XP_MN0 (I746_P20_19 I746_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I86_XP_MN1 (VSS I746_pn19 I746_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I82_XP_MN0 (I746_P16_15 I746_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I82_XP_MN1 (VSS I746_pn15 I746_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I141_XP_MN0 (I746_P16_9 I746_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I141_XP_MN1 (VSS I746_P12_9n I746_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I135_XP_MN0 (I746_P10_3 I746_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I135_XP_MN1 (VSS I746_P6_3n I746_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I83_XP_MN0 (I792_P17_16 I792_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I83_XP_MN1 (VSS I792_pn16 I792_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I81_XP_MN0 (I792_P15_14 I792_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I81_XP_MN1 (VSS I792_pn14 I792_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I142_XP_MN0 (I792_P17_10 I792_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I142_XP_MN1 (VSS I792_P13_10n I792_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I138_XP_MN0 (I792_P13_6 I792_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I138_XP_MN1 (VSS I792_P9_6n I792_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I82_XP_MN0 (I792_P16_15 I792_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I82_XP_MN1 (VSS I792_pn15 I792_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I80_XP_MN0 (I792_P14_13 I792_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I80_XP_MN1 (VSS I792_pn13 I792_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I84_XP_MN0 (I792_P18_17 I792_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I84_XP_MN1 (VSS I792_pn17 I792_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I143_XP_MN0 (I792_P18_11 I792_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I143_XP_MN1 (VSS I792_P14_11n I792_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I139_XP_MN0 (I792_P14_7 I792_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I139_XP_MN1 (VSS I792_P10_7n I792_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I140_XP_MN0 (I838_P15_8 I838_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I140_XP_MN1 (VSS I838_P11_8n I838_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I150_XP_MN0 (I838_P25_18 I838_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I150_XP_MN1 (VSS I838_P21_18n I838_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I80_XP_MN0 (I838_P14_13 I838_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I80_XP_MN1 (VSS I838_pn13 I838_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I145_XP_MN0 (I838_P20_13 I838_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I145_XP_MN1 (VSS I838_P16_13n I838_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I149_XP_MN0 (I838_P24_17 I838_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I149_XP_MN1 (VSS I838_P20_17n I838_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I143_XP_MN0 (I838_P18_11 I838_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I143_XP_MN1 (VSS I838_P14_11n I838_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I80_XP_MN0 (I884_P14_13 I884_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I80_XP_MN1 (VSS I884_pn13 I884_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I143_XP_MN0 (I884_P18_11 I884_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I143_XP_MN1 (VSS I884_P14_11n I884_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I139_XP_MN0 (I884_P14_7 I884_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I139_XP_MN1 (VSS I884_P10_7n I884_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I79_XP_MN0 (I884_P13_12 I884_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I79_XP_MN1 (VSS I884_pn12 I884_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I138_XP_MN0 (I884_P13_6 I884_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I138_XP_MN1 (VSS I884_P9_6n I884_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I142_XP_MN0 (I884_P17_10 I884_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I142_XP_MN1 (VSS I884_P13_10n I884_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I149_XP_MN0 (I1712_P24_17 I1712_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I149_XP_MN1 (VSS I1712_P20_17n I1712_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I145_XP_MN0 (I1712_P20_13 I1712_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I145_XP_MN1 (VSS I1712_P16_13n I1712_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I80_XP_MN0 (I1712_P14_13 I1712_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I80_XP_MN1 (VSS I1712_pn13 I1712_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I78_XP_MN0 (I1712_P12_11 I1712_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I78_XP_MN1 (VSS I1712_pn11 I1712_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I77_XP_MN0 (I1712_P11_10 I1712_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I77_XP_MN1 (VSS I1712_pn10 I1712_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I138_XP_MN0 (I1712_P13_6 I1712_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I138_XP_MN1 (VSS I1712_P9_6n I1712_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I136_XP_MN0 (I1712_P11_4 I1712_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I136_XP_MN1 (VSS I1712_P7_4n I1712_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I78_XP_MN0 (I1758_P12_11 I1758_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I78_XP_MN1 (VSS I1758_pn11 I1758_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I143_XP_MN0 (I1758_P18_11 I1758_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I143_XP_MN1 (VSS I1758_P14_11n I1758_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I139_XP_MN0 (I1758_P14_7 I1758_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I139_XP_MN1 (VSS I1758_P10_7n I1758_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I79_XP_MN0 (I1758_P13_12 I1758_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I79_XP_MN1 (VSS I1758_pn12 I1758_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I138_XP_MN0 (I1758_P13_6 I1758_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I138_XP_MN1 (VSS I1758_P9_6n I1758_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I142_XP_MN0 (I1758_P17_10 I1758_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I142_XP_MN1 (VSS I1758_P13_10n I1758_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I79_XP_MN0 (I1804_P13_12 I1804_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I79_XP_MN1 (VSS I1804_pn12 I1804_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I138_XP_MN0 (I1804_P13_6 I1804_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I138_XP_MN1 (VSS I1804_P9_6n I1804_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I142_XP_MN0 (I1804_P17_10 I1804_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I142_XP_MN1 (VSS I1804_P13_10n I1804_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I80_XP_MN0 (I1804_P14_13 I1804_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I80_XP_MN1 (VSS I1804_pn13 I1804_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I84_XP_MN0 (I1804_P18_17 I1804_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I84_XP_MN1 (VSS I1804_pn17 I1804_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I149_XP_MN0 (I1804_P24_17 I1804_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I149_XP_MN1 (VSS I1804_P20_17n I1804_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I147_XP_MN0 (I1804_P22_15 I1804_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I147_XP_MN1 (VSS I1804_P18_15n I1804_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I91_XP_MN0 (I746_P25_24 I746_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I91_XP_MN1 (VSS I746_pn24 I746_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I88_XP_MN0 (I746_P22_21 I746_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I88_XP_MN1 (VSS I746_pn21 I746_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I149_XP_MN0 (I746_P24_17 I746_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I149_XP_MN1 (VSS I746_P20_17n I746_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I145_XP_MN0 (I746_P20_13 I746_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I145_XP_MN1 (VSS I746_P16_13n I746_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I143_XP_MN0 (I746_P18_11 I746_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I143_XP_MN1 (VSS I746_P14_11n I746_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I139_XP_MN0 (I746_P14_7 I746_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I139_XP_MN1 (VSS I746_P10_7n I746_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I85_XP_MN0 (I792_P19_18 I792_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I85_XP_MN1 (VSS I792_pn18 I792_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I144_XP_MN0 (I792_P19_12 I792_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I144_XP_MN1 (VSS I792_P15_12n I792_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I140_XP_MN0 (I792_P15_8 I792_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I140_XP_MN1 (VSS I792_P11_8n I792_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I149_XP_MN0 (I792_P24_17 I792_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I149_XP_MN1 (VSS I792_P20_17n I792_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I145_XP_MN0 (I792_P20_13 I792_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I145_XP_MN1 (VSS I792_P16_13n I792_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I81_XP_MN0 (I838_P15_14 I838_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I81_XP_MN1 (VSS I838_pn14 I838_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I144_XP_MN0 (I838_P19_12 I838_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I144_XP_MN1 (VSS I838_P15_12n I838_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I146_XP_MN0 (I838_P21_14 I838_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I146_XP_MN1 (VSS I838_P17_14n I838_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I82_XP_MN0 (I838_P16_15 I838_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I82_XP_MN1 (VSS I838_pn15 I838_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I82_XP_MN0 (I884_P16_15 I884_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I82_XP_MN1 (VSS I884_pn15 I884_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I81_XP_MN0 (I884_P15_14 I884_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I81_XP_MN1 (VSS I884_pn14 I884_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I145_XP_MN0 (I884_P20_13 I884_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I145_XP_MN1 (VSS I884_P16_13n I884_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I143_XP_MN0 (I1712_P18_11 I1712_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I143_XP_MN1 (VSS I1712_P14_11n I1712_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I139_XP_MN0 (I1712_P14_7 I1712_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I139_XP_MN1 (VSS I1712_P10_7n I1712_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I79_XP_MN0 (I1712_P13_12 I1712_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I79_XP_MN1 (VSS I1712_pn12 I1712_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I142_XP_MN0 (I1712_P17_10 I1712_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I142_XP_MN1 (VSS I1712_P13_10n I1712_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I80_XP_MN0 (I1758_P14_13 I1758_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I80_XP_MN1 (VSS I1758_pn13 I1758_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I145_XP_MN0 (I1758_P20_13 I1758_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I145_XP_MN1 (VSS I1758_P16_13n I1758_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I81_XP_MN0 (I1758_P15_14 I1758_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I81_XP_MN1 (VSS I1758_pn14 I1758_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I140_XP_MN0 (I1758_P15_8 I1758_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I140_XP_MN1 (VSS I1758_P11_8n I1758_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I81_XP_MN0 (I1804_P15_14 I1804_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I81_XP_MN1 (VSS I1804_pn14 I1804_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I82_XP_MN0 (I1804_P16_15 I1804_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I82_XP_MN1 (VSS I1804_pn15 I1804_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I83_XP_MN0 (I1804_P17_16 I1804_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I83_XP_MN1 (VSS I1804_pn16 I1804_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I86_XP_MN0 (I1804_P20_19 I1804_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I86_XP_MN1 (VSS I1804_pn19 I1804_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I153_XP_MN0 (I1804_P28_21 I1804_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I153_XP_MN1 (VSS I1804_P24_21n I1804_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I155_XP_MN0 (I1804_P30_23 I1804_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I155_XP_MN1 (VSS I1804_P26_23n I1804_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I151_XP_MN0 (I1804_P26_19 I1804_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I151_XP_MN1 (VSS I1804_P22_19n I1804_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I93_XP_MN0 (I746_P27_26 I746_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I93_XP_MN1 (VSS I746_pn26 I746_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I90_XP_MN0 (I746_P24_23 I746_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I90_XP_MN1 (VSS I746_pn23 I746_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I92_XP_MN0 (I746_P26_25 I746_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I92_XP_MN1 (VSS I746_pn25 I746_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I153_XP_MN0 (I746_P28_21 I746_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I153_XP_MN1 (VSS I746_P24_21n I746_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I87_XP_MN0 (I792_P21_20 I792_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I87_XP_MN1 (VSS I792_pn20 I792_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I150_XP_MN0 (I792_P25_18 I792_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I150_XP_MN1 (VSS I792_P21_18n I792_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I146_XP_MN0 (I792_P21_14 I792_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I146_XP_MN1 (VSS I792_P17_14n I792_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I86_XP_MN0 (I792_P20_19 I792_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I86_XP_MN1 (VSS I792_pn19 I792_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I153_XP_MN0 (I792_P28_21 I792_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I153_XP_MN1 (VSS I792_P24_21n I792_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I83_XP_MN0 (I838_P17_16 I838_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I83_XP_MN1 (VSS I838_pn16 I838_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I85_XP_MN0 (I838_P19_18 I838_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I85_XP_MN1 (VSS I838_pn18 I838_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I84_XP_MN0 (I838_P18_17 I838_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I84_XP_MN1 (VSS I838_pn17 I838_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I147_XP_MN0 (I838_P22_15 I838_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I147_XP_MN1 (VSS I838_P18_15n I838_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I151_XP_MN0 (I838_P26_19 I838_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I151_XP_MN1 (VSS I838_P22_19n I838_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I83_XP_MN0 (I884_P17_16 I884_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I83_XP_MN1 (VSS I884_pn16 I884_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I84_XP_MN0 (I884_P18_17 I884_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I84_XP_MN1 (VSS I884_pn17 I884_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I147_XP_MN0 (I884_P22_15 I884_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I147_XP_MN1 (VSS I884_P18_15n I884_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I149_XP_MN0 (I884_P24_17 I884_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I149_XP_MN1 (VSS I884_P20_17n I884_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I146_XP_MN0 (I884_P21_14 I884_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I146_XP_MN1 (VSS I884_P17_14n I884_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I150_XP_MN0 (I884_P25_18 I884_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I150_XP_MN1 (VSS I884_P21_18n I884_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I136_XP_MN0 (I884_P11_4 I884_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I136_XP_MN1 (VSS I884_P7_4n I884_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I144_XP_MN0 (I884_P19_12 I884_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I144_XP_MN1 (VSS I884_P15_12n I884_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I140_XP_MN0 (I884_P15_8 I884_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I140_XP_MN1 (VSS I884_P11_8n I884_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I147_XP_MN0 (I1712_P22_15 I1712_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I147_XP_MN1 (VSS I1712_P18_15n I1712_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I82_XP_MN0 (I1712_P16_15 I1712_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I82_XP_MN1 (VSS I1712_pn15 I1712_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I81_XP_MN0 (I1712_P15_14 I1712_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I81_XP_MN1 (VSS I1712_pn14 I1712_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I146_XP_MN0 (I1712_P21_14 I1712_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I146_XP_MN1 (VSS I1712_P17_14n I1712_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I144_XP_MN0 (I1712_P19_12 I1712_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I144_XP_MN1 (VSS I1712_P15_12n I1712_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I140_XP_MN0 (I1712_P15_8 I1712_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I140_XP_MN1 (VSS I1712_P11_8n I1712_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I82_XP_MN0 (I1758_P16_15 I1758_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I82_XP_MN1 (VSS I1758_pn15 I1758_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I84_XP_MN0 (I1758_P18_17 I1758_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I84_XP_MN1 (VSS I1758_pn17 I1758_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I149_XP_MN0 (I1758_P24_17 I1758_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I149_XP_MN1 (VSS I1758_P20_17n I1758_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I153_XP_MN0 (I1758_P28_21 I1758_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I153_XP_MN1 (VSS I1758_P24_21n I1758_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I83_XP_MN0 (I1758_P17_16 I1758_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I83_XP_MN1 (VSS I1758_pn16 I1758_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I146_XP_MN0 (I1758_P21_14 I1758_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I146_XP_MN1 (VSS I1758_P17_14n I1758_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I150_XP_MN0 (I1758_P25_18 I1758_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I150_XP_MN1 (VSS I1758_P21_18n I1758_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I144_XP_MN0 (I1758_P19_12 I1758_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I144_XP_MN1 (VSS I1758_P15_12n I1758_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I140_XP_MN0 (I1804_P15_8 I1804_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I140_XP_MN1 (VSS I1804_P11_8n I1804_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I144_XP_MN0 (I1804_P19_12 I1804_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I144_XP_MN1 (VSS I1804_P15_12n I1804_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I146_XP_MN0 (I1804_P21_14 I1804_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I146_XP_MN1 (VSS I1804_P17_14n I1804_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I88_XP_MN0 (I1804_P22_21 I1804_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I88_XP_MN1 (VSS I1804_pn21 I1804_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I92_XP_MN0 (I1804_P26_25 I1804_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I92_XP_MN1 (VSS I1804_pn25 I1804_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I151_XP_MN0 (I746_P26_19 I746_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I151_XP_MN1 (VSS I746_P22_19n I746_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I147_XP_MN0 (I746_P22_15 I746_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I147_XP_MN1 (VSS I746_P18_15n I746_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I89_XP_MN0 (I792_P23_22 I792_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I89_XP_MN1 (VSS I792_pn22 I792_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I154_XP_MN0 (I792_P29_22 I792_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I154_XP_MN1 (VSS I792_P25_22n I792_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I88_XP_MN0 (I792_P22_21 I792_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I88_XP_MN1 (VSS I792_pn21 I792_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I90_XP_MN0 (I792_P24_23 I792_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I90_XP_MN1 (VSS I792_pn23 I792_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I147_XP_MN0 (I792_P22_15 I792_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I147_XP_MN1 (VSS I792_P18_15n I792_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I152_XP_MN0 (I838_P27_20 I838_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I152_XP_MN1 (VSS I838_P23_20n I838_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I148_XP_MN0 (I838_P23_16 I838_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I148_XP_MN1 (VSS I838_P19_16n I838_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I154_XP_MN0 (I838_P29_22 I838_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I154_XP_MN1 (VSS I838_P25_22n I838_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I86_XP_MN0 (I838_P20_19 I838_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I86_XP_MN1 (VSS I838_pn19 I838_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I153_XP_MN0 (I838_P28_21 I838_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I153_XP_MN1 (VSS I838_P24_21n I838_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I86_XP_MN0 (I884_P20_19 I884_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I86_XP_MN1 (VSS I884_pn19 I884_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I85_XP_MN0 (I884_P19_18 I884_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I85_XP_MN1 (VSS I884_pn18 I884_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I151_XP_MN0 (I884_P26_19 I884_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I151_XP_MN1 (VSS I884_P22_19n I884_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I153_XP_MN0 (I884_P28_21 I884_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I153_XP_MN1 (VSS I884_P24_21n I884_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I151_XP_MN0 (I1712_P26_19 I1712_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I151_XP_MN1 (VSS I1712_P22_19n I1712_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I153_XP_MN0 (I1712_P28_21 I1712_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I153_XP_MN1 (VSS I1712_P24_21n I1712_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I84_XP_MN0 (I1712_P18_17 I1712_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I84_XP_MN1 (VSS I1712_pn17 I1712_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I83_XP_MN0 (I1712_P17_16 I1712_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I83_XP_MN1 (VSS I1712_pn16 I1712_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I150_XP_MN0 (I1712_P25_18 I1712_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I150_XP_MN1 (VSS I1712_P21_18n I1712_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I86_XP_MN0 (I1758_P20_19 I1758_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I86_XP_MN1 (VSS I1758_pn19 I1758_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I147_XP_MN0 (I1758_P22_15 I1758_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I147_XP_MN1 (VSS I1758_P18_15n I1758_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I151_XP_MN0 (I1758_P26_19 I1758_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I151_XP_MN1 (VSS I1758_P22_19n I1758_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I85_XP_MN0 (I1758_P19_18 I1758_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I85_XP_MN1 (VSS I1758_pn18 I1758_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I148_XP_MN0 (I1804_P23_16 I1804_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I148_XP_MN1 (VSS I1804_P19_16n I1804_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I85_XP_MN0 (I1804_P19_18 I1804_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I85_XP_MN1 (VSS I1804_pn18 I1804_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I87_XP_MN0 (I1804_P21_20 I1804_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I87_XP_MN1 (VSS I1804_pn20 I1804_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I150_XP_MN0 (I1804_P25_18 I1804_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I150_XP_MN1 (VSS I1804_P21_18n I1804_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I154_XP_MN0 (I1804_P29_22 I1804_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I154_XP_MN1 (VSS I1804_P25_22n I1804_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I90_XP_MN0 (I1804_P24_23 I1804_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I90_XP_MN1 (VSS I1804_pn23 I1804_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I94_XP_MN0 (I1804_P28_27 I1804_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I94_XP_MN1 (VSS I1804_pn27 I1804_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I95_XP_MN0 (I746_P29_28 I746_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I95_XP_MN1 (VSS I746_pn28 I746_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I94_XP_MN0 (I746_P28_27 I746_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I94_XP_MN1 (VSS I746_pn27 I746_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I155_XP_MN0 (I746_P30_23 I746_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I155_XP_MN1 (VSS I746_P26_23n I746_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I91_XP_MN0 (I792_P25_24 I792_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I91_XP_MN1 (VSS I792_pn24 I792_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I152_XP_MN0 (I792_P27_20 I792_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I152_XP_MN1 (VSS I792_P23_20n I792_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I148_XP_MN0 (I792_P23_16 I792_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I148_XP_MN1 (VSS I792_P19_16n I792_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I92_XP_MN0 (I792_P26_25 I792_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I92_XP_MN1 (VSS I792_pn25 I792_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I151_XP_MN0 (I792_P26_19 I792_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I151_XP_MN1 (VSS I792_P22_19n I792_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I156_XP_MN0 (I838_P31_24 I838_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I156_XP_MN1 (VSS I838_P27_24n I838_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I89_XP_MN0 (I838_P23_22 I838_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I89_XP_MN1 (VSS I838_pn22 I838_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I87_XP_MN0 (I838_P21_20 I838_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I87_XP_MN1 (VSS I838_pn20 I838_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I88_XP_MN0 (I838_P22_21 I838_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I88_XP_MN1 (VSS I838_pn21 I838_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I155_XP_MN0 (I838_P30_23 I838_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I155_XP_MN1 (VSS I838_P26_23n I838_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I88_XP_MN0 (I884_P22_21 I884_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I88_XP_MN1 (VSS I884_pn21 I884_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I87_XP_MN0 (I884_P21_20 I884_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I87_XP_MN1 (VSS I884_pn20 I884_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I152_XP_MN0 (I884_P27_20 I884_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I152_XP_MN1 (VSS I884_P23_20n I884_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I155_XP_MN0 (I1712_P30_23 I1712_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I155_XP_MN1 (VSS I1712_P26_23n I1712_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I86_XP_MN0 (I1712_P20_19 I1712_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I86_XP_MN1 (VSS I1712_pn19 I1712_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I85_XP_MN0 (I1712_P19_18 I1712_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I85_XP_MN1 (VSS I1712_pn18 I1712_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I152_XP_MN0 (I1712_P27_20 I1712_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I152_XP_MN1 (VSS I1712_P23_20n I1712_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I148_XP_MN0 (I1712_P23_16 I1712_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I148_XP_MN1 (VSS I1712_P19_16n I1712_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I88_XP_MN0 (I1758_P22_21 I1758_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I88_XP_MN1 (VSS I1758_pn21 I1758_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I155_XP_MN0 (I1758_P30_23 I1758_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I155_XP_MN1 (VSS I1758_P26_23n I1758_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I87_XP_MN0 (I1758_P21_20 I1758_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I87_XP_MN1 (VSS I1758_pn20 I1758_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I154_XP_MN0 (I1758_P29_22 I1758_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I154_XP_MN1 (VSS I1758_P25_22n I1758_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I152_XP_MN0 (I1758_P27_20 I1758_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I152_XP_MN1 (VSS I1758_P23_20n I1758_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I148_XP_MN0 (I1758_P23_16 I1758_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I148_XP_MN1 (VSS I1758_P19_16n I1758_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I152_XP_MN0 (I1804_P27_20 I1804_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I152_XP_MN1 (VSS I1804_P23_20n I1804_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I89_XP_MN0 (I1804_P23_22 I1804_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I89_XP_MN1 (VSS I1804_pn22 I1804_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I91_XP_MN0 (I1804_P25_24 I1804_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I91_XP_MN1 (VSS I1804_pn24 I1804_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I96_XP_MN0 (I1804_P30_29 I1804_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I96_XP_MN1 (VSS I1804_pn29 I1804_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I93_XP_MN0 (I1804_P27_26 I1804_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I93_XP_MN1 (VSS I1804_pn26 I1804_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I97_XP_MN0 (I746_P31_30 I746_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I97_XP_MN1 (VSS I746_pn30 I746_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI746_I96_XP_MN0 (I746_P30_29 I746_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I96_XP_MN1 (VSS I746_pn29 I746_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I97_XP_MN0 (I792_P31_30 I792_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I97_XP_MN1 (VSS I792_pn30 I792_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I93_XP_MN0 (I792_P27_26 I792_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I93_XP_MN1 (VSS I792_pn26 I792_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I156_XP_MN0 (I792_P31_24 I792_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I156_XP_MN1 (VSS I792_P27_24n I792_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I94_XP_MN0 (I792_P28_27 I792_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I94_XP_MN1 (VSS I792_pn27 I792_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I155_XP_MN0 (I792_P30_23 I792_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I155_XP_MN1 (VSS I792_P26_23n I792_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I97_XP_MN0 (I838_P31_30 I838_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I97_XP_MN1 (VSS I838_pn30 I838_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I91_XP_MN0 (I838_P25_24 I838_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I91_XP_MN1 (VSS I838_pn24 I838_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I90_XP_MN0 (I838_P24_23 I838_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I90_XP_MN1 (VSS I838_pn23 I838_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I155_XP_MN0 (I884_P30_23 I884_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I155_XP_MN1 (VSS I884_P26_23n I884_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I89_XP_MN0 (I884_P23_22 I884_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I89_XP_MN1 (VSS I884_pn22 I884_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I90_XP_MN0 (I884_P24_23 I884_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I90_XP_MN1 (VSS I884_pn23 I884_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I154_XP_MN0 (I884_P29_22 I884_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I154_XP_MN1 (VSS I884_P25_22n I884_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I148_XP_MN0 (I884_P23_16 I884_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I148_XP_MN1 (VSS I884_P19_16n I884_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I88_XP_MN0 (I1712_P22_21 I1712_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I88_XP_MN1 (VSS I1712_pn21 I1712_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I89_XP_MN0 (I1712_P23_22 I1712_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I89_XP_MN1 (VSS I1712_pn22 I1712_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I87_XP_MN0 (I1712_P21_20 I1712_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I87_XP_MN1 (VSS I1712_pn20 I1712_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I154_XP_MN0 (I1712_P29_22 I1712_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I154_XP_MN1 (VSS I1712_P25_22n I1712_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I90_XP_MN0 (I1758_P24_23 I1758_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I90_XP_MN1 (VSS I1758_pn23 I1758_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I92_XP_MN0 (I1758_P26_25 I1758_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I92_XP_MN1 (VSS I1758_pn25 I1758_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I89_XP_MN0 (I1758_P23_22 I1758_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I89_XP_MN1 (VSS I1758_pn22 I1758_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I91_XP_MN0 (I1758_P25_24 I1758_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I91_XP_MN1 (VSS I1758_pn24 I1758_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I156_XP_MN0 (I1758_P31_24 I1758_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I156_XP_MN1 (VSS I1758_P27_24n I1758_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I156_XP_MN0 (I1804_P31_24 I1804_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I156_XP_MN1 (VSS I1804_P27_24n I1804_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I95_XP_MN0 (I1804_P29_28 I1804_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I95_XP_MN1 (VSS I1804_pn28 I1804_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I95_XP_MN0 (I792_P29_28 I792_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I95_XP_MN1 (VSS I792_pn28 I792_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI792_I96_XP_MN0 (I792_P30_29 I792_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I96_XP_MN1 (VSS I792_pn29 I792_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I95_XP_MN0 (I838_P29_28 I838_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I95_XP_MN1 (VSS I838_pn28 I838_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I93_XP_MN0 (I838_P27_26 I838_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I93_XP_MN1 (VSS I838_pn26 I838_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I94_XP_MN0 (I838_P28_27 I838_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I94_XP_MN1 (VSS I838_pn27 I838_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I92_XP_MN0 (I838_P26_25 I838_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I92_XP_MN1 (VSS I838_pn25 I838_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI838_I96_XP_MN0 (I838_P30_29 I838_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I96_XP_MN1 (VSS I838_pn29 I838_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I92_XP_MN0 (I884_P26_25 I884_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I92_XP_MN1 (VSS I884_pn25 I884_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I91_XP_MN0 (I884_P25_24 I884_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I91_XP_MN1 (VSS I884_pn24 I884_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I93_XP_MN0 (I884_P27_26 I884_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I93_XP_MN1 (VSS I884_pn26 I884_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I156_XP_MN0 (I884_P31_24 I884_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I156_XP_MN1 (VSS I884_P27_24n I884_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I90_XP_MN0 (I1712_P24_23 I1712_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I90_XP_MN1 (VSS I1712_pn23 I1712_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I91_XP_MN0 (I1712_P25_24 I1712_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I91_XP_MN1 (VSS I1712_pn24 I1712_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I156_XP_MN0 (I1712_P31_24 I1712_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I156_XP_MN1 (VSS I1712_P27_24n I1712_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I94_XP_MN0 (I1758_P28_27 I1758_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I94_XP_MN1 (VSS I1758_pn27 I1758_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I93_XP_MN0 (I1758_P27_26 I1758_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I93_XP_MN1 (VSS I1758_pn26 I1758_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I96_XP_MN0 (I1758_P30_29 I1758_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I96_XP_MN1 (VSS I1758_pn29 I1758_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I95_XP_MN0 (I1758_P29_28 I1758_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I95_XP_MN1 (VSS I1758_pn28 I1758_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1758_I97_XP_MN0 (I1758_P31_30 I1758_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I97_XP_MN1 (VSS I1758_pn30 I1758_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1804_I97_XP_MN0 (I1804_P31_30 I1804_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I97_XP_MN1 (VSS I1804_pn30 I1804_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I146_XP_MN0 (I1068_P21_14 I1068_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I146_XP_MN1 (VSS I1068_P17_14n I1068_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I142_XP_MN0 (I1068_P17_10 I1068_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I142_XP_MN1 (VSS I1068_P13_10n I1068_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I138_XP_MN0 (I1068_P13_6 I1068_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I138_XP_MN1 (VSS I1068_P9_6n I1068_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I134_XP_MN0 (I1068_P9_2 I1068_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I134_XP_MN1 (VSS I1068_P5_2n I1068_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I71_XP_MN0 (I1068_P5_4 I1068_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I71_XP_MN1 (VSS I1068_pn4 I1068_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I96_XP_MN0 (I884_P30_29 I884_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I96_XP_MN1 (VSS I884_pn29 I884_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I97_XP_MN0 (I884_P31_30 I884_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I97_XP_MN1 (VSS I884_pn30 I884_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I94_XP_MN0 (I884_P28_27 I884_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I94_XP_MN1 (VSS I884_pn27 I884_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI884_I95_XP_MN0 (I884_P29_28 I884_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I95_XP_MN1 (VSS I884_pn28 I884_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I92_XP_MN0 (I1712_P26_25 I1712_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I92_XP_MN1 (VSS I1712_pn25 I1712_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I94_XP_MN0 (I1712_P28_27 I1712_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I94_XP_MN1 (VSS I1712_pn27 I1712_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I93_XP_MN0 (I1712_P27_26 I1712_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I93_XP_MN1 (VSS I1712_pn26 I1712_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I96_XP_MN0 (I1712_P30_29 I1712_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I96_XP_MN1 (VSS I1712_pn29 I1712_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I95_XP_MN0 (I1712_P29_28 I1712_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I95_XP_MN1 (VSS I1712_pn28 I1712_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1712_I97_XP_MN0 (I1712_P31_30 I1712_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I97_XP_MN1 (VSS I1712_pn30 I1712_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I154_XP_MN0 (I1068_P29_22 I1068_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I154_XP_MN1 (VSS I1068_P25_22n I1068_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I150_XP_MN0 (I1068_P25_18 I1068_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I150_XP_MN1 (VSS I1068_P21_18n I1068_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I140_XP_MN0 (I1068_P15_8 I1068_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I140_XP_MN1 (VSS I1068_P11_8n I1068_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I136_XP_MN0 (I1068_P11_4 I1068_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I136_XP_MN1 (VSS I1068_P7_4n I1068_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I73_XP_MN0 (I1068_P7_6 I1068_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I73_XP_MN1 (VSS I1068_pn6 I1068_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I70_XP_MN0 (I1068_P4_3 I1068_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I70_XP_MN1 (VSS I1068_pn3 I1068_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I69_XP_MN0 (I1068_P3_2 I1068_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I69_XP_MN1 (VSS I1068_pn2 I1068_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I93_XP_MN0 (I1068_P27_26 I1068_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I93_XP_MN1 (VSS I1068_pn26 I1068_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I156_XP_MN0 (I1068_P31_24 I1068_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I156_XP_MN1 (VSS I1068_P27_24n I1068_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I152_XP_MN0 (I1068_P27_20 I1068_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I152_XP_MN1 (VSS I1068_P23_20n I1068_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I148_XP_MN0 (I1068_P23_16 I1068_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I148_XP_MN1 (VSS I1068_P19_16n I1068_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I144_XP_MN0 (I1068_P19_12 I1068_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I144_XP_MN1 (VSS I1068_P15_12n I1068_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I75_XP_MN0 (I1068_P9_8 I1068_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I75_XP_MN1 (VSS I1068_pn8 I1068_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I72_XP_MN0 (I1068_P6_5 I1068_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I72_XP_MN1 (VSS I1068_pn5 I1068_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I68_XP_MN0 (I1022_P2_1 I1022_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I68_XP_MN1 (VSS I1022_pn1 I1022_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I68_XP_MN0 (I1666_P2_1 I1666_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I68_XP_MN1 (VSS I1666_pn1 I1666_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I69_XP_MN0 (I1666_P3_2 I1666_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I69_XP_MN1 (VSS I1666_pn2 I1666_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I68_XP_MN0 (I1620_P2_1 I1620_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I68_XP_MN1 (VSS I1620_pn1 I1620_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I69_XP_MN0 (I1574_P3_2 I1574_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I69_XP_MN1 (VSS I1574_pn2 I1574_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I68_XP_MN0 (I1574_P2_1 I1574_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I68_XP_MN1 (VSS I1574_pn1 I1574_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I70_XP_MN0 (I1574_P4_3 I1574_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I70_XP_MN1 (VSS I1574_pn3 I1574_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I133_XP_MN0 (I1574_P8_1 I1574_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I133_XP_MN1 (VSS I1574_P4_1n I1574_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I95_XP_MN0 (I1068_P29_28 I1068_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I95_XP_MN1 (VSS I1068_pn28 I1068_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I135_XP_MN0 (I1068_P10_3 I1068_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I135_XP_MN1 (VSS I1068_P6_3n I1068_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I77_XP_MN0 (I1068_P11_10 I1068_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I77_XP_MN1 (VSS I1068_pn10 I1068_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I74_XP_MN0 (I1068_P8_7 I1068_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I74_XP_MN1 (VSS I1068_pn7 I1068_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I68_XP_MN0 (I1068_P2_1 I1068_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I68_XP_MN1 (VSS I1068_pn1 I1068_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I69_XP_MN0 (I1022_P3_2 I1022_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I69_XP_MN1 (VSS I1022_pn2 I1022_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I70_XP_MN0 (I1022_P4_3 I1022_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I70_XP_MN1 (VSS I1022_pn3 I1022_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I68_XP_MN0 (I976_P2_1 I976_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I68_XP_MN1 (VSS I976_pn1 I976_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I70_XP_MN0 (I976_P4_3 I976_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I70_XP_MN1 (VSS I976_pn3 I976_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I69_XP_MN0 (I976_P3_2 I976_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I69_XP_MN1 (VSS I976_pn2 I976_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I68_XP_MN0 (I930_P2_1 I930_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I68_XP_MN1 (VSS I930_pn1 I930_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I69_XP_MN0 (I930_P3_2 I930_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I69_XP_MN1 (VSS I930_pn2 I930_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I70_XP_MN0 (I930_P4_3 I930_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I70_XP_MN1 (VSS I930_pn3 I930_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I71_XP_MN0 (I930_P5_4 I930_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I71_XP_MN1 (VSS I930_pn4 I930_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I133_XP_MN0 (I1666_P8_1 I1666_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I133_XP_MN1 (VSS I1666_P4_1n I1666_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I72_XP_MN0 (I1666_P6_5 I1666_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I72_XP_MN1 (VSS I1666_pn5 I1666_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I70_XP_MN0 (I1666_P4_3 I1666_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I70_XP_MN1 (VSS I1666_pn3 I1666_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I71_XP_MN0 (I1666_P5_4 I1666_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I71_XP_MN1 (VSS I1666_pn4 I1666_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I69_XP_MN0 (I1620_P3_2 I1620_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I69_XP_MN1 (VSS I1620_pn2 I1620_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I71_XP_MN0 (I1620_P5_4 I1620_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I71_XP_MN1 (VSS I1620_pn4 I1620_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I70_XP_MN0 (I1620_P4_3 I1620_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I70_XP_MN1 (VSS I1620_pn3 I1620_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I71_XP_MN0 (I1574_P5_4 I1574_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I71_XP_MN1 (VSS I1574_pn4 I1574_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I72_XP_MN0 (I1574_P6_5 I1574_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I72_XP_MN1 (VSS I1574_pn5 I1574_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I94_XP_MN0 (I1068_P28_27 I1068_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I94_XP_MN1 (VSS I1068_pn27 I1068_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I155_XP_MN0 (I1068_P30_23 I1068_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I155_XP_MN1 (VSS I1068_P26_23n I1068_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I151_XP_MN0 (I1068_P26_19 I1068_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I151_XP_MN1 (VSS I1068_P22_19n I1068_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I147_XP_MN0 (I1068_P22_15 I1068_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I147_XP_MN1 (VSS I1068_P18_15n I1068_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I143_XP_MN0 (I1068_P18_11 I1068_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I143_XP_MN1 (VSS I1068_P14_11n I1068_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I139_XP_MN0 (I1068_P14_7 I1068_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I139_XP_MN1 (VSS I1068_P10_7n I1068_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I76_XP_MN0 (I1068_P10_9 I1068_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I76_XP_MN1 (VSS I1068_pn9 I1068_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I137_XP_MN0 (I1068_P12_5 I1068_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I137_XP_MN1 (VSS I1068_P8_5n I1068_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I133_XP_MN0 (I1068_P8_1 I1068_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I133_XP_MN1 (VSS I1068_P4_1n I1068_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I73_XP_MN0 (I1022_P7_6 I1022_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I73_XP_MN1 (VSS I1022_pn6 I1022_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I71_XP_MN0 (I1022_P5_4 I1022_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I71_XP_MN1 (VSS I1022_pn4 I1022_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I72_XP_MN0 (I1022_P6_5 I1022_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I72_XP_MN1 (VSS I1022_pn5 I1022_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I72_XP_MN0 (I976_P6_5 I976_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I72_XP_MN1 (VSS I976_pn5 I976_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I71_XP_MN0 (I976_P5_4 I976_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I71_XP_MN1 (VSS I976_pn4 I976_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I72_XP_MN0 (I930_P6_5 I930_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I72_XP_MN1 (VSS I930_pn5 I930_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I74_XP_MN0 (I930_P8_7 I930_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I74_XP_MN1 (VSS I930_pn7 I930_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I73_XP_MN0 (I930_P7_6 I930_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I73_XP_MN1 (VSS I930_pn6 I930_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I74_XP_MN0 (I1666_P8_7 I1666_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I74_XP_MN1 (VSS I1666_pn7 I1666_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I73_XP_MN0 (I1666_P7_6 I1666_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I73_XP_MN1 (VSS I1666_pn6 I1666_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I73_XP_MN0 (I1620_P7_6 I1620_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I73_XP_MN1 (VSS I1620_pn6 I1620_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I133_XP_MN0 (I1620_P8_1 I1620_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I133_XP_MN1 (VSS I1620_P4_1n I1620_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I72_XP_MN0 (I1620_P6_5 I1620_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I72_XP_MN1 (VSS I1620_pn5 I1620_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I74_XP_MN0 (I1620_P8_7 I1620_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I74_XP_MN1 (VSS I1620_pn7 I1620_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I75_XP_MN0 (I1574_P9_8 I1574_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I75_XP_MN1 (VSS I1574_pn8 I1574_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I73_XP_MN0 (I1574_P7_6 I1574_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I73_XP_MN1 (VSS I1574_pn6 I1574_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I74_XP_MN0 (I1574_P8_7 I1574_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I74_XP_MN1 (VSS I1574_pn7 I1574_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I137_XP_MN0 (I1574_P12_5 I1574_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I137_XP_MN1 (VSS I1574_P8_5n I1574_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I92_XP_MN0 (I1068_P26_25 I1068_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I92_XP_MN1 (VSS I1068_pn25 I1068_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I153_XP_MN0 (I1068_P28_21 I1068_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I153_XP_MN1 (VSS I1068_P24_21n I1068_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I145_XP_MN0 (I1068_P20_13 I1068_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I145_XP_MN1 (VSS I1068_P16_13n I1068_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I149_XP_MN0 (I1068_P24_17 I1068_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I149_XP_MN1 (VSS I1068_P20_17n I1068_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I141_XP_MN0 (I1068_P16_9 I1068_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I141_XP_MN1 (VSS I1068_P12_9n I1068_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I78_XP_MN0 (I1068_P12_11 I1068_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I78_XP_MN1 (VSS I1068_pn11 I1068_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I134_XP_MN0 (I1022_P9_2 I1022_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I134_XP_MN1 (VSS I1022_P5_2n I1022_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I75_XP_MN0 (I1022_P9_8 I1022_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I75_XP_MN1 (VSS I1022_pn8 I1022_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I133_XP_MN0 (I1022_P8_1 I1022_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I133_XP_MN1 (VSS I1022_P4_1n I1022_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I74_XP_MN0 (I1022_P8_7 I1022_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I74_XP_MN1 (VSS I1022_pn7 I1022_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I76_XP_MN0 (I1022_P10_9 I1022_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I76_XP_MN1 (VSS I1022_pn9 I1022_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I133_XP_MN0 (I976_P8_1 I976_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I133_XP_MN1 (VSS I976_P4_1n I976_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I74_XP_MN0 (I976_P8_7 I976_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I74_XP_MN1 (VSS I976_pn7 I976_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I73_XP_MN0 (I976_P7_6 I976_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I73_XP_MN1 (VSS I976_pn6 I976_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I133_XP_MN0 (I930_P8_1 I930_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I133_XP_MN1 (VSS I930_P4_1n I930_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I137_XP_MN0 (I930_P12_5 I930_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I137_XP_MN1 (VSS I930_P8_5n I930_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I76_XP_MN0 (I930_P10_9 I930_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I76_XP_MN1 (VSS I930_pn9 I930_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I75_XP_MN0 (I930_P9_8 I930_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I75_XP_MN1 (VSS I930_pn8 I930_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I134_XP_MN0 (I930_P9_2 I930_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I134_XP_MN1 (VSS I930_P5_2n I930_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I141_XP_MN0 (I1666_P16_9 I1666_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I141_XP_MN1 (VSS I1666_P12_9n I1666_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I137_XP_MN0 (I1666_P12_5 I1666_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I137_XP_MN1 (VSS I1666_P8_5n I1666_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I135_XP_MN0 (I1666_P10_3 I1666_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I135_XP_MN1 (VSS I1666_P6_3n I1666_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I76_XP_MN0 (I1666_P10_9 I1666_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I76_XP_MN1 (VSS I1666_pn9 I1666_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I134_XP_MN0 (I1666_P9_2 I1666_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I134_XP_MN1 (VSS I1666_P5_2n I1666_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I75_XP_MN0 (I1666_P9_8 I1666_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I75_XP_MN1 (VSS I1666_pn8 I1666_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I134_XP_MN0 (I1620_P9_2 I1620_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I134_XP_MN1 (VSS I1620_P5_2n I1620_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I75_XP_MN0 (I1620_P9_8 I1620_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I75_XP_MN1 (VSS I1620_pn8 I1620_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I135_XP_MN0 (I1620_P10_3 I1620_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I135_XP_MN1 (VSS I1620_P6_3n I1620_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I76_XP_MN0 (I1620_P10_9 I1620_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I76_XP_MN1 (VSS I1620_pn9 I1620_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I134_XP_MN0 (I1574_P9_2 I1574_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I134_XP_MN1 (VSS I1574_P5_2n I1574_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I76_XP_MN0 (I1574_P10_9 I1574_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I76_XP_MN1 (VSS I1574_pn9 I1574_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I135_XP_MN0 (I1574_P10_3 I1574_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I135_XP_MN1 (VSS I1574_P6_3n I1574_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I141_XP_MN0 (I1574_P16_9 I1574_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I141_XP_MN1 (VSS I1574_P12_9n I1574_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I97_XP_MN0 (I1068_P31_30 I1068_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I97_XP_MN1 (VSS I1068_pn30 I1068_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I96_XP_MN0 (I1068_P30_29 I1068_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I96_XP_MN1 (VSS I1068_pn29 I1068_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I91_XP_MN0 (I1068_P25_24 I1068_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I91_XP_MN1 (VSS I1068_pn24 I1068_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I90_XP_MN0 (I1068_P24_23 I1068_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I90_XP_MN1 (VSS I1068_pn23 I1068_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
