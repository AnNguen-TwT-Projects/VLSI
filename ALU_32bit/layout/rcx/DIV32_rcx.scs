    I_MXI930_I90_XG_MP1 (I930_G24_23 I930_gn23 XI930_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I91_XG_MP2 (VDD I930_gn25 I930_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I91_XG_MP0 (XI930_I91_XG_p1 I930_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I91_XG_MP1 (I930_G25_24 I930_gn24 XI930_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I156_XG_MP2 (VDD I930_G31_28n I930_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I156_XG_MP0 (XI930_I156_XG_p1 I930_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I156_XG_MP1 (I930_G31_24 I930_G27_24n XI930_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I154_XG_MP2 (VDD I930_G29_26n I930_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I154_XG_MP0 (XI930_I154_XG_p1 I930_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I154_XG_MP1 (I930_G29_22 I930_G25_22n XI930_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I92_XG_MP2 (VDD I1666_gn26 I1666_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I92_XG_MP0 (XI1666_I92_XG_p1 I1666_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I92_XG_MP1 (I1666_G26_25 I1666_gn25 XI1666_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I93_XG_MP2 (VDD I1666_gn27 I1666_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I93_XG_MP0 (XI1666_I93_XG_p1 I1666_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I93_XG_MP1 (I1666_G27_26 I1666_gn26 XI1666_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I94_XG_MP2 (VDD I1666_gn28 I1666_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I94_XG_MP0 (XI1666_I94_XG_p1 I1666_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I94_XG_MP1 (I1666_G28_27 I1666_gn27 XI1666_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I156_XG_MP2 (VDD I1666_G31_28n I1666_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I156_XG_MP0 (XI1666_I156_XG_p1 I1666_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I156_XG_MP1 (I1666_G31_24 I1666_G27_24n XI1666_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I202_XG_MP2 (VDD I1666_G31_16n c24_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I202_XG_MP0 (XI1666_I202_XG_p1 I1666_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I202_XG_MP1 (c24_o I1666_G15_0n XI1666_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I202_XG_MP2 (VDD I1620_G31_16n c23_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I202_XG_MP0 (XI1620_I202_XG_p1 I1620_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I202_XG_MP1 (c23_o I1620_G15_0n XI1620_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I198_XG_MP2 (VDD I1620_G27_12n I1620_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I198_XG_MP0 (XI1620_I198_XG_p1 I1620_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I198_XG_MP1 (I1620_G27_0 I1620_G11_0n XI1620_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I152_XG_MP2 (VDD I1620_G27_24n I1620_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I152_XG_MP0 (XI1620_I152_XG_p1 I1620_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I152_XG_MP1 (I1620_G27_20 I1620_G23_20n XI1620_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I154_XG_MP2 (VDD I1620_G29_26n I1620_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I154_XG_MP0 (XI1620_I154_XG_p1 I1620_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I154_XG_MP1 (I1620_G29_22 I1620_G25_22n XI1620_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I201_XG_MP2 (VDD I1620_G30_15n c23_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I201_XG_MP0 (XI1620_I201_XG_p1 I1620_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I201_XG_MP1 (c23_m I1620_G14_0n XI1620_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I155_XG_MP2 (VDD I1620_G30_27n I1620_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I155_XG_MP0 (XI1620_I155_XG_p1 I1620_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I155_XG_MP1 (I1620_G30_23 I1620_G26_23n XI1620_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I92_XG_MP2 (VDD I1620_gn26 I1620_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I92_XG_MP0 (XI1620_I92_XG_p1 I1620_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I92_XG_MP1 (I1620_G26_25 I1620_gn25 XI1620_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I91_XG_MP2 (VDD I1620_gn25 I1620_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I91_XG_MP0 (XI1620_I91_XG_p1 I1620_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I91_XG_MP1 (I1620_G25_24 I1620_gn24 XI1620_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I202_XG_MP2 (VDD I1574_G31_16n c22_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I202_XG_MP0 (XI1574_I202_XG_p1 I1574_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I202_XG_MP1 (c22_o I1574_G15_0n XI1574_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I156_XG_MP2 (VDD I1574_G31_28n I1574_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I156_XG_MP0 (XI1574_I156_XG_p1 I1574_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I156_XG_MP1 (I1574_G31_24 I1574_G27_24n XI1574_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I154_XG_MP2 (VDD I1574_G29_26n I1574_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I154_XG_MP0 (XI1574_I154_XG_p1 I1574_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I154_XG_MP1 (I1574_G29_22 I1574_G25_22n XI1574_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I90_XG_MP2 (VDD I1574_gn24 I1574_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I90_XG_MP0 (XI1574_I90_XG_p1 I1574_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I90_XG_MP1 (I1574_G24_23 I1574_gn23 XI1574_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I91_XG_MP2 (VDD I1574_gn25 I1574_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I91_XG_MP0 (XI1574_I91_XG_p1 I1574_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I91_XG_MP1 (I1574_G25_24 I1574_gn24 XI1574_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I97_XG_MP2 (VDD I1114_gn31 I1114_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I97_XG_MP0 (XI1114_I97_XG_p1 I1114_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I97_XG_MP1 (I1114_G31_30 I1114_gn30 XI1114_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I201_XG_MP2 (VDD I1114_G30_15n c12_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I201_XG_MP0 (XI1114_I201_XG_p1 I1114_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I201_XG_MP1 (c12_m I1114_G14_0n XI1114_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I199_XG_MP2 (VDD I1114_G28_13n I1114_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I199_XG_MP0 (XI1114_I199_XG_p1 I1114_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I199_XG_MP1 (I1114_G28_0 I1114_G12_0n XI1114_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I147_XG_MP2 (VDD I1114_G22_19n I1114_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I147_XG_MP0 (XI1114_I147_XG_p1 I1114_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I147_XG_MP1 (I1114_G22_15 I1114_G18_15n XI1114_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I139_XG_MP2 (VDD I1114_G14_11n I1114_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I139_XG_MP0 (XI1114_I139_XG_p1 I1114_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I139_XG_MP1 (I1114_G14_7 I1114_G10_7n XI1114_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I137_XG_MP2 (VDD I1114_G12_9n I1114_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I137_XG_MP0 (XI1114_I137_XG_p1 I1114_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I137_XG_MP1 (I1114_G12_5 I1114_G8_5n XI1114_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I135_XG_MP2 (VDD I1114_G10_7n I1114_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I135_XG_MP0 (XI1114_I135_XG_p1 I1114_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I135_XG_MP1 (I1114_G10_3 I1114_G6_3n XI1114_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I72_XG_MP2 (VDD I1114_gn6 I1114_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I72_XG_MP0 (XI1114_I72_XG_p1 I1114_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I72_XG_MP1 (I1114_G6_5 I1114_gn5 XI1114_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I71_XG_MP2 (VDD I1114_gn5 I1114_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I71_XG_MP0 (XI1114_I71_XG_p1 I1114_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I71_XG_MP1 (I1114_G5_4 I1114_gn4 XI1114_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I70_XG_MP2 (VDD I1114_gn4 I1114_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I70_XG_MP0 (XI1114_I70_XG_p1 I1114_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I70_XG_MP1 (I1114_G4_3 I1114_gn3 XI1114_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1068_I65_XG_MP2 (VDD I1068_gn0 I1068_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1068_I65_XG_MP0 (XI1068_I65_XG_p1 I1068_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1068_I65_XG_MP1 (I1068_G0_0 I1068_cinn XI1068_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I156_XG_MP2 (VDD I1022_G31_28n I1022_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I156_XG_MP0 (XI1022_I156_XG_p1 I1022_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I156_XG_MP1 (I1022_G31_24 I1022_G27_24n XI1022_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I94_XG_MP2 (VDD I1022_gn28 I1022_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I94_XG_MP0 (XI1022_I94_XG_p1 I1022_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I94_XG_MP1 (I1022_G28_27 I1022_gn27 XI1022_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I93_XG_MP2 (VDD I1022_gn27 I1022_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I93_XG_MP0 (XI1022_I93_XG_p1 I1022_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I93_XG_MP1 (I1022_G27_26 I1022_gn26 XI1022_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I92_XG_MP2 (VDD I1022_gn26 I1022_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I92_XG_MP0 (XI1022_I92_XG_p1 I1022_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I92_XG_MP1 (I1022_G26_25 I1022_gn25 XI1022_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I197_XG_MP2 (VDD I976_G26_11n I976_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I197_XG_MP0 (XI976_I197_XG_p1 I976_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I197_XG_MP1 (I976_G26_0 I976_G10_0n XI976_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I151_XG_MP2 (VDD I976_G26_23n I976_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I151_XG_MP0 (XI976_I151_XG_p1 I976_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I151_XG_MP1 (I976_G26_19 I976_G22_19n XI976_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I198_XG_MP2 (VDD I976_G27_12n I976_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I198_XG_MP0 (XI976_I198_XG_p1 I976_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I198_XG_MP1 (I976_G27_0 I976_G11_0n XI976_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I148_XG_MP2 (VDD I976_G23_20n I976_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I148_XG_MP0 (XI976_I148_XG_p1 I976_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I148_XG_MP1 (I976_G23_16 I976_G19_16n XI976_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I152_XG_MP2 (VDD I976_G27_24n I976_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I152_XG_MP0 (XI976_I152_XG_p1 I976_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I152_XG_MP1 (I976_G27_20 I976_G23_20n XI976_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I90_XG_MP2 (VDD I976_gn24 I976_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I90_XG_MP0 (XI976_I90_XG_p1 I976_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I90_XG_MP1 (I976_G24_23 I976_gn23 XI976_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I89_XG_MP2 (VDD I976_gn23 I976_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I89_XG_MP0 (XI976_I89_XG_p1 I976_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I89_XG_MP1 (I976_G23_22 I976_gn22 XI976_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I91_XG_MP2 (VDD I976_gn25 I976_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I91_XG_MP0 (XI976_I91_XG_p1 I976_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I91_XG_MP1 (I976_G25_24 I976_gn24 XI976_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I155_XG_MP2 (VDD I930_G30_27n I930_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I155_XG_MP0 (XI930_I155_XG_p1 I930_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I155_XG_MP1 (I930_G30_23 I930_G26_23n XI930_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I92_XG_MP2 (VDD I930_gn26 I930_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I92_XG_MP0 (XI930_I92_XG_p1 I930_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I92_XG_MP1 (I930_G26_25 I930_gn25 XI930_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I93_XG_MP2 (VDD I930_gn27 I930_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I93_XG_MP0 (XI930_I93_XG_p1 I930_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I93_XG_MP1 (I930_G27_26 I930_gn26 XI930_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I95_XG_MP2 (VDD I1666_gn29 I1666_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I95_XG_MP0 (XI1666_I95_XG_p1 I1666_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I95_XG_MP1 (I1666_G29_28 I1666_gn28 XI1666_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I96_XG_MP2 (VDD I1666_gn30 I1666_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I96_XG_MP0 (XI1666_I96_XG_p1 I1666_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I96_XG_MP1 (I1666_G30_29 I1666_gn29 XI1666_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1666_I97_XG_MP2 (VDD I1666_gn31 I1666_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1666_I97_XG_MP0 (XI1666_I97_XG_p1 I1666_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1666_I97_XG_MP1 (I1666_G31_30 I1666_gn30 XI1666_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I156_XG_MP2 (VDD I1620_G31_28n I1620_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I156_XG_MP0 (XI1620_I156_XG_p1 I1620_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I156_XG_MP1 (I1620_G31_24 I1620_G27_24n XI1620_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I94_XG_MP2 (VDD I1620_gn28 I1620_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I94_XG_MP0 (XI1620_I94_XG_p1 I1620_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I94_XG_MP1 (I1620_G28_27 I1620_gn27 XI1620_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I93_XG_MP2 (VDD I1620_gn27 I1620_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I93_XG_MP0 (XI1620_I93_XG_p1 I1620_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I93_XG_MP1 (I1620_G27_26 I1620_gn26 XI1620_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I92_XG_MP2 (VDD I1574_gn26 I1574_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I92_XG_MP0 (XI1574_I92_XG_p1 I1574_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I92_XG_MP1 (I1574_G26_25 I1574_gn25 XI1574_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I192_XG_MP2 (VDD I1114_G22_7n I1114_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I192_XG_MP0 (XI1114_I192_XG_p1 I1114_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I192_XG_MP1 (I1114_G22_0 I1114_G6_0n XI1114_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I197_XG_MP2 (VDD I1114_G26_11n I1114_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I197_XG_MP0 (XI1114_I197_XG_p1 I1114_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I197_XG_MP1 (I1114_G26_0 I1114_G10_0n XI1114_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I188_XG_MP2 (VDD I1114_G20_5n I1114_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I188_XG_MP0 (XI1114_I188_XG_p1 I1114_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I188_XG_MP1 (I1114_G20_0 I1114_G4_0n XI1114_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I195_XG_MP2 (VDD I1114_G24_9n I1114_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I195_XG_MP0 (XI1114_I195_XG_p1 I1114_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I195_XG_MP1 (I1114_G24_0 I1114_G8_0n XI1114_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I185_XG_MP2 (VDD I1114_G18_3n I1114_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I185_XG_MP0 (XI1114_I185_XG_p1 I1114_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I185_XG_MP1 (I1114_G18_0 I1114_G2_0n XI1114_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I183_XG_MP2 (VDD I1114_G16_1n I1114_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I183_XG_MP0 (XI1114_I183_XG_p1 I1114_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I183_XG_MP1 (I1114_G16_0 I1114_G0_0n XI1114_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I133_XG_MP2 (VDD I1114_G8_5n I1114_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I133_XG_MP0 (XI1114_I133_XG_p1 I1114_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I133_XG_MP1 (I1114_G8_1 I1114_G4_1n XI1114_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I131_XG_MP2 (VDD I1114_G6_3n I1114_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I131_XG_MP0 (XI1114_I131_XG_p1 I1114_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I131_XG_MP1 (I1114_G6_0 I1114_G2_0n XI1114_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I128_XG_MP2 (VDD I1114_G4_1n I1114_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I128_XG_MP0 (XI1114_I128_XG_p1 I1114_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I128_XG_MP1 (I1114_G4_0 I1114_G0_0n XI1114_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I69_XG_MP2 (VDD I1114_gn3 I1114_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I69_XG_MP0 (XI1114_I69_XG_p1 I1114_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I69_XG_MP1 (I1114_G3_2 I1114_gn2 XI1114_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I97_XG_MP2 (VDD I1022_gn31 I1022_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I97_XG_MP0 (XI1022_I97_XG_p1 I1022_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I97_XG_MP1 (I1022_G31_30 I1022_gn30 XI1022_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I96_XG_MP2 (VDD I1022_gn30 I1022_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I96_XG_MP0 (XI1022_I96_XG_p1 I1022_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I96_XG_MP1 (I1022_G30_29 I1022_gn29 XI1022_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I95_XG_MP2 (VDD I1022_gn29 I1022_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I95_XG_MP0 (XI1022_I95_XG_p1 I1022_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I95_XG_MP1 (I1022_G29_28 I1022_gn28 XI1022_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I199_XG_MP2 (VDD I976_G28_13n I976_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I199_XG_MP0 (XI976_I199_XG_p1 I976_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I199_XG_MP1 (I976_G28_0 I976_G12_0n XI976_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I153_XG_MP2 (VDD I976_G28_25n I976_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I153_XG_MP0 (XI976_I153_XG_p1 I976_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I153_XG_MP1 (I976_G28_21 I976_G24_21n XI976_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I200_XG_MP2 (VDD I976_G29_14n I976_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I200_XG_MP0 (XI976_I200_XG_p1 I976_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I200_XG_MP1 (I976_G29_0 I976_G13_0n XI976_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I154_XG_MP2 (VDD I976_G29_26n I976_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I154_XG_MP0 (XI976_I154_XG_p1 I976_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I154_XG_MP1 (I976_G29_22 I976_G25_22n XI976_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I92_XG_MP2 (VDD I976_gn26 I976_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I92_XG_MP0 (XI976_I92_XG_p1 I976_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I92_XG_MP1 (I976_G26_25 I976_gn25 XI976_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I93_XG_MP2 (VDD I976_gn27 I976_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I93_XG_MP0 (XI976_I93_XG_p1 I976_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I93_XG_MP1 (I976_G27_26 I976_gn26 XI976_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I201_XG_MP2 (VDD I930_G30_15n c8_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I201_XG_MP0 (XI930_I201_XG_p1 I930_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I201_XG_MP1 (c8_m I930_G14_0n XI930_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I94_XG_MP2 (VDD I930_gn28 I930_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I94_XG_MP0 (XI930_I94_XG_p1 I930_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I94_XG_MP1 (I930_G28_27 I930_gn27 XI930_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I97_XG_MP2 (VDD I1620_gn31 I1620_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I97_XG_MP0 (XI1620_I97_XG_p1 I1620_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I97_XG_MP1 (I1620_G31_30 I1620_gn30 XI1620_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I96_XG_MP2 (VDD I1620_gn30 I1620_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I96_XG_MP0 (XI1620_I96_XG_p1 I1620_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I96_XG_MP1 (I1620_G30_29 I1620_gn29 XI1620_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1620_I95_XG_MP2 (VDD I1620_gn29 I1620_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1620_I95_XG_MP0 (XI1620_I95_XG_p1 I1620_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1620_I95_XG_MP1 (I1620_G29_28 I1620_gn28 XI1620_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I65_XG_MP2 (VDD I1528_gn0 I1528_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I65_XG_MP0 (XI1528_I65_XG_p1 I1528_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I65_XG_MP1 (I1528_G0_0 I1528_cinn XI1528_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I97_XG_MP2 (VDD I1574_gn31 I1574_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I97_XG_MP0 (XI1574_I97_XG_p1 I1574_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I97_XG_MP1 (I1574_G31_30 I1574_gn30 XI1574_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I96_XG_MP2 (VDD I1574_gn30 I1574_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I96_XG_MP0 (XI1574_I96_XG_p1 I1574_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I96_XG_MP1 (I1574_G30_29 I1574_gn29 XI1574_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I95_XG_MP2 (VDD I1574_gn29 I1574_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I95_XG_MP0 (XI1574_I95_XG_p1 I1574_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I95_XG_MP1 (I1574_G29_28 I1574_gn28 XI1574_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I93_XG_MP2 (VDD I1574_gn27 I1574_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I93_XG_MP0 (XI1574_I93_XG_p1 I1574_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I93_XG_MP1 (I1574_G27_26 I1574_gn26 XI1574_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I94_XG_MP2 (VDD I1574_gn28 I1574_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I94_XG_MP0 (XI1574_I94_XG_p1 I1574_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I94_XG_MP1 (I1574_G28_27 I1574_gn27 XI1574_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I154_XG_MP2 (VDD I1114_G29_26n I1114_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I154_XG_MP0 (XI1114_I154_XG_p1 I1114_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I154_XG_MP1 (I1114_G29_22 I1114_G25_22n XI1114_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I150_XG_MP2 (VDD I1114_G25_22n I1114_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I150_XG_MP0 (XI1114_I150_XG_p1 I1114_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I150_XG_MP1 (I1114_G25_18 I1114_G21_18n XI1114_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I146_XG_MP2 (VDD I1114_G21_18n I1114_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I146_XG_MP0 (XI1114_I146_XG_p1 I1114_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I146_XG_MP1 (I1114_G21_14 I1114_G17_14n XI1114_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I67_XG_MP2 (VDD I1114_gn1 I1114_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I67_XG_MP0 (XI1114_I67_XG_p1 I1114_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I67_XG_MP1 (I1114_G1_0 I1114_G0_0n XI1114_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I68_XG_MP2 (VDD I1114_gn2 I1114_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I68_XG_MP0 (XI1114_I68_XG_p1 I1114_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I68_XG_MP1 (I1114_G2_1 I1114_gn1 XI1114_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I201_XG_MP2 (VDD I976_G30_15n c9_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I201_XG_MP0 (XI976_I201_XG_p1 I976_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I201_XG_MP1 (c9_m I976_G14_0n XI976_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I155_XG_MP2 (VDD I976_G30_27n I976_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I155_XG_MP0 (XI976_I155_XG_p1 I976_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I155_XG_MP1 (I976_G30_23 I976_G26_23n XI976_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I202_XG_MP2 (VDD I976_G31_16n c9_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I202_XG_MP0 (XI976_I202_XG_p1 I976_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I202_XG_MP1 (c9_o I976_G15_0n XI976_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I156_XG_MP2 (VDD I976_G31_28n I976_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I156_XG_MP0 (XI976_I156_XG_p1 I976_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I156_XG_MP1 (I976_G31_24 I976_G27_24n XI976_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I95_XG_MP2 (VDD I976_gn29 I976_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I95_XG_MP0 (XI976_I95_XG_p1 I976_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I95_XG_MP1 (I976_G29_28 I976_gn28 XI976_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I94_XG_MP2 (VDD I976_gn28 I976_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I94_XG_MP0 (XI976_I94_XG_p1 I976_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I94_XG_MP1 (I976_G28_27 I976_gn27 XI976_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I97_XG_MP2 (VDD I930_gn31 I930_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I97_XG_MP0 (XI930_I97_XG_p1 I930_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I97_XG_MP1 (I930_G31_30 I930_gn30 XI930_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I96_XG_MP2 (VDD I930_gn30 I930_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I96_XG_MP0 (XI930_I96_XG_p1 I930_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I96_XG_MP1 (I930_G30_29 I930_gn29 XI930_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I95_XG_MP2 (VDD I930_gn29 I930_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I95_XG_MP0 (XI930_I95_XG_p1 I930_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I95_XG_MP1 (I930_G29_28 I930_gn28 XI930_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I65_XG_MP2 (VDD I1344_gn0 I1344_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I65_XG_MP0 (XI1344_I65_XG_p1 I1344_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I65_XG_MP1 (I1344_G0_0 I1344_cinn XI1344_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I65_XG_MP2 (VDD I1390_gn0 I1390_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I65_XG_MP0 (XI1390_I65_XG_p1 I1390_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I65_XG_MP1 (I1390_G0_0 I1390_cinn XI1390_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I65_XG_MP2 (VDD I1436_gn0 I1436_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I65_XG_MP0 (XI1436_I65_XG_p1 I1436_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I65_XG_MP1 (I1436_G0_0 I1436_cinn XI1436_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I65_XG_MP2 (VDD I1482_gn0 I1482_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I65_XG_MP0 (XI1482_I65_XG_p1 I1482_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I65_XG_MP1 (I1482_G0_0 I1482_cinn XI1482_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I69_XG_MP2 (VDD I1528_gn3 I1528_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I69_XG_MP0 (XI1528_I69_XG_p1 I1528_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I69_XG_MP1 (I1528_G3_2 I1528_gn2 XI1528_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I68_XG_MP2 (VDD I1528_gn2 I1528_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I68_XG_MP0 (XI1528_I68_XG_p1 I1528_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I68_XG_MP1 (I1528_G2_1 I1528_gn1 XI1528_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I67_XG_MP2 (VDD I1528_gn1 I1528_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I67_XG_MP0 (XI1528_I67_XG_p1 I1528_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I67_XG_MP1 (I1528_G1_0 I1528_G0_0n XI1528_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I183_XG_MP2 (VDD I1528_G16_1n I1528_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I183_XG_MP0 (XI1528_I183_XG_p1 I1528_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I183_XG_MP1 (I1528_G16_0 I1528_G0_0n XI1528_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I156_XG_MP2 (VDD I1114_G31_28n I1114_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I156_XG_MP0 (XI1114_I156_XG_p1 I1114_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I156_XG_MP1 (I1114_G31_24 I1114_G27_24n XI1114_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I152_XG_MP2 (VDD I1114_G27_24n I1114_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I152_XG_MP0 (XI1114_I152_XG_p1 I1114_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I152_XG_MP1 (I1114_G27_20 I1114_G23_20n XI1114_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I148_XG_MP2 (VDD I1114_G23_20n I1114_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I148_XG_MP0 (XI1114_I148_XG_p1 I1114_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I148_XG_MP1 (I1114_G23_16 I1114_G19_16n XI1114_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I200_XG_MP2 (VDD I1114_G29_14n I1114_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I200_XG_MP0 (XI1114_I200_XG_p1 I1114_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I200_XG_MP1 (I1114_G29_0 I1114_G13_0n XI1114_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I196_XG_MP2 (VDD I1114_G25_10n I1114_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I196_XG_MP0 (XI1114_I196_XG_p1 I1114_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I196_XG_MP1 (I1114_G25_0 I1114_G9_0n XI1114_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I142_XG_MP2 (VDD I1114_G17_14n I1114_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I142_XG_MP0 (XI1114_I142_XG_p1 I1114_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I142_XG_MP1 (I1114_G17_10 I1114_G13_10n XI1114_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I138_XG_MP2 (VDD I1114_G13_10n I1114_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I138_XG_MP0 (XI1114_I138_XG_p1 I1114_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I138_XG_MP1 (I1114_G13_6 I1114_G9_6n XI1114_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I184_XG_MP2 (VDD I1114_G17_2n I1114_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I184_XG_MP0 (XI1114_I184_XG_p1 I1114_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I184_XG_MP1 (I1114_G17_0 I1114_G1_0n XI1114_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I134_XG_MP2 (VDD I1114_G9_6n I1114_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I134_XG_MP0 (XI1114_I134_XG_p1 I1114_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I134_XG_MP1 (I1114_G9_2 I1114_G5_2n XI1114_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I130_XG_MP2 (VDD I1114_G5_2n I1114_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I130_XG_MP0 (XI1114_I130_XG_p1 I1114_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I130_XG_MP1 (I1114_G5_0 I1114_G1_0n XI1114_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I65_XG_MP2 (VDD I1114_gn0 I1114_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I65_XG_MP0 (XI1114_I65_XG_p1 I1114_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I65_XG_MP1 (I1114_G0_0 I1114_cinn XI1114_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I97_XG_MP2 (VDD I976_gn31 I976_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I97_XG_MP0 (XI976_I97_XG_p1 I976_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I97_XG_MP1 (I976_G31_30 I976_gn30 XI976_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I96_XG_MP2 (VDD I976_gn30 I976_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I96_XG_MP0 (XI976_I96_XG_p1 I976_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I96_XG_MP1 (I976_G30_29 I976_gn29 XI976_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I68_XG_MP2 (VDD I1482_gn2 I1482_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I68_XG_MP0 (XI1482_I68_XG_p1 I1482_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I68_XG_MP1 (I1482_G2_1 I1482_gn1 XI1482_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I67_XG_MP2 (VDD I1482_gn1 I1482_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I67_XG_MP0 (XI1482_I67_XG_p1 I1482_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I67_XG_MP1 (I1482_G1_0 I1482_G0_0n XI1482_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I71_XG_MP2 (VDD I1528_gn5 I1528_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I71_XG_MP0 (XI1528_I71_XG_p1 I1528_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I71_XG_MP1 (I1528_G5_4 I1528_gn4 XI1528_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I70_XG_MP2 (VDD I1528_gn4 I1528_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I70_XG_MP0 (XI1528_I70_XG_p1 I1528_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I70_XG_MP1 (I1528_G4_3 I1528_gn3 XI1528_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I128_XG_MP2 (VDD I1528_G4_1n I1528_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I128_XG_MP0 (XI1528_I128_XG_p1 I1528_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I128_XG_MP1 (I1528_G4_0 I1528_G0_0n XI1528_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I184_XG_MP2 (VDD I1528_G17_2n I1528_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I184_XG_MP0 (XI1528_I184_XG_p1 I1528_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I184_XG_MP1 (I1528_G17_0 I1528_G1_0n XI1528_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I202_XG_MP2 (VDD I1114_G31_16n c12_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I202_XG_MP0 (XI1114_I202_XG_p1 I1114_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I202_XG_MP1 (c12_o I1114_G15_0n XI1114_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I198_XG_MP2 (VDD I1114_G27_12n I1114_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I198_XG_MP0 (XI1114_I198_XG_p1 I1114_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I198_XG_MP1 (I1114_G27_0 I1114_G11_0n XI1114_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I190_XG_MP2 (VDD I1114_G21_6n I1114_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I190_XG_MP0 (XI1114_I190_XG_p1 I1114_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I190_XG_MP1 (I1114_G21_0 I1114_G5_0n XI1114_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I144_XG_MP2 (VDD I1114_G19_16n I1114_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I144_XG_MP0 (XI1114_I144_XG_p1 I1114_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I144_XG_MP1 (I1114_G19_12 I1114_G15_12n XI1114_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I140_XG_MP2 (VDD I1114_G15_12n I1114_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I140_XG_MP0 (XI1114_I140_XG_p1 I1114_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I140_XG_MP1 (I1114_G15_8 I1114_G11_8n XI1114_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I136_XG_MP2 (VDD I1114_G11_8n I1114_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I136_XG_MP0 (XI1114_I136_XG_p1 I1114_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I136_XG_MP1 (I1114_G11_4 I1114_G7_4n XI1114_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I132_XG_MP2 (VDD I1114_G7_4n I1114_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I132_XG_MP0 (XI1114_I132_XG_p1 I1114_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I132_XG_MP1 (I1114_G7_0 I1114_G3_0n XI1114_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I65_XG_MP2 (VDD I1160_gn0 I1160_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I65_XG_MP0 (XI1160_I65_XG_p1 I1160_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I65_XG_MP1 (I1160_G0_0 I1160_cinn XI1160_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I65_XG_MP2 (VDD I1206_gn0 I1206_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I65_XG_MP0 (XI1206_I65_XG_p1 I1206_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I65_XG_MP1 (I1206_G0_0 I1206_cinn XI1206_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I65_XG_MP2 (VDD I1252_gn0 I1252_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I65_XG_MP0 (XI1252_I65_XG_p1 I1252_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I65_XG_MP1 (I1252_G0_0 I1252_cinn XI1252_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I68_XG_MP2 (VDD I1298_gn2 I1298_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I68_XG_MP0 (XI1298_I68_XG_p1 I1298_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I68_XG_MP1 (I1298_G2_1 I1298_gn1 XI1298_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I67_XG_MP2 (VDD I1298_gn1 I1298_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I67_XG_MP0 (XI1298_I67_XG_p1 I1298_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I67_XG_MP1 (I1298_G1_0 I1298_G0_0n XI1298_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I65_XG_MP2 (VDD I1298_gn0 I1298_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I65_XG_MP0 (XI1298_I65_XG_p1 I1298_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I65_XG_MP1 (I1298_G0_0 I1298_cinn XI1298_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I71_XG_MP2 (VDD I1344_gn5 I1344_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I71_XG_MP0 (XI1344_I71_XG_p1 I1344_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I71_XG_MP1 (I1344_G5_4 I1344_gn4 XI1344_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I70_XG_MP2 (VDD I1344_gn4 I1344_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I70_XG_MP0 (XI1344_I70_XG_p1 I1344_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I70_XG_MP1 (I1344_G4_3 I1344_gn3 XI1344_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I69_XG_MP2 (VDD I1344_gn3 I1344_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I69_XG_MP0 (XI1344_I69_XG_p1 I1344_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I69_XG_MP1 (I1344_G3_2 I1344_gn2 XI1344_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I68_XG_MP2 (VDD I1344_gn2 I1344_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I68_XG_MP0 (XI1344_I68_XG_p1 I1344_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I68_XG_MP1 (I1344_G2_1 I1344_gn1 XI1344_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I67_XG_MP2 (VDD I1344_gn1 I1344_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I67_XG_MP0 (XI1344_I67_XG_p1 I1344_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I67_XG_MP1 (I1344_G1_0 I1344_G0_0n XI1344_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I70_XG_MP2 (VDD I1390_gn4 I1390_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I70_XG_MP0 (XI1390_I70_XG_p1 I1390_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I70_XG_MP1 (I1390_G4_3 I1390_gn3 XI1390_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I69_XG_MP2 (VDD I1390_gn3 I1390_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I69_XG_MP0 (XI1390_I69_XG_p1 I1390_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I69_XG_MP1 (I1390_G3_2 I1390_gn2 XI1390_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I68_XG_MP2 (VDD I1390_gn2 I1390_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I68_XG_MP0 (XI1390_I68_XG_p1 I1390_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I68_XG_MP1 (I1390_G2_1 I1390_gn1 XI1390_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I67_XG_MP2 (VDD I1390_gn1 I1390_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I67_XG_MP0 (XI1390_I67_XG_p1 I1390_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I67_XG_MP1 (I1390_G1_0 I1390_G0_0n XI1390_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I70_XG_MP2 (VDD I1436_gn4 I1436_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I70_XG_MP0 (XI1436_I70_XG_p1 I1436_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I70_XG_MP1 (I1436_G4_3 I1436_gn3 XI1436_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I69_XG_MP2 (VDD I1436_gn3 I1436_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I69_XG_MP0 (XI1436_I69_XG_p1 I1436_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I69_XG_MP1 (I1436_G3_2 I1436_gn2 XI1436_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I68_XG_MP2 (VDD I1436_gn2 I1436_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I68_XG_MP0 (XI1436_I68_XG_p1 I1436_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I68_XG_MP1 (I1436_G2_1 I1436_gn1 XI1436_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I67_XG_MP2 (VDD I1436_gn1 I1436_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I67_XG_MP0 (XI1436_I67_XG_p1 I1436_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I67_XG_MP1 (I1436_G1_0 I1436_G0_0n XI1436_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I70_XG_MP2 (VDD I1482_gn4 I1482_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I70_XG_MP0 (XI1482_I70_XG_p1 I1482_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I70_XG_MP1 (I1482_G4_3 I1482_gn3 XI1482_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I69_XG_MP2 (VDD I1482_gn3 I1482_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I69_XG_MP0 (XI1482_I69_XG_p1 I1482_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I69_XG_MP1 (I1482_G3_2 I1482_gn2 XI1482_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I72_XG_MP2 (VDD I1528_gn6 I1528_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I72_XG_MP0 (XI1528_I72_XG_p1 I1528_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I72_XG_MP1 (I1528_G6_5 I1528_gn5 XI1528_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I73_XG_MP2 (VDD I1528_gn7 I1528_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I73_XG_MP0 (XI1528_I73_XG_p1 I1528_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I73_XG_MP1 (I1528_G7_6 I1528_gn6 XI1528_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I131_XG_MP2 (VDD I1528_G6_3n I1528_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I131_XG_MP0 (XI1528_I131_XG_p1 I1528_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I131_XG_MP1 (I1528_G6_0 I1528_G2_0n XI1528_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I133_XG_MP2 (VDD I1528_G8_5n I1528_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I133_XG_MP0 (XI1528_I133_XG_p1 I1528_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I133_XG_MP1 (I1528_G8_1 I1528_G4_1n XI1528_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I195_XG_MP2 (VDD I1528_G24_9n I1528_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I195_XG_MP0 (XI1528_I195_XG_p1 I1528_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I195_XG_MP1 (I1528_G24_0 I1528_G8_0n XI1528_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I130_XG_MP2 (VDD I1528_G5_2n I1528_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I130_XG_MP0 (XI1528_I130_XG_p1 I1528_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I130_XG_MP1 (I1528_G5_0 I1528_G1_0n XI1528_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I134_XG_MP2 (VDD I1528_G9_6n I1528_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I134_XG_MP0 (XI1528_I134_XG_p1 I1528_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I134_XG_MP1 (I1528_G9_2 I1528_G5_2n XI1528_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I194_XG_MP2 (VDD I1114_G23_8n I1114_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I194_XG_MP0 (XI1114_I194_XG_p1 I1114_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I194_XG_MP1 (I1114_G23_0 I1114_G7_0n XI1114_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I186_XG_MP2 (VDD I1114_G19_4n I1114_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I186_XG_MP0 (XI1114_I186_XG_p1 I1114_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I186_XG_MP1 (I1114_G19_0 I1114_G3_0n XI1114_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I68_XG_MP2 (VDD I1252_gn2 I1252_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I68_XG_MP0 (XI1252_I68_XG_p1 I1252_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I68_XG_MP1 (I1252_G2_1 I1252_gn1 XI1252_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I67_XG_MP2 (VDD I1252_gn1 I1252_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I67_XG_MP0 (XI1252_I67_XG_p1 I1252_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I67_XG_MP1 (I1252_G1_0 I1252_G0_0n XI1252_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I69_XG_MP2 (VDD I1298_gn3 I1298_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I69_XG_MP0 (XI1298_I69_XG_p1 I1298_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I69_XG_MP1 (I1298_G3_2 I1298_gn2 XI1298_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I70_XG_MP2 (VDD I1298_gn4 I1298_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I70_XG_MP0 (XI1298_I70_XG_p1 I1298_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I70_XG_MP1 (I1298_G4_3 I1298_gn3 XI1298_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I72_XG_MP2 (VDD I1344_gn6 I1344_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I72_XG_MP0 (XI1344_I72_XG_p1 I1344_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I72_XG_MP1 (I1344_G6_5 I1344_gn5 XI1344_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I128_XG_MP2 (VDD I1344_G4_1n I1344_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I128_XG_MP0 (XI1344_I128_XG_p1 I1344_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I128_XG_MP1 (I1344_G4_0 I1344_G0_0n XI1344_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I72_XG_MP2 (VDD I1390_gn6 I1390_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I72_XG_MP0 (XI1390_I72_XG_p1 I1390_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I72_XG_MP1 (I1390_G6_5 I1390_gn5 XI1390_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I71_XG_MP2 (VDD I1390_gn5 I1390_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I71_XG_MP0 (XI1390_I71_XG_p1 I1390_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I71_XG_MP1 (I1390_G5_4 I1390_gn4 XI1390_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I128_XG_MP2 (VDD I1390_G4_1n I1390_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I128_XG_MP0 (XI1390_I128_XG_p1 I1390_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I128_XG_MP1 (I1390_G4_0 I1390_G0_0n XI1390_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I72_XG_MP2 (VDD I1436_gn6 I1436_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I72_XG_MP0 (XI1436_I72_XG_p1 I1436_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I72_XG_MP1 (I1436_G6_5 I1436_gn5 XI1436_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I71_XG_MP2 (VDD I1436_gn5 I1436_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I71_XG_MP0 (XI1436_I71_XG_p1 I1436_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I71_XG_MP1 (I1436_G5_4 I1436_gn4 XI1436_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I128_XG_MP2 (VDD I1436_G4_1n I1436_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I128_XG_MP0 (XI1436_I128_XG_p1 I1436_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I128_XG_MP1 (I1436_G4_0 I1436_G0_0n XI1436_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I71_XG_MP2 (VDD I1482_gn5 I1482_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I71_XG_MP0 (XI1482_I71_XG_p1 I1482_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I71_XG_MP1 (I1482_G5_4 I1482_gn4 XI1482_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I72_XG_MP2 (VDD I1482_gn6 I1482_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I72_XG_MP0 (XI1482_I72_XG_p1 I1482_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I72_XG_MP1 (I1482_G6_5 I1482_gn5 XI1482_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I74_XG_MP2 (VDD I1528_gn8 I1528_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I74_XG_MP0 (XI1528_I74_XG_p1 I1528_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I74_XG_MP1 (I1528_G8_7 I1528_gn7 XI1528_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I75_XG_MP2 (VDD I1528_gn9 I1528_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I75_XG_MP0 (XI1528_I75_XG_p1 I1528_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I75_XG_MP1 (I1528_G9_8 I1528_gn8 XI1528_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I137_XG_MP2 (VDD I1528_G12_9n I1528_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I137_XG_MP0 (XI1528_I137_XG_p1 I1528_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I137_XG_MP1 (I1528_G12_5 I1528_G8_5n XI1528_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I188_XG_MP2 (VDD I1528_G20_5n I1528_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I188_XG_MP0 (XI1528_I188_XG_p1 I1528_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I188_XG_MP1 (I1528_G20_0 I1528_G4_0n XI1528_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I132_XG_MP2 (VDD I1528_G7_4n I1528_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I132_XG_MP0 (XI1528_I132_XG_p1 I1528_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I132_XG_MP1 (I1528_G7_0 I1528_G3_0n XI1528_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I196_XG_MP2 (VDD I1528_G25_10n I1528_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I196_XG_MP0 (XI1528_I196_XG_p1 I1528_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I196_XG_MP1 (I1528_G25_0 I1528_G9_0n XI1528_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I87_XG_MP2 (VDD I1160_gn21 I1160_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I87_XG_MP0 (XI1160_I87_XG_p1 I1160_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I87_XG_MP1 (I1160_G21_20 I1160_gn20 XI1160_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I73_XG_MP2 (VDD I1160_gn7 I1160_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I73_XG_MP0 (XI1160_I73_XG_p1 I1160_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I73_XG_MP1 (I1160_G7_6 I1160_gn6 XI1160_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I72_XG_MP2 (VDD I1160_gn6 I1160_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I72_XG_MP0 (XI1160_I72_XG_p1 I1160_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I72_XG_MP1 (I1160_G6_5 I1160_gn5 XI1160_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I71_XG_MP2 (VDD I1160_gn5 I1160_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I71_XG_MP0 (XI1160_I71_XG_p1 I1160_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I71_XG_MP1 (I1160_G5_4 I1160_gn4 XI1160_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I70_XG_MP2 (VDD I1160_gn4 I1160_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I70_XG_MP0 (XI1160_I70_XG_p1 I1160_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I70_XG_MP1 (I1160_G4_3 I1160_gn3 XI1160_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I69_XG_MP2 (VDD I1160_gn3 I1160_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I69_XG_MP0 (XI1160_I69_XG_p1 I1160_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I69_XG_MP1 (I1160_G3_2 I1160_gn2 XI1160_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I67_XG_MP2 (VDD I1160_gn1 I1160_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I67_XG_MP0 (XI1160_I67_XG_p1 I1160_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I67_XG_MP1 (I1160_G1_0 I1160_G0_0n XI1160_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I68_XG_MP2 (VDD I1160_gn2 I1160_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I68_XG_MP0 (XI1160_I68_XG_p1 I1160_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I68_XG_MP1 (I1160_G2_1 I1160_gn1 XI1160_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I68_XG_MP2 (VDD I1206_gn2 I1206_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I68_XG_MP0 (XI1206_I68_XG_p1 I1206_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I68_XG_MP1 (I1206_G2_1 I1206_gn1 XI1206_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I67_XG_MP2 (VDD I1206_gn1 I1206_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I67_XG_MP0 (XI1206_I67_XG_p1 I1206_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I67_XG_MP1 (I1206_G1_0 I1206_G0_0n XI1206_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I70_XG_MP2 (VDD I1252_gn4 I1252_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I70_XG_MP0 (XI1252_I70_XG_p1 I1252_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I70_XG_MP1 (I1252_G4_3 I1252_gn3 XI1252_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I69_XG_MP2 (VDD I1252_gn3 I1252_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I69_XG_MP0 (XI1252_I69_XG_p1 I1252_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I69_XG_MP1 (I1252_G3_2 I1252_gn2 XI1252_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I72_XG_MP2 (VDD I1298_gn6 I1298_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I72_XG_MP0 (XI1298_I72_XG_p1 I1298_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I72_XG_MP1 (I1298_G6_5 I1298_gn5 XI1298_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I71_XG_MP2 (VDD I1298_gn5 I1298_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I71_XG_MP0 (XI1298_I71_XG_p1 I1298_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I71_XG_MP1 (I1298_G5_4 I1298_gn4 XI1298_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I128_XG_MP2 (VDD I1298_G4_1n I1298_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I128_XG_MP0 (XI1298_I128_XG_p1 I1298_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I128_XG_MP1 (I1298_G4_0 I1298_G0_0n XI1298_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I73_XG_MP2 (VDD I1344_gn7 I1344_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I73_XG_MP0 (XI1344_I73_XG_p1 I1344_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I73_XG_MP1 (I1344_G7_6 I1344_gn6 XI1344_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I74_XG_MP2 (VDD I1344_gn8 I1344_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I74_XG_MP0 (XI1344_I74_XG_p1 I1344_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I74_XG_MP1 (I1344_G8_7 I1344_gn7 XI1344_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I133_XG_MP2 (VDD I1344_G8_5n I1344_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I133_XG_MP0 (XI1344_I133_XG_p1 I1344_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I133_XG_MP1 (I1344_G8_1 I1344_G4_1n XI1344_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I130_XG_MP2 (VDD I1344_G5_2n I1344_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I130_XG_MP0 (XI1344_I130_XG_p1 I1344_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I130_XG_MP1 (I1344_G5_0 I1344_G1_0n XI1344_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I74_XG_MP2 (VDD I1390_gn8 I1390_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I74_XG_MP0 (XI1390_I74_XG_p1 I1390_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I74_XG_MP1 (I1390_G8_7 I1390_gn7 XI1390_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I73_XG_MP2 (VDD I1390_gn7 I1390_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I73_XG_MP0 (XI1390_I73_XG_p1 I1390_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I73_XG_MP1 (I1390_G7_6 I1390_gn6 XI1390_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I133_XG_MP2 (VDD I1390_G8_5n I1390_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I133_XG_MP0 (XI1390_I133_XG_p1 I1390_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I133_XG_MP1 (I1390_G8_1 I1390_G4_1n XI1390_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I130_XG_MP2 (VDD I1390_G5_2n I1390_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I130_XG_MP0 (XI1390_I130_XG_p1 I1390_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I130_XG_MP1 (I1390_G5_0 I1390_G1_0n XI1390_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I74_XG_MP2 (VDD I1436_gn8 I1436_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I74_XG_MP0 (XI1436_I74_XG_p1 I1436_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I74_XG_MP1 (I1436_G8_7 I1436_gn7 XI1436_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I73_XG_MP2 (VDD I1436_gn7 I1436_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I73_XG_MP0 (XI1436_I73_XG_p1 I1436_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I73_XG_MP1 (I1436_G7_6 I1436_gn6 XI1436_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I133_XG_MP2 (VDD I1436_G8_5n I1436_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I133_XG_MP0 (XI1436_I133_XG_p1 I1436_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I133_XG_MP1 (I1436_G8_1 I1436_G4_1n XI1436_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I131_XG_MP2 (VDD I1436_G6_3n I1436_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I131_XG_MP0 (XI1436_I131_XG_p1 I1436_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I131_XG_MP1 (I1436_G6_0 I1436_G2_0n XI1436_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I74_XG_MP2 (VDD I1482_gn8 I1482_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I74_XG_MP0 (XI1482_I74_XG_p1 I1482_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I74_XG_MP1 (I1482_G8_7 I1482_gn7 XI1482_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I73_XG_MP2 (VDD I1482_gn7 I1482_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I73_XG_MP0 (XI1482_I73_XG_p1 I1482_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I73_XG_MP1 (I1482_G7_6 I1482_gn6 XI1482_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I128_XG_MP2 (VDD I1482_G4_1n I1482_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I128_XG_MP0 (XI1482_I128_XG_p1 I1482_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I128_XG_MP1 (I1482_G4_0 I1482_G0_0n XI1482_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I76_XG_MP2 (VDD I1528_gn10 I1528_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I76_XG_MP0 (XI1528_I76_XG_p1 I1528_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I76_XG_MP1 (I1528_G10_9 I1528_gn9 XI1528_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I77_XG_MP2 (VDD I1528_gn11 I1528_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I77_XG_MP0 (XI1528_I77_XG_p1 I1528_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I77_XG_MP1 (I1528_G11_10 I1528_gn10 XI1528_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I135_XG_MP2 (VDD I1528_G10_7n I1528_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I135_XG_MP0 (XI1528_I135_XG_p1 I1528_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I135_XG_MP1 (I1528_G10_3 I1528_G6_3n XI1528_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I141_XG_MP2 (VDD I1528_G16_13n I1528_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I141_XG_MP0 (XI1528_I141_XG_p1 I1528_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I141_XG_MP1 (I1528_G16_9 I1528_G12_9n XI1528_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I136_XG_MP2 (VDD I1528_G11_8n I1528_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I136_XG_MP0 (XI1528_I136_XG_p1 I1528_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I136_XG_MP1 (I1528_G11_4 I1528_G7_4n XI1528_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I186_XG_MP2 (VDD I1528_G19_4n I1528_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I186_XG_MP0 (XI1528_I186_XG_p1 I1528_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I186_XG_MP1 (I1528_G19_0 I1528_G3_0n XI1528_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I89_XG_MP2 (VDD I1160_gn23 I1160_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I89_XG_MP0 (XI1160_I89_XG_p1 I1160_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I89_XG_MP1 (I1160_G23_22 I1160_gn22 XI1160_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I88_XG_MP2 (VDD I1160_gn22 I1160_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I88_XG_MP0 (XI1160_I88_XG_p1 I1160_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I88_XG_MP1 (I1160_G22_21 I1160_gn21 XI1160_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I86_XG_MP2 (VDD I1160_gn20 I1160_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I86_XG_MP0 (XI1160_I86_XG_p1 I1160_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I86_XG_MP1 (I1160_G20_19 I1160_gn19 XI1160_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I85_XG_MP2 (VDD I1160_gn19 I1160_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I85_XG_MP0 (XI1160_I85_XG_p1 I1160_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I85_XG_MP1 (I1160_G19_18 I1160_gn18 XI1160_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I84_XG_MP2 (VDD I1160_gn18 I1160_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I84_XG_MP0 (XI1160_I84_XG_p1 I1160_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I84_XG_MP1 (I1160_G18_17 I1160_gn17 XI1160_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I82_XG_MP2 (VDD I1160_gn16 I1160_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I82_XG_MP0 (XI1160_I82_XG_p1 I1160_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I82_XG_MP1 (I1160_G16_15 I1160_gn15 XI1160_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I83_XG_MP2 (VDD I1160_gn17 I1160_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I83_XG_MP0 (XI1160_I83_XG_p1 I1160_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I83_XG_MP1 (I1160_G17_16 I1160_gn16 XI1160_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I81_XG_MP2 (VDD I1160_gn15 I1160_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I81_XG_MP0 (XI1160_I81_XG_p1 I1160_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I81_XG_MP1 (I1160_G15_14 I1160_gn14 XI1160_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I80_XG_MP2 (VDD I1160_gn14 I1160_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I80_XG_MP0 (XI1160_I80_XG_p1 I1160_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I80_XG_MP1 (I1160_G14_13 I1160_gn13 XI1160_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I79_XG_MP2 (VDD I1160_gn13 I1160_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I79_XG_MP0 (XI1160_I79_XG_p1 I1160_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I79_XG_MP1 (I1160_G13_12 I1160_gn12 XI1160_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I78_XG_MP2 (VDD I1160_gn12 I1160_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I78_XG_MP0 (XI1160_I78_XG_p1 I1160_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I78_XG_MP1 (I1160_G12_11 I1160_gn11 XI1160_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I77_XG_MP2 (VDD I1160_gn11 I1160_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I77_XG_MP0 (XI1160_I77_XG_p1 I1160_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I77_XG_MP1 (I1160_G11_10 I1160_gn10 XI1160_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I76_XG_MP2 (VDD I1160_gn10 I1160_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I76_XG_MP0 (XI1160_I76_XG_p1 I1160_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I76_XG_MP1 (I1160_G10_9 I1160_gn9 XI1160_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I75_XG_MP2 (VDD I1160_gn9 I1160_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I75_XG_MP0 (XI1160_I75_XG_p1 I1160_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I75_XG_MP1 (I1160_G9_8 I1160_gn8 XI1160_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I74_XG_MP2 (VDD I1160_gn8 I1160_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I74_XG_MP0 (XI1160_I74_XG_p1 I1160_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I74_XG_MP1 (I1160_G8_7 I1160_gn7 XI1160_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I69_XG_MP2 (VDD I1206_gn3 I1206_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I69_XG_MP0 (XI1206_I69_XG_p1 I1206_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I69_XG_MP1 (I1206_G3_2 I1206_gn2 XI1206_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I72_XG_MP2 (VDD I1252_gn6 I1252_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I72_XG_MP0 (XI1252_I72_XG_p1 I1252_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I72_XG_MP1 (I1252_G6_5 I1252_gn5 XI1252_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I71_XG_MP2 (VDD I1252_gn5 I1252_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I71_XG_MP0 (XI1252_I71_XG_p1 I1252_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I71_XG_MP1 (I1252_G5_4 I1252_gn4 XI1252_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I128_XG_MP2 (VDD I1252_G4_1n I1252_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I128_XG_MP0 (XI1252_I128_XG_p1 I1252_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I128_XG_MP1 (I1252_G4_0 I1252_G0_0n XI1252_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I130_XG_MP2 (VDD I1252_G5_2n I1252_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I130_XG_MP0 (XI1252_I130_XG_p1 I1252_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I130_XG_MP1 (I1252_G5_0 I1252_G1_0n XI1252_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I73_XG_MP2 (VDD I1298_gn7 I1298_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I73_XG_MP0 (XI1298_I73_XG_p1 I1298_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I73_XG_MP1 (I1298_G7_6 I1298_gn6 XI1298_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I74_XG_MP2 (VDD I1298_gn8 I1298_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I74_XG_MP0 (XI1298_I74_XG_p1 I1298_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I74_XG_MP1 (I1298_G8_7 I1298_gn7 XI1298_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I133_XG_MP2 (VDD I1298_G8_5n I1298_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I133_XG_MP0 (XI1298_I133_XG_p1 I1298_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I133_XG_MP1 (I1298_G8_1 I1298_G4_1n XI1298_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I132_XG_MP2 (VDD I1298_G7_4n I1298_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I132_XG_MP0 (XI1298_I132_XG_p1 I1298_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I132_XG_MP1 (I1298_G7_0 I1298_G3_0n XI1298_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I130_XG_MP2 (VDD I1298_G5_2n I1298_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I130_XG_MP0 (XI1298_I130_XG_p1 I1298_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I130_XG_MP1 (I1298_G5_0 I1298_G1_0n XI1298_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I135_XG_MP2 (VDD I1344_G10_7n I1344_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I135_XG_MP0 (XI1344_I135_XG_p1 I1344_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I135_XG_MP1 (I1344_G10_3 I1344_G6_3n XI1344_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I131_XG_MP2 (VDD I1344_G6_3n I1344_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I131_XG_MP0 (XI1344_I131_XG_p1 I1344_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I131_XG_MP1 (I1344_G6_0 I1344_G2_0n XI1344_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I183_XG_MP2 (VDD I1344_G16_1n I1344_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I183_XG_MP0 (XI1344_I183_XG_p1 I1344_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I183_XG_MP1 (I1344_G16_0 I1344_G0_0n XI1344_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I75_XG_MP2 (VDD I1344_gn9 I1344_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I75_XG_MP0 (XI1344_I75_XG_p1 I1344_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I75_XG_MP1 (I1344_G9_8 I1344_gn8 XI1344_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I76_XG_MP2 (VDD I1344_gn10 I1344_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I76_XG_MP0 (XI1344_I76_XG_p1 I1344_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I76_XG_MP1 (I1344_G10_9 I1344_gn9 XI1344_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I132_XG_MP2 (VDD I1344_G7_4n I1344_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I132_XG_MP0 (XI1344_I132_XG_p1 I1344_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I132_XG_MP1 (I1344_G7_0 I1344_G3_0n XI1344_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I134_XG_MP2 (VDD I1344_G9_6n I1344_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I134_XG_MP0 (XI1344_I134_XG_p1 I1344_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I134_XG_MP1 (I1344_G9_2 I1344_G5_2n XI1344_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I75_XG_MP2 (VDD I1390_gn9 I1390_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I75_XG_MP0 (XI1390_I75_XG_p1 I1390_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I75_XG_MP1 (I1390_G9_8 I1390_gn8 XI1390_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I131_XG_MP2 (VDD I1390_G6_3n I1390_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I131_XG_MP0 (XI1390_I131_XG_p1 I1390_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I131_XG_MP1 (I1390_G6_0 I1390_G2_0n XI1390_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I183_XG_MP2 (VDD I1390_G16_1n I1390_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I183_XG_MP0 (XI1390_I183_XG_p1 I1390_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I183_XG_MP1 (I1390_G16_0 I1390_G0_0n XI1390_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I134_XG_MP2 (VDD I1390_G9_6n I1390_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I134_XG_MP0 (XI1390_I134_XG_p1 I1390_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I134_XG_MP1 (I1390_G9_2 I1390_G5_2n XI1390_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I132_XG_MP2 (VDD I1390_G7_4n I1390_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I132_XG_MP0 (XI1390_I132_XG_p1 I1390_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I132_XG_MP1 (I1390_G7_0 I1390_G3_0n XI1390_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I75_XG_MP2 (VDD I1436_gn9 I1436_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I75_XG_MP0 (XI1436_I75_XG_p1 I1436_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I75_XG_MP1 (I1436_G9_8 I1436_gn8 XI1436_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I183_XG_MP2 (VDD I1436_G16_1n I1436_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I183_XG_MP0 (XI1436_I183_XG_p1 I1436_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I183_XG_MP1 (I1436_G16_0 I1436_G0_0n XI1436_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I130_XG_MP2 (VDD I1436_G5_2n I1436_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I130_XG_MP0 (XI1436_I130_XG_p1 I1436_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I130_XG_MP1 (I1436_G5_0 I1436_G1_0n XI1436_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I132_XG_MP2 (VDD I1436_G7_4n I1436_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I132_XG_MP0 (XI1436_I132_XG_p1 I1436_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I132_XG_MP1 (I1436_G7_0 I1436_G3_0n XI1436_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I75_XG_MP2 (VDD I1482_gn9 I1482_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I75_XG_MP0 (XI1482_I75_XG_p1 I1482_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I75_XG_MP1 (I1482_G9_8 I1482_gn8 XI1482_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I132_XG_MP2 (VDD I1482_G7_4n I1482_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I132_XG_MP0 (XI1482_I132_XG_p1 I1482_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I132_XG_MP1 (I1482_G7_0 I1482_G3_0n XI1482_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I130_XG_MP2 (VDD I1482_G5_2n I1482_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I130_XG_MP0 (XI1482_I130_XG_p1 I1482_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I130_XG_MP1 (I1482_G5_0 I1482_G1_0n XI1482_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I133_XG_MP2 (VDD I1482_G8_5n I1482_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I133_XG_MP0 (XI1482_I133_XG_p1 I1482_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I133_XG_MP1 (I1482_G8_1 I1482_G4_1n XI1482_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I131_XG_MP2 (VDD I1482_G6_3n I1482_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I131_XG_MP0 (XI1482_I131_XG_p1 I1482_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I131_XG_MP1 (I1482_G6_0 I1482_G2_0n XI1482_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I78_XG_MP2 (VDD I1528_gn12 I1528_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I78_XG_MP0 (XI1528_I78_XG_p1 I1528_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I78_XG_MP1 (I1528_G12_11 I1528_gn11 XI1528_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I185_XG_MP2 (VDD I1528_G18_3n I1528_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I185_XG_MP0 (XI1528_I185_XG_p1 I1528_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I185_XG_MP1 (I1528_G18_0 I1528_G2_0n XI1528_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I199_XG_MP2 (VDD I1528_G28_13n I1528_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I199_XG_MP0 (XI1528_I199_XG_p1 I1528_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I199_XG_MP1 (I1528_G28_0 I1528_G12_0n XI1528_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I142_XG_MP2 (VDD I1528_G17_14n I1528_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I142_XG_MP0 (XI1528_I142_XG_p1 I1528_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I142_XG_MP1 (I1528_G17_10 I1528_G13_10n XI1528_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I138_XG_MP2 (VDD I1528_G13_10n I1528_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I138_XG_MP0 (XI1528_I138_XG_p1 I1528_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I138_XG_MP1 (I1528_G13_6 I1528_G9_6n XI1528_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I97_XG_MP2 (VDD I1160_gn31 I1160_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I97_XG_MP0 (XI1160_I97_XG_p1 I1160_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I97_XG_MP1 (I1160_G31_30 I1160_gn30 XI1160_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I202_XG_MP2 (VDD I1160_G31_16n c13_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I202_XG_MP0 (XI1160_I202_XG_p1 I1160_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I202_XG_MP1 (c13_o I1160_G15_0n XI1160_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I148_XG_MP2 (VDD I1160_G23_20n I1160_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I148_XG_MP0 (XI1160_I148_XG_p1 I1160_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I148_XG_MP1 (I1160_G23_16 I1160_G19_16n XI1160_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I144_XG_MP2 (VDD I1160_G19_16n I1160_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I144_XG_MP0 (XI1160_I144_XG_p1 I1160_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I144_XG_MP1 (I1160_G19_12 I1160_G15_12n XI1160_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I140_XG_MP2 (VDD I1160_G15_12n I1160_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I140_XG_MP0 (XI1160_I140_XG_p1 I1160_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I140_XG_MP1 (I1160_G15_8 I1160_G11_8n XI1160_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I136_XG_MP2 (VDD I1160_G11_8n I1160_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I136_XG_MP0 (XI1160_I136_XG_p1 I1160_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I136_XG_MP1 (I1160_G11_4 I1160_G7_4n XI1160_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I132_XG_MP2 (VDD I1160_G7_4n I1160_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I132_XG_MP0 (XI1160_I132_XG_p1 I1160_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I132_XG_MP1 (I1160_G7_0 I1160_G3_0n XI1160_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I70_XG_MP2 (VDD I1206_gn4 I1206_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I70_XG_MP0 (XI1206_I70_XG_p1 I1206_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I70_XG_MP1 (I1206_G4_3 I1206_gn3 XI1206_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I75_XG_MP2 (VDD I1252_gn9 I1252_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I75_XG_MP0 (XI1252_I75_XG_p1 I1252_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I75_XG_MP1 (I1252_G9_8 I1252_gn8 XI1252_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I74_XG_MP2 (VDD I1252_gn8 I1252_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I74_XG_MP0 (XI1252_I74_XG_p1 I1252_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I74_XG_MP1 (I1252_G8_7 I1252_gn7 XI1252_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I73_XG_MP2 (VDD I1252_gn7 I1252_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I73_XG_MP0 (XI1252_I73_XG_p1 I1252_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I73_XG_MP1 (I1252_G7_6 I1252_gn6 XI1252_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I131_XG_MP2 (VDD I1252_G6_3n I1252_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I131_XG_MP0 (XI1252_I131_XG_p1 I1252_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I131_XG_MP1 (I1252_G6_0 I1252_G2_0n XI1252_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I133_XG_MP2 (VDD I1252_G8_5n I1252_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I133_XG_MP0 (XI1252_I133_XG_p1 I1252_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I133_XG_MP1 (I1252_G8_1 I1252_G4_1n XI1252_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I134_XG_MP2 (VDD I1252_G9_6n I1252_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I134_XG_MP0 (XI1252_I134_XG_p1 I1252_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I134_XG_MP1 (I1252_G9_2 I1252_G5_2n XI1252_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I75_XG_MP2 (VDD I1298_gn9 I1298_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I75_XG_MP0 (XI1298_I75_XG_p1 I1298_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I75_XG_MP1 (I1298_G9_8 I1298_gn8 XI1298_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I131_XG_MP2 (VDD I1298_G6_3n I1298_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I131_XG_MP0 (XI1298_I131_XG_p1 I1298_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I131_XG_MP1 (I1298_G6_0 I1298_G2_0n XI1298_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I183_XG_MP2 (VDD I1298_G16_1n I1298_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I183_XG_MP0 (XI1298_I183_XG_p1 I1298_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I183_XG_MP1 (I1298_G16_0 I1298_G0_0n XI1298_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I134_XG_MP2 (VDD I1298_G9_6n I1298_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I134_XG_MP0 (XI1298_I134_XG_p1 I1298_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I134_XG_MP1 (I1298_G9_2 I1298_G5_2n XI1298_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I137_XG_MP2 (VDD I1344_G12_9n I1344_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I137_XG_MP0 (XI1344_I137_XG_p1 I1344_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I137_XG_MP1 (I1344_G12_5 I1344_G8_5n XI1344_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I141_XG_MP2 (VDD I1344_G16_13n I1344_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I141_XG_MP0 (XI1344_I141_XG_p1 I1344_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I141_XG_MP1 (I1344_G16_9 I1344_G12_9n XI1344_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I77_XG_MP2 (VDD I1344_gn11 I1344_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I77_XG_MP0 (XI1344_I77_XG_p1 I1344_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I77_XG_MP1 (I1344_G11_10 I1344_gn10 XI1344_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I136_XG_MP2 (VDD I1344_G11_8n I1344_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I136_XG_MP0 (XI1344_I136_XG_p1 I1344_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I136_XG_MP1 (I1344_G11_4 I1344_G7_4n XI1344_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I184_XG_MP2 (VDD I1344_G17_2n I1344_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I184_XG_MP0 (XI1344_I184_XG_p1 I1344_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I184_XG_MP1 (I1344_G17_0 I1344_G1_0n XI1344_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I77_XG_MP2 (VDD I1390_gn11 I1390_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I77_XG_MP0 (XI1390_I77_XG_p1 I1390_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I77_XG_MP1 (I1390_G11_10 I1390_gn10 XI1390_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I76_XG_MP2 (VDD I1390_gn10 I1390_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I76_XG_MP0 (XI1390_I76_XG_p1 I1390_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I76_XG_MP1 (I1390_G10_9 I1390_gn9 XI1390_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I135_XG_MP2 (VDD I1390_G10_7n I1390_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I135_XG_MP0 (XI1390_I135_XG_p1 I1390_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I135_XG_MP1 (I1390_G10_3 I1390_G6_3n XI1390_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I184_XG_MP2 (VDD I1390_G17_2n I1390_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I184_XG_MP0 (XI1390_I184_XG_p1 I1390_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I184_XG_MP1 (I1390_G17_0 I1390_G1_0n XI1390_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I77_XG_MP2 (VDD I1436_gn11 I1436_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I77_XG_MP0 (XI1436_I77_XG_p1 I1436_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I77_XG_MP1 (I1436_G11_10 I1436_gn10 XI1436_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I76_XG_MP2 (VDD I1436_gn10 I1436_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I76_XG_MP0 (XI1436_I76_XG_p1 I1436_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I76_XG_MP1 (I1436_G10_9 I1436_gn9 XI1436_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I135_XG_MP2 (VDD I1436_G10_7n I1436_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I135_XG_MP0 (XI1436_I135_XG_p1 I1436_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I135_XG_MP1 (I1436_G10_3 I1436_G6_3n XI1436_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I134_XG_MP2 (VDD I1436_G9_6n I1436_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I134_XG_MP0 (XI1436_I134_XG_p1 I1436_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I134_XG_MP1 (I1436_G9_2 I1436_G5_2n XI1436_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I76_XG_MP2 (VDD I1482_gn10 I1482_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I76_XG_MP0 (XI1482_I76_XG_p1 I1482_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I76_XG_MP1 (I1482_G10_9 I1482_gn9 XI1482_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I77_XG_MP2 (VDD I1482_gn11 I1482_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I77_XG_MP0 (XI1482_I77_XG_p1 I1482_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I77_XG_MP1 (I1482_G11_10 I1482_gn10 XI1482_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I134_XG_MP2 (VDD I1482_G9_6n I1482_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I134_XG_MP0 (XI1482_I134_XG_p1 I1482_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I134_XG_MP1 (I1482_G9_2 I1482_G5_2n XI1482_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I183_XG_MP2 (VDD I1482_G16_1n I1482_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I183_XG_MP0 (XI1482_I183_XG_p1 I1482_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I183_XG_MP1 (I1482_G16_0 I1482_G0_0n XI1482_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I79_XG_MP2 (VDD I1528_gn13 I1528_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I79_XG_MP0 (XI1528_I79_XG_p1 I1528_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I79_XG_MP1 (I1528_G13_12 I1528_gn12 XI1528_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I80_XG_MP2 (VDD I1528_gn14 I1528_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I80_XG_MP0 (XI1528_I80_XG_p1 I1528_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I80_XG_MP1 (I1528_G14_13 I1528_gn13 XI1528_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I139_XG_MP2 (VDD I1528_G14_11n I1528_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I139_XG_MP0 (XI1528_I139_XG_p1 I1528_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I139_XG_MP1 (I1528_G14_7 I1528_G10_7n XI1528_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I143_XG_MP2 (VDD I1528_G18_15n I1528_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I143_XG_MP0 (XI1528_I143_XG_p1 I1528_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I143_XG_MP1 (I1528_G18_11 I1528_G14_11n XI1528_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I197_XG_MP2 (VDD I1528_G26_11n I1528_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I197_XG_MP0 (XI1528_I197_XG_p1 I1528_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I197_XG_MP1 (I1528_G26_0 I1528_G10_0n XI1528_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I198_XG_MP2 (VDD I1528_G27_12n I1528_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I198_XG_MP0 (XI1528_I198_XG_p1 I1528_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I198_XG_MP1 (I1528_G27_0 I1528_G11_0n XI1528_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I190_XG_MP2 (VDD I1528_G21_6n I1528_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I190_XG_MP0 (XI1528_I190_XG_p1 I1528_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I190_XG_MP1 (I1528_G21_0 I1528_G5_0n XI1528_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I156_XG_MP2 (VDD I1160_G31_28n I1160_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I156_XG_MP0 (XI1160_I156_XG_p1 I1160_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I156_XG_MP1 (I1160_G31_24 I1160_G27_24n XI1160_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I152_XG_MP2 (VDD I1160_G27_24n I1160_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I152_XG_MP0 (XI1160_I152_XG_p1 I1160_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I152_XG_MP1 (I1160_G27_20 I1160_G23_20n XI1160_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I198_XG_MP2 (VDD I1160_G27_12n I1160_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I198_XG_MP0 (XI1160_I198_XG_p1 I1160_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I198_XG_MP1 (I1160_G27_0 I1160_G11_0n XI1160_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I194_XG_MP2 (VDD I1160_G23_8n I1160_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I194_XG_MP0 (XI1160_I194_XG_p1 I1160_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I194_XG_MP1 (I1160_G23_0 I1160_G7_0n XI1160_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I150_XG_MP2 (VDD I1160_G25_22n I1160_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I150_XG_MP0 (XI1160_I150_XG_p1 I1160_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I150_XG_MP1 (I1160_G25_18 I1160_G21_18n XI1160_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I146_XG_MP2 (VDD I1160_G21_18n I1160_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I146_XG_MP0 (XI1160_I146_XG_p1 I1160_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I146_XG_MP1 (I1160_G21_14 I1160_G17_14n XI1160_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I186_XG_MP2 (VDD I1160_G19_4n I1160_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I186_XG_MP0 (XI1160_I186_XG_p1 I1160_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I186_XG_MP1 (I1160_G19_0 I1160_G3_0n XI1160_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I142_XG_MP2 (VDD I1160_G17_14n I1160_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I142_XG_MP0 (XI1160_I142_XG_p1 I1160_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I142_XG_MP1 (I1160_G17_10 I1160_G13_10n XI1160_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I138_XG_MP2 (VDD I1160_G13_10n I1160_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I138_XG_MP0 (XI1160_I138_XG_p1 I1160_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I138_XG_MP1 (I1160_G13_6 I1160_G9_6n XI1160_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I184_XG_MP2 (VDD I1160_G17_2n I1160_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I184_XG_MP0 (XI1160_I184_XG_p1 I1160_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I184_XG_MP1 (I1160_G17_0 I1160_G1_0n XI1160_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I134_XG_MP2 (VDD I1160_G9_6n I1160_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I134_XG_MP0 (XI1160_I134_XG_p1 I1160_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I134_XG_MP1 (I1160_G9_2 I1160_G5_2n XI1160_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I130_XG_MP2 (VDD I1160_G5_2n I1160_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I130_XG_MP0 (XI1160_I130_XG_p1 I1160_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I130_XG_MP1 (I1160_G5_0 I1160_G1_0n XI1160_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I71_XG_MP2 (VDD I1206_gn5 I1206_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I71_XG_MP0 (XI1206_I71_XG_p1 I1206_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I71_XG_MP1 (I1206_G5_4 I1206_gn4 XI1206_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I128_XG_MP2 (VDD I1206_G4_1n I1206_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I128_XG_MP0 (XI1206_I128_XG_p1 I1206_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I128_XG_MP1 (I1206_G4_0 I1206_G0_0n XI1206_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I77_XG_MP2 (VDD I1252_gn11 I1252_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I77_XG_MP0 (XI1252_I77_XG_p1 I1252_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I77_XG_MP1 (I1252_G11_10 I1252_gn10 XI1252_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I76_XG_MP2 (VDD I1252_gn10 I1252_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I76_XG_MP0 (XI1252_I76_XG_p1 I1252_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I76_XG_MP1 (I1252_G10_9 I1252_gn9 XI1252_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I135_XG_MP2 (VDD I1252_G10_7n I1252_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I135_XG_MP0 (XI1252_I135_XG_p1 I1252_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I135_XG_MP1 (I1252_G10_3 I1252_G6_3n XI1252_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I185_XG_MP2 (VDD I1252_G18_3n I1252_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I185_XG_MP0 (XI1252_I185_XG_p1 I1252_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I185_XG_MP1 (I1252_G18_0 I1252_G2_0n XI1252_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I183_XG_MP2 (VDD I1252_G16_1n I1252_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I183_XG_MP0 (XI1252_I183_XG_p1 I1252_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I183_XG_MP1 (I1252_G16_0 I1252_G0_0n XI1252_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I132_XG_MP2 (VDD I1252_G7_4n I1252_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I132_XG_MP0 (XI1252_I132_XG_p1 I1252_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I132_XG_MP1 (I1252_G7_0 I1252_G3_0n XI1252_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I184_XG_MP2 (VDD I1252_G17_2n I1252_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I184_XG_MP0 (XI1252_I184_XG_p1 I1252_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I184_XG_MP1 (I1252_G17_0 I1252_G1_0n XI1252_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I77_XG_MP2 (VDD I1298_gn11 I1298_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I77_XG_MP0 (XI1298_I77_XG_p1 I1298_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I77_XG_MP1 (I1298_G11_10 I1298_gn10 XI1298_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I76_XG_MP2 (VDD I1298_gn10 I1298_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I76_XG_MP0 (XI1298_I76_XG_p1 I1298_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I76_XG_MP1 (I1298_G10_9 I1298_gn9 XI1298_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I137_XG_MP2 (VDD I1298_G12_9n I1298_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I137_XG_MP0 (XI1298_I137_XG_p1 I1298_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I137_XG_MP1 (I1298_G12_5 I1298_G8_5n XI1298_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I135_XG_MP2 (VDD I1298_G10_7n I1298_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I135_XG_MP0 (XI1298_I135_XG_p1 I1298_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I135_XG_MP1 (I1298_G10_3 I1298_G6_3n XI1298_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I185_XG_MP2 (VDD I1298_G18_3n I1298_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I185_XG_MP0 (XI1298_I185_XG_p1 I1298_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I185_XG_MP1 (I1298_G18_0 I1298_G2_0n XI1298_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I136_XG_MP2 (VDD I1298_G11_8n I1298_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I136_XG_MP0 (XI1298_I136_XG_p1 I1298_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I136_XG_MP1 (I1298_G11_4 I1298_G7_4n XI1298_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I184_XG_MP2 (VDD I1298_G17_2n I1298_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I184_XG_MP0 (XI1298_I184_XG_p1 I1298_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I184_XG_MP1 (I1298_G17_0 I1298_G1_0n XI1298_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I185_XG_MP2 (VDD I1344_G18_3n I1344_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I185_XG_MP0 (XI1344_I185_XG_p1 I1344_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I185_XG_MP1 (I1344_G18_0 I1344_G2_0n XI1344_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I195_XG_MP2 (VDD I1344_G24_9n I1344_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I195_XG_MP0 (XI1344_I195_XG_p1 I1344_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I195_XG_MP1 (I1344_G24_0 I1344_G8_0n XI1344_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I78_XG_MP2 (VDD I1344_gn12 I1344_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I78_XG_MP0 (XI1344_I78_XG_p1 I1344_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I78_XG_MP1 (I1344_G12_11 I1344_gn11 XI1344_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I79_XG_MP2 (VDD I1344_gn13 I1344_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I79_XG_MP0 (XI1344_I79_XG_p1 I1344_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I79_XG_MP1 (I1344_G13_12 I1344_gn12 XI1344_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I186_XG_MP2 (VDD I1344_G19_4n I1344_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I186_XG_MP0 (XI1344_I186_XG_p1 I1344_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I186_XG_MP1 (I1344_G19_0 I1344_G3_0n XI1344_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I78_XG_MP2 (VDD I1390_gn12 I1390_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I78_XG_MP0 (XI1390_I78_XG_p1 I1390_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I78_XG_MP1 (I1390_G12_11 I1390_gn11 XI1390_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I79_XG_MP2 (VDD I1390_gn13 I1390_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I79_XG_MP0 (XI1390_I79_XG_p1 I1390_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I79_XG_MP1 (I1390_G13_12 I1390_gn12 XI1390_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I137_XG_MP2 (VDD I1390_G12_9n I1390_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I137_XG_MP0 (XI1390_I137_XG_p1 I1390_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I137_XG_MP1 (I1390_G12_5 I1390_G8_5n XI1390_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I141_XG_MP2 (VDD I1390_G16_13n I1390_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I141_XG_MP0 (XI1390_I141_XG_p1 I1390_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I141_XG_MP1 (I1390_G16_9 I1390_G12_9n XI1390_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I185_XG_MP2 (VDD I1390_G18_3n I1390_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I185_XG_MP0 (XI1390_I185_XG_p1 I1390_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I185_XG_MP1 (I1390_G18_0 I1390_G2_0n XI1390_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I138_XG_MP2 (VDD I1390_G13_10n I1390_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I138_XG_MP0 (XI1390_I138_XG_p1 I1390_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I138_XG_MP1 (I1390_G13_6 I1390_G9_6n XI1390_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I136_XG_MP2 (VDD I1390_G11_8n I1390_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I136_XG_MP0 (XI1390_I136_XG_p1 I1390_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I136_XG_MP1 (I1390_G11_4 I1390_G7_4n XI1390_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I78_XG_MP2 (VDD I1436_gn12 I1436_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I78_XG_MP0 (XI1436_I78_XG_p1 I1436_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I78_XG_MP1 (I1436_G12_11 I1436_gn11 XI1436_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I137_XG_MP2 (VDD I1436_G12_9n I1436_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I137_XG_MP0 (XI1436_I137_XG_p1 I1436_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I137_XG_MP1 (I1436_G12_5 I1436_G8_5n XI1436_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I141_XG_MP2 (VDD I1436_G16_13n I1436_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I141_XG_MP0 (XI1436_I141_XG_p1 I1436_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I141_XG_MP1 (I1436_G16_9 I1436_G12_9n XI1436_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I185_XG_MP2 (VDD I1436_G18_3n I1436_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I185_XG_MP0 (XI1436_I185_XG_p1 I1436_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I185_XG_MP1 (I1436_G18_0 I1436_G2_0n XI1436_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I184_XG_MP2 (VDD I1436_G17_2n I1436_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I184_XG_MP0 (XI1436_I184_XG_p1 I1436_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I184_XG_MP1 (I1436_G17_0 I1436_G1_0n XI1436_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I136_XG_MP2 (VDD I1436_G11_8n I1436_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I136_XG_MP0 (XI1436_I136_XG_p1 I1436_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I136_XG_MP1 (I1436_G11_4 I1436_G7_4n XI1436_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I78_XG_MP2 (VDD I1482_gn12 I1482_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I78_XG_MP0 (XI1482_I78_XG_p1 I1482_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I78_XG_MP1 (I1482_G12_11 I1482_gn11 XI1482_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I136_XG_MP2 (VDD I1482_G11_8n I1482_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I136_XG_MP0 (XI1482_I136_XG_p1 I1482_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I136_XG_MP1 (I1482_G11_4 I1482_G7_4n XI1482_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I184_XG_MP2 (VDD I1482_G17_2n I1482_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I184_XG_MP0 (XI1482_I184_XG_p1 I1482_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I184_XG_MP1 (I1482_G17_0 I1482_G1_0n XI1482_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I137_XG_MP2 (VDD I1482_G12_9n I1482_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I137_XG_MP0 (XI1482_I137_XG_p1 I1482_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I137_XG_MP1 (I1482_G12_5 I1482_G8_5n XI1482_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I135_XG_MP2 (VDD I1482_G10_7n I1482_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I135_XG_MP0 (XI1482_I135_XG_p1 I1482_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I135_XG_MP1 (I1482_G10_3 I1482_G6_3n XI1482_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I81_XG_MP2 (VDD I1528_gn15 I1528_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I81_XG_MP0 (XI1528_I81_XG_p1 I1528_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I81_XG_MP1 (I1528_G15_14 I1528_gn14 XI1528_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I82_XG_MP2 (VDD I1528_gn16 I1528_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I82_XG_MP0 (XI1528_I82_XG_p1 I1528_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I82_XG_MP1 (I1528_G16_15 I1528_gn15 XI1528_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I145_XG_MP2 (VDD I1528_G20_17n I1528_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I145_XG_MP0 (XI1528_I145_XG_p1 I1528_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I145_XG_MP1 (I1528_G20_13 I1528_G16_13n XI1528_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I192_XG_MP2 (VDD I1528_G22_7n I1528_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I192_XG_MP0 (XI1528_I192_XG_p1 I1528_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I192_XG_MP1 (I1528_G22_0 I1528_G6_0n XI1528_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I140_XG_MP2 (VDD I1528_G15_12n I1528_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I140_XG_MP0 (XI1528_I140_XG_p1 I1528_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I140_XG_MP1 (I1528_G15_8 I1528_G11_8n XI1528_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I144_XG_MP2 (VDD I1528_G19_16n I1528_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I144_XG_MP0 (XI1528_I144_XG_p1 I1528_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I144_XG_MP1 (I1528_G19_12 I1528_G15_12n XI1528_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I154_XG_MP2 (VDD I1160_G29_26n I1160_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I154_XG_MP0 (XI1160_I154_XG_p1 I1160_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I154_XG_MP1 (I1160_G29_22 I1160_G25_22n XI1160_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I200_XG_MP2 (VDD I1160_G29_14n I1160_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I200_XG_MP0 (XI1160_I200_XG_p1 I1160_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I200_XG_MP1 (I1160_G29_0 I1160_G13_0n XI1160_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I190_XG_MP2 (VDD I1160_G21_6n I1160_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I190_XG_MP0 (XI1160_I190_XG_p1 I1160_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I190_XG_MP1 (I1160_G21_0 I1160_G5_0n XI1160_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I196_XG_MP2 (VDD I1160_G25_10n I1160_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I196_XG_MP0 (XI1160_I196_XG_p1 I1160_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I196_XG_MP1 (I1160_G25_0 I1160_G9_0n XI1160_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I133_XG_MP2 (VDD I1160_G8_5n I1160_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I133_XG_MP0 (XI1160_I133_XG_p1 I1160_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I133_XG_MP1 (I1160_G8_1 I1160_G4_1n XI1160_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I128_XG_MP2 (VDD I1160_G4_1n I1160_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I128_XG_MP0 (XI1160_I128_XG_p1 I1160_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I128_XG_MP1 (I1160_G4_0 I1160_G0_0n XI1160_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I73_XG_MP2 (VDD I1206_gn7 I1206_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I73_XG_MP0 (XI1206_I73_XG_p1 I1206_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I73_XG_MP1 (I1206_G7_6 I1206_gn6 XI1206_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I74_XG_MP2 (VDD I1206_gn8 I1206_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I74_XG_MP0 (XI1206_I74_XG_p1 I1206_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I74_XG_MP1 (I1206_G8_7 I1206_gn7 XI1206_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I72_XG_MP2 (VDD I1206_gn6 I1206_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I72_XG_MP0 (XI1206_I72_XG_p1 I1206_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I72_XG_MP1 (I1206_G6_5 I1206_gn5 XI1206_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I131_XG_MP2 (VDD I1206_G6_3n I1206_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I131_XG_MP0 (XI1206_I131_XG_p1 I1206_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I131_XG_MP1 (I1206_G6_0 I1206_G2_0n XI1206_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I78_XG_MP2 (VDD I1252_gn12 I1252_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I78_XG_MP0 (XI1252_I78_XG_p1 I1252_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I78_XG_MP1 (I1252_G12_11 I1252_gn11 XI1252_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I137_XG_MP2 (VDD I1252_G12_9n I1252_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I137_XG_MP0 (XI1252_I137_XG_p1 I1252_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I137_XG_MP1 (I1252_G12_5 I1252_G8_5n XI1252_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I136_XG_MP2 (VDD I1252_G11_8n I1252_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I136_XG_MP0 (XI1252_I136_XG_p1 I1252_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I136_XG_MP1 (I1252_G11_4 I1252_G7_4n XI1252_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I79_XG_MP2 (VDD I1298_gn13 I1298_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I79_XG_MP0 (XI1298_I79_XG_p1 I1298_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I79_XG_MP1 (I1298_G13_12 I1298_gn12 XI1298_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I78_XG_MP2 (VDD I1298_gn12 I1298_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I78_XG_MP0 (XI1298_I78_XG_p1 I1298_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I78_XG_MP1 (I1298_G12_11 I1298_gn11 XI1298_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I141_XG_MP2 (VDD I1298_G16_13n I1298_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I141_XG_MP0 (XI1298_I141_XG_p1 I1298_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I141_XG_MP1 (I1298_G16_9 I1298_G12_9n XI1298_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I195_XG_MP2 (VDD I1298_G24_9n I1298_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I195_XG_MP0 (XI1298_I195_XG_p1 I1298_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I195_XG_MP1 (I1298_G24_0 I1298_G8_0n XI1298_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I138_XG_MP2 (VDD I1298_G13_10n I1298_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I138_XG_MP0 (XI1298_I138_XG_p1 I1298_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I138_XG_MP1 (I1298_G13_6 I1298_G9_6n XI1298_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I186_XG_MP2 (VDD I1298_G19_4n I1298_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I186_XG_MP0 (XI1298_I186_XG_p1 I1298_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I186_XG_MP1 (I1298_G19_0 I1298_G3_0n XI1298_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I139_XG_MP2 (VDD I1344_G14_11n I1344_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I139_XG_MP0 (XI1344_I139_XG_p1 I1344_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I139_XG_MP1 (I1344_G14_7 I1344_G10_7n XI1344_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I188_XG_MP2 (VDD I1344_G20_5n I1344_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I188_XG_MP0 (XI1344_I188_XG_p1 I1344_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I188_XG_MP1 (I1344_G20_0 I1344_G4_0n XI1344_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I80_XG_MP2 (VDD I1344_gn14 I1344_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I80_XG_MP0 (XI1344_I80_XG_p1 I1344_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I80_XG_MP1 (I1344_G14_13 I1344_gn13 XI1344_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I142_XG_MP2 (VDD I1344_G17_14n I1344_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I142_XG_MP0 (XI1344_I142_XG_p1 I1344_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I142_XG_MP1 (I1344_G17_10 I1344_G13_10n XI1344_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I138_XG_MP2 (VDD I1344_G13_10n I1344_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I138_XG_MP0 (XI1344_I138_XG_p1 I1344_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I138_XG_MP1 (I1344_G13_6 I1344_G9_6n XI1344_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I80_XG_MP2 (VDD I1390_gn14 I1390_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I80_XG_MP0 (XI1390_I80_XG_p1 I1390_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I80_XG_MP1 (I1390_G14_13 I1390_gn13 XI1390_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I139_XG_MP2 (VDD I1390_G14_11n I1390_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I139_XG_MP0 (XI1390_I139_XG_p1 I1390_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I139_XG_MP1 (I1390_G14_7 I1390_G10_7n XI1390_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I195_XG_MP2 (VDD I1390_G24_9n I1390_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I195_XG_MP0 (XI1390_I195_XG_p1 I1390_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I195_XG_MP1 (I1390_G24_0 I1390_G8_0n XI1390_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I142_XG_MP2 (VDD I1390_G17_14n I1390_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I142_XG_MP0 (XI1390_I142_XG_p1 I1390_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I142_XG_MP1 (I1390_G17_10 I1390_G13_10n XI1390_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I186_XG_MP2 (VDD I1390_G19_4n I1390_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I186_XG_MP0 (XI1390_I186_XG_p1 I1390_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I186_XG_MP1 (I1390_G19_0 I1390_G3_0n XI1390_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I80_XG_MP2 (VDD I1436_gn14 I1436_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I80_XG_MP0 (XI1436_I80_XG_p1 I1436_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I80_XG_MP1 (I1436_G14_13 I1436_gn13 XI1436_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I79_XG_MP2 (VDD I1436_gn13 I1436_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I79_XG_MP0 (XI1436_I79_XG_p1 I1436_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I79_XG_MP1 (I1436_G13_12 I1436_gn12 XI1436_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I195_XG_MP2 (VDD I1436_G24_9n I1436_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I195_XG_MP0 (XI1436_I195_XG_p1 I1436_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I195_XG_MP1 (I1436_G24_0 I1436_G8_0n XI1436_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I138_XG_MP2 (VDD I1436_G13_10n I1436_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I138_XG_MP0 (XI1436_I138_XG_p1 I1436_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I138_XG_MP1 (I1436_G13_6 I1436_G9_6n XI1436_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I79_XG_MP2 (VDD I1482_gn13 I1482_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I79_XG_MP0 (XI1482_I79_XG_p1 I1482_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I79_XG_MP1 (I1482_G13_12 I1482_gn12 XI1482_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I141_XG_MP2 (VDD I1482_G16_13n I1482_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I141_XG_MP0 (XI1482_I141_XG_p1 I1482_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I141_XG_MP1 (I1482_G16_9 I1482_G12_9n XI1482_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I83_XG_MP2 (VDD I1528_gn17 I1528_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I83_XG_MP0 (XI1528_I83_XG_p1 I1528_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I83_XG_MP1 (I1528_G17_16 I1528_gn16 XI1528_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I149_XG_MP2 (VDD I1528_G24_21n I1528_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I149_XG_MP0 (XI1528_I149_XG_p1 I1528_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I149_XG_MP1 (I1528_G24_17 I1528_G20_17n XI1528_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I146_XG_MP2 (VDD I1528_G21_18n I1528_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I146_XG_MP0 (XI1528_I146_XG_p1 I1528_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I146_XG_MP1 (I1528_G21_14 I1528_G17_14n XI1528_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I200_XG_MP2 (VDD I1528_G29_14n I1528_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I200_XG_MP0 (XI1528_I200_XG_p1 I1528_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I200_XG_MP1 (I1528_G29_0 I1528_G13_0n XI1528_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I96_XG_MP2 (VDD I1160_gn30 I1160_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I96_XG_MP0 (XI1160_I96_XG_p1 I1160_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I96_XG_MP1 (I1160_G30_29 I1160_gn29 XI1160_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I91_XG_MP2 (VDD I1160_gn25 I1160_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I91_XG_MP0 (XI1160_I91_XG_p1 I1160_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I91_XG_MP1 (I1160_G25_24 I1160_gn24 XI1160_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I90_XG_MP2 (VDD I1160_gn24 I1160_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I90_XG_MP0 (XI1160_I90_XG_p1 I1160_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I90_XG_MP1 (I1160_G24_23 I1160_gn23 XI1160_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I145_XG_MP2 (VDD I1160_G20_17n I1160_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I145_XG_MP0 (XI1160_I145_XG_p1 I1160_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I145_XG_MP1 (I1160_G20_13 I1160_G16_13n XI1160_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I141_XG_MP2 (VDD I1160_G16_13n I1160_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I141_XG_MP0 (XI1160_I141_XG_p1 I1160_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I141_XG_MP1 (I1160_G16_9 I1160_G12_9n XI1160_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I137_XG_MP2 (VDD I1160_G12_9n I1160_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I137_XG_MP0 (XI1160_I137_XG_p1 I1160_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I137_XG_MP1 (I1160_G12_5 I1160_G8_5n XI1160_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I183_XG_MP2 (VDD I1160_G16_1n I1160_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I183_XG_MP0 (XI1160_I183_XG_p1 I1160_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I183_XG_MP1 (I1160_G16_0 I1160_G0_0n XI1160_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I77_XG_MP2 (VDD I1206_gn11 I1206_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I77_XG_MP0 (XI1206_I77_XG_p1 I1206_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I77_XG_MP1 (I1206_G11_10 I1206_gn10 XI1206_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I76_XG_MP2 (VDD I1206_gn10 I1206_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I76_XG_MP0 (XI1206_I76_XG_p1 I1206_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I76_XG_MP1 (I1206_G10_9 I1206_gn9 XI1206_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I75_XG_MP2 (VDD I1206_gn9 I1206_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I75_XG_MP0 (XI1206_I75_XG_p1 I1206_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I75_XG_MP1 (I1206_G9_8 I1206_gn8 XI1206_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I133_XG_MP2 (VDD I1206_G8_5n I1206_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I133_XG_MP0 (XI1206_I133_XG_p1 I1206_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I133_XG_MP1 (I1206_G8_1 I1206_G4_1n XI1206_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I79_XG_MP2 (VDD I1252_gn13 I1252_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I79_XG_MP0 (XI1252_I79_XG_p1 I1252_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I79_XG_MP1 (I1252_G13_12 I1252_gn12 XI1252_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I141_XG_MP2 (VDD I1252_G16_13n I1252_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I141_XG_MP0 (XI1252_I141_XG_p1 I1252_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I141_XG_MP1 (I1252_G16_9 I1252_G12_9n XI1252_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I195_XG_MP2 (VDD I1252_G24_9n I1252_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I195_XG_MP0 (XI1252_I195_XG_p1 I1252_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I195_XG_MP1 (I1252_G24_0 I1252_G8_0n XI1252_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I138_XG_MP2 (VDD I1252_G13_10n I1252_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I138_XG_MP0 (XI1252_I138_XG_p1 I1252_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I138_XG_MP1 (I1252_G13_6 I1252_G9_6n XI1252_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I186_XG_MP2 (VDD I1252_G19_4n I1252_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I186_XG_MP0 (XI1252_I186_XG_p1 I1252_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I186_XG_MP1 (I1252_G19_0 I1252_G3_0n XI1252_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I80_XG_MP2 (VDD I1298_gn14 I1298_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I80_XG_MP0 (XI1298_I80_XG_p1 I1298_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I80_XG_MP1 (I1298_G14_13 I1298_gn13 XI1298_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I81_XG_MP2 (VDD I1298_gn15 I1298_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I81_XG_MP0 (XI1298_I81_XG_p1 I1298_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I81_XG_MP1 (I1298_G15_14 I1298_gn14 XI1298_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I143_XG_MP2 (VDD I1298_G18_15n I1298_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I143_XG_MP0 (XI1298_I143_XG_p1 I1298_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I143_XG_MP1 (I1298_G18_11 I1298_G14_11n XI1298_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I139_XG_MP2 (VDD I1298_G14_11n I1298_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I139_XG_MP0 (XI1298_I139_XG_p1 I1298_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I139_XG_MP1 (I1298_G14_7 I1298_G10_7n XI1298_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I142_XG_MP2 (VDD I1298_G17_14n I1298_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I142_XG_MP0 (XI1298_I142_XG_p1 I1298_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I142_XG_MP1 (I1298_G17_10 I1298_G13_10n XI1298_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I140_XG_MP2 (VDD I1298_G15_12n I1298_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I140_XG_MP0 (XI1298_I140_XG_p1 I1298_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I140_XG_MP1 (I1298_G15_8 I1298_G11_8n XI1298_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I143_XG_MP2 (VDD I1344_G18_15n I1344_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I143_XG_MP0 (XI1344_I143_XG_p1 I1344_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I143_XG_MP1 (I1344_G18_11 I1344_G14_11n XI1344_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I197_XG_MP2 (VDD I1344_G26_11n I1344_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I197_XG_MP0 (XI1344_I197_XG_p1 I1344_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I197_XG_MP1 (I1344_G26_0 I1344_G10_0n XI1344_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I145_XG_MP2 (VDD I1344_G20_17n I1344_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I145_XG_MP0 (XI1344_I145_XG_p1 I1344_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I145_XG_MP1 (I1344_G20_13 I1344_G16_13n XI1344_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I82_XG_MP2 (VDD I1344_gn16 I1344_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I82_XG_MP0 (XI1344_I82_XG_p1 I1344_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I82_XG_MP1 (I1344_G16_15 I1344_gn15 XI1344_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I81_XG_MP2 (VDD I1344_gn15 I1344_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I81_XG_MP0 (XI1344_I81_XG_p1 I1344_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I81_XG_MP1 (I1344_G15_14 I1344_gn14 XI1344_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I196_XG_MP2 (VDD I1344_G25_10n I1344_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I196_XG_MP0 (XI1344_I196_XG_p1 I1344_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I196_XG_MP1 (I1344_G25_0 I1344_G9_0n XI1344_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I81_XG_MP2 (VDD I1390_gn15 I1390_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I81_XG_MP0 (XI1390_I81_XG_p1 I1390_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I81_XG_MP1 (I1390_G15_14 I1390_gn14 XI1390_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I143_XG_MP2 (VDD I1390_G18_15n I1390_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I143_XG_MP0 (XI1390_I143_XG_p1 I1390_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I143_XG_MP1 (I1390_G18_11 I1390_G14_11n XI1390_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I188_XG_MP2 (VDD I1390_G20_5n I1390_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I188_XG_MP0 (XI1390_I188_XG_p1 I1390_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I188_XG_MP1 (I1390_G20_0 I1390_G4_0n XI1390_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I140_XG_MP2 (VDD I1390_G15_12n I1390_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I140_XG_MP0 (XI1390_I140_XG_p1 I1390_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I140_XG_MP1 (I1390_G15_8 I1390_G11_8n XI1390_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I196_XG_MP2 (VDD I1390_G25_10n I1390_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I196_XG_MP0 (XI1390_I196_XG_p1 I1390_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I196_XG_MP1 (I1390_G25_0 I1390_G9_0n XI1390_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I81_XG_MP2 (VDD I1436_gn15 I1436_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I81_XG_MP0 (XI1436_I81_XG_p1 I1436_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I81_XG_MP1 (I1436_G15_14 I1436_gn14 XI1436_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I143_XG_MP2 (VDD I1436_G18_15n I1436_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I143_XG_MP0 (XI1436_I143_XG_p1 I1436_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I143_XG_MP1 (I1436_G18_11 I1436_G14_11n XI1436_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I139_XG_MP2 (VDD I1436_G14_11n I1436_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I139_XG_MP0 (XI1436_I139_XG_p1 I1436_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I139_XG_MP1 (I1436_G14_7 I1436_G10_7n XI1436_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I188_XG_MP2 (VDD I1436_G20_5n I1436_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I188_XG_MP0 (XI1436_I188_XG_p1 I1436_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I188_XG_MP1 (I1436_G20_0 I1436_G4_0n XI1436_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I142_XG_MP2 (VDD I1436_G17_14n I1436_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I142_XG_MP0 (XI1436_I142_XG_p1 I1436_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I142_XG_MP1 (I1436_G17_10 I1436_G13_10n XI1436_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I186_XG_MP2 (VDD I1436_G19_4n I1436_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I186_XG_MP0 (XI1436_I186_XG_p1 I1436_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I186_XG_MP1 (I1436_G19_0 I1436_G3_0n XI1436_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I81_XG_MP2 (VDD I1482_gn15 I1482_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I81_XG_MP0 (XI1482_I81_XG_p1 I1482_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I81_XG_MP1 (I1482_G15_14 I1482_gn14 XI1482_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I80_XG_MP2 (VDD I1482_gn14 I1482_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I80_XG_MP0 (XI1482_I80_XG_p1 I1482_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I80_XG_MP1 (I1482_G14_13 I1482_gn13 XI1482_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I138_XG_MP2 (VDD I1482_G13_10n I1482_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I138_XG_MP0 (XI1482_I138_XG_p1 I1482_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I138_XG_MP1 (I1482_G13_6 I1482_G9_6n XI1482_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I188_XG_MP2 (VDD I1482_G20_5n I1482_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I188_XG_MP0 (XI1482_I188_XG_p1 I1482_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I188_XG_MP1 (I1482_G20_0 I1482_G4_0n XI1482_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I139_XG_MP2 (VDD I1482_G14_11n I1482_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I139_XG_MP0 (XI1482_I139_XG_p1 I1482_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I139_XG_MP1 (I1482_G14_7 I1482_G10_7n XI1482_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I185_XG_MP2 (VDD I1482_G18_3n I1482_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I185_XG_MP0 (XI1482_I185_XG_p1 I1482_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I185_XG_MP1 (I1482_G18_0 I1482_G2_0n XI1482_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I84_XG_MP2 (VDD I1528_gn18 I1528_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I84_XG_MP0 (XI1528_I84_XG_p1 I1528_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I84_XG_MP1 (I1528_G18_17 I1528_gn17 XI1528_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I85_XG_MP2 (VDD I1528_gn19 I1528_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I85_XG_MP0 (XI1528_I85_XG_p1 I1528_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I85_XG_MP1 (I1528_G19_18 I1528_gn18 XI1528_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I147_XG_MP2 (VDD I1528_G22_19n I1528_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I147_XG_MP0 (XI1528_I147_XG_p1 I1528_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I147_XG_MP1 (I1528_G22_15 I1528_G18_15n XI1528_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I194_XG_MP2 (VDD I1528_G23_8n I1528_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I194_XG_MP0 (XI1528_I194_XG_p1 I1528_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I194_XG_MP1 (I1528_G23_0 I1528_G7_0n XI1528_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I150_XG_MP2 (VDD I1528_G25_22n I1528_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I150_XG_MP0 (XI1528_I150_XG_p1 I1528_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I150_XG_MP1 (I1528_G25_18 I1528_G21_18n XI1528_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I95_XG_MP2 (VDD I1160_gn29 I1160_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I95_XG_MP0 (XI1160_I95_XG_p1 I1160_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I95_XG_MP1 (I1160_G29_28 I1160_gn28 XI1160_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I149_XG_MP2 (VDD I1160_G24_21n I1160_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I149_XG_MP0 (XI1160_I149_XG_p1 I1160_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I149_XG_MP1 (I1160_G24_17 I1160_G20_17n XI1160_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I195_XG_MP2 (VDD I1160_G24_9n I1160_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I195_XG_MP0 (XI1160_I195_XG_p1 I1160_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I195_XG_MP1 (I1160_G24_0 I1160_G8_0n XI1160_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I188_XG_MP2 (VDD I1160_G20_5n I1160_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I188_XG_MP0 (XI1160_I188_XG_p1 I1160_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I188_XG_MP1 (I1160_G20_0 I1160_G4_0n XI1160_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I131_XG_MP2 (VDD I1160_G6_3n I1160_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I131_XG_MP0 (XI1160_I131_XG_p1 I1160_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I131_XG_MP1 (I1160_G6_0 I1160_G2_0n XI1160_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I78_XG_MP2 (VDD I1206_gn12 I1206_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I78_XG_MP0 (XI1206_I78_XG_p1 I1206_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I78_XG_MP1 (I1206_G12_11 I1206_gn11 XI1206_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I132_XG_MP2 (VDD I1206_G7_4n I1206_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I132_XG_MP0 (XI1206_I132_XG_p1 I1206_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I132_XG_MP1 (I1206_G7_0 I1206_G3_0n XI1206_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I135_XG_MP2 (VDD I1206_G10_7n I1206_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I135_XG_MP0 (XI1206_I135_XG_p1 I1206_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I135_XG_MP1 (I1206_G10_3 I1206_G6_3n XI1206_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I183_XG_MP2 (VDD I1206_G16_1n I1206_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I183_XG_MP0 (XI1206_I183_XG_p1 I1206_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I183_XG_MP1 (I1206_G16_0 I1206_G0_0n XI1206_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I80_XG_MP2 (VDD I1252_gn14 I1252_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I80_XG_MP0 (XI1252_I80_XG_p1 I1252_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I80_XG_MP1 (I1252_G14_13 I1252_gn13 XI1252_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I81_XG_MP2 (VDD I1252_gn15 I1252_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I81_XG_MP0 (XI1252_I81_XG_p1 I1252_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I81_XG_MP1 (I1252_G15_14 I1252_gn14 XI1252_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I139_XG_MP2 (VDD I1252_G14_11n I1252_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I139_XG_MP0 (XI1252_I139_XG_p1 I1252_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I139_XG_MP1 (I1252_G14_7 I1252_G10_7n XI1252_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I145_XG_MP2 (VDD I1252_G20_17n I1252_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I145_XG_MP0 (XI1252_I145_XG_p1 I1252_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I145_XG_MP1 (I1252_G20_13 I1252_G16_13n XI1252_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I188_XG_MP2 (VDD I1252_G20_5n I1252_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I188_XG_MP0 (XI1252_I188_XG_p1 I1252_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I188_XG_MP1 (I1252_G20_0 I1252_G4_0n XI1252_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I142_XG_MP2 (VDD I1252_G17_14n I1252_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I142_XG_MP0 (XI1252_I142_XG_p1 I1252_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I142_XG_MP1 (I1252_G17_10 I1252_G13_10n XI1252_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I196_XG_MP2 (VDD I1252_G25_10n I1252_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I196_XG_MP0 (XI1252_I196_XG_p1 I1252_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I196_XG_MP1 (I1252_G25_0 I1252_G9_0n XI1252_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I82_XG_MP2 (VDD I1298_gn16 I1298_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I82_XG_MP0 (XI1298_I82_XG_p1 I1298_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I82_XG_MP1 (I1298_G16_15 I1298_gn15 XI1298_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I145_XG_MP2 (VDD I1298_G20_17n I1298_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I145_XG_MP0 (XI1298_I145_XG_p1 I1298_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I145_XG_MP1 (I1298_G20_13 I1298_G16_13n XI1298_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I188_XG_MP2 (VDD I1298_G20_5n I1298_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I188_XG_MP0 (XI1298_I188_XG_p1 I1298_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I188_XG_MP1 (I1298_G20_0 I1298_G4_0n XI1298_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I149_XG_MP2 (VDD I1344_G24_21n I1344_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I149_XG_MP0 (XI1344_I149_XG_p1 I1344_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I149_XG_MP1 (I1344_G24_17 I1344_G20_17n XI1344_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I83_XG_MP2 (VDD I1344_gn17 I1344_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I83_XG_MP0 (XI1344_I83_XG_p1 I1344_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I83_XG_MP1 (I1344_G17_16 I1344_gn16 XI1344_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I140_XG_MP2 (VDD I1344_G15_12n I1344_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I140_XG_MP0 (XI1344_I140_XG_p1 I1344_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I140_XG_MP1 (I1344_G15_8 I1344_G11_8n XI1344_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I82_XG_MP2 (VDD I1390_gn16 I1390_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I82_XG_MP0 (XI1390_I82_XG_p1 I1390_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I82_XG_MP1 (I1390_G16_15 I1390_gn15 XI1390_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I83_XG_MP2 (VDD I1390_gn17 I1390_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I83_XG_MP0 (XI1390_I83_XG_p1 I1390_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I83_XG_MP1 (I1390_G17_16 I1390_gn16 XI1390_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I145_XG_MP2 (VDD I1390_G20_17n I1390_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I145_XG_MP0 (XI1390_I145_XG_p1 I1390_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I145_XG_MP1 (I1390_G20_13 I1390_G16_13n XI1390_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I197_XG_MP2 (VDD I1390_G26_11n I1390_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I197_XG_MP0 (XI1390_I197_XG_p1 I1390_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I197_XG_MP1 (I1390_G26_0 I1390_G10_0n XI1390_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I144_XG_MP2 (VDD I1390_G19_16n I1390_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I144_XG_MP0 (XI1390_I144_XG_p1 I1390_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I144_XG_MP1 (I1390_G19_12 I1390_G15_12n XI1390_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I82_XG_MP2 (VDD I1436_gn16 I1436_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I82_XG_MP0 (XI1436_I82_XG_p1 I1436_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I82_XG_MP1 (I1436_G16_15 I1436_gn15 XI1436_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I83_XG_MP2 (VDD I1436_gn17 I1436_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I83_XG_MP0 (XI1436_I83_XG_p1 I1436_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I83_XG_MP1 (I1436_G17_16 I1436_gn16 XI1436_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I145_XG_MP2 (VDD I1436_G20_17n I1436_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I145_XG_MP0 (XI1436_I145_XG_p1 I1436_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I145_XG_MP1 (I1436_G20_13 I1436_G16_13n XI1436_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I140_XG_MP2 (VDD I1436_G15_12n I1436_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I140_XG_MP0 (XI1436_I140_XG_p1 I1436_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I140_XG_MP1 (I1436_G15_8 I1436_G11_8n XI1436_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I82_XG_MP2 (VDD I1482_gn16 I1482_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I82_XG_MP0 (XI1482_I82_XG_p1 I1482_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I82_XG_MP1 (I1482_G16_15 I1482_gn15 XI1482_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I83_XG_MP2 (VDD I1482_gn17 I1482_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I83_XG_MP0 (XI1482_I83_XG_p1 I1482_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I83_XG_MP1 (I1482_G17_16 I1482_gn16 XI1482_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I140_XG_MP2 (VDD I1482_G15_12n I1482_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I140_XG_MP0 (XI1482_I140_XG_p1 I1482_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I140_XG_MP1 (I1482_G15_8 I1482_G11_8n XI1482_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I142_XG_MP2 (VDD I1482_G17_14n I1482_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I142_XG_MP0 (XI1482_I142_XG_p1 I1482_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I142_XG_MP1 (I1482_G17_10 I1482_G13_10n XI1482_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I145_XG_MP2 (VDD I1482_G20_17n I1482_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I145_XG_MP0 (XI1482_I145_XG_p1 I1482_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I145_XG_MP1 (I1482_G20_13 I1482_G16_13n XI1482_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I143_XG_MP2 (VDD I1482_G18_15n I1482_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I143_XG_MP0 (XI1482_I143_XG_p1 I1482_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I143_XG_MP1 (I1482_G18_11 I1482_G14_11n XI1482_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I86_XG_MP2 (VDD I1528_gn20 I1528_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I86_XG_MP0 (XI1528_I86_XG_p1 I1528_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I86_XG_MP1 (I1528_G20_19 I1528_gn19 XI1528_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I87_XG_MP2 (VDD I1528_gn21 I1528_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I87_XG_MP0 (XI1528_I87_XG_p1 I1528_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I87_XG_MP1 (I1528_G21_20 I1528_gn20 XI1528_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I201_XG_MP2 (VDD I1528_G30_15n c21_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I201_XG_MP0 (XI1528_I201_XG_p1 I1528_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I201_XG_MP1 (c21_m I1528_G14_0n XI1528_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I151_XG_MP2 (VDD I1528_G26_23n I1528_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I151_XG_MP0 (XI1528_I151_XG_p1 I1528_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I151_XG_MP1 (I1528_G26_19 I1528_G22_19n XI1528_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I148_XG_MP2 (VDD I1528_G23_20n I1528_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I148_XG_MP0 (XI1528_I148_XG_p1 I1528_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I148_XG_MP1 (I1528_G23_16 I1528_G19_16n XI1528_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I153_XG_MP2 (VDD I1160_G28_25n I1160_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I153_XG_MP0 (XI1160_I153_XG_p1 I1160_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I153_XG_MP1 (I1160_G28_21 I1160_G24_21n XI1160_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I151_XG_MP2 (VDD I1160_G26_23n I1160_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I151_XG_MP0 (XI1160_I151_XG_p1 I1160_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I151_XG_MP1 (I1160_G26_19 I1160_G22_19n XI1160_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I147_XG_MP2 (VDD I1160_G22_19n I1160_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I147_XG_MP0 (XI1160_I147_XG_p1 I1160_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I147_XG_MP1 (I1160_G22_15 I1160_G18_15n XI1160_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I199_XG_MP2 (VDD I1160_G28_13n I1160_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I199_XG_MP0 (XI1160_I199_XG_p1 I1160_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I199_XG_MP1 (I1160_G28_0 I1160_G12_0n XI1160_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I143_XG_MP2 (VDD I1160_G18_15n I1160_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I143_XG_MP0 (XI1160_I143_XG_p1 I1160_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I143_XG_MP1 (I1160_G18_11 I1160_G14_11n XI1160_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I139_XG_MP2 (VDD I1160_G14_11n I1160_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I139_XG_MP0 (XI1160_I139_XG_p1 I1160_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I139_XG_MP1 (I1160_G14_7 I1160_G10_7n XI1160_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I135_XG_MP2 (VDD I1160_G10_7n I1160_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I135_XG_MP0 (XI1160_I135_XG_p1 I1160_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I135_XG_MP1 (I1160_G10_3 I1160_G6_3n XI1160_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I80_XG_MP2 (VDD I1206_gn14 I1206_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I80_XG_MP0 (XI1206_I80_XG_p1 I1206_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I80_XG_MP1 (I1206_G14_13 I1206_gn13 XI1206_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I79_XG_MP2 (VDD I1206_gn13 I1206_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I79_XG_MP0 (XI1206_I79_XG_p1 I1206_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I79_XG_MP1 (I1206_G13_12 I1206_gn12 XI1206_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I134_XG_MP2 (VDD I1206_G9_6n I1206_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I134_XG_MP0 (XI1206_I134_XG_p1 I1206_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I134_XG_MP1 (I1206_G9_2 I1206_G5_2n XI1206_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I130_XG_MP2 (VDD I1206_G5_2n I1206_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I130_XG_MP0 (XI1206_I130_XG_p1 I1206_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I130_XG_MP1 (I1206_G5_0 I1206_G1_0n XI1206_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I141_XG_MP2 (VDD I1206_G16_13n I1206_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I141_XG_MP0 (XI1206_I141_XG_p1 I1206_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I141_XG_MP1 (I1206_G16_9 I1206_G12_9n XI1206_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I137_XG_MP2 (VDD I1206_G12_9n I1206_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I137_XG_MP0 (XI1206_I137_XG_p1 I1206_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I137_XG_MP1 (I1206_G12_5 I1206_G8_5n XI1206_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I83_XG_MP2 (VDD I1252_gn17 I1252_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I83_XG_MP0 (XI1252_I83_XG_p1 I1252_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I83_XG_MP1 (I1252_G17_16 I1252_gn16 XI1252_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I82_XG_MP2 (VDD I1252_gn16 I1252_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I82_XG_MP0 (XI1252_I82_XG_p1 I1252_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I82_XG_MP1 (I1252_G16_15 I1252_gn15 XI1252_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I149_XG_MP2 (VDD I1252_G24_21n I1252_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I149_XG_MP0 (XI1252_I149_XG_p1 I1252_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I149_XG_MP1 (I1252_G24_17 I1252_G20_17n XI1252_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I143_XG_MP2 (VDD I1252_G18_15n I1252_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I143_XG_MP0 (XI1252_I143_XG_p1 I1252_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I143_XG_MP1 (I1252_G18_11 I1252_G14_11n XI1252_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I140_XG_MP2 (VDD I1252_G15_12n I1252_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I140_XG_MP0 (XI1252_I140_XG_p1 I1252_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I140_XG_MP1 (I1252_G15_8 I1252_G11_8n XI1252_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I83_XG_MP2 (VDD I1298_gn17 I1298_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I83_XG_MP0 (XI1298_I83_XG_p1 I1298_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I83_XG_MP1 (I1298_G17_16 I1298_gn16 XI1298_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I84_XG_MP2 (VDD I1298_gn18 I1298_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I84_XG_MP0 (XI1298_I84_XG_p1 I1298_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I84_XG_MP1 (I1298_G18_17 I1298_gn17 XI1298_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I149_XG_MP2 (VDD I1298_G24_21n I1298_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I149_XG_MP0 (XI1298_I149_XG_p1 I1298_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I149_XG_MP1 (I1298_G24_17 I1298_G20_17n XI1298_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I197_XG_MP2 (VDD I1298_G26_11n I1298_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I197_XG_MP0 (XI1298_I197_XG_p1 I1298_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I197_XG_MP1 (I1298_G26_0 I1298_G10_0n XI1298_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I144_XG_MP2 (VDD I1298_G19_16n I1298_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I144_XG_MP0 (XI1298_I144_XG_p1 I1298_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I144_XG_MP1 (I1298_G19_12 I1298_G15_12n XI1298_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I190_XG_MP2 (VDD I1298_G21_6n I1298_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I190_XG_MP0 (XI1298_I190_XG_p1 I1298_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I190_XG_MP1 (I1298_G21_0 I1298_G5_0n XI1298_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I192_XG_MP2 (VDD I1344_G22_7n I1344_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I192_XG_MP0 (XI1344_I192_XG_p1 I1344_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I192_XG_MP1 (I1344_G22_0 I1344_G6_0n XI1344_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I85_XG_MP2 (VDD I1344_gn19 I1344_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I85_XG_MP0 (XI1344_I85_XG_p1 I1344_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I85_XG_MP1 (I1344_G19_18 I1344_gn18 XI1344_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I84_XG_MP2 (VDD I1344_gn18 I1344_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I84_XG_MP0 (XI1344_I84_XG_p1 I1344_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I84_XG_MP1 (I1344_G18_17 I1344_gn17 XI1344_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I146_XG_MP2 (VDD I1344_G21_18n I1344_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I146_XG_MP0 (XI1344_I146_XG_p1 I1344_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I146_XG_MP1 (I1344_G21_14 I1344_G17_14n XI1344_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I144_XG_MP2 (VDD I1344_G19_16n I1344_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I144_XG_MP0 (XI1344_I144_XG_p1 I1344_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I144_XG_MP1 (I1344_G19_12 I1344_G15_12n XI1344_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I85_XG_MP2 (VDD I1390_gn19 I1390_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I85_XG_MP0 (XI1390_I85_XG_p1 I1390_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I85_XG_MP1 (I1390_G19_18 I1390_gn18 XI1390_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I84_XG_MP2 (VDD I1390_gn18 I1390_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I84_XG_MP0 (XI1390_I84_XG_p1 I1390_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I84_XG_MP1 (I1390_G18_17 I1390_gn17 XI1390_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I149_XG_MP2 (VDD I1390_G24_21n I1390_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I149_XG_MP0 (XI1390_I149_XG_p1 I1390_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I149_XG_MP1 (I1390_G24_17 I1390_G20_17n XI1390_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I192_XG_MP2 (VDD I1390_G22_7n I1390_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I192_XG_MP0 (XI1390_I192_XG_p1 I1390_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I192_XG_MP1 (I1390_G22_0 I1390_G6_0n XI1390_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I146_XG_MP2 (VDD I1390_G21_18n I1390_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I146_XG_MP0 (XI1390_I146_XG_p1 I1390_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I146_XG_MP1 (I1390_G21_14 I1390_G17_14n XI1390_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I190_XG_MP2 (VDD I1390_G21_6n I1390_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I190_XG_MP0 (XI1390_I190_XG_p1 I1390_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I190_XG_MP1 (I1390_G21_0 I1390_G5_0n XI1390_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I84_XG_MP2 (VDD I1436_gn18 I1436_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I84_XG_MP0 (XI1436_I84_XG_p1 I1436_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I84_XG_MP1 (I1436_G18_17 I1436_gn17 XI1436_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I85_XG_MP2 (VDD I1436_gn19 I1436_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I85_XG_MP0 (XI1436_I85_XG_p1 I1436_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I85_XG_MP1 (I1436_G19_18 I1436_gn18 XI1436_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I149_XG_MP2 (VDD I1436_G24_21n I1436_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I149_XG_MP0 (XI1436_I149_XG_p1 I1436_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I149_XG_MP1 (I1436_G24_17 I1436_G20_17n XI1436_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I197_XG_MP2 (VDD I1436_G26_11n I1436_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I197_XG_MP0 (XI1436_I197_XG_p1 I1436_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I197_XG_MP1 (I1436_G26_0 I1436_G10_0n XI1436_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I144_XG_MP2 (VDD I1436_G19_16n I1436_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I144_XG_MP0 (XI1436_I144_XG_p1 I1436_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I144_XG_MP1 (I1436_G19_12 I1436_G15_12n XI1436_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I84_XG_MP2 (VDD I1482_gn18 I1482_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I84_XG_MP0 (XI1482_I84_XG_p1 I1482_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I84_XG_MP1 (I1482_G18_17 I1482_gn17 XI1482_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I186_XG_MP2 (VDD I1482_G19_4n I1482_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I186_XG_MP0 (XI1482_I186_XG_p1 I1482_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I186_XG_MP1 (I1482_G19_0 I1482_G3_0n XI1482_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I195_XG_MP2 (VDD I1482_G24_9n I1482_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I195_XG_MP0 (XI1482_I195_XG_p1 I1482_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I195_XG_MP1 (I1482_G24_0 I1482_G8_0n XI1482_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I197_XG_MP2 (VDD I1482_G26_11n I1482_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I197_XG_MP0 (XI1482_I197_XG_p1 I1482_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I197_XG_MP1 (I1482_G26_0 I1482_G10_0n XI1482_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I88_XG_MP2 (VDD I1528_gn22 I1528_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I88_XG_MP0 (XI1528_I88_XG_p1 I1528_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I88_XG_MP1 (I1528_G22_21 I1528_gn21 XI1528_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I153_XG_MP2 (VDD I1528_G28_25n I1528_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I153_XG_MP0 (XI1528_I153_XG_p1 I1528_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I153_XG_MP1 (I1528_G28_21 I1528_G24_21n XI1528_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I202_XG_MP2 (VDD I1528_G31_16n c21_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I202_XG_MP0 (XI1528_I202_XG_p1 I1528_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I202_XG_MP1 (c21_o I1528_G15_0n XI1528_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I152_XG_MP2 (VDD I1528_G27_24n I1528_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I152_XG_MP0 (XI1528_I152_XG_p1 I1528_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I152_XG_MP1 (I1528_G27_20 I1528_G23_20n XI1528_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I154_XG_MP2 (VDD I1528_G29_26n I1528_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I154_XG_MP0 (XI1528_I154_XG_p1 I1528_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I154_XG_MP1 (I1528_G29_22 I1528_G25_22n XI1528_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I94_XG_MP2 (VDD I1160_gn28 I1160_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I94_XG_MP0 (XI1160_I94_XG_p1 I1160_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I94_XG_MP1 (I1160_G28_27 I1160_gn27 XI1160_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I93_XG_MP2 (VDD I1160_gn27 I1160_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I93_XG_MP0 (XI1160_I93_XG_p1 I1160_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I93_XG_MP1 (I1160_G27_26 I1160_gn26 XI1160_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I92_XG_MP2 (VDD I1160_gn26 I1160_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I92_XG_MP0 (XI1160_I92_XG_p1 I1160_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I92_XG_MP1 (I1160_G26_25 I1160_gn25 XI1160_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I155_XG_MP2 (VDD I1160_G30_27n I1160_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I155_XG_MP0 (XI1160_I155_XG_p1 I1160_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I155_XG_MP1 (I1160_G30_23 I1160_G26_23n XI1160_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I197_XG_MP2 (VDD I1160_G26_11n I1160_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I197_XG_MP0 (XI1160_I197_XG_p1 I1160_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I197_XG_MP1 (I1160_G26_0 I1160_G10_0n XI1160_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I185_XG_MP2 (VDD I1160_G18_3n I1160_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I185_XG_MP0 (XI1160_I185_XG_p1 I1160_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I185_XG_MP1 (I1160_G18_0 I1160_G2_0n XI1160_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I82_XG_MP2 (VDD I1206_gn16 I1206_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I82_XG_MP0 (XI1206_I82_XG_p1 I1206_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I82_XG_MP1 (I1206_G16_15 I1206_gn15 XI1206_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I81_XG_MP2 (VDD I1206_gn15 I1206_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I81_XG_MP0 (XI1206_I81_XG_p1 I1206_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I81_XG_MP1 (I1206_G15_14 I1206_gn14 XI1206_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I138_XG_MP2 (VDD I1206_G13_10n I1206_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I138_XG_MP0 (XI1206_I138_XG_p1 I1206_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I138_XG_MP1 (I1206_G13_6 I1206_G9_6n XI1206_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I136_XG_MP2 (VDD I1206_G11_8n I1206_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I136_XG_MP0 (XI1206_I136_XG_p1 I1206_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I136_XG_MP1 (I1206_G11_4 I1206_G7_4n XI1206_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I184_XG_MP2 (VDD I1206_G17_2n I1206_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I184_XG_MP0 (XI1206_I184_XG_p1 I1206_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I184_XG_MP1 (I1206_G17_0 I1206_G1_0n XI1206_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I139_XG_MP2 (VDD I1206_G14_11n I1206_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I139_XG_MP0 (XI1206_I139_XG_p1 I1206_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I139_XG_MP1 (I1206_G14_7 I1206_G10_7n XI1206_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I185_XG_MP2 (VDD I1206_G18_3n I1206_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I185_XG_MP0 (XI1206_I185_XG_p1 I1206_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I185_XG_MP1 (I1206_G18_0 I1206_G2_0n XI1206_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I85_XG_MP2 (VDD I1252_gn19 I1252_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I85_XG_MP0 (XI1252_I85_XG_p1 I1252_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I85_XG_MP1 (I1252_G19_18 I1252_gn18 XI1252_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I84_XG_MP2 (VDD I1252_gn18 I1252_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I84_XG_MP0 (XI1252_I84_XG_p1 I1252_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I84_XG_MP1 (I1252_G18_17 I1252_gn17 XI1252_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I86_XG_MP2 (VDD I1252_gn20 I1252_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I86_XG_MP0 (XI1252_I86_XG_p1 I1252_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I86_XG_MP1 (I1252_G20_19 I1252_gn19 XI1252_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I197_XG_MP2 (VDD I1252_G26_11n I1252_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I197_XG_MP0 (XI1252_I197_XG_p1 I1252_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I197_XG_MP1 (I1252_G26_0 I1252_G10_0n XI1252_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I146_XG_MP2 (VDD I1252_G21_18n I1252_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I146_XG_MP0 (XI1252_I146_XG_p1 I1252_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I146_XG_MP1 (I1252_G21_14 I1252_G17_14n XI1252_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I144_XG_MP2 (VDD I1252_G19_16n I1252_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I144_XG_MP0 (XI1252_I144_XG_p1 I1252_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I144_XG_MP1 (I1252_G19_12 I1252_G15_12n XI1252_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I190_XG_MP2 (VDD I1252_G21_6n I1252_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I190_XG_MP0 (XI1252_I190_XG_p1 I1252_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I190_XG_MP1 (I1252_G21_0 I1252_G5_0n XI1252_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I86_XG_MP2 (VDD I1298_gn20 I1298_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I86_XG_MP0 (XI1298_I86_XG_p1 I1298_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I86_XG_MP1 (I1298_G20_19 I1298_gn19 XI1298_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I85_XG_MP2 (VDD I1298_gn19 I1298_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I85_XG_MP0 (XI1298_I85_XG_p1 I1298_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I85_XG_MP1 (I1298_G19_18 I1298_gn18 XI1298_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I147_XG_MP2 (VDD I1298_G22_19n I1298_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I147_XG_MP0 (XI1298_I147_XG_p1 I1298_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I147_XG_MP1 (I1298_G22_15 I1298_G18_15n XI1298_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I192_XG_MP2 (VDD I1298_G22_7n I1298_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I192_XG_MP0 (XI1298_I192_XG_p1 I1298_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I192_XG_MP1 (I1298_G22_0 I1298_G6_0n XI1298_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I146_XG_MP2 (VDD I1298_G21_18n I1298_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I146_XG_MP0 (XI1298_I146_XG_p1 I1298_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I146_XG_MP1 (I1298_G21_14 I1298_G17_14n XI1298_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I196_XG_MP2 (VDD I1298_G25_10n I1298_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I196_XG_MP0 (XI1298_I196_XG_p1 I1298_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I196_XG_MP1 (I1298_G25_0 I1298_G9_0n XI1298_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I151_XG_MP2 (VDD I1344_G26_23n I1344_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I151_XG_MP0 (XI1344_I151_XG_p1 I1344_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I151_XG_MP1 (I1344_G26_19 I1344_G22_19n XI1344_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I147_XG_MP2 (VDD I1344_G22_19n I1344_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I147_XG_MP0 (XI1344_I147_XG_p1 I1344_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I147_XG_MP1 (I1344_G22_15 I1344_G18_15n XI1344_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I86_XG_MP2 (VDD I1344_gn20 I1344_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I86_XG_MP0 (XI1344_I86_XG_p1 I1344_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I86_XG_MP1 (I1344_G20_19 I1344_gn19 XI1344_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I150_XG_MP2 (VDD I1344_G25_22n I1344_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I150_XG_MP0 (XI1344_I150_XG_p1 I1344_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I150_XG_MP1 (I1344_G25_18 I1344_G21_18n XI1344_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I198_XG_MP2 (VDD I1344_G27_12n I1344_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I198_XG_MP0 (XI1344_I198_XG_p1 I1344_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I198_XG_MP1 (I1344_G27_0 I1344_G11_0n XI1344_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I190_XG_MP2 (VDD I1344_G21_6n I1344_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I190_XG_MP0 (XI1344_I190_XG_p1 I1344_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I190_XG_MP1 (I1344_G21_0 I1344_G5_0n XI1344_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I86_XG_MP2 (VDD I1390_gn20 I1390_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I86_XG_MP0 (XI1390_I86_XG_p1 I1390_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I86_XG_MP1 (I1390_G20_19 I1390_gn19 XI1390_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I147_XG_MP2 (VDD I1390_G22_19n I1390_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I147_XG_MP0 (XI1390_I147_XG_p1 I1390_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I147_XG_MP1 (I1390_G22_15 I1390_G18_15n XI1390_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I151_XG_MP2 (VDD I1390_G26_23n I1390_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I151_XG_MP0 (XI1390_I151_XG_p1 I1390_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I151_XG_MP1 (I1390_G26_19 I1390_G22_19n XI1390_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I199_XG_MP2 (VDD I1390_G28_13n I1390_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I199_XG_MP0 (XI1390_I199_XG_p1 I1390_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I199_XG_MP1 (I1390_G28_0 I1390_G12_0n XI1390_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I150_XG_MP2 (VDD I1390_G25_22n I1390_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I150_XG_MP0 (XI1390_I150_XG_p1 I1390_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I150_XG_MP1 (I1390_G25_18 I1390_G21_18n XI1390_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I198_XG_MP2 (VDD I1390_G27_12n I1390_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I198_XG_MP0 (XI1390_I198_XG_p1 I1390_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I198_XG_MP1 (I1390_G27_0 I1390_G11_0n XI1390_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I86_XG_MP2 (VDD I1436_gn20 I1436_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I86_XG_MP0 (XI1436_I86_XG_p1 I1436_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I86_XG_MP1 (I1436_G20_19 I1436_gn19 XI1436_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I147_XG_MP2 (VDD I1436_G22_19n I1436_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I147_XG_MP0 (XI1436_I147_XG_p1 I1436_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I147_XG_MP1 (I1436_G22_15 I1436_G18_15n XI1436_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I151_XG_MP2 (VDD I1436_G26_23n I1436_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I151_XG_MP0 (XI1436_I151_XG_p1 I1436_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I151_XG_MP1 (I1436_G26_19 I1436_G22_19n XI1436_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I192_XG_MP2 (VDD I1436_G22_7n I1436_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I192_XG_MP0 (XI1436_I192_XG_p1 I1436_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I192_XG_MP1 (I1436_G22_0 I1436_G6_0n XI1436_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I146_XG_MP2 (VDD I1436_G21_18n I1436_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I146_XG_MP0 (XI1436_I146_XG_p1 I1436_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I146_XG_MP1 (I1436_G21_14 I1436_G17_14n XI1436_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I190_XG_MP2 (VDD I1436_G21_6n I1436_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I190_XG_MP0 (XI1436_I190_XG_p1 I1436_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I190_XG_MP1 (I1436_G21_0 I1436_G5_0n XI1436_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I86_XG_MP2 (VDD I1482_gn20 I1482_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I86_XG_MP0 (XI1482_I86_XG_p1 I1482_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I86_XG_MP1 (I1482_G20_19 I1482_gn19 XI1482_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I85_XG_MP2 (VDD I1482_gn19 I1482_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I85_XG_MP0 (XI1482_I85_XG_p1 I1482_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I85_XG_MP1 (I1482_G19_18 I1482_gn18 XI1482_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I144_XG_MP2 (VDD I1482_G19_16n I1482_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I144_XG_MP0 (XI1482_I144_XG_p1 I1482_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I144_XG_MP1 (I1482_G19_12 I1482_G15_12n XI1482_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I190_XG_MP2 (VDD I1482_G21_6n I1482_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I190_XG_MP0 (XI1482_I190_XG_p1 I1482_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I190_XG_MP1 (I1482_G21_0 I1482_G5_0n XI1482_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I149_XG_MP2 (VDD I1482_G24_21n I1482_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I149_XG_MP0 (XI1482_I149_XG_p1 I1482_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I149_XG_MP1 (I1482_G24_17 I1482_G20_17n XI1482_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I147_XG_MP2 (VDD I1482_G22_19n I1482_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I147_XG_MP0 (XI1482_I147_XG_p1 I1482_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I147_XG_MP1 (I1482_G22_15 I1482_G18_15n XI1482_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I192_XG_MP2 (VDD I1482_G22_7n I1482_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I192_XG_MP0 (XI1482_I192_XG_p1 I1482_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I192_XG_MP1 (I1482_G22_0 I1482_G6_0n XI1482_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I89_XG_MP2 (VDD I1528_gn23 I1528_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I89_XG_MP0 (XI1528_I89_XG_p1 I1528_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I89_XG_MP1 (I1528_G23_22 I1528_gn22 XI1528_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I90_XG_MP2 (VDD I1528_gn24 I1528_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I90_XG_MP0 (XI1528_I90_XG_p1 I1528_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I90_XG_MP1 (I1528_G24_23 I1528_gn23 XI1528_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I155_XG_MP2 (VDD I1528_G30_27n I1528_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I155_XG_MP0 (XI1528_I155_XG_p1 I1528_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I155_XG_MP1 (I1528_G30_23 I1528_G26_23n XI1528_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1528_I156_XG_MP2 (VDD I1528_G31_28n I1528_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1528_I156_XG_MP0 (XI1528_I156_XG_p1 I1528_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1528_I156_XG_MP1 (I1528_G31_24 I1528_G27_24n XI1528_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I201_XG_MP2 (VDD I1160_G30_15n c13_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I201_XG_MP0 (XI1160_I201_XG_p1 I1160_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I201_XG_MP1 (c13_m I1160_G14_0n XI1160_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1160_I192_XG_MP2 (VDD I1160_G22_7n I1160_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1160_I192_XG_MP0 (XI1160_I192_XG_p1 I1160_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1160_I192_XG_MP1 (I1160_G22_0 I1160_G6_0n XI1160_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I84_XG_MP2 (VDD I1206_gn18 I1206_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I84_XG_MP0 (XI1206_I84_XG_p1 I1206_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I84_XG_MP1 (I1206_G18_17 I1206_gn17 XI1206_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I83_XG_MP2 (VDD I1206_gn17 I1206_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I83_XG_MP0 (XI1206_I83_XG_p1 I1206_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I83_XG_MP1 (I1206_G17_16 I1206_gn16 XI1206_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I140_XG_MP2 (VDD I1206_G15_12n I1206_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I140_XG_MP0 (XI1206_I140_XG_p1 I1206_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I140_XG_MP1 (I1206_G15_8 I1206_G11_8n XI1206_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I142_XG_MP2 (VDD I1206_G17_14n I1206_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I142_XG_MP0 (XI1206_I142_XG_p1 I1206_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I142_XG_MP1 (I1206_G17_10 I1206_G13_10n XI1206_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I186_XG_MP2 (VDD I1206_G19_4n I1206_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I186_XG_MP0 (XI1206_I186_XG_p1 I1206_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I186_XG_MP1 (I1206_G19_0 I1206_G3_0n XI1206_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I143_XG_MP2 (VDD I1206_G18_15n I1206_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I143_XG_MP0 (XI1206_I143_XG_p1 I1206_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I143_XG_MP1 (I1206_G18_11 I1206_G14_11n XI1206_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1206_I188_XG_MP2 (VDD I1206_G20_5n I1206_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1206_I188_XG_MP0 (XI1206_I188_XG_p1 I1206_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1206_I188_XG_MP1 (I1206_G20_0 I1206_G4_0n XI1206_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I87_XG_MP2 (VDD I1252_gn21 I1252_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I87_XG_MP0 (XI1252_I87_XG_p1 I1252_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I87_XG_MP1 (I1252_G21_20 I1252_gn20 XI1252_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I147_XG_MP2 (VDD I1252_G22_19n I1252_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I147_XG_MP0 (XI1252_I147_XG_p1 I1252_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I147_XG_MP1 (I1252_G22_15 I1252_G18_15n XI1252_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I151_XG_MP2 (VDD I1252_G26_23n I1252_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I151_XG_MP0 (XI1252_I151_XG_p1 I1252_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I151_XG_MP1 (I1252_G26_19 I1252_G22_19n XI1252_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I192_XG_MP2 (VDD I1252_G22_7n I1252_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I192_XG_MP0 (XI1252_I192_XG_p1 I1252_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I192_XG_MP1 (I1252_G22_0 I1252_G6_0n XI1252_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I150_XG_MP2 (VDD I1252_G25_22n I1252_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I150_XG_MP0 (XI1252_I150_XG_p1 I1252_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I150_XG_MP1 (I1252_G25_18 I1252_G21_18n XI1252_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1252_I198_XG_MP2 (VDD I1252_G27_12n I1252_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1252_I198_XG_MP0 (XI1252_I198_XG_p1 I1252_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1252_I198_XG_MP1 (I1252_G27_0 I1252_G11_0n XI1252_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I88_XG_MP2 (VDD I1298_gn22 I1298_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I88_XG_MP0 (XI1298_I88_XG_p1 I1298_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I88_XG_MP1 (I1298_G22_21 I1298_gn21 XI1298_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I87_XG_MP2 (VDD I1298_gn21 I1298_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I87_XG_MP0 (XI1298_I87_XG_p1 I1298_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I87_XG_MP1 (I1298_G21_20 I1298_gn20 XI1298_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I151_XG_MP2 (VDD I1298_G26_23n I1298_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I151_XG_MP0 (XI1298_I151_XG_p1 I1298_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I151_XG_MP1 (I1298_G26_19 I1298_G22_19n XI1298_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I199_XG_MP2 (VDD I1298_G28_13n I1298_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I199_XG_MP0 (XI1298_I199_XG_p1 I1298_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I199_XG_MP1 (I1298_G28_0 I1298_G12_0n XI1298_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I150_XG_MP2 (VDD I1298_G25_22n I1298_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I150_XG_MP0 (XI1298_I150_XG_p1 I1298_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I150_XG_MP1 (I1298_G25_18 I1298_G21_18n XI1298_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1298_I194_XG_MP2 (VDD I1298_G23_8n I1298_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1298_I194_XG_MP0 (XI1298_I194_XG_p1 I1298_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1298_I194_XG_MP1 (I1298_G23_0 I1298_G7_0n XI1298_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I201_XG_MP2 (VDD I1344_G30_15n c17_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I201_XG_MP0 (XI1344_I201_XG_p1 I1344_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I201_XG_MP1 (c17_m I1344_G14_0n XI1344_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I199_XG_MP2 (VDD I1344_G28_13n I1344_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I199_XG_MP0 (XI1344_I199_XG_p1 I1344_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I199_XG_MP1 (I1344_G28_0 I1344_G12_0n XI1344_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I87_XG_MP2 (VDD I1344_gn21 I1344_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I87_XG_MP0 (XI1344_I87_XG_p1 I1344_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I87_XG_MP1 (I1344_G21_20 I1344_gn20 XI1344_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I88_XG_MP2 (VDD I1344_gn22 I1344_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I88_XG_MP0 (XI1344_I88_XG_p1 I1344_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I88_XG_MP1 (I1344_G22_21 I1344_gn21 XI1344_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I148_XG_MP2 (VDD I1344_G23_20n I1344_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I148_XG_MP0 (XI1344_I148_XG_p1 I1344_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I148_XG_MP1 (I1344_G23_16 I1344_G19_16n XI1344_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1344_I194_XG_MP2 (VDD I1344_G23_8n I1344_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1344_I194_XG_MP0 (XI1344_I194_XG_p1 I1344_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1344_I194_XG_MP1 (I1344_G23_0 I1344_G7_0n XI1344_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I88_XG_MP2 (VDD I1390_gn22 I1390_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I88_XG_MP0 (XI1390_I88_XG_p1 I1390_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I88_XG_MP1 (I1390_G22_21 I1390_gn21 XI1390_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I87_XG_MP2 (VDD I1390_gn21 I1390_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I87_XG_MP0 (XI1390_I87_XG_p1 I1390_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I87_XG_MP1 (I1390_G21_20 I1390_gn20 XI1390_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I153_XG_MP2 (VDD I1390_G28_25n I1390_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I153_XG_MP0 (XI1390_I153_XG_p1 I1390_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I153_XG_MP1 (I1390_G28_21 I1390_G24_21n XI1390_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I201_XG_MP2 (VDD I1390_G30_15n c18_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I201_XG_MP0 (XI1390_I201_XG_p1 I1390_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I201_XG_MP1 (c18_m I1390_G14_0n XI1390_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I148_XG_MP2 (VDD I1390_G23_20n I1390_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I148_XG_MP0 (XI1390_I148_XG_p1 I1390_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I148_XG_MP1 (I1390_G23_16 I1390_G19_16n XI1390_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1390_I194_XG_MP2 (VDD I1390_G23_8n I1390_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1390_I194_XG_MP0 (XI1390_I194_XG_p1 I1390_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1390_I194_XG_MP1 (I1390_G23_0 I1390_G7_0n XI1390_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I87_XG_MP2 (VDD I1436_gn21 I1436_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I87_XG_MP0 (XI1436_I87_XG_p1 I1436_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I87_XG_MP1 (I1436_G21_20 I1436_gn20 XI1436_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I199_XG_MP2 (VDD I1436_G28_13n I1436_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I199_XG_MP0 (XI1436_I199_XG_p1 I1436_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I199_XG_MP1 (I1436_G28_0 I1436_G12_0n XI1436_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I150_XG_MP2 (VDD I1436_G25_22n I1436_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I150_XG_MP0 (XI1436_I150_XG_p1 I1436_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I150_XG_MP1 (I1436_G25_18 I1436_G21_18n XI1436_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1436_I196_XG_MP2 (VDD I1436_G25_10n I1436_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1436_I196_XG_MP0 (XI1436_I196_XG_p1 I1436_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1436_I196_XG_MP1 (I1436_G25_0 I1436_G9_0n XI1436_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I87_XG_MP2 (VDD I1482_gn21 I1482_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I87_XG_MP0 (XI1482_I87_XG_p1 I1482_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I87_XG_MP1 (I1482_G21_20 I1482_gn20 XI1482_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I146_XG_MP2 (VDD I1482_G21_18n I1482_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I146_XG_MP0 (XI1482_I146_XG_p1 I1482_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I146_XG_MP1 (I1482_G21_14 I1482_G17_14n XI1482_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I150_XG_MP2 (VDD I1482_G25_22n I1482_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I150_XG_MP0 (XI1482_I150_XG_p1 I1482_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I150_XG_MP1 (I1482_G25_18 I1482_G21_18n XI1482_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I196_XG_MP2 (VDD I1482_G25_10n I1482_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I196_XG_MP0 (XI1482_I196_XG_p1 I1482_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1482_I196_XG_MP1 (I1482_G25_0 I1482_G9_0n XI1482_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1482_I199_XG_MP2 (VDD I1482_G28_13n I1482_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1482_I199_XG_MP0 (XI1482_I199_XG_p1 I1482_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I199_XG_MP1 (I1482_G28_0 I1482_G12_0n XI1482_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I151_XG_MP2 (VDD I1482_G26_23n I1482_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I151_XG_MP0 (XI1482_I151_XG_p1 I1482_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I151_XG_MP1 (I1482_G26_19 I1482_G22_19n XI1482_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I201_XG_MP2 (VDD I1482_G30_15n c20_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I201_XG_MP0 (XI1482_I201_XG_p1 I1482_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I201_XG_MP1 (c20_m I1482_G14_0n XI1482_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I91_XG_MP2 (VDD I1528_gn25 I1528_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I91_XG_MP0 (XI1528_I91_XG_p1 I1528_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I91_XG_MP1 (I1528_G25_24 I1528_gn24 XI1528_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I87_XG_MP2 (VDD I1206_gn21 I1206_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I87_XG_MP0 (XI1206_I87_XG_p1 I1206_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I87_XG_MP1 (I1206_G21_20 I1206_gn20 XI1206_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I86_XG_MP2 (VDD I1206_gn20 I1206_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I86_XG_MP0 (XI1206_I86_XG_p1 I1206_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I86_XG_MP1 (I1206_G20_19 I1206_gn19 XI1206_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I85_XG_MP2 (VDD I1206_gn19 I1206_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I85_XG_MP0 (XI1206_I85_XG_p1 I1206_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I85_XG_MP1 (I1206_G19_18 I1206_gn18 XI1206_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I144_XG_MP2 (VDD I1206_G19_16n I1206_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I144_XG_MP0 (XI1206_I144_XG_p1 I1206_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I144_XG_MP1 (I1206_G19_12 I1206_G15_12n XI1206_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I190_XG_MP2 (VDD I1206_G21_6n I1206_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I190_XG_MP0 (XI1206_I190_XG_p1 I1206_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I190_XG_MP1 (I1206_G21_0 I1206_G5_0n XI1206_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I149_XG_MP2 (VDD I1206_G24_21n I1206_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I149_XG_MP0 (XI1206_I149_XG_p1 I1206_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I149_XG_MP1 (I1206_G24_17 I1206_G20_17n XI1206_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I145_XG_MP2 (VDD I1206_G20_17n I1206_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I145_XG_MP0 (XI1206_I145_XG_p1 I1206_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I145_XG_MP1 (I1206_G20_13 I1206_G16_13n XI1206_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I195_XG_MP2 (VDD I1206_G24_9n I1206_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I195_XG_MP0 (XI1206_I195_XG_p1 I1206_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I195_XG_MP1 (I1206_G24_0 I1206_G8_0n XI1206_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I88_XG_MP2 (VDD I1252_gn22 I1252_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I88_XG_MP0 (XI1252_I88_XG_p1 I1252_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I88_XG_MP1 (I1252_G22_21 I1252_gn21 XI1252_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I153_XG_MP2 (VDD I1252_G28_25n I1252_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I153_XG_MP0 (XI1252_I153_XG_p1 I1252_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I153_XG_MP1 (I1252_G28_21 I1252_G24_21n XI1252_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I199_XG_MP2 (VDD I1252_G28_13n I1252_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I199_XG_MP0 (XI1252_I199_XG_p1 I1252_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I199_XG_MP1 (I1252_G28_0 I1252_G12_0n XI1252_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I152_XG_MP2 (VDD I1252_G27_24n I1252_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I152_XG_MP0 (XI1252_I152_XG_p1 I1252_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I152_XG_MP1 (I1252_G27_20 I1252_G23_20n XI1252_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I148_XG_MP2 (VDD I1252_G23_20n I1252_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I148_XG_MP0 (XI1252_I148_XG_p1 I1252_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I148_XG_MP1 (I1252_G23_16 I1252_G19_16n XI1252_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I194_XG_MP2 (VDD I1252_G23_8n I1252_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I194_XG_MP0 (XI1252_I194_XG_p1 I1252_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I194_XG_MP1 (I1252_G23_0 I1252_G7_0n XI1252_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I89_XG_MP2 (VDD I1298_gn23 I1298_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I89_XG_MP0 (XI1298_I89_XG_p1 I1298_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I89_XG_MP1 (I1298_G23_22 I1298_gn22 XI1298_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I153_XG_MP2 (VDD I1298_G28_25n I1298_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I153_XG_MP0 (XI1298_I153_XG_p1 I1298_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I153_XG_MP1 (I1298_G28_21 I1298_G24_21n XI1298_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I201_XG_MP2 (VDD I1298_G30_15n c16_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I201_XG_MP0 (XI1298_I201_XG_p1 I1298_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I201_XG_MP1 (c16_m I1298_G14_0n XI1298_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I152_XG_MP2 (VDD I1298_G27_24n I1298_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I152_XG_MP0 (XI1298_I152_XG_p1 I1298_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I152_XG_MP1 (I1298_G27_20 I1298_G23_20n XI1298_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I148_XG_MP2 (VDD I1298_G23_20n I1298_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I148_XG_MP0 (XI1298_I148_XG_p1 I1298_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I148_XG_MP1 (I1298_G23_16 I1298_G19_16n XI1298_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I198_XG_MP2 (VDD I1298_G27_12n I1298_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I198_XG_MP0 (XI1298_I198_XG_p1 I1298_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I198_XG_MP1 (I1298_G27_0 I1298_G11_0n XI1298_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I153_XG_MP2 (VDD I1344_G28_25n I1344_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I153_XG_MP0 (XI1344_I153_XG_p1 I1344_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I153_XG_MP1 (I1344_G28_21 I1344_G24_21n XI1344_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I90_XG_MP2 (VDD I1344_gn24 I1344_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I90_XG_MP0 (XI1344_I90_XG_p1 I1344_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I90_XG_MP1 (I1344_G24_23 I1344_gn23 XI1344_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I89_XG_MP2 (VDD I1344_gn23 I1344_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I89_XG_MP0 (XI1344_I89_XG_p1 I1344_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I89_XG_MP1 (I1344_G23_22 I1344_gn22 XI1344_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I152_XG_MP2 (VDD I1344_G27_24n I1344_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I152_XG_MP0 (XI1344_I152_XG_p1 I1344_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I152_XG_MP1 (I1344_G27_20 I1344_G23_20n XI1344_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I89_XG_MP2 (VDD I1390_gn23 I1390_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I89_XG_MP0 (XI1390_I89_XG_p1 I1390_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I89_XG_MP1 (I1390_G23_22 I1390_gn22 XI1390_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I90_XG_MP2 (VDD I1390_gn24 I1390_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I90_XG_MP0 (XI1390_I90_XG_p1 I1390_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I90_XG_MP1 (I1390_G24_23 I1390_gn23 XI1390_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I152_XG_MP2 (VDD I1390_G27_24n I1390_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I152_XG_MP0 (XI1390_I152_XG_p1 I1390_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I152_XG_MP1 (I1390_G27_20 I1390_G23_20n XI1390_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I200_XG_MP2 (VDD I1390_G29_14n I1390_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I200_XG_MP0 (XI1390_I200_XG_p1 I1390_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I200_XG_MP1 (I1390_G29_0 I1390_G13_0n XI1390_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I88_XG_MP2 (VDD I1436_gn22 I1436_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I88_XG_MP0 (XI1436_I88_XG_p1 I1436_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I88_XG_MP1 (I1436_G22_21 I1436_gn21 XI1436_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I89_XG_MP2 (VDD I1436_gn23 I1436_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I89_XG_MP0 (XI1436_I89_XG_p1 I1436_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I89_XG_MP1 (I1436_G23_22 I1436_gn22 XI1436_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I153_XG_MP2 (VDD I1436_G28_25n I1436_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I153_XG_MP0 (XI1436_I153_XG_p1 I1436_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I153_XG_MP1 (I1436_G28_21 I1436_G24_21n XI1436_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I201_XG_MP2 (VDD I1436_G30_15n c19_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I201_XG_MP0 (XI1436_I201_XG_p1 I1436_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I201_XG_MP1 (c19_m I1436_G14_0n XI1436_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I148_XG_MP2 (VDD I1436_G23_20n I1436_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I148_XG_MP0 (XI1436_I148_XG_p1 I1436_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I148_XG_MP1 (I1436_G23_16 I1436_G19_16n XI1436_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I200_XG_MP2 (VDD I1436_G29_14n I1436_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I200_XG_MP0 (XI1436_I200_XG_p1 I1436_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I200_XG_MP1 (I1436_G29_0 I1436_G13_0n XI1436_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I194_XG_MP2 (VDD I1436_G23_8n I1436_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I194_XG_MP0 (XI1436_I194_XG_p1 I1436_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I194_XG_MP1 (I1436_G23_0 I1436_G7_0n XI1436_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I88_XG_MP2 (VDD I1482_gn22 I1482_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I88_XG_MP0 (XI1482_I88_XG_p1 I1482_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I88_XG_MP1 (I1482_G22_21 I1482_gn21 XI1482_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I194_XG_MP2 (VDD I1482_G23_8n I1482_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I194_XG_MP0 (XI1482_I194_XG_p1 I1482_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I194_XG_MP1 (I1482_G23_0 I1482_G7_0n XI1482_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I200_XG_MP2 (VDD I1482_G29_14n I1482_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I200_XG_MP0 (XI1482_I200_XG_p1 I1482_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I200_XG_MP1 (I1482_G29_0 I1482_G13_0n XI1482_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I90_XG_MP2 (VDD I1482_gn24 I1482_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I90_XG_MP0 (XI1482_I90_XG_p1 I1482_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I90_XG_MP1 (I1482_G24_23 I1482_gn23 XI1482_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I153_XG_MP2 (VDD I1482_G28_25n I1482_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I153_XG_MP0 (XI1482_I153_XG_p1 I1482_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I153_XG_MP1 (I1482_G28_21 I1482_G24_21n XI1482_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I155_XG_MP2 (VDD I1482_G30_27n I1482_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I155_XG_MP0 (XI1482_I155_XG_p1 I1482_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I155_XG_MP1 (I1482_G30_23 I1482_G26_23n XI1482_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I92_XG_MP2 (VDD I1528_gn26 I1528_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I92_XG_MP0 (XI1528_I92_XG_p1 I1528_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I92_XG_MP1 (I1528_G26_25 I1528_gn25 XI1528_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I94_XG_MP2 (VDD I1528_gn28 I1528_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I94_XG_MP0 (XI1528_I94_XG_p1 I1528_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I94_XG_MP1 (I1528_G28_27 I1528_gn27 XI1528_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I93_XG_MP2 (VDD I1528_gn27 I1528_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I93_XG_MP0 (XI1528_I93_XG_p1 I1528_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I93_XG_MP1 (I1528_G27_26 I1528_gn26 XI1528_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I89_XG_MP2 (VDD I1206_gn23 I1206_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I89_XG_MP0 (XI1206_I89_XG_p1 I1206_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I89_XG_MP1 (I1206_G23_22 I1206_gn22 XI1206_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I88_XG_MP2 (VDD I1206_gn22 I1206_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I88_XG_MP0 (XI1206_I88_XG_p1 I1206_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I88_XG_MP1 (I1206_G22_21 I1206_gn21 XI1206_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I202_XG_MP2 (VDD I1206_G31_16n c14_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I202_XG_MP0 (XI1206_I202_XG_p1 I1206_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I202_XG_MP1 (c14_o I1206_G15_0n XI1206_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I146_XG_MP2 (VDD I1206_G21_18n I1206_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I146_XG_MP0 (XI1206_I146_XG_p1 I1206_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I146_XG_MP1 (I1206_G21_14 I1206_G17_14n XI1206_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I196_XG_MP2 (VDD I1206_G25_10n I1206_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I196_XG_MP0 (XI1206_I196_XG_p1 I1206_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I196_XG_MP1 (I1206_G25_0 I1206_G9_0n XI1206_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I192_XG_MP2 (VDD I1206_G22_7n I1206_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I192_XG_MP0 (XI1206_I192_XG_p1 I1206_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I192_XG_MP1 (I1206_G22_0 I1206_G6_0n XI1206_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I89_XG_MP2 (VDD I1252_gn23 I1252_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I89_XG_MP0 (XI1252_I89_XG_p1 I1252_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I89_XG_MP1 (I1252_G23_22 I1252_gn22 XI1252_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I90_XG_MP2 (VDD I1252_gn24 I1252_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I90_XG_MP0 (XI1252_I90_XG_p1 I1252_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I90_XG_MP1 (I1252_G24_23 I1252_gn23 XI1252_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I201_XG_MP2 (VDD I1252_G30_15n c15_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I201_XG_MP0 (XI1252_I201_XG_p1 I1252_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I201_XG_MP1 (c15_m I1252_G14_0n XI1252_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I154_XG_MP2 (VDD I1252_G29_26n I1252_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I154_XG_MP0 (XI1252_I154_XG_p1 I1252_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I154_XG_MP1 (I1252_G29_22 I1252_G25_22n XI1252_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I200_XG_MP2 (VDD I1252_G29_14n I1252_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I200_XG_MP0 (XI1252_I200_XG_p1 I1252_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I200_XG_MP1 (I1252_G29_0 I1252_G13_0n XI1252_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I91_XG_MP2 (VDD I1298_gn25 I1298_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I91_XG_MP0 (XI1298_I91_XG_p1 I1298_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I91_XG_MP1 (I1298_G25_24 I1298_gn24 XI1298_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I90_XG_MP2 (VDD I1298_gn24 I1298_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I90_XG_MP0 (XI1298_I90_XG_p1 I1298_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I90_XG_MP1 (I1298_G24_23 I1298_gn23 XI1298_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I155_XG_MP2 (VDD I1298_G30_27n I1298_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I155_XG_MP0 (XI1298_I155_XG_p1 I1298_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I155_XG_MP1 (I1298_G30_23 I1298_G26_23n XI1298_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I200_XG_MP2 (VDD I1298_G29_14n I1298_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I200_XG_MP0 (XI1298_I200_XG_p1 I1298_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I200_XG_MP1 (I1298_G29_0 I1298_G13_0n XI1298_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I155_XG_MP2 (VDD I1344_G30_27n I1344_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I155_XG_MP0 (XI1344_I155_XG_p1 I1344_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I155_XG_MP1 (I1344_G30_23 I1344_G26_23n XI1344_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I154_XG_MP2 (VDD I1344_G29_26n I1344_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I154_XG_MP0 (XI1344_I154_XG_p1 I1344_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I154_XG_MP1 (I1344_G29_22 I1344_G25_22n XI1344_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I200_XG_MP2 (VDD I1344_G29_14n I1344_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I200_XG_MP0 (XI1344_I200_XG_p1 I1344_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I200_XG_MP1 (I1344_G29_0 I1344_G13_0n XI1344_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I91_XG_MP2 (VDD I1390_gn25 I1390_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I91_XG_MP0 (XI1390_I91_XG_p1 I1390_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I91_XG_MP1 (I1390_G25_24 I1390_gn24 XI1390_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I155_XG_MP2 (VDD I1390_G30_27n I1390_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I155_XG_MP0 (XI1390_I155_XG_p1 I1390_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I155_XG_MP1 (I1390_G30_23 I1390_G26_23n XI1390_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I154_XG_MP2 (VDD I1390_G29_26n I1390_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I154_XG_MP0 (XI1390_I154_XG_p1 I1390_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I154_XG_MP1 (I1390_G29_22 I1390_G25_22n XI1390_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I202_XG_MP2 (VDD I1390_G31_16n c18_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I202_XG_MP0 (XI1390_I202_XG_p1 I1390_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I202_XG_MP1 (c18_o I1390_G15_0n XI1390_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I90_XG_MP2 (VDD I1436_gn24 I1436_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I90_XG_MP0 (XI1436_I90_XG_p1 I1436_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I90_XG_MP1 (I1436_G24_23 I1436_gn23 XI1436_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I91_XG_MP2 (VDD I1436_gn25 I1436_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I91_XG_MP0 (XI1436_I91_XG_p1 I1436_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I91_XG_MP1 (I1436_G25_24 I1436_gn24 XI1436_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I155_XG_MP2 (VDD I1436_G30_27n I1436_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I155_XG_MP0 (XI1436_I155_XG_p1 I1436_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I155_XG_MP1 (I1436_G30_23 I1436_G26_23n XI1436_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I154_XG_MP2 (VDD I1436_G29_26n I1436_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I154_XG_MP0 (XI1436_I154_XG_p1 I1436_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I154_XG_MP1 (I1436_G29_22 I1436_G25_22n XI1436_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I152_XG_MP2 (VDD I1436_G27_24n I1436_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I152_XG_MP0 (XI1436_I152_XG_p1 I1436_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I152_XG_MP1 (I1436_G27_20 I1436_G23_20n XI1436_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I198_XG_MP2 (VDD I1436_G27_12n I1436_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I198_XG_MP0 (XI1436_I198_XG_p1 I1436_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I198_XG_MP1 (I1436_G27_0 I1436_G11_0n XI1436_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I89_XG_MP2 (VDD I1482_gn23 I1482_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I89_XG_MP0 (XI1482_I89_XG_p1 I1482_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I89_XG_MP1 (I1482_G23_22 I1482_gn22 XI1482_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I148_XG_MP2 (VDD I1482_G23_20n I1482_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I148_XG_MP0 (XI1482_I148_XG_p1 I1482_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I148_XG_MP1 (I1482_G23_16 I1482_G19_16n XI1482_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I198_XG_MP2 (VDD I1482_G27_12n I1482_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I198_XG_MP0 (XI1482_I198_XG_p1 I1482_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I198_XG_MP1 (I1482_G27_0 I1482_G11_0n XI1482_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I91_XG_MP2 (VDD I1482_gn25 I1482_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I91_XG_MP0 (XI1482_I91_XG_p1 I1482_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I91_XG_MP1 (I1482_G25_24 I1482_gn24 XI1482_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I92_XG_MP2 (VDD I1482_gn26 I1482_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I92_XG_MP0 (XI1482_I92_XG_p1 I1482_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I92_XG_MP1 (I1482_G26_25 I1482_gn25 XI1482_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I96_XG_MP2 (VDD I1528_gn30 I1528_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I96_XG_MP0 (XI1528_I96_XG_p1 I1528_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I96_XG_MP1 (I1528_G30_29 I1528_gn29 XI1528_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I95_XG_MP2 (VDD I1528_gn29 I1528_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I95_XG_MP0 (XI1528_I95_XG_p1 I1528_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I95_XG_MP1 (I1528_G29_28 I1528_gn28 XI1528_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I90_XG_MP2 (VDD I1206_gn24 I1206_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I90_XG_MP0 (XI1206_I90_XG_p1 I1206_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I90_XG_MP1 (I1206_G24_23 I1206_gn23 XI1206_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I91_XG_MP2 (VDD I1206_gn25 I1206_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I91_XG_MP0 (XI1206_I91_XG_p1 I1206_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I91_XG_MP1 (I1206_G25_24 I1206_gn24 XI1206_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I152_XG_MP2 (VDD I1206_G27_24n I1206_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I152_XG_MP0 (XI1206_I152_XG_p1 I1206_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I152_XG_MP1 (I1206_G27_20 I1206_G23_20n XI1206_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I148_XG_MP2 (VDD I1206_G23_20n I1206_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I148_XG_MP0 (XI1206_I148_XG_p1 I1206_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I148_XG_MP1 (I1206_G23_16 I1206_G19_16n XI1206_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I150_XG_MP2 (VDD I1206_G25_22n I1206_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I150_XG_MP0 (XI1206_I150_XG_p1 I1206_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I150_XG_MP1 (I1206_G25_18 I1206_G21_18n XI1206_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I194_XG_MP2 (VDD I1206_G23_8n I1206_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I194_XG_MP0 (XI1206_I194_XG_p1 I1206_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I194_XG_MP1 (I1206_G23_0 I1206_G7_0n XI1206_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I151_XG_MP2 (VDD I1206_G26_23n I1206_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I151_XG_MP0 (XI1206_I151_XG_p1 I1206_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I151_XG_MP1 (I1206_G26_19 I1206_G22_19n XI1206_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I147_XG_MP2 (VDD I1206_G22_19n I1206_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I147_XG_MP0 (XI1206_I147_XG_p1 I1206_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I147_XG_MP1 (I1206_G22_15 I1206_G18_15n XI1206_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I197_XG_MP2 (VDD I1206_G26_11n I1206_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I197_XG_MP0 (XI1206_I197_XG_p1 I1206_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I197_XG_MP1 (I1206_G26_0 I1206_G10_0n XI1206_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I92_XG_MP2 (VDD I1252_gn26 I1252_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I92_XG_MP0 (XI1252_I92_XG_p1 I1252_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I92_XG_MP1 (I1252_G26_25 I1252_gn25 XI1252_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I91_XG_MP2 (VDD I1252_gn25 I1252_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I91_XG_MP0 (XI1252_I91_XG_p1 I1252_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I91_XG_MP1 (I1252_G25_24 I1252_gn24 XI1252_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I155_XG_MP2 (VDD I1252_G30_27n I1252_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I155_XG_MP0 (XI1252_I155_XG_p1 I1252_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I155_XG_MP1 (I1252_G30_23 I1252_G26_23n XI1252_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I156_XG_MP2 (VDD I1252_G31_28n I1252_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I156_XG_MP0 (XI1252_I156_XG_p1 I1252_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I156_XG_MP1 (I1252_G31_24 I1252_G27_24n XI1252_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I202_XG_MP2 (VDD I1252_G31_16n c15_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I202_XG_MP0 (XI1252_I202_XG_p1 I1252_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I202_XG_MP1 (c15_o I1252_G15_0n XI1252_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I92_XG_MP2 (VDD I1298_gn26 I1298_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I92_XG_MP0 (XI1298_I92_XG_p1 I1298_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I92_XG_MP1 (I1298_G26_25 I1298_gn25 XI1298_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I93_XG_MP2 (VDD I1298_gn27 I1298_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I93_XG_MP0 (XI1298_I93_XG_p1 I1298_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I93_XG_MP1 (I1298_G27_26 I1298_gn26 XI1298_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I154_XG_MP2 (VDD I1298_G29_26n I1298_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I154_XG_MP0 (XI1298_I154_XG_p1 I1298_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I154_XG_MP1 (I1298_G29_22 I1298_G25_22n XI1298_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I92_XG_MP2 (VDD I1344_gn26 I1344_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I92_XG_MP0 (XI1344_I92_XG_p1 I1344_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I92_XG_MP1 (I1344_G26_25 I1344_gn25 XI1344_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I93_XG_MP2 (VDD I1344_gn27 I1344_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I93_XG_MP0 (XI1344_I93_XG_p1 I1344_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I93_XG_MP1 (I1344_G27_26 I1344_gn26 XI1344_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I91_XG_MP2 (VDD I1344_gn25 I1344_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I91_XG_MP0 (XI1344_I91_XG_p1 I1344_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I91_XG_MP1 (I1344_G25_24 I1344_gn24 XI1344_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I156_XG_MP2 (VDD I1344_G31_28n I1344_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I156_XG_MP0 (XI1344_I156_XG_p1 I1344_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I156_XG_MP1 (I1344_G31_24 I1344_G27_24n XI1344_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I202_XG_MP2 (VDD I1344_G31_16n c17_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I202_XG_MP0 (XI1344_I202_XG_p1 I1344_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I202_XG_MP1 (c17_o I1344_G15_0n XI1344_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I93_XG_MP2 (VDD I1390_gn27 I1390_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I93_XG_MP0 (XI1390_I93_XG_p1 I1390_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I93_XG_MP1 (I1390_G27_26 I1390_gn26 XI1390_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I92_XG_MP2 (VDD I1390_gn26 I1390_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I92_XG_MP0 (XI1390_I92_XG_p1 I1390_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I92_XG_MP1 (I1390_G26_25 I1390_gn25 XI1390_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I94_XG_MP2 (VDD I1390_gn28 I1390_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I94_XG_MP0 (XI1390_I94_XG_p1 I1390_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I94_XG_MP1 (I1390_G28_27 I1390_gn27 XI1390_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I156_XG_MP2 (VDD I1390_G31_28n I1390_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I156_XG_MP0 (XI1390_I156_XG_p1 I1390_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I156_XG_MP1 (I1390_G31_24 I1390_G27_24n XI1390_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I93_XG_MP2 (VDD I1436_gn27 I1436_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I93_XG_MP0 (XI1436_I93_XG_p1 I1436_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I93_XG_MP1 (I1436_G27_26 I1436_gn26 XI1436_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I92_XG_MP2 (VDD I1436_gn26 I1436_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I92_XG_MP0 (XI1436_I92_XG_p1 I1436_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I92_XG_MP1 (I1436_G26_25 I1436_gn25 XI1436_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I202_XG_MP2 (VDD I1436_G31_16n c19_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I202_XG_MP0 (XI1436_I202_XG_p1 I1436_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I202_XG_MP1 (c19_o I1436_G15_0n XI1436_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I202_XG_MP2 (VDD I1482_G31_16n c20_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I202_XG_MP0 (XI1482_I202_XG_p1 I1482_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I202_XG_MP1 (c20_o I1482_G15_0n XI1482_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I152_XG_MP2 (VDD I1482_G27_24n I1482_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I152_XG_MP0 (XI1482_I152_XG_p1 I1482_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I152_XG_MP1 (I1482_G27_20 I1482_G23_20n XI1482_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I154_XG_MP2 (VDD I1482_G29_26n I1482_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I154_XG_MP0 (XI1482_I154_XG_p1 I1482_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I154_XG_MP1 (I1482_G29_22 I1482_G25_22n XI1482_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I93_XG_MP2 (VDD I1482_gn27 I1482_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I93_XG_MP0 (XI1482_I93_XG_p1 I1482_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I93_XG_MP1 (I1482_G27_26 I1482_gn26 XI1482_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I97_XG_MP2 (VDD I1528_gn31 I1528_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1528_I97_XG_MP0 (XI1528_I97_XG_p1 I1528_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1528_I97_XG_MP1 (I1528_G31_30 I1528_gn30 XI1528_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I93_XG_MP2 (VDD I1206_gn27 I1206_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I93_XG_MP0 (XI1206_I93_XG_p1 I1206_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I93_XG_MP1 (I1206_G27_26 I1206_gn26 XI1206_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I92_XG_MP2 (VDD I1206_gn26 I1206_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I92_XG_MP0 (XI1206_I92_XG_p1 I1206_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I92_XG_MP1 (I1206_G26_25 I1206_gn25 XI1206_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I156_XG_MP2 (VDD I1206_G31_28n I1206_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I156_XG_MP0 (XI1206_I156_XG_p1 I1206_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I156_XG_MP1 (I1206_G31_24 I1206_G27_24n XI1206_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I154_XG_MP2 (VDD I1206_G29_26n I1206_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I154_XG_MP0 (XI1206_I154_XG_p1 I1206_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I154_XG_MP1 (I1206_G29_22 I1206_G25_22n XI1206_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I200_XG_MP2 (VDD I1206_G29_14n I1206_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I200_XG_MP0 (XI1206_I200_XG_p1 I1206_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I200_XG_MP1 (I1206_G29_0 I1206_G13_0n XI1206_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I198_XG_MP2 (VDD I1206_G27_12n I1206_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I198_XG_MP0 (XI1206_I198_XG_p1 I1206_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I198_XG_MP1 (I1206_G27_0 I1206_G11_0n XI1206_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I155_XG_MP2 (VDD I1206_G30_27n I1206_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I155_XG_MP0 (XI1206_I155_XG_p1 I1206_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I155_XG_MP1 (I1206_G30_23 I1206_G26_23n XI1206_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I153_XG_MP2 (VDD I1206_G28_25n I1206_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I153_XG_MP0 (XI1206_I153_XG_p1 I1206_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I153_XG_MP1 (I1206_G28_21 I1206_G24_21n XI1206_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I199_XG_MP2 (VDD I1206_G28_13n I1206_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I199_XG_MP0 (XI1206_I199_XG_p1 I1206_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I199_XG_MP1 (I1206_G28_0 I1206_G12_0n XI1206_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I94_XG_MP2 (VDD I1252_gn28 I1252_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I94_XG_MP0 (XI1252_I94_XG_p1 I1252_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I94_XG_MP1 (I1252_G28_27 I1252_gn27 XI1252_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I93_XG_MP2 (VDD I1252_gn27 I1252_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I93_XG_MP0 (XI1252_I93_XG_p1 I1252_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I93_XG_MP1 (I1252_G27_26 I1252_gn26 XI1252_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I94_XG_MP2 (VDD I1298_gn28 I1298_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I94_XG_MP0 (XI1298_I94_XG_p1 I1298_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I94_XG_MP1 (I1298_G28_27 I1298_gn27 XI1298_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I95_XG_MP2 (VDD I1298_gn29 I1298_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I95_XG_MP0 (XI1298_I95_XG_p1 I1298_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I95_XG_MP1 (I1298_G29_28 I1298_gn28 XI1298_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I156_XG_MP2 (VDD I1298_G31_28n I1298_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I156_XG_MP0 (XI1298_I156_XG_p1 I1298_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I156_XG_MP1 (I1298_G31_24 I1298_G27_24n XI1298_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I202_XG_MP2 (VDD I1298_G31_16n c16_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I202_XG_MP0 (XI1298_I202_XG_p1 I1298_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I202_XG_MP1 (c16_o I1298_G15_0n XI1298_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I94_XG_MP2 (VDD I1344_gn28 I1344_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I94_XG_MP0 (XI1344_I94_XG_p1 I1344_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I94_XG_MP1 (I1344_G28_27 I1344_gn27 XI1344_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I95_XG_MP2 (VDD I1344_gn29 I1344_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I95_XG_MP0 (XI1344_I95_XG_p1 I1344_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I95_XG_MP1 (I1344_G29_28 I1344_gn28 XI1344_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I95_XG_MP2 (VDD I1390_gn29 I1390_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I95_XG_MP0 (XI1390_I95_XG_p1 I1390_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I95_XG_MP1 (I1390_G29_28 I1390_gn28 XI1390_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I96_XG_MP2 (VDD I1390_gn30 I1390_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I96_XG_MP0 (XI1390_I96_XG_p1 I1390_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I96_XG_MP1 (I1390_G30_29 I1390_gn29 XI1390_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I97_XG_MP2 (VDD I1390_gn31 I1390_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1390_I97_XG_MP0 (XI1390_I97_XG_p1 I1390_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1390_I97_XG_MP1 (I1390_G31_30 I1390_gn30 XI1390_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I95_XG_MP2 (VDD I1436_gn29 I1436_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I95_XG_MP0 (XI1436_I95_XG_p1 I1436_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I95_XG_MP1 (I1436_G29_28 I1436_gn28 XI1436_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I94_XG_MP2 (VDD I1436_gn28 I1436_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I94_XG_MP0 (XI1436_I94_XG_p1 I1436_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I94_XG_MP1 (I1436_G28_27 I1436_gn27 XI1436_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I96_XG_MP2 (VDD I1436_gn30 I1436_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I96_XG_MP0 (XI1436_I96_XG_p1 I1436_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I96_XG_MP1 (I1436_G30_29 I1436_gn29 XI1436_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I97_XG_MP2 (VDD I1436_gn31 I1436_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I97_XG_MP0 (XI1436_I97_XG_p1 I1436_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I97_XG_MP1 (I1436_G31_30 I1436_gn30 XI1436_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I156_XG_MP2 (VDD I1436_G31_28n I1436_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1436_I156_XG_MP0 (XI1436_I156_XG_p1 I1436_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1436_I156_XG_MP1 (I1436_G31_24 I1436_G27_24n XI1436_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I97_XG_MP2 (VDD I1482_gn31 I1482_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I97_XG_MP0 (XI1482_I97_XG_p1 I1482_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I97_XG_MP1 (I1482_G31_30 I1482_gn30 XI1482_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I156_XG_MP2 (VDD I1482_G31_28n I1482_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I156_XG_MP0 (XI1482_I156_XG_p1 I1482_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I156_XG_MP1 (I1482_G31_24 I1482_G27_24n XI1482_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I95_XG_MP2 (VDD I1482_gn29 I1482_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I95_XG_MP0 (XI1482_I95_XG_p1 I1482_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I95_XG_MP1 (I1482_G29_28 I1482_gn28 XI1482_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I96_XG_MP2 (VDD I1482_gn30 I1482_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I96_XG_MP0 (XI1482_I96_XG_p1 I1482_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I96_XG_MP1 (I1482_G30_29 I1482_gn29 XI1482_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I94_XG_MP2 (VDD I1482_gn28 I1482_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1482_I94_XG_MP0 (XI1482_I94_XG_p1 I1482_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1482_I94_XG_MP1 (I1482_G28_27 I1482_gn27 XI1482_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I97_XG_MP2 (VDD I1206_gn31 I1206_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I97_XG_MP0 (XI1206_I97_XG_p1 I1206_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I97_XG_MP1 (I1206_G31_30 I1206_gn30 XI1206_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I96_XG_MP2 (VDD I1206_gn30 I1206_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I96_XG_MP0 (XI1206_I96_XG_p1 I1206_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I96_XG_MP1 (I1206_G30_29 I1206_gn29 XI1206_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I95_XG_MP2 (VDD I1206_gn29 I1206_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I95_XG_MP0 (XI1206_I95_XG_p1 I1206_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I95_XG_MP1 (I1206_G29_28 I1206_gn28 XI1206_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I94_XG_MP2 (VDD I1206_gn28 I1206_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I94_XG_MP0 (XI1206_I94_XG_p1 I1206_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I94_XG_MP1 (I1206_G28_27 I1206_gn27 XI1206_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I201_XG_MP2 (VDD I1206_G30_15n c14_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1206_I201_XG_MP0 (XI1206_I201_XG_p1 I1206_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1206_I201_XG_MP1 (c14_m I1206_G14_0n XI1206_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I95_XG_MP2 (VDD I1252_gn29 I1252_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I95_XG_MP0 (XI1252_I95_XG_p1 I1252_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I95_XG_MP1 (I1252_G29_28 I1252_gn28 XI1252_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I96_XG_MP2 (VDD I1252_gn30 I1252_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I96_XG_MP0 (XI1252_I96_XG_p1 I1252_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I96_XG_MP1 (I1252_G30_29 I1252_gn29 XI1252_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I97_XG_MP2 (VDD I1252_gn31 I1252_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1252_I97_XG_MP0 (XI1252_I97_XG_p1 I1252_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1252_I97_XG_MP1 (I1252_G31_30 I1252_gn30 XI1252_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I96_XG_MP2 (VDD I1298_gn30 I1298_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I96_XG_MP0 (XI1298_I96_XG_p1 I1298_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I96_XG_MP1 (I1298_G30_29 I1298_gn29 XI1298_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I97_XG_MP2 (VDD I1298_gn31 I1298_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1298_I97_XG_MP0 (XI1298_I97_XG_p1 I1298_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1298_I97_XG_MP1 (I1298_G31_30 I1298_gn30 XI1298_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I96_XG_MP2 (VDD I1344_gn30 I1344_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I96_XG_MP0 (XI1344_I96_XG_p1 I1344_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I96_XG_MP1 (I1344_G30_29 I1344_gn29 XI1344_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I97_XG_MP2 (VDD I1344_gn31 I1344_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.92u ps=1.16u
    I_MXI1344_I97_XG_MP0 (XI1344_I97_XG_p1 I1344_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.92u ps=0.92u
    I_MXI1344_I97_XG_MP1 (I1344_G31_30 I1344_gn30 XI1344_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI654_I30_MP1 (I654_gn30 b2_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I30_MP0 (VDD p1_29 I654_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I31_MP1 (I654_gn31 b2_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I31_MP0 (VDD p1_30 I654_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I30_MP1 (I562_gn30 b0_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I30_MP0 (VDD VSS I562_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I31_MP1 (I2066_gn31 dm31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I31_MP0 (VDD p31_31 I2066_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2064_MP1 (dmn31 p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2064_MP0 (VDD dd31_b3_5 dmn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I29_MP1 (I1942_gn29 b30_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I29_MP0 (VDD p29_28 I1942_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I31_MP1 (I700_gn31 b3_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I31_MP0 (VDD p2_30 I700_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I127_XP_MP1 (I654_P31_28n I654_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I127_XP_MP0 (VDD I654_P31_30 I654_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I28_MP1 (I654_gn28 b2_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I28_MP0 (VDD p1_27 I654_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I29_MP1 (I654_gn29 b2_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I29_MP0 (VDD p1_28 I654_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I127_XP_MP1 (I608_P31_28n I608_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I127_XP_MP0 (VDD I608_P31_30 I608_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I31_MP1 (I608_gn31 b1_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I31_MP0 (VDD p0_30 I608_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I30_MP1 (I608_gn30 b1_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I30_MP0 (VDD p0_29 I608_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I28_MP1 (I608_gn28 b1_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I28_MP0 (VDD p0_27 I608_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I29_MP1 (I608_gn29 b1_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I29_MP0 (VDD p0_28 I608_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I31_MP1 (I562_gn31 b0_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I31_MP0 (VDD VSS I562_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I29_MP1 (I562_gn29 b0_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I29_MP0 (VDD VSS I562_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I28_MP1 (I562_gn28 b0_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I28_MP0 (VDD VSS I562_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I29_MP1 (I2066_gn29 dm29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I29_MP0 (VDD p31_29 I2066_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I28_MP1 (I2066_gn28 dm28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I28_MP0 (VDD p31_28 I2066_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I30_MP1 (I2066_gn30 dm30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I30_MP0 (VDD p31_30 I2066_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2058_MP1 (dmn28 p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2058_MP0 (VDD dd28_b3_5 dmn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2062_MP1 (dmn30 p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2062_MP0 (VDD dd30_b3_5 dmn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2060_MP1 (dmn29 p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2060_MP0 (VDD dd29_b3_5 dmn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I30_MP1 (I1988_gn30 b31_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I30_MP0 (VDD p30_29 I1988_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I31_MP1 (I1988_gn31 b31_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I31_MP0 (VDD p30_30 I1988_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I28_MP1 (I1988_gn28 b31_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I28_MP0 (VDD p30_27 I1988_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I29_MP1 (I1988_gn29 b31_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I29_MP0 (VDD p30_28 I1988_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I126_XP_MP1 (I1942_P30_27n I1942_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I126_XP_MP0 (VDD I1942_P30_29 I1942_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I30_MP1 (I1942_gn30 b30_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I30_MP0 (VDD p29_29 I1942_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I127_XP_MP1 (I1942_P31_28n I1942_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I127_XP_MP0 (VDD I1942_P31_30 I1942_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I31_MP1 (I1942_gn31 b30_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I31_MP0 (VDD p29_30 I1942_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I28_MP1 (I1942_gn28 b30_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I28_MP0 (VDD p29_27 I1942_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I27_MP1 (I1942_gn27 b30_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I27_MP0 (VDD p29_26 I1942_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I181_XP_MP1 (I1896_P30_15n I1896_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I181_XP_MP0 (VDD I1896_P30_23 I1896_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I126_XP_MP1 (I1896_P30_27n I1896_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I126_XP_MP0 (VDD I1896_P30_29 I1896_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I26_MP1 (I1896_gn26 b29_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I26_MP0 (VDD p28_25 I1896_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I27_MP1 (I1896_gn27 b29_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I27_MP0 (VDD p28_26 I1896_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I29_MP1 (I700_gn29 b3_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I29_MP0 (VDD p2_28 I700_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I30_MP1 (I700_gn30 b3_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I30_MP0 (VDD p2_29 I700_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I182_XP_MP1 (I654_P31_16n I654_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I182_XP_MP0 (VDD I654_P31_24 I654_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I123_XP_MP1 (I654_P27_24n I654_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I123_XP_MP0 (VDD I654_P27_26 I654_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I125_XP_MP1 (I654_P29_26n I654_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I125_XP_MP0 (VDD I654_P29_28 I654_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I27_MP1 (I654_gn27 b2_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I27_MP0 (VDD p1_26 I654_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I126_XP_MP1 (I654_P30_27n I654_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I126_XP_MP0 (VDD I654_P30_29 I654_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I25_MP1 (I654_gn25 b2_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I25_MP0 (VDD p1_24 I654_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I26_MP1 (I654_gn26 b2_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I26_MP0 (VDD p1_25 I654_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I182_XP_MP1 (I608_P31_16n I608_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I182_XP_MP0 (VDD I608_P31_24 I608_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I125_XP_MP1 (I608_P29_26n I608_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I125_XP_MP0 (VDD I608_P29_28 I608_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I123_XP_MP1 (I608_P27_24n I608_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I123_XP_MP0 (VDD I608_P27_26 I608_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I126_XP_MP1 (I608_P30_27n I608_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I126_XP_MP0 (VDD I608_P30_29 I608_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I25_MP1 (I608_gn25 b1_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I25_MP0 (VDD p0_24 I608_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I26_MP1 (I608_gn26 b1_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I26_MP0 (VDD p0_25 I608_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I27_MP1 (I608_gn27 b1_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I27_MP0 (VDD p0_26 I608_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I25_MP1 (I562_gn25 b0_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I25_MP0 (VDD VSS I562_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I24_MP1 (I562_gn24 b0_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I24_MP0 (VDD VSS I562_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I126_XP_MP1 (I562_P30_27n I562_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I126_XP_MP0 (VDD I562_P30_29 I562_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I26_MP1 (I562_gn26 b0_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I26_MP0 (VDD VSS I562_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I27_MP1 (I562_gn27 b0_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I27_MP0 (VDD VSS I562_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I127_XP_MP1 (I562_P31_28n I562_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I127_XP_MP0 (VDD I562_P31_30 I562_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I127_XP_MP1 (I2066_P31_28n I2066_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I127_XP_MP0 (VDD I2066_P31_30 I2066_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I126_XP_MP1 (I2066_P30_27n I2066_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I126_XP_MP0 (VDD I2066_P30_29 I2066_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I26_MP1 (I2066_gn26 dm26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I26_MP0 (VDD p31_26 I2066_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I27_MP1 (I2066_gn27 dm27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I27_MP0 (VDD p31_27 I2066_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2056_MP1 (dmn27 p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2056_MP0 (VDD dd27_b3_5 dmn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I126_XP_MP1 (I1988_P30_27n I1988_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I126_XP_MP0 (VDD I1988_P30_29 I1988_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I127_XP_MP1 (I1988_P31_28n I1988_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I127_XP_MP0 (VDD I1988_P31_30 I1988_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I125_XP_MP1 (I1988_P29_26n I1988_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I125_XP_MP0 (VDD I1988_P29_28 I1988_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I27_MP1 (I1988_gn27 b31_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I27_MP0 (VDD p30_26 I1988_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I26_MP1 (I1988_gn26 b31_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I26_MP0 (VDD p30_25 I1988_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I181_XP_MP1 (I1942_P30_15n I1942_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I181_XP_MP0 (VDD I1942_P30_23 I1942_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I124_XP_MP1 (I1942_P28_25n I1942_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I124_XP_MP0 (VDD I1942_P28_27 I1942_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I125_XP_MP1 (I1942_P29_26n I1942_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I125_XP_MP0 (VDD I1942_P29_28 I1942_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I123_XP_MP1 (I1942_P27_24n I1942_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I123_XP_MP0 (VDD I1942_P27_26 I1942_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I25_MP1 (I1942_gn25 b30_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I25_MP0 (VDD p29_24 I1942_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I26_MP1 (I1942_gn26 b30_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I26_MP0 (VDD p29_25 I1942_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I177_XP_MP1 (I1896_P26_11n I1896_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I177_XP_MP0 (VDD I1896_P26_19 I1896_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I179_XP_MP1 (I1896_P28_13n I1896_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I179_XP_MP0 (VDD I1896_P28_21 I1896_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I122_XP_MP1 (I1896_P26_23n I1896_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I122_XP_MP0 (VDD I1896_P26_25 I1896_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I124_XP_MP1 (I1896_P28_25n I1896_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I124_XP_MP0 (VDD I1896_P28_27 I1896_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I25_MP1 (I1896_gn25 b29_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I25_MP0 (VDD p28_24 I1896_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I28_MP1 (I1896_gn28 b29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I28_MP0 (VDD p28_27 I1896_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I29_MP1 (I1896_gn29 b29_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I29_MP0 (VDD p28_28 I1896_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I28_MP1 (I700_gn28 b3_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I28_MP0 (VDD p2_27 I700_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I27_MP1 (I700_gn27 b3_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I27_MP0 (VDD p2_26 I700_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I178_XP_MP1 (I654_P27_12n I654_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I178_XP_MP0 (VDD I654_P27_20 I654_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I181_XP_MP1 (I654_P30_15n I654_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I181_XP_MP0 (VDD I654_P30_23 I654_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I124_XP_MP1 (I654_P28_25n I654_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I124_XP_MP0 (VDD I654_P28_27 I654_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I24_MP1 (I654_gn24 b2_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I24_MP0 (VDD p1_23 I654_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I178_XP_MP1 (I608_P27_12n I608_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I178_XP_MP0 (VDD I608_P27_20 I608_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I122_XP_MP1 (I608_P26_23n I608_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I122_XP_MP0 (VDD I608_P26_25 I608_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I124_XP_MP1 (I608_P28_25n I608_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I124_XP_MP0 (VDD I608_P28_27 I608_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I23_MP1 (I608_gn23 b1_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I23_MP0 (VDD p0_22 I608_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I24_MP1 (I608_gn24 b1_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I24_MP0 (VDD p0_23 I608_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I23_MP1 (I562_gn23 b0_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I23_MP0 (VDD VSS I562_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I124_XP_MP1 (I562_P28_25n I562_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I124_XP_MP0 (VDD I562_P28_27 I562_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I182_XP_MP1 (I2066_P31_16n I2066_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I182_XP_MP0 (VDD I2066_P31_24 I2066_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I125_XP_MP1 (I2066_P29_26n I2066_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I125_XP_MP0 (VDD I2066_P29_28 I2066_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I123_XP_MP1 (I2066_P27_24n I2066_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I123_XP_MP0 (VDD I2066_P27_26 I2066_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I124_XP_MP1 (I2066_P28_25n I2066_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I124_XP_MP0 (VDD I2066_P28_27 I2066_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I25_MP1 (I2066_gn25 dm25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I25_MP0 (VDD p31_25 I2066_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2054_MP1 (dmn26 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2054_MP0 (VDD dd26_b3_5 dmn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2052_MP1 (dmn25 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2052_MP0 (VDD dd25_b3_5 dmn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I124_XP_MP1 (I1988_P28_25n I1988_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I124_XP_MP0 (VDD I1988_P28_27 I1988_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I123_XP_MP1 (I1988_P27_24n I1988_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I123_XP_MP0 (VDD I1988_P27_26 I1988_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I25_MP1 (I1988_gn25 b31_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I25_MP0 (VDD p30_24 I1988_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I24_MP1 (I1988_gn24 b31_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I24_MP0 (VDD p30_23 I1988_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I179_XP_MP1 (I1942_P28_13n I1942_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I179_XP_MP0 (VDD I1942_P28_21 I1942_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I122_XP_MP1 (I1942_P26_23n I1942_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I122_XP_MP0 (VDD I1942_P26_25 I1942_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I120_XP_MP1 (I1942_P24_21n I1942_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I120_XP_MP0 (VDD I1942_P24_23 I1942_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I180_XP_MP1 (I1942_P29_14n I1942_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I180_XP_MP0 (VDD I1942_P29_22 I1942_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I182_XP_MP1 (I1942_P31_16n I1942_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I182_XP_MP0 (VDD I1942_P31_24 I1942_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I121_XP_MP1 (I1942_P25_22n I1942_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I121_XP_MP0 (VDD I1942_P25_24 I1942_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I22_MP1 (I1942_gn22 b30_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I22_MP0 (VDD p29_21 I1942_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I23_MP1 (I1942_gn23 b30_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I23_MP0 (VDD p29_22 I1942_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I24_MP1 (I1942_gn24 b30_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I24_MP0 (VDD p29_23 I1942_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I175_XP_MP1 (I1896_P24_9n I1896_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I175_XP_MP0 (VDD I1896_P24_17 I1896_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I173_XP_MP1 (I1896_P22_7n I1896_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I173_XP_MP0 (VDD I1896_P22_15 I1896_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I120_XP_MP1 (I1896_P24_21n I1896_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I120_XP_MP0 (VDD I1896_P24_23 I1896_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I24_MP1 (I1896_gn24 b29_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I24_MP0 (VDD p28_23 I1896_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I125_XP_MP1 (I1896_P29_26n I1896_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I125_XP_MP0 (VDD I1896_P29_28 I1896_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I127_XP_MP1 (I1896_P31_28n I1896_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I127_XP_MP0 (VDD I1896_P31_30 I1896_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I26_MP1 (I700_gn26 b3_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I26_MP0 (VDD p2_25 I700_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I24_MP1 (I700_gn24 b3_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I24_MP0 (VDD p2_23 I700_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I25_MP1 (I700_gn25 b3_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I25_MP0 (VDD p2_24 I700_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I174_XP_MP1 (I654_P23_8n I654_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I174_XP_MP0 (VDD I654_P23_16 I654_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I180_XP_MP1 (I654_P29_14n I654_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I180_XP_MP0 (VDD I654_P29_22 I654_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I119_XP_MP1 (I654_P23_20n I654_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I119_XP_MP0 (VDD I654_P23_22 I654_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I121_XP_MP1 (I654_P25_22n I654_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I121_XP_MP0 (VDD I654_P25_24 I654_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I179_XP_MP1 (I654_P28_13n I654_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I179_XP_MP0 (VDD I654_P28_21 I654_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I122_XP_MP1 (I654_P26_23n I654_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I122_XP_MP0 (VDD I654_P26_25 I654_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I120_XP_MP1 (I654_P24_21n I654_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I120_XP_MP0 (VDD I654_P24_23 I654_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I22_MP1 (I654_gn22 b2_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I22_MP0 (VDD p1_21 I654_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I23_MP1 (I654_gn23 b2_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I23_MP0 (VDD p1_22 I654_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I174_XP_MP1 (I608_P23_8n I608_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I174_XP_MP0 (VDD I608_P23_16 I608_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I121_XP_MP1 (I608_P25_22n I608_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I121_XP_MP0 (VDD I608_P25_24 I608_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I119_XP_MP1 (I608_P23_20n I608_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I119_XP_MP0 (VDD I608_P23_22 I608_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I181_XP_MP1 (I608_P30_15n I608_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I181_XP_MP0 (VDD I608_P30_23 I608_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I120_XP_MP1 (I608_P24_21n I608_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I120_XP_MP0 (VDD I608_P24_23 I608_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I22_MP1 (I608_gn22 b1_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I22_MP0 (VDD p0_21 I608_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I22_MP1 (I562_gn22 b0_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I22_MP0 (VDD VSS I562_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I122_XP_MP1 (I562_P26_23n I562_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I122_XP_MP0 (VDD I562_P26_25 I562_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I121_XP_MP1 (I562_P25_22n I562_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I121_XP_MP0 (VDD I562_P25_24 I562_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I123_XP_MP1 (I562_P27_24n I562_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I123_XP_MP0 (VDD I562_P27_26 I562_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I125_XP_MP1 (I562_P29_26n I562_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I125_XP_MP0 (VDD I562_P29_28 I562_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I174_XP_MP1 (I2066_P23_8n I2066_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I174_XP_MP0 (VDD I2066_P23_16 I2066_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I180_XP_MP1 (I2066_P29_14n I2066_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I180_XP_MP0 (VDD I2066_P29_22 I2066_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I121_XP_MP1 (I2066_P25_22n I2066_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I121_XP_MP0 (VDD I2066_P25_24 I2066_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I181_XP_MP1 (I2066_P30_15n I2066_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I181_XP_MP0 (VDD I2066_P30_23 I2066_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I122_XP_MP1 (I2066_P26_23n I2066_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I122_XP_MP0 (VDD I2066_P26_25 I2066_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I24_MP1 (I2066_gn24 dm24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I24_MP0 (VDD p31_24 I2066_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I23_MP1 (I2066_gn23 dm23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I23_MP0 (VDD p31_23 I2066_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2050_MP1 (dmn24 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2050_MP0 (VDD dd24_b3_5 dmn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2048_MP1 (dmn23 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2048_MP0 (VDD dd23_b3_5 dmn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I181_XP_MP1 (I1988_P30_15n I1988_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I181_XP_MP0 (VDD I1988_P30_23 I1988_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I122_XP_MP1 (I1988_P26_23n I1988_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I122_XP_MP0 (VDD I1988_P26_25 I1988_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I182_XP_MP1 (I1988_P31_16n I1988_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I182_XP_MP0 (VDD I1988_P31_24 I1988_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I121_XP_MP1 (I1988_P25_22n I1988_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I121_XP_MP0 (VDD I1988_P25_24 I1988_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I23_MP1 (I1988_gn23 b31_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I23_MP0 (VDD p30_22 I1988_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I22_MP1 (I1988_gn22 b31_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I22_MP0 (VDD p30_21 I1988_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I177_XP_MP1 (I1942_P26_11n I1942_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I177_XP_MP0 (VDD I1942_P26_19 I1942_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I178_XP_MP1 (I1942_P27_12n I1942_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I178_XP_MP0 (VDD I1942_P27_20 I1942_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I174_XP_MP1 (I1942_P23_8n I1942_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I174_XP_MP0 (VDD I1942_P23_16 I1942_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I171_XP_MP1 (I1896_P20_5n I1896_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I171_XP_MP0 (VDD I1896_P20_13 I1896_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I176_XP_MP1 (I1896_P25_10n I1896_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I176_XP_MP0 (VDD I1896_P25_18 I1896_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I118_XP_MP1 (I1896_P22_19n I1896_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I118_XP_MP0 (VDD I1896_P22_21 I1896_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I180_XP_MP1 (I1896_P29_14n I1896_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I180_XP_MP0 (VDD I1896_P29_22 I1896_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I21_MP1 (I1896_gn21 b29_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I21_MP0 (VDD p28_20 I1896_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I121_XP_MP1 (I1896_P25_22n I1896_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I121_XP_MP0 (VDD I1896_P25_24 I1896_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I22_MP1 (I1896_gn22 b29_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I22_MP0 (VDD p28_21 I1896_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I123_XP_MP1 (I1896_P27_24n I1896_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I123_XP_MP0 (VDD I1896_P27_26 I1896_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I23_MP1 (I1896_gn23 b29_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I23_MP0 (VDD p28_22 I1896_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I30_MP1 (I1896_gn30 b29_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I30_MP0 (VDD p28_29 I1896_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I31_MP1 (I1896_gn31 b29_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I31_MP0 (VDD p28_30 I1896_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I23_MP1 (I700_gn23 b3_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I23_MP0 (VDD p2_22 I700_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I173_XP_MP1 (I654_P22_7n I654_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I173_XP_MP0 (VDD I654_P22_15 I654_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I118_XP_MP1 (I654_P22_19n I654_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I118_XP_MP0 (VDD I654_P22_21 I654_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I21_MP1 (I654_gn21 b2_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I21_MP0 (VDD p1_20 I654_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I20_MP1 (I654_gn20 b2_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I20_MP0 (VDD p1_19 I654_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I180_XP_MP1 (I608_P29_14n I608_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I180_XP_MP0 (VDD I608_P29_22 I608_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I117_XP_MP1 (I608_P21_18n I608_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I117_XP_MP0 (VDD I608_P21_20 I608_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I179_XP_MP1 (I608_P28_13n I608_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I179_XP_MP0 (VDD I608_P28_21 I608_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I21_MP1 (I608_gn21 b1_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I21_MP0 (VDD p0_20 I608_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I21_MP1 (I562_gn21 b0_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I21_MP0 (VDD VSS I562_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I20_MP1 (I562_gn20 b0_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I20_MP0 (VDD VSS I562_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I181_XP_MP1 (I562_P30_15n I562_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I181_XP_MP0 (VDD I562_P30_23 I562_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I119_XP_MP1 (I562_P23_20n I562_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I119_XP_MP0 (VDD I562_P23_22 I562_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I180_XP_MP1 (I562_P29_14n I562_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I180_XP_MP0 (VDD I562_P29_22 I562_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I182_XP_MP1 (I562_P31_16n I562_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I182_XP_MP0 (VDD I562_P31_24 I562_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I178_XP_MP1 (I2066_P27_12n I2066_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I178_XP_MP0 (VDD I2066_P27_20 I2066_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I119_XP_MP1 (I2066_P23_20n I2066_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I119_XP_MP0 (VDD I2066_P23_22 I2066_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I173_XP_MP1 (I2066_P22_7n I2066_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I173_XP_MP0 (VDD I2066_P22_15 I2066_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I120_XP_MP1 (I2066_P24_21n I2066_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I120_XP_MP0 (VDD I2066_P24_23 I2066_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I22_MP1 (I2066_gn22 dm22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I22_MP0 (VDD p31_22 I2066_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I21_MP1 (I2066_gn21 dm21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I21_MP0 (VDD p31_21 I2066_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2044_MP1 (dmn21 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2044_MP0 (VDD dd21_b3_5 dmn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2046_MP1 (dmn22 p31_32_b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2046_MP0 (VDD dd22_b3_5 dmn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I179_XP_MP1 (I1988_P28_13n I1988_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I179_XP_MP0 (VDD I1988_P28_21 I1988_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I120_XP_MP1 (I1988_P24_21n I1988_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I120_XP_MP0 (VDD I1988_P24_23 I1988_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I180_XP_MP1 (I1988_P29_14n I1988_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I180_XP_MP0 (VDD I1988_P29_22 I1988_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I119_XP_MP1 (I1988_P23_20n I1988_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I119_XP_MP0 (VDD I1988_P23_22 I1988_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I21_MP1 (I1988_gn21 b31_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I21_MP0 (VDD p30_20 I1988_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I173_XP_MP1 (I1942_P22_7n I1942_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I173_XP_MP0 (VDD I1942_P22_15 I1942_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I118_XP_MP1 (I1942_P22_19n I1942_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I118_XP_MP0 (VDD I1942_P22_21 I1942_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I176_XP_MP1 (I1942_P25_10n I1942_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I176_XP_MP0 (VDD I1942_P25_18 I1942_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I119_XP_MP1 (I1942_P23_20n I1942_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I119_XP_MP0 (VDD I1942_P23_22 I1942_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I20_MP1 (I1942_gn20 b30_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I20_MP0 (VDD p29_19 I1942_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I21_MP1 (I1942_gn21 b30_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I21_MP0 (VDD p29_20 I1942_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I169_XP_MP1 (I1896_P18_3n I1896_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I169_XP_MP0 (VDD I1896_P18_11 I1896_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I116_XP_MP1 (I1896_P20_17n I1896_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I116_XP_MP0 (VDD I1896_P20_19 I1896_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I172_XP_MP1 (I1896_P21_6n I1896_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I172_XP_MP0 (VDD I1896_P21_14 I1896_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I117_XP_MP1 (I1896_P21_18n I1896_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I117_XP_MP0 (VDD I1896_P21_20 I1896_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I119_XP_MP1 (I1896_P23_20n I1896_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I119_XP_MP0 (VDD I1896_P23_22 I1896_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I127_XP_MP1 (I700_P31_28n I700_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I127_XP_MP0 (VDD I700_P31_30 I700_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I22_MP1 (I700_gn22 b3_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I22_MP0 (VDD p2_21 I700_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I21_MP1 (I700_gn21 b3_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I21_MP0 (VDD p2_20 I700_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I20_MP1 (I700_gn20 b3_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I20_MP0 (VDD p2_19 I700_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I170_XP_MP1 (I654_P19_4n I654_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I170_XP_MP0 (VDD I654_P19_12 I654_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I172_XP_MP1 (I654_P21_6n I654_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I172_XP_MP0 (VDD I654_P21_14 I654_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I117_XP_MP1 (I654_P21_18n I654_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I117_XP_MP0 (VDD I654_P21_20 I654_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I115_XP_MP1 (I654_P19_16n I654_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I115_XP_MP0 (VDD I654_P19_18 I654_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I177_XP_MP1 (I654_P26_11n I654_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I177_XP_MP0 (VDD I654_P26_19 I654_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I175_XP_MP1 (I654_P24_9n I654_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I175_XP_MP0 (VDD I654_P24_17 I654_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I116_XP_MP1 (I654_P20_17n I654_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I116_XP_MP0 (VDD I654_P20_19 I654_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I18_MP1 (I654_gn18 b2_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I18_MP0 (VDD p1_17 I654_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I19_MP1 (I654_gn19 b2_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I19_MP0 (VDD p1_18 I654_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I172_XP_MP1 (I608_P21_6n I608_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I172_XP_MP0 (VDD I608_P21_14 I608_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I176_XP_MP1 (I608_P25_10n I608_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I176_XP_MP0 (VDD I608_P25_18 I608_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I173_XP_MP1 (I608_P22_7n I608_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I173_XP_MP0 (VDD I608_P22_15 I608_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I118_XP_MP1 (I608_P22_19n I608_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I118_XP_MP0 (VDD I608_P22_21 I608_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I19_MP1 (I608_gn19 b1_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I19_MP0 (VDD p0_18 I608_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I20_MP1 (I608_gn20 b1_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I20_MP0 (VDD p0_19 I608_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I18_MP1 (I608_gn18 b1_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I18_MP0 (VDD p0_17 I608_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I19_MP1 (I562_gn19 b0_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I19_MP0 (VDD VSS I562_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I118_XP_MP1 (I562_P22_19n I562_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I118_XP_MP0 (VDD I562_P22_21 I562_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I120_XP_MP1 (I562_P24_21n I562_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I120_XP_MP0 (VDD I562_P24_23 I562_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I173_XP_MP1 (I562_P22_7n I562_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I173_XP_MP0 (VDD I562_P22_15 I562_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I172_XP_MP1 (I562_P21_6n I562_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I172_XP_MP0 (VDD I562_P21_14 I562_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I117_XP_MP1 (I562_P21_18n I562_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I117_XP_MP0 (VDD I562_P21_20 I562_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I178_XP_MP1 (I562_P27_12n I562_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I178_XP_MP0 (VDD I562_P27_20 I562_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I174_XP_MP1 (I562_P23_8n I562_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I174_XP_MP0 (VDD I562_P23_16 I562_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I172_XP_MP1 (I2066_P21_6n I2066_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I172_XP_MP0 (VDD I2066_P21_14 I2066_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I117_XP_MP1 (I2066_P21_18n I2066_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I117_XP_MP0 (VDD I2066_P21_20 I2066_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I177_XP_MP1 (I2066_P26_11n I2066_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I177_XP_MP0 (VDD I2066_P26_19 I2066_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I118_XP_MP1 (I2066_P22_19n I2066_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I118_XP_MP0 (VDD I2066_P22_21 I2066_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I19_MP1 (I2066_gn19 dm19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I19_MP0 (VDD p31_19 I2066_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I20_MP1 (I2066_gn20 dm20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I20_MP0 (VDD p31_20 I2066_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2042_MP1 (dmn20 p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2042_MP0 (VDD dd20_b3_5 dmn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2040_MP1 (dmn19 p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2040_MP0 (VDD dd19_b3_5 dmn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I177_XP_MP1 (I1988_P26_11n I1988_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I177_XP_MP0 (VDD I1988_P26_19 I1988_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I118_XP_MP1 (I1988_P22_19n I1988_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I118_XP_MP0 (VDD I1988_P22_21 I1988_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I174_XP_MP1 (I1988_P23_8n I1988_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I174_XP_MP0 (VDD I1988_P23_16 I1988_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I20_MP1 (I1988_gn20 b31_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I20_MP0 (VDD p30_19 I1988_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I19_MP1 (I1988_gn19 b31_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I19_MP0 (VDD p30_18 I1988_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I175_XP_MP1 (I1942_P24_9n I1942_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I175_XP_MP0 (VDD I1942_P24_17 I1942_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I116_XP_MP1 (I1942_P20_17n I1942_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I116_XP_MP0 (VDD I1942_P20_19 I1942_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I172_XP_MP1 (I1942_P21_6n I1942_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I172_XP_MP0 (VDD I1942_P21_14 I1942_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I115_XP_MP1 (I1942_P19_16n I1942_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I115_XP_MP0 (VDD I1942_P19_18 I1942_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I117_XP_MP1 (I1942_P21_18n I1942_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I117_XP_MP0 (VDD I1942_P21_20 I1942_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I19_MP1 (I1942_gn19 b30_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I19_MP0 (VDD p29_18 I1942_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I110_XP_MP1 (I1896_P14_11n I1896_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I110_XP_MP0 (VDD I1896_P14_13 I1896_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I112_XP_MP1 (I1896_P16_13n I1896_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I112_XP_MP0 (VDD I1896_P16_15 I1896_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I114_XP_MP1 (I1896_P18_15n I1896_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I114_XP_MP0 (VDD I1896_P18_17 I1896_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I18_MP1 (I1896_gn18 b29_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
