    I_MXI1206_I213_MN5 (XI1206_I213_n2 XI1206_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I213_MN4 (p14_10 XI1206_I213_An XI1206_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I213_MN2 (XI1206_I213_n1 I1206_pn10 p14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I213_MN3 (VSS I1206_G9_0n XI1206_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I213_MN0 (XI1206_I213_An I1206_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I216_MN1 (XI1206_I216_Bn I1206_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I216_MN5 (XI1206_I216_n2 XI1206_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I216_MN4 (p14_13 XI1206_I216_An XI1206_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I216_MN2 (XI1206_I216_n1 I1206_pn13 p14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I216_MN3 (VSS I1206_G12_0n XI1206_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I216_MN0 (XI1206_I216_An I1206_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1236_MN1 (XI1236_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1236_MN5 (XI1236_n2 XI1236_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1236_MN4 (b15_16 XI1236_An XI1236_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1236_MN2 (XI1236_n1 dd16_b3_2 b15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1236_MN3 (VSS qu17_b3_2 XI1236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1236_MN0 (XI1236_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1235_MN1 (XI1235_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1235_MN5 (XI1235_n2 XI1235_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1235_MN4 (b15_15 XI1235_An XI1235_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1235_MN2 (XI1235_n1 dd15_b3_2 b15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1235_MN3 (VSS qu17_b3_2 XI1235_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1235_MN0 (XI1235_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I218_MN1 (XI1252_I218_Bn I1252_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I218_MN5 (XI1252_I218_n2 XI1252_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I218_MN4 (p15_15 XI1252_I218_An XI1252_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I218_MN2 (XI1252_I218_n1 I1252_pn15 p15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I218_MN3 (VSS I1252_G14_0n XI1252_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I218_MN0 (XI1252_I218_An I1252_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I217_MN1 (XI1252_I217_Bn I1252_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I217_MN5 (XI1252_I217_n2 XI1252_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I217_MN4 (p15_14 XI1252_I217_An XI1252_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I217_MN2 (XI1252_I217_n1 I1252_pn14 p15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I217_MN3 (VSS I1252_G13_0n XI1252_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I217_MN0 (XI1252_I217_An I1252_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1283_MN1 (XI1283_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1283_MN5 (XI1283_n2 XI1283_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1283_MN4 (b16_17 XI1283_An XI1283_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1283_MN2 (XI1283_n1 dd17_b3_2 b16_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1283_MN3 (VSS qu16_b3_2 XI1283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1283_MN0 (XI1283_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1282_MN1 (XI1282_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1282_MN5 (XI1282_n2 XI1282_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1282_MN4 (b16_16 XI1282_An XI1282_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1282_MN2 (XI1282_n1 dd16_b3_2 b16_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1282_MN3 (VSS qu16_b3_2 XI1282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1282_MN0 (XI1282_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I218_MN1 (XI1298_I218_Bn I1298_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I218_MN5 (XI1298_I218_n2 XI1298_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I218_MN4 (p16_15 XI1298_I218_An XI1298_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I218_MN2 (XI1298_I218_n1 I1298_pn15 p16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I218_MN3 (VSS I1298_G14_0n XI1298_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I218_MN0 (XI1298_I218_An I1298_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I219_MN1 (XI1298_I219_Bn I1298_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I219_MN5 (XI1298_I219_n2 XI1298_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I219_MN4 (p16_16 XI1298_I219_An XI1298_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I219_MN2 (XI1298_I219_n1 I1298_pn16 p16_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I219_MN3 (VSS I1298_G15_0n XI1298_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I219_MN0 (XI1298_I219_An I1298_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I218_MN1 (XI1344_I218_Bn I1344_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I218_MN5 (XI1344_I218_n2 XI1344_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I218_MN4 (p17_15 XI1344_I218_An XI1344_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I218_MN2 (XI1344_I218_n1 I1344_pn15 p17_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I218_MN3 (VSS I1344_G14_0n XI1344_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I218_MN0 (XI1344_I218_An I1344_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1329_MN1 (XI1329_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1329_MN5 (XI1329_n2 XI1329_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1329_MN4 (b17_17 XI1329_An XI1329_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1329_MN2 (XI1329_n1 dd17_b3_3 b17_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1329_MN3 (VSS qu15_b3_2 XI1329_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1329_MN0 (XI1329_An dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I219_MN1 (XI1344_I219_Bn I1344_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I219_MN5 (XI1344_I219_n2 XI1344_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I219_MN4 (p17_16 XI1344_I219_An XI1344_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I219_MN2 (XI1344_I219_n1 I1344_pn16 p17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I219_MN3 (VSS I1344_G15_0n XI1344_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I219_MN0 (XI1344_I219_An I1344_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1375_MN1 (XI1375_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1375_MN5 (XI1375_n2 XI1375_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1375_MN4 (b18_17 XI1375_An XI1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1375_MN2 (XI1375_n1 dd17_b3_3 b18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1375_MN3 (VSS qu14_b3_2 XI1375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1375_MN0 (XI1375_An dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I218_MN1 (XI1390_I218_Bn I1390_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I218_MN5 (XI1390_I218_n2 XI1390_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I218_MN4 (p18_15 XI1390_I218_An XI1390_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I218_MN2 (XI1390_I218_n1 I1390_pn15 p18_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I218_MN3 (VSS I1390_G14_0n XI1390_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I218_MN0 (XI1390_I218_An I1390_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1421_MN1 (XI1421_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1421_MN5 (XI1421_n2 XI1421_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1421_MN4 (b19_17 XI1421_An XI1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1421_MN2 (XI1421_n1 dd17_b3_3 b19_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1421_MN3 (VSS qu13_b3_2 XI1421_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1421_MN0 (XI1421_An dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I218_MN1 (XI1436_I218_Bn I1436_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I218_MN5 (XI1436_I218_n2 XI1436_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I218_MN4 (p19_15 XI1436_I218_An XI1436_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I218_MN2 (XI1436_I218_n1 I1436_pn15 p19_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I218_MN3 (VSS I1436_G14_0n XI1436_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I218_MN0 (XI1436_I218_An I1436_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1467_MN1 (XI1467_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1467_MN5 (XI1467_n2 XI1467_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1467_MN4 (b20_17 XI1467_An XI1467_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1467_MN2 (XI1467_n1 dd17_b3_3 b20_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1467_MN3 (VSS qu12_b3_2 XI1467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1467_MN0 (XI1467_An dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I219_MN1 (XI1482_I219_Bn I1482_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I219_MN5 (XI1482_I219_n2 XI1482_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I219_MN4 (p20_16 XI1482_I219_An XI1482_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I219_MN2 (XI1482_I219_n1 I1482_pn16 p20_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I219_MN3 (VSS I1482_G15_0n XI1482_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I219_MN0 (XI1482_I219_An I1482_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1514_MN1 (XI1514_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1514_MN5 (XI1514_n2 XI1514_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1514_MN4 (b21_18 XI1514_An XI1514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1514_MN2 (XI1514_n1 dd18_b3_3 b21_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1514_MN3 (VSS qu11_b3_3 XI1514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1514_MN0 (XI1514_An dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1515_MN1 (XI1515_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1515_MN5 (XI1515_n2 XI1515_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1515_MN4 (b21_19 XI1515_An XI1515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1515_MN2 (XI1515_n1 dd19_b3_3 b21_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1515_MN3 (VSS qu11_b3_3 XI1515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1515_MN0 (XI1515_An dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1153_MN1 (XI1153_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1153_MN5 (XI1153_n2 XI1153_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1153_MN4 (b13_25 XI1153_An XI1153_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1153_MN2 (XI1153_n1 dd25_b3_2 b13_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1153_MN3 (VSS qu19_b3_4 XI1153_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1153_MN0 (XI1153_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I216_MN1 (XI1160_I216_Bn I1160_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I216_MN5 (XI1160_I216_n2 XI1160_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I216_MN4 (p13_13 XI1160_I216_An XI1160_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I216_MN2 (XI1160_I216_n1 I1160_pn13 p13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I216_MN3 (VSS I1160_G12_0n XI1160_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I216_MN0 (XI1160_I216_An I1160_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1191_MN1 (XI1191_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1191_MN5 (XI1191_n2 XI1191_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1191_MN4 (b14_17 XI1191_An XI1191_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1191_MN2 (XI1191_n1 dd17_b3_2 b14_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1191_MN3 (VSS qu18_b3_2 XI1191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1191_MN0 (XI1191_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I217_MN1 (XI1206_I217_Bn I1206_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I217_MN5 (XI1206_I217_n2 XI1206_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I217_MN4 (p14_14 XI1206_I217_An XI1206_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I217_MN2 (XI1206_I217_n1 I1206_pn14 p14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I217_MN3 (VSS I1206_G13_0n XI1206_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I217_MN0 (XI1206_I217_An I1206_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1237_MN1 (XI1237_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1237_MN5 (XI1237_n2 XI1237_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1237_MN4 (b15_17 XI1237_An XI1237_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1237_MN2 (XI1237_n1 dd17_b3_2 b15_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1237_MN3 (VSS qu17_b3_2 XI1237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1237_MN0 (XI1237_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I219_MN1 (XI1252_I219_Bn I1252_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I219_MN5 (XI1252_I219_n2 XI1252_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I219_MN4 (p15_16 XI1252_I219_An XI1252_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I219_MN2 (XI1252_I219_n1 I1252_pn16 p15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I219_MN3 (VSS I1252_G15_0n XI1252_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I219_MN0 (XI1252_I219_An I1252_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1330_MN1 (XI1330_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1330_MN5 (XI1330_n2 XI1330_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1330_MN4 (b17_18 XI1330_An XI1330_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1330_MN2 (XI1330_n1 dd18_b3_3 b17_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1330_MN3 (VSS qu15_b3_3 XI1330_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1330_MN0 (XI1330_An dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1376_MN1 (XI1376_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1376_MN5 (XI1376_n2 XI1376_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1376_MN4 (b18_18 XI1376_An XI1376_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1376_MN2 (XI1376_n1 dd18_b3_3 b18_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1376_MN3 (VSS qu14_b3_3 XI1376_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1376_MN0 (XI1376_An dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I219_MN1 (XI1390_I219_Bn I1390_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I219_MN5 (XI1390_I219_n2 XI1390_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I219_MN4 (p18_16 XI1390_I219_An XI1390_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I219_MN2 (XI1390_I219_n1 I1390_pn16 p18_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I219_MN3 (VSS I1390_G15_0n XI1390_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I219_MN0 (XI1390_I219_An I1390_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1422_MN1 (XI1422_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1422_MN5 (XI1422_n2 XI1422_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1422_MN4 (b19_18 XI1422_An XI1422_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1422_MN2 (XI1422_n1 dd18_b3_3 b19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1422_MN3 (VSS qu13_b3_3 XI1422_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1422_MN0 (XI1422_An dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I219_MN1 (XI1436_I219_Bn I1436_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I219_MN5 (XI1436_I219_n2 XI1436_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I219_MN4 (p19_16 XI1436_I219_An XI1436_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I219_MN2 (XI1436_I219_n1 I1436_pn16 p19_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I219_MN3 (VSS I1436_G15_0n XI1436_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I219_MN0 (XI1436_I219_An I1436_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1468_MN1 (XI1468_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1468_MN5 (XI1468_n2 XI1468_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1468_MN4 (b20_18 XI1468_An XI1468_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1468_MN2 (XI1468_n1 dd18_b3_3 b20_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1468_MN3 (VSS qu12_b3_3 XI1468_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1468_MN0 (XI1468_An dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1516_MN1 (XI1516_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1516_MN5 (XI1516_n2 XI1516_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1516_MN4 (b21_20 XI1516_An XI1516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1516_MN2 (XI1516_n1 dd20_b3_3 b21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1516_MN3 (VSS qu11_b3_3 XI1516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1516_MN0 (XI1516_An dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1530_MN1 (XI1530_Bn c21_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1530_MN5 (XI1530_n2 XI1530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1530_MN4 (p21_32 XI1530_An XI1530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1530_MN2 (XI1530_n1 h21 p21_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1530_MN3 (VSS c21_o XI1530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1530_MN0 (XI1530_An h21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I218_MN1 (XI1160_I218_Bn I1160_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I218_MN5 (XI1160_I218_n2 XI1160_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I218_MN4 (p13_15 XI1160_I218_An XI1160_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I218_MN2 (XI1160_I218_n1 I1160_pn15 p13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I218_MN3 (VSS I1160_G14_0n XI1160_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I218_MN0 (XI1160_I218_An I1160_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1192_MN1 (XI1192_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1192_MN5 (XI1192_n2 XI1192_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1192_MN4 (b14_18 XI1192_An XI1192_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1192_MN2 (XI1192_n1 dd18_b3_2 b14_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1192_MN3 (VSS qu18_b3_3 XI1192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1192_MN0 (XI1192_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I218_MN1 (XI1206_I218_Bn I1206_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I218_MN5 (XI1206_I218_n2 XI1206_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I218_MN4 (p14_15 XI1206_I218_An XI1206_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I218_MN2 (XI1206_I218_n1 I1206_pn15 p14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I218_MN3 (VSS I1206_G14_0n XI1206_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I218_MN0 (XI1206_I218_An I1206_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1238_MN1 (XI1238_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1238_MN5 (XI1238_n2 XI1238_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1238_MN4 (b15_18 XI1238_An XI1238_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1238_MN2 (XI1238_n1 dd18_b3_2 b15_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1238_MN3 (VSS qu17_b3_3 XI1238_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1238_MN0 (XI1238_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1285_MN1 (XI1285_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1285_MN5 (XI1285_n2 XI1285_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1285_MN4 (b16_19 XI1285_An XI1285_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1285_MN2 (XI1285_n1 dd19_b3_2 b16_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1285_MN3 (VSS qu16_b3_3 XI1285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1285_MN0 (XI1285_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1284_MN1 (XI1284_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1284_MN5 (XI1284_n2 XI1284_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1284_MN4 (b16_18 XI1284_An XI1284_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1284_MN2 (XI1284_n1 dd18_b3_2 b16_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1284_MN3 (VSS qu16_b3_3 XI1284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1284_MN0 (XI1284_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1331_MN1 (XI1331_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1331_MN5 (XI1331_n2 XI1331_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1331_MN4 (b17_19 XI1331_An XI1331_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1331_MN2 (XI1331_n1 dd19_b3_3 b17_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1331_MN3 (VSS qu15_b3_3 XI1331_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1331_MN0 (XI1331_An dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1332_MN1 (XI1332_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1332_MN5 (XI1332_n2 XI1332_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1332_MN4 (b17_20 XI1332_An XI1332_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1332_MN2 (XI1332_n1 dd20_b3_3 b17_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1332_MN3 (VSS qu15_b3_3 XI1332_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1332_MN0 (XI1332_An dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1378_MN1 (XI1378_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1378_MN5 (XI1378_n2 XI1378_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1378_MN4 (b18_20 XI1378_An XI1378_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1378_MN2 (XI1378_n1 dd20_b3_3 b18_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1378_MN3 (VSS qu14_b3_3 XI1378_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1378_MN0 (XI1378_An dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1377_MN1 (XI1377_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1377_MN5 (XI1377_n2 XI1377_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1377_MN4 (b18_19 XI1377_An XI1377_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1377_MN2 (XI1377_n1 dd19_b3_3 b18_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1377_MN3 (VSS qu14_b3_3 XI1377_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1377_MN0 (XI1377_An dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1423_MN1 (XI1423_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1423_MN5 (XI1423_n2 XI1423_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1423_MN4 (b19_19 XI1423_An XI1423_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1423_MN2 (XI1423_n1 dd19_b3_3 b19_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1423_MN3 (VSS qu13_b3_3 XI1423_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1423_MN0 (XI1423_An dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1424_MN1 (XI1424_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1424_MN5 (XI1424_n2 XI1424_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1424_MN4 (b19_20 XI1424_An XI1424_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1424_MN2 (XI1424_n1 dd20_b3_3 b19_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1424_MN3 (VSS qu13_b3_3 XI1424_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1424_MN0 (XI1424_An dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1469_MN1 (XI1469_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1469_MN5 (XI1469_n2 XI1469_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1469_MN4 (b20_19 XI1469_An XI1469_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1469_MN2 (XI1469_n1 dd19_b3_3 b20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1469_MN3 (VSS qu12_b3_3 XI1469_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1469_MN0 (XI1469_An dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1470_MN1 (XI1470_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1470_MN5 (XI1470_n2 XI1470_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1470_MN4 (b20_20 XI1470_An XI1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1470_MN2 (XI1470_n1 dd20_b3_3 b20_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1470_MN3 (VSS qu12_b3_3 XI1470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1470_MN0 (XI1470_An dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1517_MN1 (XI1517_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1517_MN5 (XI1517_n2 XI1517_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1517_MN4 (b21_21 XI1517_An XI1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1517_MN2 (XI1517_n1 dd21_b3_3 b21_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1517_MN3 (VSS qu11_b3_3 XI1517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1517_MN0 (XI1517_An dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1518_MN1 (XI1518_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1518_MN5 (XI1518_n2 XI1518_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1518_MN4 (b21_22 XI1518_An XI1518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1518_MN2 (XI1518_n1 dd22_b3_3 b21_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1518_MN3 (VSS qu11_b3_3 XI1518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1518_MN0 (XI1518_An dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1157_MN1 (XI1157_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1157_MN5 (XI1157_n2 XI1157_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1157_MN4 (b13_29 XI1157_An XI1157_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1157_MN2 (XI1157_n1 dd29_b3_2 b13_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1157_MN3 (VSS qu19_b3_4 XI1157_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1157_MN0 (XI1157_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1156_MN1 (XI1156_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1156_MN5 (XI1156_n2 XI1156_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1156_MN4 (b13_28 XI1156_An XI1156_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1156_MN2 (XI1156_n1 dd28_b3_2 b13_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1156_MN3 (VSS qu19_b3_4 XI1156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1156_MN0 (XI1156_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1154_MN1 (XI1154_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1154_MN5 (XI1154_n2 XI1154_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1154_MN4 (b13_26 XI1154_An XI1154_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1154_MN2 (XI1154_n1 dd26_b3_2 b13_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1154_MN3 (VSS qu19_b3_4 XI1154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1154_MN0 (XI1154_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1195_MN1 (XI1195_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1195_MN5 (XI1195_n2 XI1195_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1195_MN4 (b14_21 XI1195_An XI1195_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1195_MN2 (XI1195_n1 dd21_b3_2 b14_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1195_MN3 (VSS qu18_b3_3 XI1195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1195_MN0 (XI1195_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1193_MN1 (XI1193_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1193_MN5 (XI1193_n2 XI1193_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1193_MN4 (b14_19 XI1193_An XI1193_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1193_MN2 (XI1193_n1 dd19_b3_2 b14_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1193_MN3 (VSS qu18_b3_3 XI1193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1193_MN0 (XI1193_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1194_MN1 (XI1194_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1194_MN5 (XI1194_n2 XI1194_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1194_MN4 (b14_20 XI1194_An XI1194_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1194_MN2 (XI1194_n1 dd20_b3_2 b14_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1194_MN3 (VSS qu18_b3_3 XI1194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1194_MN0 (XI1194_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I219_MN1 (XI1206_I219_Bn I1206_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I219_MN5 (XI1206_I219_n2 XI1206_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I219_MN4 (p14_16 XI1206_I219_An XI1206_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I219_MN2 (XI1206_I219_n1 I1206_pn16 p14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I219_MN3 (VSS I1206_G15_0n XI1206_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I219_MN0 (XI1206_I219_An I1206_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1239_MN1 (XI1239_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1239_MN5 (XI1239_n2 XI1239_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1239_MN4 (b15_19 XI1239_An XI1239_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1239_MN2 (XI1239_n1 dd19_b3_2 b15_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1239_MN3 (VSS qu17_b3_3 XI1239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1239_MN0 (XI1239_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1241_MN1 (XI1241_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1241_MN5 (XI1241_n2 XI1241_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1241_MN4 (b15_21 XI1241_An XI1241_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1241_MN2 (XI1241_n1 dd21_b3_2 b15_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1241_MN3 (VSS qu17_b3_3 XI1241_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1241_MN0 (XI1241_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1240_MN1 (XI1240_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1240_MN5 (XI1240_n2 XI1240_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1240_MN4 (b15_20 XI1240_An XI1240_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1240_MN2 (XI1240_n1 dd20_b3_2 b15_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1240_MN3 (VSS qu17_b3_3 XI1240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1240_MN0 (XI1240_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1287_MN1 (XI1287_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1287_MN5 (XI1287_n2 XI1287_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1287_MN4 (b16_21 XI1287_An XI1287_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1287_MN2 (XI1287_n1 dd21_b3_2 b16_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1287_MN3 (VSS qu16_b3_3 XI1287_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1287_MN0 (XI1287_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1286_MN1 (XI1286_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1286_MN5 (XI1286_n2 XI1286_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1286_MN4 (b16_20 XI1286_An XI1286_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1286_MN2 (XI1286_n1 dd20_b3_2 b16_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1286_MN3 (VSS qu16_b3_3 XI1286_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1286_MN0 (XI1286_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1333_MN1 (XI1333_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1333_MN5 (XI1333_n2 XI1333_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1333_MN4 (b17_21 XI1333_An XI1333_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1333_MN2 (XI1333_n1 dd21_b3_3 b17_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1333_MN3 (VSS qu15_b3_3 XI1333_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1333_MN0 (XI1333_An dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1334_MN1 (XI1334_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1334_MN5 (XI1334_n2 XI1334_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1334_MN4 (b17_22 XI1334_An XI1334_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1334_MN2 (XI1334_n1 dd22_b3_3 b17_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1334_MN3 (VSS qu15_b3_3 XI1334_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1334_MN0 (XI1334_An dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1379_MN1 (XI1379_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1379_MN5 (XI1379_n2 XI1379_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1379_MN4 (b18_21 XI1379_An XI1379_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1379_MN2 (XI1379_n1 dd21_b3_3 b18_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1379_MN3 (VSS qu14_b3_3 XI1379_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1379_MN0 (XI1379_An dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1380_MN1 (XI1380_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1380_MN5 (XI1380_n2 XI1380_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1380_MN4 (b18_22 XI1380_An XI1380_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1380_MN2 (XI1380_n1 dd22_b3_3 b18_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1380_MN3 (VSS qu14_b3_3 XI1380_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1380_MN0 (XI1380_An dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1425_MN1 (XI1425_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1425_MN5 (XI1425_n2 XI1425_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1425_MN4 (b19_21 XI1425_An XI1425_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1425_MN2 (XI1425_n1 dd21_b3_3 b19_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1425_MN3 (VSS qu13_b3_3 XI1425_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1425_MN0 (XI1425_An dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1426_MN1 (XI1426_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1426_MN5 (XI1426_n2 XI1426_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1426_MN4 (b19_22 XI1426_An XI1426_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1426_MN2 (XI1426_n1 dd22_b3_3 b19_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1426_MN3 (VSS qu13_b3_3 XI1426_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1426_MN0 (XI1426_An dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1472_MN1 (XI1472_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1472_MN5 (XI1472_n2 XI1472_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1472_MN4 (b20_22 XI1472_An XI1472_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1472_MN2 (XI1472_n1 dd22_b3_3 b20_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1472_MN3 (VSS qu12_b3_3 XI1472_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1472_MN0 (XI1472_An dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1471_MN1 (XI1471_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1471_MN5 (XI1471_n2 XI1471_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1471_MN4 (b20_21 XI1471_An XI1471_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1471_MN2 (XI1471_n1 dd21_b3_3 b20_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1471_MN3 (VSS qu12_b3_3 XI1471_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1471_MN0 (XI1471_An dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1529_MN1 (XI1529_Bn qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1529_MN5 (XI1529_n2 XI1529_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1529_MN4 (h21 XI1529_An XI1529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1529_MN2 (XI1529_n1 p20_31 h21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1529_MN3 (VSS qu11_b3_5 XI1529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1529_MN0 (XI1529_An p20_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1519_MN1 (XI1519_Bn qu11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1519_MN5 (XI1519_n2 XI1519_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1519_MN4 (b21_23 XI1519_An XI1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1519_MN2 (XI1519_n1 dd23_b3_3 b21_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1519_MN3 (VSS qu11_b3_3 XI1519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1519_MN0 (XI1519_An dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1155_MN1 (XI1155_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1155_MN5 (XI1155_n2 XI1155_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1155_MN4 (b13_27 XI1155_An XI1155_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1155_MN2 (XI1155_n1 dd27_b3_2 b13_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1155_MN3 (VSS qu19_b3_4 XI1155_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1155_MN0 (XI1155_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1207_MN1 (XI1207_Bn qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1207_MN5 (XI1207_n2 XI1207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1207_MN4 (h14 XI1207_An XI1207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1207_MN2 (XI1207_n1 p13_31 h14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1207_MN3 (VSS qu18_b3_5 XI1207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1207_MN0 (XI1207_An p13_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1196_MN1 (XI1196_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1196_MN5 (XI1196_n2 XI1196_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1196_MN4 (b14_22 XI1196_An XI1196_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1196_MN2 (XI1196_n1 dd22_b3_2 b14_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1196_MN3 (VSS qu18_b3_3 XI1196_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1196_MN0 (XI1196_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1208_MN1 (XI1208_Bn c14_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1208_MN5 (XI1208_n2 XI1208_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1208_MN4 (p14_32 XI1208_An XI1208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1208_MN2 (XI1208_n1 h14 p14_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1208_MN3 (VSS c14_o XI1208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1208_MN0 (XI1208_An h14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1243_MN1 (XI1243_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1243_MN5 (XI1243_n2 XI1243_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1243_MN4 (b15_23 XI1243_An XI1243_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1243_MN2 (XI1243_n1 dd23_b3_2 b15_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1243_MN3 (VSS qu17_b3_3 XI1243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1243_MN0 (XI1243_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1242_MN1 (XI1242_Bn qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1242_MN5 (XI1242_n2 XI1242_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1242_MN4 (b15_22 XI1242_An XI1242_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1242_MN2 (XI1242_n1 dd22_b3_2 b15_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1242_MN3 (VSS qu17_b3_3 XI1242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1242_MN0 (XI1242_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1289_MN1 (XI1289_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1289_MN5 (XI1289_n2 XI1289_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1289_MN4 (b16_23 XI1289_An XI1289_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1289_MN2 (XI1289_n1 dd23_b3_2 b16_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1289_MN3 (VSS qu16_b3_3 XI1289_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1289_MN0 (XI1289_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1288_MN1 (XI1288_Bn qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1288_MN5 (XI1288_n2 XI1288_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1288_MN4 (b16_22 XI1288_An XI1288_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1288_MN2 (XI1288_n1 dd22_b3_2 b16_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1288_MN3 (VSS qu16_b3_3 XI1288_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1288_MN0 (XI1288_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1335_MN1 (XI1335_Bn qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1335_MN5 (XI1335_n2 XI1335_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1335_MN4 (b17_23 XI1335_An XI1335_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1335_MN2 (XI1335_n1 dd23_b3_3 b17_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1335_MN3 (VSS qu15_b3_3 XI1335_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1335_MN0 (XI1335_An dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1381_MN1 (XI1381_Bn qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1381_MN5 (XI1381_n2 XI1381_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1381_MN4 (b18_23 XI1381_An XI1381_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1381_MN2 (XI1381_n1 dd23_b3_3 b18_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1381_MN3 (VSS qu14_b3_3 XI1381_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1381_MN0 (XI1381_An dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1427_MN1 (XI1427_Bn qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1427_MN5 (XI1427_n2 XI1427_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1427_MN4 (b19_23 XI1427_An XI1427_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1427_MN2 (XI1427_n1 dd23_b3_3 b19_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1427_MN3 (VSS qu13_b3_3 XI1427_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1427_MN0 (XI1427_An dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1473_MN1 (XI1473_Bn qu12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1473_MN5 (XI1473_n2 XI1473_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1473_MN4 (b20_23 XI1473_An XI1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1473_MN2 (XI1473_n1 dd23_b3_3 b20_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1473_MN3 (VSS qu12_b3_3 XI1473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1473_MN0 (XI1473_An dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1520_MN1 (XI1520_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1520_MN5 (XI1520_n2 XI1520_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1520_MN4 (b21_24 XI1520_An XI1520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1520_MN2 (XI1520_n1 dd24_b3_3 b21_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1520_MN3 (VSS qu11_b3_4 XI1520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1520_MN0 (XI1520_An dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1521_MN1 (XI1521_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1521_MN5 (XI1521_n2 XI1521_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1521_MN4 (b21_25 XI1521_An XI1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1521_MN2 (XI1521_n1 dd25_b3_3 b21_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1521_MN3 (VSS qu11_b3_4 XI1521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1521_MN0 (XI1521_An dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1522_MN1 (XI1522_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1522_MN5 (XI1522_n2 XI1522_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1522_MN4 (b21_26 XI1522_An XI1522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1522_MN2 (XI1522_n1 dd26_b3_3 b21_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1522_MN3 (VSS qu11_b3_4 XI1522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1522_MN0 (XI1522_An dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1199_MN1 (XI1199_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1199_MN5 (XI1199_n2 XI1199_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1199_MN4 (b14_25 XI1199_An XI1199_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1199_MN2 (XI1199_n1 dd25_b3_2 b14_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1199_MN3 (VSS qu18_b3_4 XI1199_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1199_MN0 (XI1199_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1197_MN1 (XI1197_Bn qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1197_MN5 (XI1197_n2 XI1197_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1197_MN4 (b14_23 XI1197_An XI1197_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1197_MN2 (XI1197_n1 dd23_b3_2 b14_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1197_MN3 (VSS qu18_b3_3 XI1197_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1197_MN0 (XI1197_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1198_MN1 (XI1198_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1198_MN5 (XI1198_n2 XI1198_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1198_MN4 (b14_24 XI1198_An XI1198_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1198_MN2 (XI1198_n1 dd24_b3_2 b14_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1198_MN3 (VSS qu18_b3_4 XI1198_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1198_MN0 (XI1198_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1244_MN1 (XI1244_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1244_MN5 (XI1244_n2 XI1244_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1244_MN4 (b15_24 XI1244_An XI1244_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1244_MN2 (XI1244_n1 dd24_b3_2 b15_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1244_MN3 (VSS qu17_b3_4 XI1244_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1244_MN0 (XI1244_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1290_MN1 (XI1290_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1290_MN5 (XI1290_n2 XI1290_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1290_MN4 (b16_24 XI1290_An XI1290_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1290_MN2 (XI1290_n1 dd24_b3_2 b16_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1290_MN3 (VSS qu16_b3_4 XI1290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1290_MN0 (XI1290_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1336_MN1 (XI1336_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1336_MN5 (XI1336_n2 XI1336_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1336_MN4 (b17_24 XI1336_An XI1336_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1336_MN2 (XI1336_n1 dd24_b3_3 b17_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1336_MN3 (VSS qu15_b3_4 XI1336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1336_MN0 (XI1336_An dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1382_MN1 (XI1382_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1382_MN5 (XI1382_n2 XI1382_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1382_MN4 (b18_24 XI1382_An XI1382_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1382_MN2 (XI1382_n1 dd24_b3_3 b18_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1382_MN3 (VSS qu14_b3_4 XI1382_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1382_MN0 (XI1382_An dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1428_MN1 (XI1428_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1428_MN5 (XI1428_n2 XI1428_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1428_MN4 (b19_24 XI1428_An XI1428_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1428_MN2 (XI1428_n1 dd24_b3_3 b19_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1428_MN3 (VSS qu13_b3_4 XI1428_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1428_MN0 (XI1428_An dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1523_MN1 (XI1523_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1523_MN5 (XI1523_n2 XI1523_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1523_MN4 (b21_27 XI1523_An XI1523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1523_MN2 (XI1523_n1 dd27_b3_3 b21_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1523_MN3 (VSS qu11_b3_4 XI1523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1523_MN0 (XI1523_An dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1525_MN1 (XI1525_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1525_MN5 (XI1525_n2 XI1525_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1525_MN4 (b21_29 XI1525_An XI1525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1525_MN2 (XI1525_n1 dd29_b3_3 b21_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1525_MN3 (VSS qu11_b3_4 XI1525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1525_MN0 (XI1525_An dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1204_MN1 (XI1204_Bn qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1204_MN5 (XI1204_n2 XI1204_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1204_MN4 (b14_30 XI1204_An XI1204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1204_MN2 (XI1204_n1 dd30_b3_2 b14_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1204_MN3 (VSS qu18_b3_5 XI1204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1204_MN0 (XI1204_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1200_MN1 (XI1200_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1200_MN5 (XI1200_n2 XI1200_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1200_MN4 (b14_26 XI1200_An XI1200_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1200_MN2 (XI1200_n1 dd26_b3_2 b14_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1200_MN3 (VSS qu18_b3_4 XI1200_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1200_MN0 (XI1200_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1201_MN1 (XI1201_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1201_MN5 (XI1201_n2 XI1201_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1201_MN4 (b14_27 XI1201_An XI1201_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1201_MN2 (XI1201_n1 dd27_b3_2 b14_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1201_MN3 (VSS qu18_b3_4 XI1201_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1201_MN0 (XI1201_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1246_MN1 (XI1246_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1246_MN5 (XI1246_n2 XI1246_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1246_MN4 (b15_26 XI1246_An XI1246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1246_MN2 (XI1246_n1 dd26_b3_2 b15_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1246_MN3 (VSS qu17_b3_4 XI1246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1246_MN0 (XI1246_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1245_MN1 (XI1245_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1245_MN5 (XI1245_n2 XI1245_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1245_MN4 (b15_25 XI1245_An XI1245_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1245_MN2 (XI1245_n1 dd25_b3_2 b15_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1245_MN3 (VSS qu17_b3_4 XI1245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1245_MN0 (XI1245_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1292_MN1 (XI1292_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1292_MN5 (XI1292_n2 XI1292_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1292_MN4 (b16_26 XI1292_An XI1292_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1292_MN2 (XI1292_n1 dd26_b3_2 b16_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1292_MN3 (VSS qu16_b3_4 XI1292_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1292_MN0 (XI1292_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1293_MN1 (XI1293_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1293_MN5 (XI1293_n2 XI1293_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1293_MN4 (b16_27 XI1293_An XI1293_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1293_MN2 (XI1293_n1 dd27_b3_2 b16_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1293_MN3 (VSS qu16_b3_4 XI1293_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1293_MN0 (XI1293_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1291_MN1 (XI1291_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1291_MN5 (XI1291_n2 XI1291_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1291_MN4 (b16_25 XI1291_An XI1291_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1291_MN2 (XI1291_n1 dd25_b3_2 b16_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1291_MN3 (VSS qu16_b3_4 XI1291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1291_MN0 (XI1291_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1338_MN1 (XI1338_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1338_MN5 (XI1338_n2 XI1338_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1338_MN4 (b17_26 XI1338_An XI1338_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1338_MN2 (XI1338_n1 dd26_b3_3 b17_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1338_MN3 (VSS qu15_b3_4 XI1338_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1338_MN0 (XI1338_An dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1337_MN1 (XI1337_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1337_MN5 (XI1337_n2 XI1337_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1337_MN4 (b17_25 XI1337_An XI1337_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1337_MN2 (XI1337_n1 dd25_b3_3 b17_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1337_MN3 (VSS qu15_b3_4 XI1337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1337_MN0 (XI1337_An dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1383_MN1 (XI1383_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1383_MN5 (XI1383_n2 XI1383_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1383_MN4 (b18_25 XI1383_An XI1383_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1383_MN2 (XI1383_n1 dd25_b3_3 b18_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1383_MN3 (VSS qu14_b3_4 XI1383_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1383_MN0 (XI1383_An dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1384_MN1 (XI1384_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1384_MN5 (XI1384_n2 XI1384_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1384_MN4 (b18_26 XI1384_An XI1384_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1384_MN2 (XI1384_n1 dd26_b3_3 b18_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1384_MN3 (VSS qu14_b3_4 XI1384_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1384_MN0 (XI1384_An dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1429_MN1 (XI1429_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1429_MN5 (XI1429_n2 XI1429_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1429_MN4 (b19_25 XI1429_An XI1429_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1429_MN2 (XI1429_n1 dd25_b3_3 b19_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1429_MN3 (VSS qu13_b3_4 XI1429_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1429_MN0 (XI1429_An dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1430_MN1 (XI1430_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1430_MN5 (XI1430_n2 XI1430_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1430_MN4 (b19_26 XI1430_An XI1430_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1430_MN2 (XI1430_n1 dd26_b3_3 b19_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1430_MN3 (VSS qu13_b3_4 XI1430_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1430_MN0 (XI1430_An dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1474_MN1 (XI1474_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1474_MN5 (XI1474_n2 XI1474_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1474_MN4 (b20_24 XI1474_An XI1474_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1474_MN2 (XI1474_n1 dd24_b3_3 b20_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1474_MN3 (VSS qu12_b3_4 XI1474_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1474_MN0 (XI1474_An dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1475_MN1 (XI1475_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1475_MN5 (XI1475_n2 XI1475_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1475_MN4 (b20_25 XI1475_An XI1475_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1475_MN2 (XI1475_n1 dd25_b3_3 b20_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1475_MN3 (VSS qu12_b3_4 XI1475_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1475_MN0 (XI1475_An dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1476_MN1 (XI1476_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1476_MN5 (XI1476_n2 XI1476_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1476_MN4 (b20_26 XI1476_An XI1476_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1476_MN2 (XI1476_n1 dd26_b3_3 b20_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1476_MN3 (VSS qu12_b3_4 XI1476_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1476_MN0 (XI1476_An dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1524_MN1 (XI1524_Bn qu11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1524_MN5 (XI1524_n2 XI1524_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1524_MN4 (b21_28 XI1524_An XI1524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1524_MN2 (XI1524_n1 dd28_b3_3 b21_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1524_MN3 (VSS qu11_b3_4 XI1524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1524_MN0 (XI1524_An dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1526_MN1 (XI1526_Bn qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1526_MN5 (XI1526_n2 XI1526_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1526_MN4 (b21_30 XI1526_An XI1526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1526_MN2 (XI1526_n1 dd30_b3_3 b21_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1526_MN3 (VSS qu11_b3_5 XI1526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1526_MN0 (XI1526_An dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1205_MN1 (XI1205_Bn qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1205_MN5 (XI1205_n2 XI1205_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1205_MN4 (b14_31 XI1205_An XI1205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1205_MN2 (XI1205_n1 dd31_b3_2 b14_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1205_MN3 (VSS qu18_b3_5 XI1205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1205_MN0 (XI1205_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1203_MN1 (XI1203_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1203_MN5 (XI1203_n2 XI1203_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1203_MN4 (b14_29 XI1203_An XI1203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1203_MN2 (XI1203_n1 dd29_b3_2 b14_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1203_MN3 (VSS qu18_b3_4 XI1203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1203_MN0 (XI1203_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1202_MN1 (XI1202_Bn qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1202_MN5 (XI1202_n2 XI1202_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1202_MN4 (b14_28 XI1202_An XI1202_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1202_MN2 (XI1202_n1 dd28_b3_2 b14_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1202_MN3 (VSS qu18_b3_4 XI1202_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1202_MN0 (XI1202_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1248_MN1 (XI1248_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1248_MN5 (XI1248_n2 XI1248_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1248_MN4 (b15_28 XI1248_An XI1248_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1248_MN2 (XI1248_n1 dd28_b3_2 b15_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1248_MN3 (VSS qu17_b3_4 XI1248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1248_MN0 (XI1248_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1247_MN1 (XI1247_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1247_MN5 (XI1247_n2 XI1247_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1247_MN4 (b15_27 XI1247_An XI1247_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1247_MN2 (XI1247_n1 dd27_b3_2 b15_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1247_MN3 (VSS qu17_b3_4 XI1247_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1247_MN0 (XI1247_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1254_MN1 (XI1254_Bn c15_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1254_MN5 (XI1254_n2 XI1254_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1254_MN4 (p15_32 XI1254_An XI1254_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1254_MN2 (XI1254_n1 h15 p15_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1254_MN3 (VSS c15_o XI1254_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1254_MN0 (XI1254_An h15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1295_MN1 (XI1295_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1295_MN5 (XI1295_n2 XI1295_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1295_MN4 (b16_29 XI1295_An XI1295_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1295_MN2 (XI1295_n1 dd29_b3_2 b16_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1295_MN3 (VSS qu16_b3_4 XI1295_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1295_MN0 (XI1295_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1294_MN1 (XI1294_Bn qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1294_MN5 (XI1294_n2 XI1294_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1294_MN4 (b16_28 XI1294_An XI1294_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1294_MN2 (XI1294_n1 dd28_b3_2 b16_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1294_MN3 (VSS qu16_b3_4 XI1294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1294_MN0 (XI1294_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1300_MN1 (XI1300_Bn c16_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1300_MN5 (XI1300_n2 XI1300_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1300_MN4 (p16_32 XI1300_An XI1300_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1300_MN2 (XI1300_n1 h16 p16_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1300_MN3 (VSS c16_o XI1300_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1300_MN0 (XI1300_An h16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1346_MN1 (XI1346_Bn c17_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1346_MN5 (XI1346_n2 XI1346_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1346_MN4 (p17_32 XI1346_An XI1346_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1346_MN2 (XI1346_n1 h17 p17_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1346_MN3 (VSS c17_o XI1346_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1346_MN0 (XI1346_An h17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1341_MN1 (XI1341_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1341_MN5 (XI1341_n2 XI1341_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1341_MN4 (b17_29 XI1341_An XI1341_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1341_MN2 (XI1341_n1 dd29_b3_3 b17_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1341_MN3 (VSS qu15_b3_4 XI1341_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1341_MN0 (XI1341_An dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1339_MN1 (XI1339_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1339_MN5 (XI1339_n2 XI1339_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1339_MN4 (b17_27 XI1339_An XI1339_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1339_MN2 (XI1339_n1 dd27_b3_3 b17_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1339_MN3 (VSS qu15_b3_4 XI1339_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1339_MN0 (XI1339_An dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1385_MN1 (XI1385_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1385_MN5 (XI1385_n2 XI1385_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1385_MN4 (b18_27 XI1385_An XI1385_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1385_MN2 (XI1385_n1 dd27_b3_3 b18_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1385_MN3 (VSS qu14_b3_4 XI1385_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1385_MN0 (XI1385_An dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1386_MN1 (XI1386_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1386_MN5 (XI1386_n2 XI1386_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1386_MN4 (b18_28 XI1386_An XI1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1386_MN2 (XI1386_n1 dd28_b3_3 b18_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1386_MN3 (VSS qu14_b3_4 XI1386_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1386_MN0 (XI1386_An dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1391_MN1 (XI1391_Bn qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1391_MN5 (XI1391_n2 XI1391_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1391_MN4 (h18 XI1391_An XI1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1391_MN2 (XI1391_n1 p17_31 h18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1391_MN3 (VSS qu14_b3_5 XI1391_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1391_MN0 (XI1391_An p17_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1392_MN1 (XI1392_Bn c18_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1392_MN5 (XI1392_n2 XI1392_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1392_MN4 (p18_32 XI1392_An XI1392_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1392_MN2 (XI1392_n1 h18 p18_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1392_MN3 (VSS c18_o XI1392_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1392_MN0 (XI1392_An h18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1432_MN1 (XI1432_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1432_MN5 (XI1432_n2 XI1432_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1432_MN4 (b19_28 XI1432_An XI1432_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1432_MN2 (XI1432_n1 dd28_b3_3 b19_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1432_MN3 (VSS qu13_b3_4 XI1432_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1432_MN0 (XI1432_An dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1431_MN1 (XI1431_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1431_MN5 (XI1431_n2 XI1431_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1431_MN4 (b19_27 XI1431_An XI1431_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1431_MN2 (XI1431_n1 dd27_b3_3 b19_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1431_MN3 (VSS qu13_b3_4 XI1431_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1431_MN0 (XI1431_An dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1483_MN1 (XI1483_Bn qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1483_MN5 (XI1483_n2 XI1483_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1483_MN4 (h20 XI1483_An XI1483_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1483_MN2 (XI1483_n1 p19_31 h20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1483_MN3 (VSS qu12_b3_5 XI1483_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1483_MN0 (XI1483_An p19_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1481_MN1 (XI1481_Bn qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1481_MN5 (XI1481_n2 XI1481_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1481_MN4 (b20_31 XI1481_An XI1481_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1481_MN2 (XI1481_n1 dd31_b3_3 b20_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1481_MN3 (VSS qu12_b3_5 XI1481_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1481_MN0 (XI1481_An dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1484_MN1 (XI1484_Bn c20_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1484_MN5 (XI1484_n2 XI1484_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1484_MN4 (p20_32 XI1484_An XI1484_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1484_MN2 (XI1484_n1 h20 p20_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1484_MN3 (VSS c20_o XI1484_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1484_MN0 (XI1484_An h20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1480_MN1 (XI1480_Bn qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1480_MN5 (XI1480_n2 XI1480_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1480_MN4 (b20_30 XI1480_An XI1480_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1480_MN2 (XI1480_n1 dd30_b3_3 b20_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1480_MN3 (VSS qu12_b3_5 XI1480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1480_MN0 (XI1480_An dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1477_MN1 (XI1477_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1477_MN5 (XI1477_n2 XI1477_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1477_MN4 (b20_27 XI1477_An XI1477_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1477_MN2 (XI1477_n1 dd27_b3_3 b20_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1477_MN3 (VSS qu12_b3_4 XI1477_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1477_MN0 (XI1477_An dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1527_MN1 (XI1527_Bn qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1527_MN5 (XI1527_n2 XI1527_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1527_MN4 (b21_31 XI1527_An XI1527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1527_MN2 (XI1527_n1 dd31_b3_3 b21_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1527_MN3 (VSS qu11_b3_5 XI1527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1527_MN0 (XI1527_An dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1249_MN1 (XI1249_Bn qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1249_MN5 (XI1249_n2 XI1249_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1249_MN4 (b15_29 XI1249_An XI1249_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1249_MN2 (XI1249_n1 dd29_b3_2 b15_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1249_MN3 (VSS qu17_b3_4 XI1249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1249_MN0 (XI1249_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1250_MN1 (XI1250_Bn qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1250_MN5 (XI1250_n2 XI1250_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1250_MN4 (b15_30 XI1250_An XI1250_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1250_MN2 (XI1250_n1 dd30_b3_2 b15_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1250_MN3 (VSS qu17_b3_5 XI1250_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1250_MN0 (XI1250_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1251_MN1 (XI1251_Bn qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1251_MN5 (XI1251_n2 XI1251_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1251_MN4 (b15_31 XI1251_An XI1251_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1251_MN2 (XI1251_n1 dd31_b3_2 b15_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1251_MN3 (VSS qu17_b3_5 XI1251_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1251_MN0 (XI1251_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1253_MN1 (XI1253_Bn qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1253_MN5 (XI1253_n2 XI1253_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1253_MN4 (h15 XI1253_An XI1253_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1253_MN2 (XI1253_n1 p14_31 h15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1253_MN3 (VSS qu17_b3_5 XI1253_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1253_MN0 (XI1253_An p14_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1299_MN1 (XI1299_Bn qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1299_MN5 (XI1299_n2 XI1299_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1299_MN4 (h16 XI1299_An XI1299_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1299_MN2 (XI1299_n1 p15_31 h16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1299_MN3 (VSS qu16_b3_5 XI1299_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1299_MN0 (XI1299_An p15_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1297_MN1 (XI1297_Bn qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1297_MN5 (XI1297_n2 XI1297_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1297_MN4 (b16_31 XI1297_An XI1297_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1297_MN2 (XI1297_n1 dd31_b3_2 b16_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1297_MN3 (VSS qu16_b3_5 XI1297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1297_MN0 (XI1297_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1296_MN1 (XI1296_Bn qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1296_MN5 (XI1296_n2 XI1296_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1296_MN4 (b16_30 XI1296_An XI1296_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1296_MN2 (XI1296_n1 dd30_b3_2 b16_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1296_MN3 (VSS qu16_b3_5 XI1296_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1296_MN0 (XI1296_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1345_MN1 (XI1345_Bn qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1345_MN5 (XI1345_n2 XI1345_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1345_MN4 (h17 XI1345_An XI1345_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1345_MN2 (XI1345_n1 p16_31 h17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1345_MN3 (VSS qu15_b3_5 XI1345_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1345_MN0 (XI1345_An p16_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1340_MN1 (XI1340_Bn qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1340_MN5 (XI1340_n2 XI1340_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1340_MN4 (b17_28 XI1340_An XI1340_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1340_MN2 (XI1340_n1 dd28_b3_3 b17_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1340_MN3 (VSS qu15_b3_4 XI1340_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1340_MN0 (XI1340_An dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1342_MN1 (XI1342_Bn qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1342_MN5 (XI1342_n2 XI1342_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1342_MN4 (b17_30 XI1342_An XI1342_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1342_MN2 (XI1342_n1 dd30_b3_3 b17_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1342_MN3 (VSS qu15_b3_5 XI1342_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1342_MN0 (XI1342_An dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1343_MN1 (XI1343_Bn qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1343_MN5 (XI1343_n2 XI1343_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1343_MN4 (b17_31 XI1343_An XI1343_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1343_MN2 (XI1343_n1 dd31_b3_3 b17_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1343_MN3 (VSS qu15_b3_5 XI1343_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1343_MN0 (XI1343_An dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1387_MN1 (XI1387_Bn qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1387_MN5 (XI1387_n2 XI1387_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1387_MN4 (b18_29 XI1387_An XI1387_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1387_MN2 (XI1387_n1 dd29_b3_3 b18_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1387_MN3 (VSS qu14_b3_4 XI1387_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1387_MN0 (XI1387_An dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1388_MN1 (XI1388_Bn qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1388_MN5 (XI1388_n2 XI1388_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1388_MN4 (b18_30 XI1388_An XI1388_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1388_MN2 (XI1388_n1 dd30_b3_3 b18_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1388_MN3 (VSS qu14_b3_5 XI1388_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1388_MN0 (XI1388_An dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1389_MN1 (XI1389_Bn qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1389_MN5 (XI1389_n2 XI1389_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1389_MN4 (b18_31 XI1389_An XI1389_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1389_MN2 (XI1389_n1 dd31_b3_3 b18_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1389_MN3 (VSS qu14_b3_5 XI1389_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1389_MN0 (XI1389_An dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1437_MN1 (XI1437_Bn qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1437_MN5 (XI1437_n2 XI1437_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1437_MN4 (h19 XI1437_An XI1437_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1437_MN2 (XI1437_n1 p18_31 h19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1437_MN3 (VSS qu13_b3_5 XI1437_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1437_MN0 (XI1437_An p18_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1433_MN1 (XI1433_Bn qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1433_MN5 (XI1433_n2 XI1433_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1433_MN4 (b19_29 XI1433_An XI1433_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1433_MN2 (XI1433_n1 dd29_b3_3 b19_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1433_MN3 (VSS qu13_b3_4 XI1433_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1433_MN0 (XI1433_An dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1434_MN1 (XI1434_Bn qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1434_MN5 (XI1434_n2 XI1434_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1434_MN4 (b19_30 XI1434_An XI1434_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1434_MN2 (XI1434_n1 dd30_b3_3 b19_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1434_MN3 (VSS qu13_b3_5 XI1434_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1434_MN0 (XI1434_An dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1435_MN1 (XI1435_Bn qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1435_MN5 (XI1435_n2 XI1435_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1435_MN4 (b19_31 XI1435_An XI1435_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1435_MN2 (XI1435_n1 dd31_b3_3 b19_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1435_MN3 (VSS qu13_b3_5 XI1435_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1435_MN0 (XI1435_An dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1438_MN1 (XI1438_Bn c19_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1438_MN5 (XI1438_n2 XI1438_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1438_MN4 (p19_32 XI1438_An XI1438_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1438_MN2 (XI1438_n1 h19 p19_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1438_MN3 (VSS c19_o XI1438_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1438_MN0 (XI1438_An h19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1479_MN1 (XI1479_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1479_MN5 (XI1479_n2 XI1479_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1479_MN4 (b20_29 XI1479_An XI1479_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1479_MN2 (XI1479_n1 dd29_b3_3 b20_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1479_MN3 (VSS qu12_b3_4 XI1479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1479_MN0 (XI1479_An dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1478_MN1 (XI1478_Bn qu12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1478_MN5 (XI1478_n2 XI1478_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1478_MN4 (b20_28 XI1478_An XI1478_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1478_MN2 (XI1478_n1 dd28_b3_3 b20_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1478_MN3 (VSS qu12_b3_4 XI1478_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1478_MN0 (XI1478_An dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I232_MP1 (VDD I608_G28_0 XI608_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I232_MP5 (p1_29 I608_G28_0 XI608_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I232_MP4 (XI608_I232_p1 XI608_I232_An p1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I232_MP2 (VDD I608_pn29 XI608_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I232_MP3 (XI608_I232_p1 XI608_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I232_MP0 (VDD I608_pn29 XI608_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I63_MP1 (VDD b1_31 XI608_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I63_MP5 (I608_pn31 b1_31 XI608_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I63_MP4 (XI608_I63_p1 XI608_I63_An I608_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I63_MP2 (VDD p0_30 XI608_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I63_MP3 (XI608_I63_p1 XI608_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I63_MP0 (VDD p0_30 XI608_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I62_MP1 (VDD b1_30 XI608_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I62_MP5 (I608_pn30 b1_30 XI608_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I62_MP4 (XI608_I62_p1 XI608_I62_An I608_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I62_MP2 (VDD p0_29 XI608_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I62_MP3 (XI608_I62_p1 XI608_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I62_MP0 (VDD p0_29 XI608_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I62_MP1 (VDD b0_30 XI562_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I62_MP5 (I562_pn30 b0_30 XI562_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I62_MP4 (XI562_I62_p1 XI562_I62_An I562_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I62_MP2 (VDD VSS XI562_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I62_MP3 (XI562_I62_p1 XI562_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I62_MP0 (VDD VSS XI562_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I60_MP1 (VDD b0_28 XI562_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I60_MP5 (I562_pn28 b0_28 XI562_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I60_MP4 (XI562_I60_p1 XI562_I60_An I562_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I60_MP2 (VDD VSS XI562_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I60_MP3 (XI562_I60_p1 XI562_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I60_MP0 (VDD VSS XI562_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2231_MP1 (VDD nrkn21 XI2231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2231_MP5 (R_21 nrkn21 XI2231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2231_MP4 (XI2231_p1 XI2231_An R_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2231_MP2 (VDD ru21 XI2231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2231_MP3 (XI2231_p1 XI2231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2231_MP0 (VDD ru21 XI2231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2234_MP1 (VDD nrkn22 XI2234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2234_MP5 (R_22 nrkn22 XI2234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2234_MP4 (XI2234_p1 XI2234_An R_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2234_MP2 (VDD ru22 XI2234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2234_MP3 (XI2234_p1 XI2234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2234_MP0 (VDD ru22 XI2234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2237_MP1 (VDD nrkn23 XI2237_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2237_MP5 (R_23 nrkn23 XI2237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2237_MP4 (XI2237_p1 XI2237_An R_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2237_MP2 (VDD ru23 XI2237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2237_MP3 (XI2237_p1 XI2237_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2237_MP0 (VDD ru23 XI2237_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2240_MP1 (VDD nrkn24 XI2240_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2240_MP5 (R_24 nrkn24 XI2240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2240_MP4 (XI2240_p1 XI2240_An R_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2240_MP2 (VDD ru24 XI2240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2240_MP3 (XI2240_p1 XI2240_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2240_MP0 (VDD ru24 XI2240_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2249_MP1 (VDD nrkn27 XI2249_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2249_MP5 (R_27 nrkn27 XI2249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2249_MP4 (XI2249_p1 XI2249_An R_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2249_MP2 (VDD ru27 XI2249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2249_MP3 (XI2249_p1 XI2249_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2249_MP0 (VDD ru27 XI2249_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2252_MP1 (VDD nrkn28 XI2252_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2252_MP5 (R_28 nrkn28 XI2252_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2252_MP4 (XI2252_p1 XI2252_An R_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2252_MP2 (VDD ru28 XI2252_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2252_MP3 (XI2252_p1 XI2252_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2252_MP0 (VDD ru28 XI2252_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2258_MP1 (VDD nrkn30 XI2258_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2258_MP5 (R_30 nrkn30 XI2258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2258_MP4 (XI2258_p1 XI2258_An R_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2258_MP2 (VDD ru30 XI2258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2258_MP3 (XI2258_p1 XI2258_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2258_MP0 (VDD ru30 XI2258_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2261_MP1 (VDD nrkn31 XI2261_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2261_MP5 (R_31 nrkn31 XI2261_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2261_MP4 (XI2261_p1 XI2261_An R_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2261_MP2 (VDD ru31 XI2261_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2261_MP3 (XI2261_p1 XI2261_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2261_MP0 (VDD ru31 XI2261_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I63_MP1 (VDD dm31 XI2066_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I63_MP5 (I2066_pn31 dm31 XI2066_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I63_MP4 (XI2066_I63_p1 XI2066_I63_An I2066_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I63_MP2 (VDD p31_31 XI2066_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I63_MP3 (XI2066_I63_p1 XI2066_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I63_MP0 (VDD p31_31 XI2066_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I234_MP1 (VDD c31_m XI1988_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I234_MP5 (p31_31 c31_m XI1988_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I234_MP4 (XI1988_I234_p1 XI1988_I234_An p31_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I234_MP2 (VDD I1988_pn31 XI1988_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I234_MP3 (XI1988_I234_p1 XI1988_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I234_MP0 (VDD I1988_pn31 XI1988_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I62_MP1 (VDD b31_30 XI1988_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I62_MP5 (I1988_pn30 b31_30 XI1988_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I62_MP4 (XI1988_I62_p1 XI1988_I62_An I1988_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I62_MP2 (VDD p30_29 XI1988_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I62_MP3 (XI1988_I62_p1 XI1988_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I62_MP0 (VDD p30_29 XI1988_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I63_MP1 (VDD b31_31 XI1988_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I63_MP5 (I1988_pn31 b31_31 XI1988_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I63_MP4 (XI1988_I63_p1 XI1988_I63_An I1988_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I63_MP2 (VDD p30_30 XI1988_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I63_MP3 (XI1988_I63_p1 XI1988_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I63_MP0 (VDD p30_30 XI1988_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I61_MP1 (VDD b31_29 XI1988_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I61_MP5 (I1988_pn29 b31_29 XI1988_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I61_MP4 (XI1988_I61_p1 XI1988_I61_An I1988_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I61_MP2 (VDD p30_28 XI1988_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I61_MP3 (XI1988_I61_p1 XI1988_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I61_MP0 (VDD p30_28 XI1988_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I232_MP1 (VDD I1942_G28_0 XI1942_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I232_MP5 (p30_29 I1942_G28_0 XI1942_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I232_MP4 (XI1942_I232_p1 XI1942_I232_An p30_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I232_MP2 (VDD I1942_pn29 XI1942_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I232_MP3 (XI1942_I232_p1 XI1942_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I232_MP0 (VDD I1942_pn29 XI1942_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I233_MP1 (VDD I1942_G29_0 XI1942_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I233_MP5 (p30_30 I1942_G29_0 XI1942_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I233_MP4 (XI1942_I233_p1 XI1942_I233_An p30_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I233_MP2 (VDD I1942_pn30 XI1942_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I233_MP3 (XI1942_I233_p1 XI1942_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I233_MP0 (VDD I1942_pn30 XI1942_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I62_MP1 (VDD b30_30 XI1942_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I62_MP5 (I1942_pn30 b30_30 XI1942_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I62_MP4 (XI1942_I62_p1 XI1942_I62_An I1942_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I62_MP2 (VDD p29_29 XI1942_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I62_MP3 (XI1942_I62_p1 XI1942_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I62_MP0 (VDD p29_29 XI1942_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I63_MP1 (VDD b30_31 XI1942_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I63_MP5 (I1942_pn31 b30_31 XI1942_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I63_MP4 (XI1942_I63_p1 XI1942_I63_An I1942_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I63_MP2 (VDD p29_30 XI1942_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I63_MP3 (XI1942_I63_p1 XI1942_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I63_MP0 (VDD p29_30 XI1942_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I61_MP1 (VDD b30_29 XI1942_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I61_MP5 (I1942_pn29 b30_29 XI1942_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I61_MP4 (XI1942_I61_p1 XI1942_I61_An I1942_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I61_MP2 (VDD p29_28 XI1942_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I61_MP3 (XI1942_I61_p1 XI1942_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I61_MP0 (VDD p29_28 XI1942_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I232_MP1 (VDD I1896_G28_0 XI1896_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I232_MP5 (p29_29 I1896_G28_0 XI1896_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I232_MP4 (XI1896_I232_p1 XI1896_I232_An p29_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I232_MP2 (VDD I1896_pn29 XI1896_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I232_MP3 (XI1896_I232_p1 XI1896_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I232_MP0 (VDD I1896_pn29 XI1896_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I231_MP1 (VDD I1896_G27_0 XI1896_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I231_MP5 (p29_28 I1896_G27_0 XI1896_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I231_MP4 (XI1896_I231_p1 XI1896_I231_An p29_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I231_MP2 (VDD I1896_pn28 XI1896_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I231_MP3 (XI1896_I231_p1 XI1896_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I231_MP0 (VDD I1896_pn28 XI1896_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I59_MP1 (VDD b29_27 XI1896_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I59_MP5 (I1896_pn27 b29_27 XI1896_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I59_MP4 (XI1896_I59_p1 XI1896_I59_An I1896_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I59_MP2 (VDD p28_26 XI1896_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I59_MP3 (XI1896_I59_p1 XI1896_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I59_MP0 (VDD p28_26 XI1896_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I63_MP1 (VDD b3_31 XI700_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I63_MP5 (I700_pn31 b3_31 XI700_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I63_MP4 (XI700_I63_p1 XI700_I63_An I700_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I63_MP2 (VDD p2_30 XI700_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I63_MP3 (XI700_I63_p1 XI700_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I63_MP0 (VDD p2_30 XI700_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I233_MP1 (VDD I654_G29_0 XI654_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I233_MP5 (p2_30 I654_G29_0 XI654_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I233_MP4 (XI654_I233_p1 XI654_I233_An p2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I233_MP2 (VDD I654_pn30 XI654_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I233_MP3 (XI654_I233_p1 XI654_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I233_MP0 (VDD I654_pn30 XI654_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I232_MP1 (VDD I654_G28_0 XI654_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I232_MP5 (p2_29 I654_G28_0 XI654_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I232_MP4 (XI654_I232_p1 XI654_I232_An p2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I232_MP2 (VDD I654_pn29 XI654_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I232_MP3 (XI654_I232_p1 XI654_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I232_MP0 (VDD I654_pn29 XI654_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I60_MP1 (VDD b2_28 XI654_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I60_MP5 (I654_pn28 b2_28 XI654_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I60_MP4 (XI654_I60_p1 XI654_I60_An I654_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I60_MP2 (VDD p1_27 XI654_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I60_MP3 (XI654_I60_p1 XI654_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I60_MP0 (VDD p1_27 XI654_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I61_MP1 (VDD b2_29 XI654_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I61_MP5 (I654_pn29 b2_29 XI654_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I61_MP4 (XI654_I61_p1 XI654_I61_An I654_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I61_MP2 (VDD p1_28 XI654_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I61_MP3 (XI654_I61_p1 XI654_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I61_MP0 (VDD p1_28 XI654_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I62_MP1 (VDD b2_30 XI654_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I62_MP5 (I654_pn30 b2_30 XI654_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I62_MP4 (XI654_I62_p1 XI654_I62_An I654_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I62_MP2 (VDD p1_29 XI654_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I62_MP3 (XI654_I62_p1 XI654_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I62_MP0 (VDD p1_29 XI654_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I63_MP1 (VDD b2_31 XI654_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I63_MP5 (I654_pn31 b2_31 XI654_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I63_MP4 (XI654_I63_p1 XI654_I63_An I654_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I63_MP2 (VDD p1_30 XI654_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I63_MP3 (XI654_I63_p1 XI654_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I63_MP0 (VDD p1_30 XI654_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I231_MP1 (VDD I608_G27_0 XI608_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I231_MP5 (p1_28 I608_G27_0 XI608_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I231_MP4 (XI608_I231_p1 XI608_I231_An p1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I231_MP2 (VDD I608_pn28 XI608_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I231_MP3 (XI608_I231_p1 XI608_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I231_MP0 (VDD I608_pn28 XI608_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I233_MP1 (VDD I608_G29_0 XI608_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I233_MP5 (p1_30 I608_G29_0 XI608_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I233_MP4 (XI608_I233_p1 XI608_I233_An p1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I233_MP2 (VDD I608_pn30 XI608_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I233_MP3 (XI608_I233_p1 XI608_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I233_MP0 (VDD I608_pn30 XI608_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I234_MP1 (VDD c1_m XI608_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I234_MP5 (p1_31 c1_m XI608_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I234_MP4 (XI608_I234_p1 XI608_I234_An p1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I234_MP2 (VDD I608_pn31 XI608_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I234_MP3 (XI608_I234_p1 XI608_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I234_MP0 (VDD I608_pn31 XI608_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I230_MP1 (VDD I608_G26_0 XI608_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I230_MP5 (p1_27 I608_G26_0 XI608_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I230_MP4 (XI608_I230_p1 XI608_I230_An p1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I230_MP2 (VDD I608_pn27 XI608_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I230_MP3 (XI608_I230_p1 XI608_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I230_MP0 (VDD I608_pn27 XI608_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I60_MP1 (VDD b1_28 XI608_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I60_MP5 (I608_pn28 b1_28 XI608_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I60_MP4 (XI608_I60_p1 XI608_I60_An I608_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I60_MP2 (VDD p0_27 XI608_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I60_MP3 (XI608_I60_p1 XI608_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I60_MP0 (VDD p0_27 XI608_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I61_MP1 (VDD b1_29 XI608_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I61_MP5 (I608_pn29 b1_29 XI608_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I61_MP4 (XI608_I61_p1 XI608_I61_An I608_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I61_MP2 (VDD p0_28 XI608_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I61_MP3 (XI608_I61_p1 XI608_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I61_MP0 (VDD p0_28 XI608_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I61_MP1 (VDD b0_29 XI562_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I61_MP5 (I562_pn29 b0_29 XI562_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I61_MP4 (XI562_I61_p1 XI562_I61_An I562_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I61_MP2 (VDD VSS XI562_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I61_MP3 (XI562_I61_p1 XI562_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I61_MP0 (VDD VSS XI562_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I63_MP1 (VDD b0_31 XI562_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I63_MP5 (I562_pn31 b0_31 XI562_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I63_MP4 (XI562_I63_p1 XI562_I63_An I562_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I63_MP2 (VDD VSS XI562_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I63_MP3 (XI562_I63_p1 XI562_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I63_MP0 (VDD VSS XI562_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I234_MP1 (VDD c0_m XI562_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I234_MP5 (p0_31 c0_m XI562_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I234_MP4 (XI562_I234_p1 XI562_I234_An p0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I234_MP2 (VDD I562_pn31 XI562_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I234_MP3 (XI562_I234_p1 XI562_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I234_MP0 (VDD I562_pn31 XI562_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I233_MP1 (VDD I562_G29_0 XI562_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I233_MP5 (p0_30 I562_G29_0 XI562_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I233_MP4 (XI562_I233_p1 XI562_I233_An p0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I233_MP2 (VDD I562_pn30 XI562_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I233_MP3 (XI562_I233_p1 XI562_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I233_MP0 (VDD I562_pn30 XI562_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I231_MP1 (VDD I562_G27_0 XI562_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I231_MP5 (p0_28 I562_G27_0 XI562_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I231_MP4 (XI562_I231_p1 XI562_I231_An p0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I231_MP2 (VDD I562_pn28 XI562_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I231_MP3 (XI562_I231_p1 XI562_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I231_MP0 (VDD I562_pn28 XI562_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2228_MP1 (VDD nrkn20 XI2228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2228_MP5 (R_20 nrkn20 XI2228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2228_MP4 (XI2228_p1 XI2228_An R_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2228_MP2 (VDD ru20 XI2228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2228_MP3 (XI2228_p1 XI2228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2228_MP0 (VDD ru20 XI2228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2243_MP1 (VDD nrkn25 XI2243_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2243_MP5 (R_25 nrkn25 XI2243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2243_MP4 (XI2243_p1 XI2243_An R_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2243_MP2 (VDD ru25 XI2243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2243_MP3 (XI2243_p1 XI2243_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2243_MP0 (VDD ru25 XI2243_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2255_MP1 (VDD nrkn29 XI2255_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2255_MP5 (R_29 nrkn29 XI2255_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2255_MP4 (XI2255_p1 XI2255_An R_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2255_MP2 (VDD ru29 XI2255_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2255_MP3 (XI2255_p1 XI2255_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2255_MP0 (VDD ru29 XI2255_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I232_MP1 (VDD I2066_G28_0 XI2066_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I232_MP5 (ru29 I2066_G28_0 XI2066_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I232_MP4 (XI2066_I232_p1 XI2066_I232_An ru29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I232_MP2 (VDD I2066_pn29 XI2066_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I232_MP3 (XI2066_I232_p1 XI2066_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I232_MP0 (VDD I2066_pn29 XI2066_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I234_MP1 (VDD rcm XI2066_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I234_MP5 (ru31 rcm XI2066_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I234_MP4 (XI2066_I234_p1 XI2066_I234_An ru31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I234_MP2 (VDD I2066_pn31 XI2066_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I234_MP3 (XI2066_I234_p1 XI2066_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I234_MP0 (VDD I2066_pn31 XI2066_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I61_MP1 (VDD dm29 XI2066_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I61_MP5 (I2066_pn29 dm29 XI2066_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I61_MP4 (XI2066_I61_p1 XI2066_I61_An I2066_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I61_MP2 (VDD p31_29 XI2066_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I61_MP3 (XI2066_I61_p1 XI2066_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I61_MP0 (VDD p31_29 XI2066_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I62_MP1 (VDD dm30 XI2066_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I62_MP5 (I2066_pn30 dm30 XI2066_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I62_MP4 (XI2066_I62_p1 XI2066_I62_An I2066_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I62_MP2 (VDD p31_30 XI2066_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I62_MP3 (XI2066_I62_p1 XI2066_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I62_MP0 (VDD p31_30 XI2066_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I232_MP1 (VDD I1988_G28_0 XI1988_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I232_MP5 (p31_29 I1988_G28_0 XI1988_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I232_MP4 (XI1988_I232_p1 XI1988_I232_An p31_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I232_MP2 (VDD I1988_pn29 XI1988_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I232_MP3 (XI1988_I232_p1 XI1988_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I232_MP0 (VDD I1988_pn29 XI1988_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I233_MP1 (VDD I1988_G29_0 XI1988_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I233_MP5 (p31_30 I1988_G29_0 XI1988_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I233_MP4 (XI1988_I233_p1 XI1988_I233_An p31_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I233_MP2 (VDD I1988_pn30 XI1988_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I233_MP3 (XI1988_I233_p1 XI1988_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I233_MP0 (VDD I1988_pn30 XI1988_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I230_MP1 (VDD I1942_G26_0 XI1942_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I230_MP5 (p30_27 I1942_G26_0 XI1942_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I230_MP4 (XI1942_I230_p1 XI1942_I230_An p30_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I230_MP2 (VDD I1942_pn27 XI1942_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I230_MP3 (XI1942_I230_p1 XI1942_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I230_MP0 (VDD I1942_pn27 XI1942_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I234_MP1 (VDD c30_m XI1942_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I234_MP5 (p30_31 c30_m XI1942_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I234_MP4 (XI1942_I234_p1 XI1942_I234_An p30_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I234_MP2 (VDD I1942_pn31 XI1942_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I234_MP3 (XI1942_I234_p1 XI1942_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I234_MP0 (VDD I1942_pn31 XI1942_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I231_MP1 (VDD I1942_G27_0 XI1942_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I231_MP5 (p30_28 I1942_G27_0 XI1942_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I231_MP4 (XI1942_I231_p1 XI1942_I231_An p30_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I231_MP2 (VDD I1942_pn28 XI1942_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I231_MP3 (XI1942_I231_p1 XI1942_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I231_MP0 (VDD I1942_pn28 XI1942_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I60_MP1 (VDD b30_28 XI1942_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I60_MP5 (I1942_pn28 b30_28 XI1942_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I60_MP4 (XI1942_I60_p1 XI1942_I60_An I1942_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I60_MP2 (VDD p29_27 XI1942_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I60_MP3 (XI1942_I60_p1 XI1942_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I60_MP0 (VDD p29_27 XI1942_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I59_MP1 (VDD b30_27 XI1942_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I59_MP5 (I1942_pn27 b30_27 XI1942_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I59_MP4 (XI1942_I59_p1 XI1942_I59_An I1942_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I59_MP2 (VDD p29_26 XI1942_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I59_MP3 (XI1942_I59_p1 XI1942_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I59_MP0 (VDD p29_26 XI1942_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I230_MP1 (VDD I1896_G26_0 XI1896_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I230_MP5 (p29_27 I1896_G26_0 XI1896_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I230_MP4 (XI1896_I230_p1 XI1896_I230_An p29_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I230_MP2 (VDD I1896_pn27 XI1896_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I230_MP3 (XI1896_I230_p1 XI1896_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I230_MP0 (VDD I1896_pn27 XI1896_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I229_MP1 (VDD I1896_G25_0 XI1896_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I229_MP5 (p29_26 I1896_G25_0 XI1896_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I229_MP4 (XI1896_I229_p1 XI1896_I229_An p29_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I229_MP2 (VDD I1896_pn26 XI1896_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I229_MP3 (XI1896_I229_p1 XI1896_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I229_MP0 (VDD I1896_pn26 XI1896_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I234_MP1 (VDD c29_m XI1896_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I234_MP5 (p29_31 c29_m XI1896_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I234_MP4 (XI1896_I234_p1 XI1896_I234_An p29_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I234_MP2 (VDD I1896_pn31 XI1896_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I234_MP3 (XI1896_I234_p1 XI1896_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I234_MP0 (VDD I1896_pn31 XI1896_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I233_MP1 (VDD I1896_G29_0 XI1896_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I233_MP5 (p29_30 I1896_G29_0 XI1896_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I233_MP4 (XI1896_I233_p1 XI1896_I233_An p29_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I233_MP2 (VDD I1896_pn30 XI1896_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I233_MP3 (XI1896_I233_p1 XI1896_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I233_MP0 (VDD I1896_pn30 XI1896_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I58_MP1 (VDD b29_26 XI1896_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I58_MP5 (I1896_pn26 b29_26 XI1896_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I58_MP4 (XI1896_I58_p1 XI1896_I58_An I1896_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I58_MP2 (VDD p28_25 XI1896_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I58_MP3 (XI1896_I58_p1 XI1896_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I58_MP0 (VDD p28_25 XI1896_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I60_MP1 (VDD b29_28 XI1896_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I60_MP5 (I1896_pn28 b29_28 XI1896_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I60_MP4 (XI1896_I60_p1 XI1896_I60_An I1896_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I60_MP2 (VDD p28_27 XI1896_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I60_MP3 (XI1896_I60_p1 XI1896_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I60_MP0 (VDD p28_27 XI1896_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I61_MP1 (VDD b3_29 XI700_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I61_MP5 (I700_pn29 b3_29 XI700_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I61_MP4 (XI700_I61_p1 XI700_I61_An I700_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I61_MP2 (VDD p2_28 XI700_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I61_MP3 (XI700_I61_p1 XI700_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I61_MP0 (VDD p2_28 XI700_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I62_MP1 (VDD b3_30 XI700_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I62_MP5 (I700_pn30 b3_30 XI700_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I62_MP4 (XI700_I62_p1 XI700_I62_An I700_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I62_MP2 (VDD p2_29 XI700_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I62_MP3 (XI700_I62_p1 XI700_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I62_MP0 (VDD p2_29 XI700_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I231_MP1 (VDD I654_G27_0 XI654_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I231_MP5 (p2_28 I654_G27_0 XI654_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I231_MP4 (XI654_I231_p1 XI654_I231_An p2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I231_MP2 (VDD I654_pn28 XI654_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I231_MP3 (XI654_I231_p1 XI654_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I231_MP0 (VDD I654_pn28 XI654_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I59_MP1 (VDD b2_27 XI654_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I59_MP5 (I654_pn27 b2_27 XI654_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I59_MP4 (XI654_I59_p1 XI654_I59_An I654_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I59_MP2 (VDD p1_26 XI654_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I59_MP3 (XI654_I59_p1 XI654_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I59_MP0 (VDD p1_26 XI654_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I57_MP1 (VDD b2_25 XI654_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I57_MP5 (I654_pn25 b2_25 XI654_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I57_MP4 (XI654_I57_p1 XI654_I57_An I654_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I57_MP2 (VDD p1_24 XI654_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I57_MP3 (XI654_I57_p1 XI654_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I57_MP0 (VDD p1_24 XI654_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I58_MP1 (VDD b2_26 XI654_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I58_MP5 (I654_pn26 b2_26 XI654_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I58_MP4 (XI654_I58_p1 XI654_I58_An I654_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I58_MP2 (VDD p1_25 XI654_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I58_MP3 (XI654_I58_p1 XI654_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I58_MP0 (VDD p1_25 XI654_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I229_MP1 (VDD I608_G25_0 XI608_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I229_MP5 (p1_26 I608_G25_0 XI608_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I229_MP4 (XI608_I229_p1 XI608_I229_An p1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I229_MP2 (VDD I608_pn26 XI608_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I229_MP3 (XI608_I229_p1 XI608_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I229_MP0 (VDD I608_pn26 XI608_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I228_MP1 (VDD I608_G24_0 XI608_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I228_MP5 (p1_25 I608_G24_0 XI608_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I228_MP4 (XI608_I228_p1 XI608_I228_An p1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I228_MP2 (VDD I608_pn25 XI608_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I228_MP3 (XI608_I228_p1 XI608_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I228_MP0 (VDD I608_pn25 XI608_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I58_MP1 (VDD b1_26 XI608_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I58_MP5 (I608_pn26 b1_26 XI608_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I58_MP4 (XI608_I58_p1 XI608_I58_An I608_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I58_MP2 (VDD p0_25 XI608_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I58_MP3 (XI608_I58_p1 XI608_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I58_MP0 (VDD p0_25 XI608_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I59_MP1 (VDD b1_27 XI608_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I59_MP5 (I608_pn27 b1_27 XI608_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I59_MP4 (XI608_I59_p1 XI608_I59_An I608_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I59_MP2 (VDD p0_26 XI608_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I59_MP3 (XI608_I59_p1 XI608_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I59_MP0 (VDD p0_26 XI608_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I232_MP1 (VDD I562_G28_0 XI562_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I232_MP5 (p0_29 I562_G28_0 XI562_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I232_MP4 (XI562_I232_p1 XI562_I232_An p0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I232_MP2 (VDD I562_pn29 XI562_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I232_MP3 (XI562_I232_p1 XI562_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I232_MP0 (VDD I562_pn29 XI562_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I57_MP1 (VDD b0_25 XI562_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I57_MP5 (I562_pn25 b0_25 XI562_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I57_MP4 (XI562_I57_p1 XI562_I57_An I562_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I57_MP2 (VDD VSS XI562_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I57_MP3 (XI562_I57_p1 XI562_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I57_MP0 (VDD VSS XI562_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I230_MP1 (VDD I562_G26_0 XI562_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I230_MP5 (p0_27 I562_G26_0 XI562_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I230_MP4 (XI562_I230_p1 XI562_I230_An p0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I230_MP2 (VDD I562_pn27 XI562_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I230_MP3 (XI562_I230_p1 XI562_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I230_MP0 (VDD I562_pn27 XI562_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I59_MP1 (VDD b0_27 XI562_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I59_MP5 (I562_pn27 b0_27 XI562_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I59_MP4 (XI562_I59_p1 XI562_I59_An I562_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I59_MP2 (VDD VSS XI562_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I59_MP3 (XI562_I59_p1 XI562_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I59_MP0 (VDD VSS XI562_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I58_MP1 (VDD b0_26 XI562_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I58_MP5 (I562_pn26 b0_26 XI562_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I58_MP4 (XI562_I58_p1 XI562_I58_An I562_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I58_MP2 (VDD VSS XI562_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I58_MP3 (XI562_I58_p1 XI562_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I58_MP0 (VDD VSS XI562_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2225_MP1 (VDD nrkn19 XI2225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2225_MP5 (R_19 nrkn19 XI2225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2225_MP4 (XI2225_p1 XI2225_An R_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2225_MP2 (VDD ru19 XI2225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2225_MP3 (XI2225_p1 XI2225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2225_MP0 (VDD ru19 XI2225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2219_MP1 (VDD nrkn17 XI2219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2219_MP5 (R_17 nrkn17 XI2219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2219_MP4 (XI2219_p1 XI2219_An R_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2219_MP2 (VDD ru17 XI2219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2219_MP3 (XI2219_p1 XI2219_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2219_MP0 (VDD ru17 XI2219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I227_MP1 (VDD I2066_G23_0 XI2066_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I227_MP5 (ru24 I2066_G23_0 XI2066_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I227_MP4 (XI2066_I227_p1 XI2066_I227_An ru24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I227_MP2 (VDD I2066_pn24 XI2066_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I227_MP3 (XI2066_I227_p1 XI2066_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I227_MP0 (VDD I2066_pn24 XI2066_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2246_MP1 (VDD nrkn26 XI2246_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2246_MP5 (R_26 nrkn26 XI2246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2246_MP4 (XI2246_p1 XI2246_An R_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2246_MP2 (VDD ru26 XI2246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2246_MP3 (XI2246_p1 XI2246_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2246_MP0 (VDD ru26 XI2246_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I229_MP1 (VDD I2066_G25_0 XI2066_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I229_MP5 (ru26 I2066_G25_0 XI2066_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I229_MP4 (XI2066_I229_p1 XI2066_I229_An ru26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I229_MP2 (VDD I2066_pn26 XI2066_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I229_MP3 (XI2066_I229_p1 XI2066_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I229_MP0 (VDD I2066_pn26 XI2066_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I231_MP1 (VDD I2066_G27_0 XI2066_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I231_MP5 (ru28 I2066_G27_0 XI2066_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I231_MP4 (XI2066_I231_p1 XI2066_I231_An ru28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I231_MP2 (VDD I2066_pn28 XI2066_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I231_MP3 (XI2066_I231_p1 XI2066_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I231_MP0 (VDD I2066_pn28 XI2066_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I230_MP1 (VDD I2066_G26_0 XI2066_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I230_MP5 (ru27 I2066_G26_0 XI2066_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I230_MP4 (XI2066_I230_p1 XI2066_I230_An ru27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I230_MP2 (VDD I2066_pn27 XI2066_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I230_MP3 (XI2066_I230_p1 XI2066_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I230_MP0 (VDD I2066_pn27 XI2066_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I233_MP1 (VDD I2066_G29_0 XI2066_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I233_MP5 (ru30 I2066_G29_0 XI2066_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I233_MP4 (XI2066_I233_p1 XI2066_I233_An ru30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I233_MP2 (VDD I2066_pn30 XI2066_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I233_MP3 (XI2066_I233_p1 XI2066_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I233_MP0 (VDD I2066_pn30 XI2066_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I58_MP1 (VDD dm26 XI2066_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I58_MP5 (I2066_pn26 dm26 XI2066_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I58_MP4 (XI2066_I58_p1 XI2066_I58_An I2066_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I58_MP2 (VDD p31_26 XI2066_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I58_MP3 (XI2066_I58_p1 XI2066_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I58_MP0 (VDD p31_26 XI2066_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I59_MP1 (VDD dm27 XI2066_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I59_MP5 (I2066_pn27 dm27 XI2066_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I59_MP4 (XI2066_I59_p1 XI2066_I59_An I2066_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I59_MP2 (VDD p31_27 XI2066_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I59_MP3 (XI2066_I59_p1 XI2066_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I59_MP0 (VDD p31_27 XI2066_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I60_MP1 (VDD dm28 XI2066_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I60_MP5 (I2066_pn28 dm28 XI2066_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I60_MP4 (XI2066_I60_p1 XI2066_I60_An I2066_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I60_MP2 (VDD p31_28 XI2066_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I60_MP3 (XI2066_I60_p1 XI2066_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I60_MP0 (VDD p31_28 XI2066_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I230_MP1 (VDD I1988_G26_0 XI1988_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I230_MP5 (p31_27 I1988_G26_0 XI1988_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I230_MP4 (XI1988_I230_p1 XI1988_I230_An p31_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I230_MP2 (VDD I1988_pn27 XI1988_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I230_MP3 (XI1988_I230_p1 XI1988_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I230_MP0 (VDD I1988_pn27 XI1988_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I231_MP1 (VDD I1988_G27_0 XI1988_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I231_MP5 (p31_28 I1988_G27_0 XI1988_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I231_MP4 (XI1988_I231_p1 XI1988_I231_An p31_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I231_MP2 (VDD I1988_pn28 XI1988_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I231_MP3 (XI1988_I231_p1 XI1988_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I231_MP0 (VDD I1988_pn28 XI1988_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I60_MP1 (VDD b31_28 XI1988_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I60_MP5 (I1988_pn28 b31_28 XI1988_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I60_MP4 (XI1988_I60_p1 XI1988_I60_An I1988_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I60_MP2 (VDD p30_27 XI1988_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I60_MP3 (XI1988_I60_p1 XI1988_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I60_MP0 (VDD p30_27 XI1988_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I58_MP1 (VDD b31_26 XI1988_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I58_MP5 (I1988_pn26 b31_26 XI1988_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I58_MP4 (XI1988_I58_p1 XI1988_I58_An I1988_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I58_MP2 (VDD p30_25 XI1988_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I58_MP3 (XI1988_I58_p1 XI1988_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I58_MP0 (VDD p30_25 XI1988_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I59_MP1 (VDD b31_27 XI1988_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I59_MP5 (I1988_pn27 b31_27 XI1988_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I59_MP4 (XI1988_I59_p1 XI1988_I59_An I1988_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I59_MP2 (VDD p30_26 XI1988_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I59_MP3 (XI1988_I59_p1 XI1988_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I59_MP0 (VDD p30_26 XI1988_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I228_MP1 (VDD I1942_G24_0 XI1942_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I228_MP5 (p30_25 I1942_G24_0 XI1942_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I228_MP4 (XI1942_I228_p1 XI1942_I228_An p30_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I228_MP2 (VDD I1942_pn25 XI1942_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I228_MP3 (XI1942_I228_p1 XI1942_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I228_MP0 (VDD I1942_pn25 XI1942_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I229_MP1 (VDD I1942_G25_0 XI1942_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I229_MP5 (p30_26 I1942_G25_0 XI1942_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I229_MP4 (XI1942_I229_p1 XI1942_I229_An p30_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I229_MP2 (VDD I1942_pn26 XI1942_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I229_MP3 (XI1942_I229_p1 XI1942_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I229_MP0 (VDD I1942_pn26 XI1942_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I57_MP1 (VDD b30_25 XI1942_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I57_MP5 (I1942_pn25 b30_25 XI1942_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I57_MP4 (XI1942_I57_p1 XI1942_I57_An I1942_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I57_MP2 (VDD p29_24 XI1942_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I57_MP3 (XI1942_I57_p1 XI1942_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I57_MP0 (VDD p29_24 XI1942_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I58_MP1 (VDD b30_26 XI1942_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I58_MP5 (I1942_pn26 b30_26 XI1942_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I58_MP4 (XI1942_I58_p1 XI1942_I58_An I1942_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I58_MP2 (VDD p29_25 XI1942_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I58_MP3 (XI1942_I58_p1 XI1942_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I58_MP0 (VDD p29_25 XI1942_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I228_MP1 (VDD I1896_G24_0 XI1896_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I228_MP5 (p29_25 I1896_G24_0 XI1896_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I228_MP4 (XI1896_I228_p1 XI1896_I228_An p29_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I228_MP2 (VDD I1896_pn25 XI1896_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I228_MP3 (XI1896_I228_p1 XI1896_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I228_MP0 (VDD I1896_pn25 XI1896_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I57_MP1 (VDD b29_25 XI1896_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I57_MP5 (I1896_pn25 b29_25 XI1896_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I57_MP4 (XI1896_I57_p1 XI1896_I57_An I1896_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I57_MP2 (VDD p28_24 XI1896_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I57_MP3 (XI1896_I57_p1 XI1896_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I57_MP0 (VDD p28_24 XI1896_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I61_MP1 (VDD b29_29 XI1896_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I61_MP5 (I1896_pn29 b29_29 XI1896_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I61_MP4 (XI1896_I61_p1 XI1896_I61_An I1896_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I61_MP2 (VDD p28_28 XI1896_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I61_MP3 (XI1896_I61_p1 XI1896_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I61_MP0 (VDD p28_28 XI1896_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I60_MP1 (VDD b3_28 XI700_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I60_MP5 (I700_pn28 b3_28 XI700_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I60_MP4 (XI700_I60_p1 XI700_I60_An I700_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I60_MP2 (VDD p2_27 XI700_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I60_MP3 (XI700_I60_p1 XI700_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I60_MP0 (VDD p2_27 XI700_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I59_MP1 (VDD b3_27 XI700_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I59_MP5 (I700_pn27 b3_27 XI700_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I59_MP4 (XI700_I59_p1 XI700_I59_An I700_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I59_MP2 (VDD p2_26 XI700_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I59_MP3 (XI700_I59_p1 XI700_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I59_MP0 (VDD p2_26 XI700_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I229_MP1 (VDD I654_G25_0 XI654_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I229_MP5 (p2_26 I654_G25_0 XI654_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I229_MP4 (XI654_I229_p1 XI654_I229_An p2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I229_MP2 (VDD I654_pn26 XI654_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I229_MP3 (XI654_I229_p1 XI654_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I229_MP0 (VDD I654_pn26 XI654_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I234_MP1 (VDD c2_m XI654_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I234_MP5 (p2_31 c2_m XI654_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I234_MP4 (XI654_I234_p1 XI654_I234_An p2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I234_MP2 (VDD I654_pn31 XI654_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I234_MP3 (XI654_I234_p1 XI654_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I234_MP0 (VDD I654_pn31 XI654_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I230_MP1 (VDD I654_G26_0 XI654_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I230_MP5 (p2_27 I654_G26_0 XI654_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I230_MP4 (XI654_I230_p1 XI654_I230_An p2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I230_MP2 (VDD I654_pn27 XI654_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I230_MP3 (XI654_I230_p1 XI654_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I230_MP0 (VDD I654_pn27 XI654_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I56_MP1 (VDD b2_24 XI654_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I56_MP5 (I654_pn24 b2_24 XI654_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I56_MP4 (XI654_I56_p1 XI654_I56_An I654_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I56_MP2 (VDD p1_23 XI654_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I56_MP3 (XI654_I56_p1 XI654_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I56_MP0 (VDD p1_23 XI654_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I227_MP1 (VDD I608_G23_0 XI608_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I227_MP5 (p1_24 I608_G23_0 XI608_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I227_MP4 (XI608_I227_p1 XI608_I227_An p1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I227_MP2 (VDD I608_pn24 XI608_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I227_MP3 (XI608_I227_p1 XI608_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I227_MP0 (VDD I608_pn24 XI608_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I226_MP1 (VDD I608_G22_0 XI608_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I226_MP5 (p1_23 I608_G22_0 XI608_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I226_MP4 (XI608_I226_p1 XI608_I226_An p1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I226_MP2 (VDD I608_pn23 XI608_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I226_MP3 (XI608_I226_p1 XI608_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I226_MP0 (VDD I608_pn23 XI608_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I57_MP1 (VDD b1_25 XI608_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I57_MP5 (I608_pn25 b1_25 XI608_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I57_MP4 (XI608_I57_p1 XI608_I57_An I608_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I57_MP2 (VDD p0_24 XI608_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I57_MP3 (XI608_I57_p1 XI608_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I57_MP0 (VDD p0_24 XI608_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I56_MP1 (VDD b1_24 XI608_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I56_MP5 (I608_pn24 b1_24 XI608_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I56_MP4 (XI608_I56_p1 XI608_I56_An I608_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I56_MP2 (VDD p0_23 XI608_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I56_MP3 (XI608_I56_p1 XI608_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I56_MP0 (VDD p0_23 XI608_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I228_MP1 (VDD I562_G24_0 XI562_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I228_MP5 (p0_25 I562_G24_0 XI562_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I228_MP4 (XI562_I228_p1 XI562_I228_An p0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I228_MP2 (VDD I562_pn25 XI562_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I228_MP3 (XI562_I228_p1 XI562_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I228_MP0 (VDD I562_pn25 XI562_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I55_MP1 (VDD b0_23 XI562_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I55_MP5 (I562_pn23 b0_23 XI562_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I55_MP4 (XI562_I55_p1 XI562_I55_An I562_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I55_MP2 (VDD VSS XI562_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I55_MP3 (XI562_I55_p1 XI562_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I55_MP0 (VDD VSS XI562_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I226_MP1 (VDD I562_G22_0 XI562_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I226_MP5 (p0_23 I562_G22_0 XI562_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I226_MP4 (XI562_I226_p1 XI562_I226_An p0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I226_MP2 (VDD I562_pn23 XI562_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I226_MP3 (XI562_I226_p1 XI562_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I226_MP0 (VDD I562_pn23 XI562_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I56_MP1 (VDD b0_24 XI562_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I56_MP5 (I562_pn24 b0_24 XI562_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I56_MP4 (XI562_I56_p1 XI562_I56_An I562_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I56_MP2 (VDD VSS XI562_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I56_MP3 (XI562_I56_p1 XI562_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I56_MP0 (VDD VSS XI562_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I229_MP1 (VDD I562_G25_0 XI562_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I229_MP5 (p0_26 I562_G25_0 XI562_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I229_MP4 (XI562_I229_p1 XI562_I229_An p0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I229_MP2 (VDD I562_pn26 XI562_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I229_MP3 (XI562_I229_p1 XI562_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I229_MP0 (VDD I562_pn26 XI562_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2216_MP1 (VDD nrkn16 XI2216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2216_MP5 (R_16 nrkn16 XI2216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2216_MP4 (XI2216_p1 XI2216_An R_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2216_MP2 (VDD ru16 XI2216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2216_MP3 (XI2216_p1 XI2216_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2216_MP0 (VDD ru16 XI2216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I228_MP1 (VDD I2066_G24_0 XI2066_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I228_MP5 (ru25 I2066_G24_0 XI2066_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I228_MP4 (XI2066_I228_p1 XI2066_I228_An ru25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I228_MP2 (VDD I2066_pn25 XI2066_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I228_MP3 (XI2066_I228_p1 XI2066_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I228_MP0 (VDD I2066_pn25 XI2066_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I57_MP1 (VDD dm25 XI2066_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I57_MP5 (I2066_pn25 dm25 XI2066_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I57_MP4 (XI2066_I57_p1 XI2066_I57_An I2066_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I57_MP2 (VDD p31_25 XI2066_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I57_MP3 (XI2066_I57_p1 XI2066_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I57_MP0 (VDD p31_25 XI2066_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I56_MP1 (VDD dm24 XI2066_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I56_MP5 (I2066_pn24 dm24 XI2066_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I56_MP4 (XI2066_I56_p1 XI2066_I56_An I2066_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I56_MP2 (VDD p31_24 XI2066_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I56_MP3 (XI2066_I56_p1 XI2066_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I56_MP0 (VDD p31_24 XI2066_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I228_MP1 (VDD I1988_G24_0 XI1988_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I228_MP5 (p31_25 I1988_G24_0 XI1988_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I228_MP4 (XI1988_I228_p1 XI1988_I228_An p31_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I228_MP2 (VDD I1988_pn25 XI1988_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I228_MP3 (XI1988_I228_p1 XI1988_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I228_MP0 (VDD I1988_pn25 XI1988_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I229_MP1 (VDD I1988_G25_0 XI1988_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I229_MP5 (p31_26 I1988_G25_0 XI1988_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I229_MP4 (XI1988_I229_p1 XI1988_I229_An p31_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I229_MP2 (VDD I1988_pn26 XI1988_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I229_MP3 (XI1988_I229_p1 XI1988_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I229_MP0 (VDD I1988_pn26 XI1988_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I57_MP1 (VDD b31_25 XI1988_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I57_MP5 (I1988_pn25 b31_25 XI1988_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I57_MP4 (XI1988_I57_p1 XI1988_I57_An I1988_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I57_MP2 (VDD p30_24 XI1988_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I57_MP3 (XI1988_I57_p1 XI1988_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I57_MP0 (VDD p30_24 XI1988_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I56_MP1 (VDD b31_24 XI1988_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I56_MP5 (I1988_pn24 b31_24 XI1988_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I56_MP4 (XI1988_I56_p1 XI1988_I56_An I1988_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I56_MP2 (VDD p30_23 XI1988_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I56_MP3 (XI1988_I56_p1 XI1988_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I56_MP0 (VDD p30_23 XI1988_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I226_MP1 (VDD I1942_G22_0 XI1942_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I226_MP5 (p30_23 I1942_G22_0 XI1942_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I226_MP4 (XI1942_I226_p1 XI1942_I226_An p30_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I226_MP2 (VDD I1942_pn23 XI1942_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I226_MP3 (XI1942_I226_p1 XI1942_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I226_MP0 (VDD I1942_pn23 XI1942_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I227_MP1 (VDD I1942_G23_0 XI1942_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I227_MP5 (p30_24 I1942_G23_0 XI1942_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I227_MP4 (XI1942_I227_p1 XI1942_I227_An p30_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I227_MP2 (VDD I1942_pn24 XI1942_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I227_MP3 (XI1942_I227_p1 XI1942_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I227_MP0 (VDD I1942_pn24 XI1942_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I55_MP1 (VDD b30_23 XI1942_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I55_MP5 (I1942_pn23 b30_23 XI1942_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I55_MP4 (XI1942_I55_p1 XI1942_I55_An I1942_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I55_MP2 (VDD p29_22 XI1942_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I55_MP3 (XI1942_I55_p1 XI1942_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I55_MP0 (VDD p29_22 XI1942_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I56_MP1 (VDD b30_24 XI1942_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I56_MP5 (I1942_pn24 b30_24 XI1942_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I56_MP4 (XI1942_I56_p1 XI1942_I56_An I1942_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I56_MP2 (VDD p29_23 XI1942_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I56_MP3 (XI1942_I56_p1 XI1942_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I56_MP0 (VDD p29_23 XI1942_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I226_MP1 (VDD I1896_G22_0 XI1896_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I226_MP5 (p29_23 I1896_G22_0 XI1896_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I226_MP4 (XI1896_I226_p1 XI1896_I226_An p29_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I226_MP2 (VDD I1896_pn23 XI1896_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I226_MP3 (XI1896_I226_p1 XI1896_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I226_MP0 (VDD I1896_pn23 XI1896_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I227_MP1 (VDD I1896_G23_0 XI1896_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I227_MP5 (p29_24 I1896_G23_0 XI1896_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I227_MP4 (XI1896_I227_p1 XI1896_I227_An p29_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I227_MP2 (VDD I1896_pn24 XI1896_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I227_MP3 (XI1896_I227_p1 XI1896_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I227_MP0 (VDD I1896_pn24 XI1896_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I56_MP1 (VDD b29_24 XI1896_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I56_MP5 (I1896_pn24 b29_24 XI1896_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I56_MP4 (XI1896_I56_p1 XI1896_I56_An I1896_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I56_MP2 (VDD p28_23 XI1896_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I56_MP3 (XI1896_I56_p1 XI1896_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I56_MP0 (VDD p28_23 XI1896_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I58_MP1 (VDD b3_26 XI700_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I58_MP5 (I700_pn26 b3_26 XI700_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I58_MP4 (XI700_I58_p1 XI700_I58_An I700_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I58_MP2 (VDD p2_25 XI700_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I58_MP3 (XI700_I58_p1 XI700_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I58_MP0 (VDD p2_25 XI700_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I56_MP1 (VDD b3_24 XI700_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I56_MP5 (I700_pn24 b3_24 XI700_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I56_MP4 (XI700_I56_p1 XI700_I56_An I700_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I56_MP2 (VDD p2_23 XI700_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I56_MP3 (XI700_I56_p1 XI700_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I56_MP0 (VDD p2_23 XI700_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I57_MP1 (VDD b3_25 XI700_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I57_MP5 (I700_pn25 b3_25 XI700_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I57_MP4 (XI700_I57_p1 XI700_I57_An I700_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I57_MP2 (VDD p2_24 XI700_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I57_MP3 (XI700_I57_p1 XI700_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I57_MP0 (VDD p2_24 XI700_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I227_MP1 (VDD I654_G23_0 XI654_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I227_MP5 (p2_24 I654_G23_0 XI654_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I227_MP4 (XI654_I227_p1 XI654_I227_An p2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I227_MP2 (VDD I654_pn24 XI654_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I227_MP3 (XI654_I227_p1 XI654_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I227_MP0 (VDD I654_pn24 XI654_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I226_MP1 (VDD I654_G22_0 XI654_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I226_MP5 (p2_23 I654_G22_0 XI654_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I226_MP4 (XI654_I226_p1 XI654_I226_An p2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I226_MP2 (VDD I654_pn23 XI654_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I226_MP3 (XI654_I226_p1 XI654_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I226_MP0 (VDD I654_pn23 XI654_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I228_MP1 (VDD I654_G24_0 XI654_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I228_MP5 (p2_25 I654_G24_0 XI654_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I228_MP4 (XI654_I228_p1 XI654_I228_An p2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I228_MP2 (VDD I654_pn25 XI654_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I228_MP3 (XI654_I228_p1 XI654_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I228_MP0 (VDD I654_pn25 XI654_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I54_MP1 (VDD b2_22 XI654_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I54_MP5 (I654_pn22 b2_22 XI654_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I54_MP4 (XI654_I54_p1 XI654_I54_An I654_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I54_MP2 (VDD p1_21 XI654_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I54_MP3 (XI654_I54_p1 XI654_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I54_MP0 (VDD p1_21 XI654_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I55_MP1 (VDD b2_23 XI654_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I55_MP5 (I654_pn23 b2_23 XI654_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I55_MP4 (XI654_I55_p1 XI654_I55_An I654_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I55_MP2 (VDD p1_22 XI654_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I55_MP3 (XI654_I55_p1 XI654_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I55_MP0 (VDD p1_22 XI654_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I225_MP1 (VDD I608_G21_0 XI608_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I225_MP5 (p1_22 I608_G21_0 XI608_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I225_MP4 (XI608_I225_p1 XI608_I225_An p1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I225_MP2 (VDD I608_pn22 XI608_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I225_MP3 (XI608_I225_p1 XI608_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I225_MP0 (VDD I608_pn22 XI608_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I224_MP1 (VDD I608_G20_0 XI608_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I224_MP5 (p1_21 I608_G20_0 XI608_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I224_MP4 (XI608_I224_p1 XI608_I224_An p1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I224_MP2 (VDD I608_pn21 XI608_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I224_MP3 (XI608_I224_p1 XI608_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I224_MP0 (VDD I608_pn21 XI608_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I55_MP1 (VDD b1_23 XI608_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I55_MP5 (I608_pn23 b1_23 XI608_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I55_MP4 (XI608_I55_p1 XI608_I55_An I608_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I55_MP2 (VDD p0_22 XI608_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I55_MP3 (XI608_I55_p1 XI608_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I55_MP0 (VDD p0_22 XI608_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I54_MP1 (VDD b1_22 XI608_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I54_MP5 (I608_pn22 b1_22 XI608_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I54_MP4 (XI608_I54_p1 XI608_I54_An I608_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I54_MP2 (VDD p0_21 XI608_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I54_MP3 (XI608_I54_p1 XI608_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I54_MP0 (VDD p0_21 XI608_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I54_MP1 (VDD b0_22 XI562_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I54_MP5 (I562_pn22 b0_22 XI562_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I54_MP4 (XI562_I54_p1 XI562_I54_An I562_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I54_MP2 (VDD VSS XI562_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I54_MP3 (XI562_I54_p1 XI562_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I54_MP0 (VDD VSS XI562_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I225_MP1 (VDD I562_G21_0 XI562_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I225_MP5 (p0_22 I562_G21_0 XI562_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I225_MP4 (XI562_I225_p1 XI562_I225_An p0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I225_MP2 (VDD I562_pn22 XI562_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I225_MP3 (XI562_I225_p1 XI562_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I225_MP0 (VDD I562_pn22 XI562_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I227_MP1 (VDD I562_G23_0 XI562_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I227_MP5 (p0_24 I562_G23_0 XI562_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I227_MP4 (XI562_I227_p1 XI562_I227_An p0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I227_MP2 (VDD I562_pn24 XI562_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I227_MP3 (XI562_I227_p1 XI562_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I227_MP0 (VDD I562_pn24 XI562_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2210_MP1 (VDD nrkn14 XI2210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2210_MP5 (R_14 nrkn14 XI2210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2210_MP4 (XI2210_p1 XI2210_An R_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2210_MP2 (VDD ru14 XI2210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2210_MP3 (XI2210_p1 XI2210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2210_MP0 (VDD ru14 XI2210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2213_MP1 (VDD nrkn15 XI2213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2213_MP5 (R_15 nrkn15 XI2213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2213_MP4 (XI2213_p1 XI2213_An R_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2213_MP2 (VDD ru15 XI2213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2213_MP3 (XI2213_p1 XI2213_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2213_MP0 (VDD ru15 XI2213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2222_MP1 (VDD nrkn18 XI2222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2222_MP5 (R_18 nrkn18 XI2222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2222_MP4 (XI2222_p1 XI2222_An R_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2222_MP2 (VDD ru18 XI2222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2222_MP3 (XI2222_p1 XI2222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2222_MP0 (VDD ru18 XI2222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I226_MP1 (VDD I2066_G22_0 XI2066_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I226_MP5 (ru23 I2066_G22_0 XI2066_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I226_MP4 (XI2066_I226_p1 XI2066_I226_An ru23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I226_MP2 (VDD I2066_pn23 XI2066_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I226_MP3 (XI2066_I226_p1 XI2066_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I226_MP0 (VDD I2066_pn23 XI2066_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I55_MP1 (VDD dm23 XI2066_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I55_MP5 (I2066_pn23 dm23 XI2066_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I55_MP4 (XI2066_I55_p1 XI2066_I55_An I2066_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I55_MP2 (VDD p31_23 XI2066_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I55_MP3 (XI2066_I55_p1 XI2066_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I55_MP0 (VDD p31_23 XI2066_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I226_MP1 (VDD I1988_G22_0 XI1988_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I226_MP5 (p31_23 I1988_G22_0 XI1988_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I226_MP4 (XI1988_I226_p1 XI1988_I226_An p31_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I226_MP2 (VDD I1988_pn23 XI1988_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I226_MP3 (XI1988_I226_p1 XI1988_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I226_MP0 (VDD I1988_pn23 XI1988_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I227_MP1 (VDD I1988_G23_0 XI1988_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I227_MP5 (p31_24 I1988_G23_0 XI1988_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I227_MP4 (XI1988_I227_p1 XI1988_I227_An p31_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I227_MP2 (VDD I1988_pn24 XI1988_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I227_MP3 (XI1988_I227_p1 XI1988_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I227_MP0 (VDD I1988_pn24 XI1988_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I55_MP1 (VDD b31_23 XI1988_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I55_MP5 (I1988_pn23 b31_23 XI1988_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I55_MP4 (XI1988_I55_p1 XI1988_I55_An I1988_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I55_MP2 (VDD p30_22 XI1988_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I55_MP3 (XI1988_I55_p1 XI1988_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I55_MP0 (VDD p30_22 XI1988_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I54_MP1 (VDD b31_22 XI1988_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I54_MP5 (I1988_pn22 b31_22 XI1988_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I54_MP4 (XI1988_I54_p1 XI1988_I54_An I1988_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I54_MP2 (VDD p30_21 XI1988_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I54_MP3 (XI1988_I54_p1 XI1988_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I54_MP0 (VDD p30_21 XI1988_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I225_MP1 (VDD I1942_G21_0 XI1942_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I225_MP5 (p30_22 I1942_G21_0 XI1942_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I225_MP4 (XI1942_I225_p1 XI1942_I225_An p30_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I225_MP2 (VDD I1942_pn22 XI1942_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I225_MP3 (XI1942_I225_p1 XI1942_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I225_MP0 (VDD I1942_pn22 XI1942_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I54_MP1 (VDD b30_22 XI1942_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I54_MP5 (I1942_pn22 b30_22 XI1942_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I54_MP4 (XI1942_I54_p1 XI1942_I54_An I1942_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I54_MP2 (VDD p29_21 XI1942_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I54_MP3 (XI1942_I54_p1 XI1942_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I54_MP0 (VDD p29_21 XI1942_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I224_MP1 (VDD I1896_G20_0 XI1896_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I224_MP5 (p29_21 I1896_G20_0 XI1896_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I224_MP4 (XI1896_I224_p1 XI1896_I224_An p29_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I224_MP2 (VDD I1896_pn21 XI1896_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I224_MP3 (XI1896_I224_p1 XI1896_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I224_MP0 (VDD I1896_pn21 XI1896_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I225_MP1 (VDD I1896_G21_0 XI1896_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I225_MP5 (p29_22 I1896_G21_0 XI1896_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I225_MP4 (XI1896_I225_p1 XI1896_I225_An p29_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I225_MP2 (VDD I1896_pn22 XI1896_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I225_MP3 (XI1896_I225_p1 XI1896_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I225_MP0 (VDD I1896_pn22 XI1896_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I55_MP1 (VDD b29_23 XI1896_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I55_MP5 (I1896_pn23 b29_23 XI1896_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I55_MP4 (XI1896_I55_p1 XI1896_I55_An I1896_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I55_MP2 (VDD p28_22 XI1896_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I55_MP3 (XI1896_I55_p1 XI1896_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I55_MP0 (VDD p28_22 XI1896_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I62_MP1 (VDD b29_30 XI1896_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I62_MP5 (I1896_pn30 b29_30 XI1896_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I62_MP4 (XI1896_I62_p1 XI1896_I62_An I1896_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I62_MP2 (VDD p28_29 XI1896_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I62_MP3 (XI1896_I62_p1 XI1896_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I62_MP0 (VDD p28_29 XI1896_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I53_MP1 (VDD b3_21 XI700_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I53_MP5 (I700_pn21 b3_21 XI700_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I53_MP4 (XI700_I53_p1 XI700_I53_An I700_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I53_MP2 (VDD p2_20 XI700_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I53_MP3 (XI700_I53_p1 XI700_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I53_MP0 (VDD p2_20 XI700_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I55_MP1 (VDD b3_23 XI700_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I55_MP5 (I700_pn23 b3_23 XI700_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I55_MP4 (XI700_I55_p1 XI700_I55_An I700_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I55_MP2 (VDD p2_22 XI700_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I55_MP3 (XI700_I55_p1 XI700_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I55_MP0 (VDD p2_22 XI700_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I223_MP1 (VDD I654_G19_0 XI654_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I223_MP5 (p2_20 I654_G19_0 XI654_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I223_MP4 (XI654_I223_p1 XI654_I223_An p2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I223_MP2 (VDD I654_pn20 XI654_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I223_MP3 (XI654_I223_p1 XI654_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I223_MP0 (VDD I654_pn20 XI654_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I225_MP1 (VDD I654_G21_0 XI654_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I225_MP5 (p2_22 I654_G21_0 XI654_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I225_MP4 (XI654_I225_p1 XI654_I225_An p2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I225_MP2 (VDD I654_pn22 XI654_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I225_MP3 (XI654_I225_p1 XI654_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I225_MP0 (VDD I654_pn22 XI654_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I224_MP1 (VDD I654_G20_0 XI654_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I224_MP5 (p2_21 I654_G20_0 XI654_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I224_MP4 (XI654_I224_p1 XI654_I224_An p2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I224_MP2 (VDD I654_pn21 XI654_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I224_MP3 (XI654_I224_p1 XI654_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I224_MP0 (VDD I654_pn21 XI654_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I53_MP1 (VDD b2_21 XI654_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I53_MP5 (I654_pn21 b2_21 XI654_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I53_MP4 (XI654_I53_p1 XI654_I53_An I654_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I53_MP2 (VDD p1_20 XI654_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I53_MP3 (XI654_I53_p1 XI654_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I53_MP0 (VDD p1_20 XI654_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I52_MP1 (VDD b2_20 XI654_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I52_MP5 (I654_pn20 b2_20 XI654_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I52_MP4 (XI654_I52_p1 XI654_I52_An I654_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I52_MP2 (VDD p1_19 XI654_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I52_MP3 (XI654_I52_p1 XI654_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I52_MP0 (VDD p1_19 XI654_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I223_MP1 (VDD I608_G19_0 XI608_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I223_MP5 (p1_20 I608_G19_0 XI608_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I223_MP4 (XI608_I223_p1 XI608_I223_An p1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I223_MP2 (VDD I608_pn20 XI608_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I223_MP3 (XI608_I223_p1 XI608_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I223_MP0 (VDD I608_pn20 XI608_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I53_MP1 (VDD b1_21 XI608_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I53_MP5 (I608_pn21 b1_21 XI608_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I53_MP4 (XI608_I53_p1 XI608_I53_An I608_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I53_MP2 (VDD p0_20 XI608_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I53_MP3 (XI608_I53_p1 XI608_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I53_MP0 (VDD p0_20 XI608_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I53_MP1 (VDD b0_21 XI562_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I53_MP5 (I562_pn21 b0_21 XI562_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I53_MP4 (XI562_I53_p1 XI562_I53_An I562_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I53_MP2 (VDD VSS XI562_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I53_MP3 (XI562_I53_p1 XI562_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I53_MP0 (VDD VSS XI562_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I224_MP1 (VDD I562_G20_0 XI562_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I224_MP5 (p0_21 I562_G20_0 XI562_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I224_MP4 (XI562_I224_p1 XI562_I224_An p0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I224_MP2 (VDD I562_pn21 XI562_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I224_MP3 (XI562_I224_p1 XI562_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I224_MP0 (VDD I562_pn21 XI562_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2207_MP1 (VDD nrkn13 XI2207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2207_MP5 (R_13 nrkn13 XI2207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2207_MP4 (XI2207_p1 XI2207_An R_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2207_MP2 (VDD ru13 XI2207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2207_MP3 (XI2207_p1 XI2207_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2207_MP0 (VDD ru13 XI2207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I225_MP1 (VDD I2066_G21_0 XI2066_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I225_MP5 (ru22 I2066_G21_0 XI2066_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I225_MP4 (XI2066_I225_p1 XI2066_I225_An ru22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I225_MP2 (VDD I2066_pn22 XI2066_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I225_MP3 (XI2066_I225_p1 XI2066_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I225_MP0 (VDD I2066_pn22 XI2066_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I224_MP1 (VDD I2066_G20_0 XI2066_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I224_MP5 (ru21 I2066_G20_0 XI2066_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I224_MP4 (XI2066_I224_p1 XI2066_I224_An ru21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I224_MP2 (VDD I2066_pn21 XI2066_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I224_MP3 (XI2066_I224_p1 XI2066_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I224_MP0 (VDD I2066_pn21 XI2066_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I54_MP1 (VDD dm22 XI2066_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I54_MP5 (I2066_pn22 dm22 XI2066_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I54_MP4 (XI2066_I54_p1 XI2066_I54_An I2066_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I54_MP2 (VDD p31_22 XI2066_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I54_MP3 (XI2066_I54_p1 XI2066_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I54_MP0 (VDD p31_22 XI2066_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I53_MP1 (VDD dm21 XI2066_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I53_MP5 (I2066_pn21 dm21 XI2066_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I53_MP4 (XI2066_I53_p1 XI2066_I53_An I2066_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I53_MP2 (VDD p31_21 XI2066_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I53_MP3 (XI2066_I53_p1 XI2066_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I53_MP0 (VDD p31_21 XI2066_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I224_MP1 (VDD I1988_G20_0 XI1988_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I224_MP5 (p31_21 I1988_G20_0 XI1988_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I224_MP4 (XI1988_I224_p1 XI1988_I224_An p31_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I224_MP2 (VDD I1988_pn21 XI1988_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I224_MP3 (XI1988_I224_p1 XI1988_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I224_MP0 (VDD I1988_pn21 XI1988_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I225_MP1 (VDD I1988_G21_0 XI1988_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I225_MP5 (p31_22 I1988_G21_0 XI1988_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I225_MP4 (XI1988_I225_p1 XI1988_I225_An p31_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I225_MP2 (VDD I1988_pn22 XI1988_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I225_MP3 (XI1988_I225_p1 XI1988_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I225_MP0 (VDD I1988_pn22 XI1988_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I53_MP1 (VDD b31_21 XI1988_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I53_MP5 (I1988_pn21 b31_21 XI1988_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I53_MP4 (XI1988_I53_p1 XI1988_I53_An I1988_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I53_MP2 (VDD p30_20 XI1988_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I53_MP3 (XI1988_I53_p1 XI1988_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I53_MP0 (VDD p30_20 XI1988_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I52_MP1 (VDD b31_20 XI1988_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I52_MP5 (I1988_pn20 b31_20 XI1988_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I52_MP4 (XI1988_I52_p1 XI1988_I52_An I1988_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I52_MP2 (VDD p30_19 XI1988_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I52_MP3 (XI1988_I52_p1 XI1988_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I52_MP0 (VDD p30_19 XI1988_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I222_MP1 (VDD I1942_G18_0 XI1942_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I222_MP5 (p30_19 I1942_G18_0 XI1942_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I222_MP4 (XI1942_I222_p1 XI1942_I222_An p30_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I222_MP2 (VDD I1942_pn19 XI1942_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I222_MP3 (XI1942_I222_p1 XI1942_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I222_MP0 (VDD I1942_pn19 XI1942_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I224_MP1 (VDD I1942_G20_0 XI1942_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I224_MP5 (p30_21 I1942_G20_0 XI1942_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I224_MP4 (XI1942_I224_p1 XI1942_I224_An p30_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I224_MP2 (VDD I1942_pn21 XI1942_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I224_MP3 (XI1942_I224_p1 XI1942_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I224_MP0 (VDD I1942_pn21 XI1942_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I223_MP1 (VDD I1942_G19_0 XI1942_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I223_MP5 (p30_20 I1942_G19_0 XI1942_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I223_MP4 (XI1942_I223_p1 XI1942_I223_An p30_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I223_MP2 (VDD I1942_pn20 XI1942_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I223_MP3 (XI1942_I223_p1 XI1942_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I223_MP0 (VDD I1942_pn20 XI1942_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I52_MP1 (VDD b30_20 XI1942_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I52_MP5 (I1942_pn20 b30_20 XI1942_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I52_MP4 (XI1942_I52_p1 XI1942_I52_An I1942_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I52_MP2 (VDD p29_19 XI1942_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I52_MP3 (XI1942_I52_p1 XI1942_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I52_MP0 (VDD p29_19 XI1942_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I53_MP1 (VDD b30_21 XI1942_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I53_MP5 (I1942_pn21 b30_21 XI1942_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I53_MP4 (XI1942_I53_p1 XI1942_I53_An I1942_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I53_MP2 (VDD p29_20 XI1942_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I53_MP3 (XI1942_I53_p1 XI1942_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I53_MP0 (VDD p29_20 XI1942_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I222_MP1 (VDD I1896_G18_0 XI1896_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I222_MP5 (p29_19 I1896_G18_0 XI1896_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I222_MP4 (XI1896_I222_p1 XI1896_I222_An p29_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I222_MP2 (VDD I1896_pn19 XI1896_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I222_MP3 (XI1896_I222_p1 XI1896_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I222_MP0 (VDD I1896_pn19 XI1896_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I53_MP1 (VDD b29_21 XI1896_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I53_MP5 (I1896_pn21 b29_21 XI1896_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I53_MP4 (XI1896_I53_p1 XI1896_I53_An I1896_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I53_MP2 (VDD p28_20 XI1896_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I53_MP3 (XI1896_I53_p1 XI1896_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I53_MP0 (VDD p28_20 XI1896_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I54_MP1 (VDD b29_22 XI1896_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I54_MP5 (I1896_pn22 b29_22 XI1896_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I54_MP4 (XI1896_I54_p1 XI1896_I54_An I1896_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I54_MP2 (VDD p28_21 XI1896_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I54_MP3 (XI1896_I54_p1 XI1896_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I54_MP0 (VDD p28_21 XI1896_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I63_MP1 (VDD b29_31 XI1896_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I63_MP5 (I1896_pn31 b29_31 XI1896_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I63_MP4 (XI1896_I63_p1 XI1896_I63_An I1896_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I63_MP2 (VDD p28_30 XI1896_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I63_MP3 (XI1896_I63_p1 XI1896_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I63_MP0 (VDD p28_30 XI1896_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I54_MP1 (VDD b3_22 XI700_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I54_MP5 (I700_pn22 b3_22 XI700_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I54_MP4 (XI700_I54_p1 XI700_I54_An I700_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I54_MP2 (VDD p2_21 XI700_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I54_MP3 (XI700_I54_p1 XI700_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I54_MP0 (VDD p2_21 XI700_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I50_MP1 (VDD b2_18 XI654_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I50_MP5 (I654_pn18 b2_18 XI654_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I50_MP4 (XI654_I50_p1 XI654_I50_An I654_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I50_MP2 (VDD p1_17 XI654_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I50_MP3 (XI654_I50_p1 XI654_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I50_MP0 (VDD p1_17 XI654_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I222_MP1 (VDD I608_G18_0 XI608_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I222_MP5 (p1_19 I608_G18_0 XI608_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I222_MP4 (XI608_I222_p1 XI608_I222_An p1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I222_MP2 (VDD I608_pn19 XI608_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I222_MP3 (XI608_I222_p1 XI608_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I222_MP0 (VDD I608_pn19 XI608_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I52_MP1 (VDD b1_20 XI608_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I52_MP5 (I608_pn20 b1_20 XI608_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I52_MP4 (XI608_I52_p1 XI608_I52_An I608_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I52_MP2 (VDD p0_19 XI608_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I52_MP3 (XI608_I52_p1 XI608_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I52_MP0 (VDD p0_19 XI608_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I51_MP1 (VDD b0_19 XI562_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I51_MP5 (I562_pn19 b0_19 XI562_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I51_MP4 (XI562_I51_p1 XI562_I51_An I562_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I51_MP2 (VDD VSS XI562_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I51_MP3 (XI562_I51_p1 XI562_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I51_MP0 (VDD VSS XI562_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I52_MP1 (VDD b0_20 XI562_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I52_MP5 (I562_pn20 b0_20 XI562_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I52_MP4 (XI562_I52_p1 XI562_I52_An I562_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I52_MP2 (VDD VSS XI562_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I52_MP3 (XI562_I52_p1 XI562_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I52_MP0 (VDD VSS XI562_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I223_MP1 (VDD I562_G19_0 XI562_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I223_MP5 (p0_20 I562_G19_0 XI562_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I223_MP4 (XI562_I223_p1 XI562_I223_An p0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I223_MP2 (VDD I562_pn20 XI562_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I223_MP3 (XI562_I223_p1 XI562_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I223_MP0 (VDD I562_pn20 XI562_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I223_MP1 (VDD I2066_G19_0 XI2066_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I223_MP5 (ru20 I2066_G19_0 XI2066_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I223_MP4 (XI2066_I223_p1 XI2066_I223_An ru20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I223_MP2 (VDD I2066_pn20 XI2066_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I223_MP3 (XI2066_I223_p1 XI2066_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I223_MP0 (VDD I2066_pn20 XI2066_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I221_MP1 (VDD I2066_G17_0 XI2066_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I221_MP5 (ru18 I2066_G17_0 XI2066_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I221_MP4 (XI2066_I221_p1 XI2066_I221_An ru18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I221_MP2 (VDD I2066_pn18 XI2066_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I221_MP3 (XI2066_I221_p1 XI2066_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I221_MP0 (VDD I2066_pn18 XI2066_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I222_MP1 (VDD I2066_G18_0 XI2066_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I222_MP5 (ru19 I2066_G18_0 XI2066_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I222_MP4 (XI2066_I222_p1 XI2066_I222_An ru19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I222_MP2 (VDD I2066_pn19 XI2066_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I222_MP3 (XI2066_I222_p1 XI2066_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I222_MP0 (VDD I2066_pn19 XI2066_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I51_MP1 (VDD dm19 XI2066_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I51_MP5 (I2066_pn19 dm19 XI2066_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I51_MP4 (XI2066_I51_p1 XI2066_I51_An I2066_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I51_MP2 (VDD p31_19 XI2066_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I51_MP3 (XI2066_I51_p1 XI2066_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I51_MP0 (VDD p31_19 XI2066_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I52_MP1 (VDD dm20 XI2066_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I52_MP5 (I2066_pn20 dm20 XI2066_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I52_MP4 (XI2066_I52_p1 XI2066_I52_An I2066_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I52_MP2 (VDD p31_20 XI2066_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I52_MP3 (XI2066_I52_p1 XI2066_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I52_MP0 (VDD p31_20 XI2066_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I223_MP1 (VDD I1988_G19_0 XI1988_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I223_MP5 (p31_20 I1988_G19_0 XI1988_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I223_MP4 (XI1988_I223_p1 XI1988_I223_An p31_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I223_MP2 (VDD I1988_pn20 XI1988_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I223_MP3 (XI1988_I223_p1 XI1988_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I223_MP0 (VDD I1988_pn20 XI1988_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I51_MP1 (VDD b31_19 XI1988_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I51_MP5 (I1988_pn19 b31_19 XI1988_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I51_MP4 (XI1988_I51_p1 XI1988_I51_An I1988_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I51_MP2 (VDD p30_18 XI1988_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I51_MP3 (XI1988_I51_p1 XI1988_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I51_MP0 (VDD p30_18 XI1988_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I221_MP1 (VDD I1942_G17_0 XI1942_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I221_MP5 (p30_18 I1942_G17_0 XI1942_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I221_MP4 (XI1942_I221_p1 XI1942_I221_An p30_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I221_MP2 (VDD I1942_pn18 XI1942_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I221_MP3 (XI1942_I221_p1 XI1942_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I221_MP0 (VDD I1942_pn18 XI1942_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I50_MP1 (VDD b30_18 XI1942_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I50_MP5 (I1942_pn18 b30_18 XI1942_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I50_MP4 (XI1942_I50_p1 XI1942_I50_An I1942_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I50_MP2 (VDD p29_17 XI1942_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I50_MP3 (XI1942_I50_p1 XI1942_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I50_MP0 (VDD p29_17 XI1942_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I51_MP1 (VDD b30_19 XI1942_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I51_MP5 (I1942_pn19 b30_19 XI1942_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I51_MP4 (XI1942_I51_p1 XI1942_I51_An I1942_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I51_MP2 (VDD p29_18 XI1942_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I51_MP3 (XI1942_I51_p1 XI1942_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I51_MP0 (VDD p29_18 XI1942_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I221_MP1 (VDD I1896_G17_0 XI1896_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I221_MP5 (p29_18 I1896_G17_0 XI1896_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I221_MP4 (XI1896_I221_p1 XI1896_I221_An p29_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I221_MP2 (VDD I1896_pn18 XI1896_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I221_MP3 (XI1896_I221_p1 XI1896_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I221_MP0 (VDD I1896_pn18 XI1896_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I50_MP1 (VDD b29_18 XI1896_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I50_MP5 (I1896_pn18 b29_18 XI1896_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I50_MP4 (XI1896_I50_p1 XI1896_I50_An I1896_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I50_MP2 (VDD p28_17 XI1896_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I50_MP3 (XI1896_I50_p1 XI1896_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I50_MP0 (VDD p28_17 XI1896_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I51_MP1 (VDD b29_19 XI1896_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I51_MP5 (I1896_pn19 b29_19 XI1896_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I51_MP4 (XI1896_I51_p1 XI1896_I51_An I1896_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I51_MP2 (VDD p28_18 XI1896_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I51_MP3 (XI1896_I51_p1 XI1896_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I51_MP0 (VDD p28_18 XI1896_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I52_MP1 (VDD b29_20 XI1896_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I52_MP5 (I1896_pn20 b29_20 XI1896_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I52_MP4 (XI1896_I52_p1 XI1896_I52_An I1896_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I52_MP2 (VDD p28_19 XI1896_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I52_MP3 (XI1896_I52_p1 XI1896_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I52_MP0 (VDD p28_19 XI1896_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I52_MP1 (VDD b3_20 XI700_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I52_MP5 (I700_pn20 b3_20 XI700_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I52_MP4 (XI700_I52_p1 XI700_I52_An I700_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I52_MP2 (VDD p2_19 XI700_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I52_MP3 (XI700_I52_p1 XI700_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I52_MP0 (VDD p2_19 XI700_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I51_MP1 (VDD b3_19 XI700_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I51_MP5 (I700_pn19 b3_19 XI700_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I51_MP4 (XI700_I51_p1 XI700_I51_An I700_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I51_MP2 (VDD p2_18 XI700_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I51_MP3 (XI700_I51_p1 XI700_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I51_MP0 (VDD p2_18 XI700_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I221_MP1 (VDD I654_G17_0 XI654_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I221_MP5 (p2_18 I654_G17_0 XI654_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I221_MP4 (XI654_I221_p1 XI654_I221_An p2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I221_MP2 (VDD I654_pn18 XI654_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I221_MP3 (XI654_I221_p1 XI654_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I221_MP0 (VDD I654_pn18 XI654_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I222_MP1 (VDD I654_G18_0 XI654_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I222_MP5 (p2_19 I654_G18_0 XI654_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I222_MP4 (XI654_I222_p1 XI654_I222_An p2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I222_MP2 (VDD I654_pn19 XI654_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I222_MP3 (XI654_I222_p1 XI654_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I222_MP0 (VDD I654_pn19 XI654_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I220_MP1 (VDD I654_G16_0 XI654_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I220_MP5 (p2_17 I654_G16_0 XI654_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I220_MP4 (XI654_I220_p1 XI654_I220_An p2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I220_MP2 (VDD I654_pn17 XI654_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I220_MP3 (XI654_I220_p1 XI654_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I220_MP0 (VDD I654_pn17 XI654_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I49_MP1 (VDD b2_17 XI654_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I49_MP5 (I654_pn17 b2_17 XI654_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I49_MP4 (XI654_I49_p1 XI654_I49_An I654_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I49_MP2 (VDD p1_16 XI654_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I49_MP3 (XI654_I49_p1 XI654_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I49_MP0 (VDD p1_16 XI654_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I48_MP1 (VDD b2_16 XI654_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I48_MP5 (I654_pn16 b2_16 XI654_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I48_MP4 (XI654_I48_p1 XI654_I48_An I654_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I48_MP2 (VDD p1_15 XI654_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I48_MP3 (XI654_I48_p1 XI654_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I48_MP0 (VDD p1_15 XI654_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I51_MP1 (VDD b2_19 XI654_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I51_MP5 (I654_pn19 b2_19 XI654_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I51_MP4 (XI654_I51_p1 XI654_I51_An I654_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I51_MP2 (VDD p1_18 XI654_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I51_MP3 (XI654_I51_p1 XI654_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I51_MP0 (VDD p1_18 XI654_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I221_MP1 (VDD I608_G17_0 XI608_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I221_MP5 (p1_18 I608_G17_0 XI608_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I221_MP4 (XI608_I221_p1 XI608_I221_An p1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I221_MP2 (VDD I608_pn18 XI608_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I221_MP3 (XI608_I221_p1 XI608_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I221_MP0 (VDD I608_pn18 XI608_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I220_MP1 (VDD I608_G16_0 XI608_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I220_MP5 (p1_17 I608_G16_0 XI608_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I220_MP4 (XI608_I220_p1 XI608_I220_An p1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I220_MP2 (VDD I608_pn17 XI608_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I220_MP3 (XI608_I220_p1 XI608_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I220_MP0 (VDD I608_pn17 XI608_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I49_MP1 (VDD b1_17 XI608_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I49_MP5 (I608_pn17 b1_17 XI608_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I49_MP4 (XI608_I49_p1 XI608_I49_An I608_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I49_MP2 (VDD p0_16 XI608_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I49_MP3 (XI608_I49_p1 XI608_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I49_MP0 (VDD p0_16 XI608_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I51_MP1 (VDD b1_19 XI608_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I51_MP5 (I608_pn19 b1_19 XI608_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I51_MP4 (XI608_I51_p1 XI608_I51_An I608_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I51_MP2 (VDD p0_18 XI608_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I51_MP3 (XI608_I51_p1 XI608_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I51_MP0 (VDD p0_18 XI608_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I50_MP1 (VDD b1_18 XI608_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I50_MP5 (I608_pn18 b1_18 XI608_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I50_MP4 (XI608_I50_p1 XI608_I50_An I608_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I50_MP2 (VDD p0_17 XI608_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I50_MP3 (XI608_I50_p1 XI608_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I50_MP0 (VDD p0_17 XI608_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I220_MP1 (VDD I562_G16_0 XI562_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I220_MP5 (p0_17 I562_G16_0 XI562_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I220_MP4 (XI562_I220_p1 XI562_I220_An p0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I220_MP2 (VDD I562_pn17 XI562_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I220_MP3 (XI562_I220_p1 XI562_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I220_MP0 (VDD I562_pn17 XI562_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I50_MP1 (VDD b0_18 XI562_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I50_MP5 (I562_pn18 b0_18 XI562_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I50_MP4 (XI562_I50_p1 XI562_I50_An I562_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I50_MP2 (VDD VSS XI562_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I50_MP3 (XI562_I50_p1 XI562_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I50_MP0 (VDD VSS XI562_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I222_MP1 (VDD I562_G18_0 XI562_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I222_MP5 (p0_19 I562_G18_0 XI562_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I222_MP4 (XI562_I222_p1 XI562_I222_An p0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I222_MP2 (VDD I562_pn19 XI562_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I222_MP3 (XI562_I222_p1 XI562_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I222_MP0 (VDD I562_pn19 XI562_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2204_MP1 (VDD nrkn12 XI2204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2204_MP5 (R_12 nrkn12 XI2204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2204_MP4 (XI2204_p1 XI2204_An R_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2204_MP2 (VDD ru12 XI2204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2204_MP3 (XI2204_p1 XI2204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2204_MP0 (VDD ru12 XI2204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2201_MP1 (VDD nrkn11 XI2201_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2201_MP5 (R_11 nrkn11 XI2201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2201_MP4 (XI2201_p1 XI2201_An R_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2201_MP2 (VDD ru11 XI2201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2201_MP3 (XI2201_p1 XI2201_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2201_MP0 (VDD ru11 XI2201_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I220_MP1 (VDD I2066_G16_0 XI2066_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I220_MP5 (ru17 I2066_G16_0 XI2066_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I220_MP4 (XI2066_I220_p1 XI2066_I220_An ru17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I220_MP2 (VDD I2066_pn17 XI2066_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I220_MP3 (XI2066_I220_p1 XI2066_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I220_MP0 (VDD I2066_pn17 XI2066_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I49_MP1 (VDD dm17 XI2066_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I49_MP5 (I2066_pn17 dm17 XI2066_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I49_MP4 (XI2066_I49_p1 XI2066_I49_An I2066_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I49_MP2 (VDD p31_17 XI2066_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I49_MP3 (XI2066_I49_p1 XI2066_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I49_MP0 (VDD p31_17 XI2066_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I50_MP1 (VDD dm18 XI2066_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I50_MP5 (I2066_pn18 dm18 XI2066_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I50_MP4 (XI2066_I50_p1 XI2066_I50_An I2066_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I50_MP2 (VDD p31_18 XI2066_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I50_MP3 (XI2066_I50_p1 XI2066_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I50_MP0 (VDD p31_18 XI2066_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I222_MP1 (VDD I1988_G18_0 XI1988_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I222_MP5 (p31_19 I1988_G18_0 XI1988_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I222_MP4 (XI1988_I222_p1 XI1988_I222_An p31_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I222_MP2 (VDD I1988_pn19 XI1988_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I222_MP3 (XI1988_I222_p1 XI1988_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I222_MP0 (VDD I1988_pn19 XI1988_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I221_MP1 (VDD I1988_G17_0 XI1988_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I221_MP5 (p31_18 I1988_G17_0 XI1988_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I221_MP4 (XI1988_I221_p1 XI1988_I221_An p31_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I221_MP2 (VDD I1988_pn18 XI1988_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I221_MP3 (XI1988_I221_p1 XI1988_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I221_MP0 (VDD I1988_pn18 XI1988_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I50_MP1 (VDD b31_18 XI1988_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I50_MP5 (I1988_pn18 b31_18 XI1988_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I50_MP4 (XI1988_I50_p1 XI1988_I50_An I1988_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I50_MP2 (VDD p30_17 XI1988_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I50_MP3 (XI1988_I50_p1 XI1988_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I50_MP0 (VDD p30_17 XI1988_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I49_MP1 (VDD b31_17 XI1988_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I49_MP5 (I1988_pn17 b31_17 XI1988_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I49_MP4 (XI1988_I49_p1 XI1988_I49_An I1988_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I49_MP2 (VDD p30_16 XI1988_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I49_MP3 (XI1988_I49_p1 XI1988_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I49_MP0 (VDD p30_16 XI1988_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I220_MP1 (VDD I1942_G16_0 XI1942_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I220_MP5 (p30_17 I1942_G16_0 XI1942_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I220_MP4 (XI1942_I220_p1 XI1942_I220_An p30_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I220_MP2 (VDD I1942_pn17 XI1942_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I220_MP3 (XI1942_I220_p1 XI1942_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I220_MP0 (VDD I1942_pn17 XI1942_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I48_MP1 (VDD b30_16 XI1942_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I48_MP5 (I1942_pn16 b30_16 XI1942_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I48_MP4 (XI1942_I48_p1 XI1942_I48_An I1942_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I48_MP2 (VDD p29_15 XI1942_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I48_MP3 (XI1942_I48_p1 XI1942_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I48_MP0 (VDD p29_15 XI1942_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I49_MP1 (VDD b30_17 XI1942_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I49_MP5 (I1942_pn17 b30_17 XI1942_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I49_MP4 (XI1942_I49_p1 XI1942_I49_An I1942_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I49_MP2 (VDD p29_16 XI1942_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I49_MP3 (XI1942_I49_p1 XI1942_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I49_MP0 (VDD p29_16 XI1942_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I220_MP1 (VDD I1896_G16_0 XI1896_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I220_MP5 (p29_17 I1896_G16_0 XI1896_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I220_MP4 (XI1896_I220_p1 XI1896_I220_An p29_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I220_MP2 (VDD I1896_pn17 XI1896_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I220_MP3 (XI1896_I220_p1 XI1896_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I220_MP0 (VDD I1896_pn17 XI1896_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I223_MP1 (VDD I1896_G19_0 XI1896_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I223_MP5 (p29_20 I1896_G19_0 XI1896_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I223_MP4 (XI1896_I223_p1 XI1896_I223_An p29_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I223_MP2 (VDD I1896_pn20 XI1896_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I223_MP3 (XI1896_I223_p1 XI1896_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I223_MP0 (VDD I1896_pn20 XI1896_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I50_MP1 (VDD b3_18 XI700_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I50_MP5 (I700_pn18 b3_18 XI700_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I50_MP4 (XI700_I50_p1 XI700_I50_An I700_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I50_MP2 (VDD p2_17 XI700_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I50_MP3 (XI700_I50_p1 XI700_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I50_MP0 (VDD p2_17 XI700_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I48_MP1 (VDD b3_16 XI700_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I48_MP5 (I700_pn16 b3_16 XI700_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I48_MP4 (XI700_I48_p1 XI700_I48_An I700_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I48_MP2 (VDD p2_15 XI700_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I48_MP3 (XI700_I48_p1 XI700_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I48_MP0 (VDD p2_15 XI700_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I49_MP1 (VDD b3_17 XI700_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I49_MP5 (I700_pn17 b3_17 XI700_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I49_MP4 (XI700_I49_p1 XI700_I49_An I700_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I49_MP2 (VDD p2_16 XI700_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I49_MP3 (XI700_I49_p1 XI700_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I49_MP0 (VDD p2_16 XI700_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I47_MP1 (VDD b3_15 XI700_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I47_MP5 (I700_pn15 b3_15 XI700_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I47_MP4 (XI700_I47_p1 XI700_I47_An I700_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I47_MP2 (VDD p2_14 XI700_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I47_MP3 (XI700_I47_p1 XI700_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I47_MP0 (VDD p2_14 XI700_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I47_MP1 (VDD b2_15 XI654_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I47_MP5 (I654_pn15 b2_15 XI654_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I47_MP4 (XI654_I47_p1 XI654_I47_An I654_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I47_MP2 (VDD p1_14 XI654_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I47_MP3 (XI654_I47_p1 XI654_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I47_MP0 (VDD p1_14 XI654_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I47_MP1 (VDD b1_15 XI608_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I47_MP5 (I608_pn15 b1_15 XI608_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I47_MP4 (XI608_I47_p1 XI608_I47_An I608_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I47_MP2 (VDD p0_14 XI608_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I47_MP3 (XI608_I47_p1 XI608_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I47_MP0 (VDD p0_14 XI608_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I48_MP1 (VDD b1_16 XI608_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I48_MP5 (I608_pn16 b1_16 XI608_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I48_MP4 (XI608_I48_p1 XI608_I48_An I608_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I48_MP2 (VDD p0_15 XI608_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I48_MP3 (XI608_I48_p1 XI608_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I48_MP0 (VDD p0_15 XI608_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I49_MP1 (VDD b0_17 XI562_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I49_MP5 (I562_pn17 b0_17 XI562_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I49_MP4 (XI562_I49_p1 XI562_I49_An I562_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I49_MP2 (VDD VSS XI562_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I49_MP3 (XI562_I49_p1 XI562_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I49_MP0 (VDD VSS XI562_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I221_MP1 (VDD I562_G17_0 XI562_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I221_MP5 (p0_18 I562_G17_0 XI562_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I221_MP4 (XI562_I221_p1 XI562_I221_An p0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I221_MP2 (VDD I562_pn18 XI562_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I221_MP3 (XI562_I221_p1 XI562_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I221_MP0 (VDD I562_pn18 XI562_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I47_MP1 (VDD b0_15 XI562_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I47_MP5 (I562_pn15 b0_15 XI562_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I47_MP4 (XI562_I47_p1 XI562_I47_An I562_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I47_MP2 (VDD VSS XI562_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I47_MP3 (XI562_I47_p1 XI562_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I47_MP0 (VDD VSS XI562_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2198_MP1 (VDD nrkn10 XI2198_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2198_MP5 (R_10 nrkn10 XI2198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2198_MP4 (XI2198_p1 XI2198_An R_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2198_MP2 (VDD ru10 XI2198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2198_MP3 (XI2198_p1 XI2198_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2198_MP0 (VDD ru10 XI2198_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I47_MP1 (VDD dm15 XI2066_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I47_MP5 (I2066_pn15 dm15 XI2066_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I47_MP4 (XI2066_I47_p1 XI2066_I47_An I2066_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I47_MP2 (VDD p31_15 XI2066_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I47_MP3 (XI2066_I47_p1 XI2066_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I47_MP0 (VDD p31_15 XI2066_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I48_MP1 (VDD dm16 XI2066_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I48_MP5 (I2066_pn16 dm16 XI2066_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I48_MP4 (XI2066_I48_p1 XI2066_I48_An I2066_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I48_MP2 (VDD p31_16 XI2066_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I48_MP3 (XI2066_I48_p1 XI2066_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I48_MP0 (VDD p31_16 XI2066_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I220_MP1 (VDD I1988_G16_0 XI1988_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I220_MP5 (p31_17 I1988_G16_0 XI1988_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I220_MP4 (XI1988_I220_p1 XI1988_I220_An p31_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I220_MP2 (VDD I1988_pn17 XI1988_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I220_MP3 (XI1988_I220_p1 XI1988_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I220_MP0 (VDD I1988_pn17 XI1988_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I47_MP1 (VDD b31_15 XI1988_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I47_MP5 (I1988_pn15 b31_15 XI1988_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I47_MP4 (XI1988_I47_p1 XI1988_I47_An I1988_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I47_MP2 (VDD p30_14 XI1988_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I47_MP3 (XI1988_I47_p1 XI1988_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I47_MP0 (VDD p30_14 XI1988_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I48_MP1 (VDD b31_16 XI1988_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I48_MP5 (I1988_pn16 b31_16 XI1988_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I48_MP4 (XI1988_I48_p1 XI1988_I48_An I1988_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I48_MP2 (VDD p30_15 XI1988_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I48_MP3 (XI1988_I48_p1 XI1988_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I48_MP0 (VDD p30_15 XI1988_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I46_MP1 (VDD b30_14 XI1942_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I46_MP5 (I1942_pn14 b30_14 XI1942_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I46_MP4 (XI1942_I46_p1 XI1942_I46_An I1942_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I46_MP2 (VDD p29_13 XI1942_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I46_MP3 (XI1942_I46_p1 XI1942_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I46_MP0 (VDD p29_13 XI1942_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I47_MP1 (VDD b30_15 XI1942_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I47_MP5 (I1942_pn15 b30_15 XI1942_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I47_MP4 (XI1942_I47_p1 XI1942_I47_An I1942_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I47_MP2 (VDD p29_14 XI1942_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I47_MP3 (XI1942_I47_p1 XI1942_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I47_MP0 (VDD p29_14 XI1942_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I49_MP1 (VDD b29_17 XI1896_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I49_MP5 (I1896_pn17 b29_17 XI1896_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I49_MP4 (XI1896_I49_p1 XI1896_I49_An I1896_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I49_MP2 (VDD p28_16 XI1896_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I49_MP3 (XI1896_I49_p1 XI1896_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I49_MP0 (VDD p28_16 XI1896_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I46_MP1 (VDD b3_14 XI700_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I46_MP5 (I700_pn14 b3_14 XI700_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I46_MP4 (XI700_I46_p1 XI700_I46_An I700_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I46_MP2 (VDD p2_13 XI700_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I46_MP3 (XI700_I46_p1 XI700_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I46_MP0 (VDD p2_13 XI700_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I45_MP1 (VDD b2_13 XI654_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I45_MP5 (I654_pn13 b2_13 XI654_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I45_MP4 (XI654_I45_p1 XI654_I45_An I654_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I45_MP2 (VDD p1_12 XI654_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I45_MP3 (XI654_I45_p1 XI654_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I45_MP0 (VDD p1_12 XI654_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I46_MP1 (VDD b2_14 XI654_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I46_MP5 (I654_pn14 b2_14 XI654_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I46_MP4 (XI654_I46_p1 XI654_I46_An I654_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I46_MP2 (VDD p1_13 XI654_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I46_MP3 (XI654_I46_p1 XI654_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I46_MP0 (VDD p1_13 XI654_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I45_MP1 (VDD b1_13 XI608_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I45_MP5 (I608_pn13 b1_13 XI608_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I45_MP4 (XI608_I45_p1 XI608_I45_An I608_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I45_MP2 (VDD p0_12 XI608_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I45_MP3 (XI608_I45_p1 XI608_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I45_MP0 (VDD p0_12 XI608_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I46_MP1 (VDD b1_14 XI608_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I46_MP5 (I608_pn14 b1_14 XI608_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I46_MP4 (XI608_I46_p1 XI608_I46_An I608_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I46_MP2 (VDD p0_13 XI608_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I46_MP3 (XI608_I46_p1 XI608_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I46_MP0 (VDD p0_13 XI608_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I48_MP1 (VDD b0_16 XI562_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I48_MP5 (I562_pn16 b0_16 XI562_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I48_MP4 (XI562_I48_p1 XI562_I48_An I562_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I48_MP2 (VDD VSS XI562_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I48_MP3 (XI562_I48_p1 XI562_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I48_MP0 (VDD VSS XI562_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2195_MP1 (VDD nrkn9 XI2195_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2195_MP5 (R_9 nrkn9 XI2195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2195_MP4 (XI2195_p1 XI2195_An R_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2195_MP2 (VDD ru9 XI2195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2195_MP3 (XI2195_p1 XI2195_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2195_MP0 (VDD ru9 XI2195_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I45_MP1 (VDD dm13 XI2066_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I45_MP5 (I2066_pn13 dm13 XI2066_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I45_MP4 (XI2066_I45_p1 XI2066_I45_An I2066_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I45_MP2 (VDD p31_13 XI2066_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I45_MP3 (XI2066_I45_p1 XI2066_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I45_MP0 (VDD p31_13 XI2066_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I46_MP1 (VDD dm14 XI2066_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I46_MP5 (I2066_pn14 dm14 XI2066_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I46_MP4 (XI2066_I46_p1 XI2066_I46_An I2066_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I46_MP2 (VDD p31_14 XI2066_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I46_MP3 (XI2066_I46_p1 XI2066_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I46_MP0 (VDD p31_14 XI2066_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I46_MP1 (VDD b31_14 XI1988_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I46_MP5 (I1988_pn14 b31_14 XI1988_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I46_MP4 (XI1988_I46_p1 XI1988_I46_An I1988_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I46_MP2 (VDD p30_13 XI1988_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I46_MP3 (XI1988_I46_p1 XI1988_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I46_MP0 (VDD p30_13 XI1988_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I44_MP1 (VDD b30_12 XI1942_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I44_MP5 (I1942_pn12 b30_12 XI1942_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I44_MP4 (XI1942_I44_p1 XI1942_I44_An I1942_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I44_MP2 (VDD p29_11 XI1942_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I44_MP3 (XI1942_I44_p1 XI1942_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I44_MP0 (VDD p29_11 XI1942_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I45_MP1 (VDD b30_13 XI1942_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I45_MP5 (I1942_pn13 b30_13 XI1942_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I45_MP4 (XI1942_I45_p1 XI1942_I45_An I1942_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I45_MP2 (VDD p29_12 XI1942_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I45_MP3 (XI1942_I45_p1 XI1942_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I45_MP0 (VDD p29_12 XI1942_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I44_MP1 (VDD b29_12 XI1896_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I44_MP5 (I1896_pn12 b29_12 XI1896_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I44_MP4 (XI1896_I44_p1 XI1896_I44_An I1896_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I44_MP2 (VDD p28_11 XI1896_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I44_MP3 (XI1896_I44_p1 XI1896_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I44_MP0 (VDD p28_11 XI1896_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I46_MP1 (VDD b29_14 XI1896_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I46_MP5 (I1896_pn14 b29_14 XI1896_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I46_MP4 (XI1896_I46_p1 XI1896_I46_An I1896_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I46_MP2 (VDD p28_13 XI1896_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I46_MP3 (XI1896_I46_p1 XI1896_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I46_MP0 (VDD p28_13 XI1896_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I47_MP1 (VDD b29_15 XI1896_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I47_MP5 (I1896_pn15 b29_15 XI1896_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I47_MP4 (XI1896_I47_p1 XI1896_I47_An I1896_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I47_MP2 (VDD p28_14 XI1896_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I47_MP3 (XI1896_I47_p1 XI1896_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I47_MP0 (VDD p28_14 XI1896_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I48_MP1 (VDD b29_16 XI1896_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I48_MP5 (I1896_pn16 b29_16 XI1896_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I48_MP4 (XI1896_I48_p1 XI1896_I48_An I1896_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I48_MP2 (VDD p28_15 XI1896_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I48_MP3 (XI1896_I48_p1 XI1896_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I48_MP0 (VDD p28_15 XI1896_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I227_MP1 (VDD I1850_G23_0 XI1850_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I227_MP5 (p28_24 I1850_G23_0 XI1850_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I227_MP4 (XI1850_I227_p1 XI1850_I227_An p28_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I227_MP2 (VDD I1850_pn24 XI1850_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I227_MP3 (XI1850_I227_p1 XI1850_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I227_MP0 (VDD I1850_pn24 XI1850_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I229_MP1 (VDD I1850_G25_0 XI1850_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I229_MP5 (p28_26 I1850_G25_0 XI1850_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I229_MP4 (XI1850_I229_p1 XI1850_I229_An p28_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I229_MP2 (VDD I1850_pn26 XI1850_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I229_MP3 (XI1850_I229_p1 XI1850_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I229_MP0 (VDD I1850_pn26 XI1850_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I231_MP1 (VDD I1850_G27_0 XI1850_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I231_MP5 (p28_28 I1850_G27_0 XI1850_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I231_MP4 (XI1850_I231_p1 XI1850_I231_An p28_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I231_MP2 (VDD I1850_pn28 XI1850_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I231_MP3 (XI1850_I231_p1 XI1850_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I231_MP0 (VDD I1850_pn28 XI1850_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I233_MP1 (VDD I700_G29_0 XI700_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I233_MP5 (p3_30 I700_G29_0 XI700_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I233_MP4 (XI700_I233_p1 XI700_I233_An p3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I233_MP2 (VDD I700_pn30 XI700_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I233_MP3 (XI700_I233_p1 XI700_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I233_MP0 (VDD I700_pn30 XI700_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I45_MP1 (VDD b3_13 XI700_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I45_MP5 (I700_pn13 b3_13 XI700_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I45_MP4 (XI700_I45_p1 XI700_I45_An I700_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I45_MP2 (VDD p2_12 XI700_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I45_MP3 (XI700_I45_p1 XI700_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I45_MP0 (VDD p2_12 XI700_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I44_MP1 (VDD b2_12 XI654_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I44_MP5 (I654_pn12 b2_12 XI654_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I44_MP4 (XI654_I44_p1 XI654_I44_An I654_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I44_MP2 (VDD p1_11 XI654_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I44_MP3 (XI654_I44_p1 XI654_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I44_MP0 (VDD p1_11 XI654_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I44_MP1 (VDD b1_12 XI608_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I44_MP5 (I608_pn12 b1_12 XI608_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I44_MP4 (XI608_I44_p1 XI608_I44_An I608_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I44_MP2 (VDD p0_11 XI608_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I44_MP3 (XI608_I44_p1 XI608_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I44_MP0 (VDD p0_11 XI608_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I45_MP1 (VDD b0_13 XI562_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I45_MP5 (I562_pn13 b0_13 XI562_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I45_MP4 (XI562_I45_p1 XI562_I45_An I562_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I45_MP2 (VDD VSS XI562_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I45_MP3 (XI562_I45_p1 XI562_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I45_MP0 (VDD VSS XI562_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I46_MP1 (VDD b0_14 XI562_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I46_MP5 (I562_pn14 b0_14 XI562_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I46_MP4 (XI562_I46_p1 XI562_I46_An I562_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I46_MP2 (VDD VSS XI562_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I46_MP3 (XI562_I46_p1 XI562_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I46_MP0 (VDD VSS XI562_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I44_MP1 (VDD b0_12 XI562_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I44_MP5 (I562_pn12 b0_12 XI562_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I44_MP4 (XI562_I44_p1 XI562_I44_An I562_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I44_MP2 (VDD VSS XI562_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I44_MP3 (XI562_I44_p1 XI562_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I44_MP0 (VDD VSS XI562_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2192_MP1 (VDD nrkn8 XI2192_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2192_MP5 (R_8 nrkn8 XI2192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2192_MP4 (XI2192_p1 XI2192_An R_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2192_MP2 (VDD ru8 XI2192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2192_MP3 (XI2192_p1 XI2192_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2192_MP0 (VDD ru8 XI2192_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2189_MP1 (VDD nrkn7 XI2189_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2189_MP5 (R_7 nrkn7 XI2189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2189_MP4 (XI2189_p1 XI2189_An R_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2189_MP2 (VDD ru7 XI2189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2189_MP3 (XI2189_p1 XI2189_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2189_MP0 (VDD ru7 XI2189_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I211_MP1 (VDD I2066_G7_0 XI2066_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I211_MP5 (ru8 I2066_G7_0 XI2066_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I211_MP4 (XI2066_I211_p1 XI2066_I211_An ru8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I211_MP2 (VDD I2066_pn8 XI2066_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I211_MP3 (XI2066_I211_p1 XI2066_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I211_MP0 (VDD I2066_pn8 XI2066_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I44_MP1 (VDD dm12 XI2066_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I44_MP5 (I2066_pn12 dm12 XI2066_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I44_MP4 (XI2066_I44_p1 XI2066_I44_An I2066_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I44_MP2 (VDD p31_12 XI2066_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I44_MP3 (XI2066_I44_p1 XI2066_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I44_MP0 (VDD p31_12 XI2066_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I45_MP1 (VDD b31_13 XI1988_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I45_MP5 (I1988_pn13 b31_13 XI1988_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I45_MP4 (XI1988_I45_p1 XI1988_I45_An I1988_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I45_MP2 (VDD p30_12 XI1988_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I45_MP3 (XI1988_I45_p1 XI1988_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I45_MP0 (VDD p30_12 XI1988_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I43_MP1 (VDD b30_11 XI1942_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I43_MP5 (I1942_pn11 b30_11 XI1942_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I43_MP4 (XI1942_I43_p1 XI1942_I43_An I1942_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I43_MP2 (VDD p29_10 XI1942_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I43_MP3 (XI1942_I43_p1 XI1942_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I43_MP0 (VDD p29_10 XI1942_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I210_MP1 (VDD I1896_G6_0 XI1896_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I210_MP5 (p29_7 I1896_G6_0 XI1896_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I210_MP4 (XI1896_I210_p1 XI1896_I210_An p29_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I210_MP2 (VDD I1896_pn7 XI1896_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I210_MP3 (XI1896_I210_p1 XI1896_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I210_MP0 (VDD I1896_pn7 XI1896_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I211_MP1 (VDD I1896_G7_0 XI1896_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I211_MP5 (p29_8 I1896_G7_0 XI1896_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I211_MP4 (XI1896_I211_p1 XI1896_I211_An p29_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I211_MP2 (VDD I1896_pn8 XI1896_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I211_MP3 (XI1896_I211_p1 XI1896_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I211_MP0 (VDD I1896_pn8 XI1896_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I43_MP1 (VDD b29_11 XI1896_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I43_MP5 (I1896_pn11 b29_11 XI1896_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I43_MP4 (XI1896_I43_p1 XI1896_I43_An I1896_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I43_MP2 (VDD p28_10 XI1896_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I43_MP3 (XI1896_I43_p1 XI1896_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I43_MP0 (VDD p28_10 XI1896_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I45_MP1 (VDD b29_13 XI1896_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I45_MP5 (I1896_pn13 b29_13 XI1896_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I45_MP4 (XI1896_I45_p1 XI1896_I45_An I1896_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I45_MP2 (VDD p28_12 XI1896_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I45_MP3 (XI1896_I45_p1 XI1896_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I45_MP0 (VDD p28_12 XI1896_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I223_MP1 (VDD I1850_G19_0 XI1850_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I223_MP5 (p28_20 I1850_G19_0 XI1850_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I223_MP4 (XI1850_I223_p1 XI1850_I223_An p28_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I223_MP2 (VDD I1850_pn20 XI1850_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I223_MP3 (XI1850_I223_p1 XI1850_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I223_MP0 (VDD I1850_pn20 XI1850_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I231_MP1 (VDD I700_G27_0 XI700_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I231_MP5 (p3_28 I700_G27_0 XI700_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I231_MP4 (XI700_I231_p1 XI700_I231_An p3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I231_MP2 (VDD I700_pn28 XI700_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I231_MP3 (XI700_I231_p1 XI700_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I231_MP0 (VDD I700_pn28 XI700_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I227_MP1 (VDD I700_G23_0 XI700_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I227_MP5 (p3_24 I700_G23_0 XI700_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I227_MP4 (XI700_I227_p1 XI700_I227_An p3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I227_MP2 (VDD I700_pn24 XI700_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I227_MP3 (XI700_I227_p1 XI700_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I227_MP0 (VDD I700_pn24 XI700_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I44_MP1 (VDD b3_12 XI700_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I44_MP5 (I700_pn12 b3_12 XI700_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I44_MP4 (XI700_I44_p1 XI700_I44_An I700_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I44_MP2 (VDD p2_11 XI700_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I44_MP3 (XI700_I44_p1 XI700_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I44_MP0 (VDD p2_11 XI700_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I211_MP1 (VDD I654_G7_0 XI654_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I211_MP5 (p2_8 I654_G7_0 XI654_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I211_MP4 (XI654_I211_p1 XI654_I211_An p2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I211_MP2 (VDD I654_pn8 XI654_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I211_MP3 (XI654_I211_p1 XI654_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I211_MP0 (VDD I654_pn8 XI654_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I41_MP1 (VDD b2_9 XI654_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I41_MP5 (I654_pn9 b2_9 XI654_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I41_MP4 (XI654_I41_p1 XI654_I41_An I654_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I41_MP2 (VDD p1_8 XI654_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I41_MP3 (XI654_I41_p1 XI654_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I41_MP0 (VDD p1_8 XI654_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I42_MP1 (VDD b2_10 XI654_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I42_MP5 (I654_pn10 b2_10 XI654_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I42_MP4 (XI654_I42_p1 XI654_I42_An I654_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I42_MP2 (VDD p1_9 XI654_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I42_MP3 (XI654_I42_p1 XI654_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I42_MP0 (VDD p1_9 XI654_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I43_MP1 (VDD b2_11 XI654_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I43_MP5 (I654_pn11 b2_11 XI654_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I43_MP4 (XI654_I43_p1 XI654_I43_An I654_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I43_MP2 (VDD p1_10 XI654_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I43_MP3 (XI654_I43_p1 XI654_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I43_MP0 (VDD p1_10 XI654_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I211_MP1 (VDD I608_G7_0 XI608_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I211_MP5 (p1_8 I608_G7_0 XI608_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I211_MP4 (XI608_I211_p1 XI608_I211_An p1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I211_MP2 (VDD I608_pn8 XI608_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I211_MP3 (XI608_I211_p1 XI608_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I211_MP0 (VDD I608_pn8 XI608_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I43_MP1 (VDD b1_11 XI608_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I43_MP5 (I608_pn11 b1_11 XI608_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I43_MP4 (XI608_I43_p1 XI608_I43_An I608_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I43_MP2 (VDD p0_10 XI608_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I43_MP3 (XI608_I43_p1 XI608_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I43_MP0 (VDD p0_10 XI608_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I42_MP1 (VDD b1_10 XI608_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I42_MP5 (I608_pn10 b1_10 XI608_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I42_MP4 (XI608_I42_p1 XI608_I42_An I608_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I42_MP2 (VDD p0_9 XI608_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I42_MP3 (XI608_I42_p1 XI608_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I42_MP0 (VDD p0_9 XI608_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I43_MP1 (VDD b0_11 XI562_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I43_MP5 (I562_pn11 b0_11 XI562_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I43_MP4 (XI562_I43_p1 XI562_I43_An I562_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I43_MP2 (VDD VSS XI562_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I43_MP3 (XI562_I43_p1 XI562_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I43_MP0 (VDD VSS XI562_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2186_MP1 (VDD nrkn6 XI2186_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2186_MP5 (R_6 nrkn6 XI2186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2186_MP4 (XI2186_p1 XI2186_An R_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2186_MP2 (VDD ru6 XI2186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2186_MP3 (XI2186_p1 XI2186_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2186_MP0 (VDD ru6 XI2186_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I209_MP1 (VDD I2066_G5_0 XI2066_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I209_MP5 (ru6 I2066_G5_0 XI2066_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I209_MP4 (XI2066_I209_p1 XI2066_I209_An ru6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I209_MP2 (VDD I2066_pn6 XI2066_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I209_MP3 (XI2066_I209_p1 XI2066_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I209_MP0 (VDD I2066_pn6 XI2066_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I210_MP1 (VDD I2066_G6_0 XI2066_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I210_MP5 (ru7 I2066_G6_0 XI2066_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I210_MP4 (XI2066_I210_p1 XI2066_I210_An ru7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I210_MP2 (VDD I2066_pn7 XI2066_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I210_MP3 (XI2066_I210_p1 XI2066_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I210_MP0 (VDD I2066_pn7 XI2066_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I43_MP1 (VDD dm11 XI2066_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I43_MP5 (I2066_pn11 dm11 XI2066_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I43_MP4 (XI2066_I43_p1 XI2066_I43_An I2066_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I43_MP2 (VDD p31_11 XI2066_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I43_MP3 (XI2066_I43_p1 XI2066_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I43_MP0 (VDD p31_11 XI2066_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I42_MP1 (VDD dm10 XI2066_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I42_MP5 (I2066_pn10 dm10 XI2066_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I42_MP4 (XI2066_I42_p1 XI2066_I42_An I2066_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I42_MP2 (VDD p31_10 XI2066_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I42_MP3 (XI2066_I42_p1 XI2066_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I42_MP0 (VDD p31_10 XI2066_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I42_MP1 (VDD b31_10 XI1988_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I42_MP5 (I1988_pn10 b31_10 XI1988_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I42_MP4 (XI1988_I42_p1 XI1988_I42_An I1988_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I42_MP2 (VDD p30_9 XI1988_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I42_MP3 (XI1988_I42_p1 XI1988_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I42_MP0 (VDD p30_9 XI1988_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I44_MP1 (VDD b31_12 XI1988_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I44_MP5 (I1988_pn12 b31_12 XI1988_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I44_MP4 (XI1988_I44_p1 XI1988_I44_An I1988_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I44_MP2 (VDD p30_11 XI1988_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I44_MP3 (XI1988_I44_p1 XI1988_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I44_MP0 (VDD p30_11 XI1988_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I43_MP1 (VDD b31_11 XI1988_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I43_MP5 (I1988_pn11 b31_11 XI1988_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I43_MP4 (XI1988_I43_p1 XI1988_I43_An I1988_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I43_MP2 (VDD p30_10 XI1988_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I43_MP3 (XI1988_I43_p1 XI1988_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I43_MP0 (VDD p30_10 XI1988_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I40_MP1 (VDD b30_8 XI1942_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I40_MP5 (I1942_pn8 b30_8 XI1942_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I40_MP4 (XI1942_I40_p1 XI1942_I40_An I1942_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I40_MP2 (VDD p29_7 XI1942_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I40_MP3 (XI1942_I40_p1 XI1942_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I40_MP0 (VDD p29_7 XI1942_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I42_MP1 (VDD b30_10 XI1942_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I42_MP5 (I1942_pn10 b30_10 XI1942_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I42_MP4 (XI1942_I42_p1 XI1942_I42_An I1942_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I42_MP2 (VDD p29_9 XI1942_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I42_MP3 (XI1942_I42_p1 XI1942_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I42_MP0 (VDD p29_9 XI1942_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I41_MP1 (VDD b30_9 XI1942_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I41_MP5 (I1942_pn9 b30_9 XI1942_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I41_MP4 (XI1942_I41_p1 XI1942_I41_An I1942_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I41_MP2 (VDD p29_8 XI1942_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I41_MP3 (XI1942_I41_p1 XI1942_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I41_MP0 (VDD p29_8 XI1942_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I39_MP1 (VDD b29_7 XI1896_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I39_MP5 (I1896_pn7 b29_7 XI1896_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I39_MP4 (XI1896_I39_p1 XI1896_I39_An I1896_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I39_MP2 (VDD p28_6 XI1896_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I39_MP3 (XI1896_I39_p1 XI1896_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I39_MP0 (VDD p28_6 XI1896_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I41_MP1 (VDD b29_9 XI1896_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I41_MP5 (I1896_pn9 b29_9 XI1896_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I41_MP4 (XI1896_I41_p1 XI1896_I41_An I1896_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I41_MP2 (VDD p28_8 XI1896_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I41_MP3 (XI1896_I41_p1 XI1896_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I41_MP0 (VDD p28_8 XI1896_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I42_MP1 (VDD b29_10 XI1896_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I42_MP5 (I1896_pn10 b29_10 XI1896_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I42_MP4 (XI1896_I42_p1 XI1896_I42_An I1896_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I42_MP2 (VDD p28_9 XI1896_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I42_MP3 (XI1896_I42_p1 XI1896_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I42_MP0 (VDD p28_9 XI1896_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I211_MP1 (VDD I1850_G7_0 XI1850_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I211_MP5 (p28_8 I1850_G7_0 XI1850_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I211_MP4 (XI1850_I211_p1 XI1850_I211_An p28_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I211_MP2 (VDD I1850_pn8 XI1850_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I211_MP3 (XI1850_I211_p1 XI1850_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I211_MP0 (VDD I1850_pn8 XI1850_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I221_MP1 (VDD I1850_G17_0 XI1850_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I221_MP5 (p28_18 I1850_G17_0 XI1850_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I221_MP4 (XI1850_I221_p1 XI1850_I221_An p28_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I221_MP2 (VDD I1850_pn18 XI1850_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I221_MP3 (XI1850_I221_p1 XI1850_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I221_MP0 (VDD I1850_pn18 XI1850_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I225_MP1 (VDD I1850_G21_0 XI1850_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I225_MP5 (p28_22 I1850_G21_0 XI1850_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I225_MP4 (XI1850_I225_p1 XI1850_I225_An p28_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I225_MP2 (VDD I1850_pn22 XI1850_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I225_MP3 (XI1850_I225_p1 XI1850_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I225_MP0 (VDD I1850_pn22 XI1850_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I229_MP1 (VDD I700_G25_0 XI700_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I229_MP5 (p3_26 I700_G25_0 XI700_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I229_MP4 (XI700_I229_p1 XI700_I229_An p3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I229_MP2 (VDD I700_pn26 XI700_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I229_MP3 (XI700_I229_p1 XI700_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I229_MP0 (VDD I700_pn26 XI700_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I43_MP1 (VDD b3_11 XI700_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I43_MP5 (I700_pn11 b3_11 XI700_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I43_MP4 (XI700_I43_p1 XI700_I43_An I700_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I43_MP2 (VDD p2_10 XI700_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I43_MP3 (XI700_I43_p1 XI700_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I43_MP0 (VDD p2_10 XI700_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I209_MP1 (VDD I654_G5_0 XI654_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I209_MP5 (p2_6 I654_G5_0 XI654_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I209_MP4 (XI654_I209_p1 XI654_I209_An p2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I209_MP2 (VDD I654_pn6 XI654_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I209_MP3 (XI654_I209_p1 XI654_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I209_MP0 (VDD I654_pn6 XI654_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I42_MP1 (VDD b3_10 XI700_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I42_MP5 (I700_pn10 b3_10 XI700_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I42_MP4 (XI700_I42_p1 XI700_I42_An I700_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I42_MP2 (VDD p2_9 XI700_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I42_MP3 (XI700_I42_p1 XI700_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I42_MP0 (VDD p2_9 XI700_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I210_MP1 (VDD I654_G6_0 XI654_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I210_MP5 (p2_7 I654_G6_0 XI654_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I210_MP4 (XI654_I210_p1 XI654_I210_An p2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I210_MP2 (VDD I654_pn7 XI654_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I210_MP3 (XI654_I210_p1 XI654_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I210_MP0 (VDD I654_pn7 XI654_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I39_MP1 (VDD b2_7 XI654_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I39_MP5 (I654_pn7 b2_7 XI654_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I39_MP4 (XI654_I39_p1 XI654_I39_An I654_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I39_MP2 (VDD p1_6 XI654_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I39_MP3 (XI654_I39_p1 XI654_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I39_MP0 (VDD p1_6 XI654_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I40_MP1 (VDD b2_8 XI654_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I40_MP5 (I654_pn8 b2_8 XI654_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I40_MP4 (XI654_I40_p1 XI654_I40_An I654_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I40_MP2 (VDD p1_7 XI654_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I40_MP3 (XI654_I40_p1 XI654_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I40_MP0 (VDD p1_7 XI654_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I38_MP1 (VDD b2_6 XI654_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I38_MP5 (I654_pn6 b2_6 XI654_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I38_MP4 (XI654_I38_p1 XI654_I38_An I654_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I38_MP2 (VDD p1_5 XI654_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I38_MP3 (XI654_I38_p1 XI654_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I38_MP0 (VDD p1_5 XI654_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I209_MP1 (VDD I608_G5_0 XI608_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I209_MP5 (p1_6 I608_G5_0 XI608_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I209_MP4 (XI608_I209_p1 XI608_I209_An p1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I209_MP2 (VDD I608_pn6 XI608_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I209_MP3 (XI608_I209_p1 XI608_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I209_MP0 (VDD I608_pn6 XI608_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I208_MP1 (VDD I608_G4_0 XI608_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I208_MP5 (p1_5 I608_G4_0 XI608_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I208_MP4 (XI608_I208_p1 XI608_I208_An p1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I208_MP2 (VDD I608_pn5 XI608_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I208_MP3 (XI608_I208_p1 XI608_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I208_MP0 (VDD I608_pn5 XI608_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I210_MP1 (VDD I608_G6_0 XI608_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I210_MP5 (p1_7 I608_G6_0 XI608_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I210_MP4 (XI608_I210_p1 XI608_I210_An p1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I210_MP2 (VDD I608_pn7 XI608_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I210_MP3 (XI608_I210_p1 XI608_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I210_MP0 (VDD I608_pn7 XI608_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I40_MP1 (VDD b1_8 XI608_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I40_MP5 (I608_pn8 b1_8 XI608_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I40_MP4 (XI608_I40_p1 XI608_I40_An I608_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I40_MP2 (VDD p0_7 XI608_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I40_MP3 (XI608_I40_p1 XI608_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I40_MP0 (VDD p0_7 XI608_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I41_MP1 (VDD b1_9 XI608_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I41_MP5 (I608_pn9 b1_9 XI608_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I41_MP4 (XI608_I41_p1 XI608_I41_An I608_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I41_MP2 (VDD p0_8 XI608_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I41_MP3 (XI608_I41_p1 XI608_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I41_MP0 (VDD p0_8 XI608_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I210_MP1 (VDD I562_G6_0 XI562_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I210_MP5 (p0_7 I562_G6_0 XI562_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I210_MP4 (XI562_I210_p1 XI562_I210_An p0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I210_MP2 (VDD I562_pn7 XI562_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I210_MP3 (XI562_I210_p1 XI562_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I210_MP0 (VDD I562_pn7 XI562_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I211_MP1 (VDD I562_G7_0 XI562_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I211_MP5 (p0_8 I562_G7_0 XI562_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I211_MP4 (XI562_I211_p1 XI562_I211_An p0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I211_MP2 (VDD I562_pn8 XI562_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I211_MP3 (XI562_I211_p1 XI562_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I211_MP0 (VDD I562_pn8 XI562_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I42_MP1 (VDD b0_10 XI562_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I42_MP5 (I562_pn10 b0_10 XI562_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I42_MP4 (XI562_I42_p1 XI562_I42_An I562_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I42_MP2 (VDD VSS XI562_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I42_MP3 (XI562_I42_p1 XI562_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I42_MP0 (VDD VSS XI562_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2180_MP1 (VDD nrkn4 XI2180_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2180_MP5 (R_4 nrkn4 XI2180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2180_MP4 (XI2180_p1 XI2180_An R_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2180_MP2 (VDD ru4 XI2180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2180_MP3 (XI2180_p1 XI2180_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2180_MP0 (VDD ru4 XI2180_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2183_MP1 (VDD nrkn5 XI2183_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2183_MP5 (R_5 nrkn5 XI2183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2183_MP4 (XI2183_p1 XI2183_An R_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2183_MP2 (VDD ru5 XI2183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2183_MP3 (XI2183_p1 XI2183_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2183_MP0 (VDD ru5 XI2183_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I208_MP1 (VDD I2066_G4_0 XI2066_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I208_MP5 (ru5 I2066_G4_0 XI2066_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I208_MP4 (XI2066_I208_p1 XI2066_I208_An ru5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I208_MP2 (VDD I2066_pn5 XI2066_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I208_MP3 (XI2066_I208_p1 XI2066_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I208_MP0 (VDD I2066_pn5 XI2066_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I41_MP1 (VDD dm9 XI2066_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I41_MP5 (I2066_pn9 dm9 XI2066_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I41_MP4 (XI2066_I41_p1 XI2066_I41_An I2066_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I41_MP2 (VDD p31_9 XI2066_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I41_MP3 (XI2066_I41_p1 XI2066_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I41_MP0 (VDD p31_9 XI2066_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I40_MP1 (VDD dm8 XI2066_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2066_I40_MP5 (I2066_pn8 dm8 XI2066_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I40_MP4 (XI2066_I40_p1 XI2066_I40_An I2066_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I40_MP2 (VDD p31_8 XI2066_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I40_MP3 (XI2066_I40_p1 XI2066_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I40_MP0 (VDD p31_8 XI2066_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I211_MP1 (VDD I1988_G7_0 XI1988_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I211_MP5 (p31_8 I1988_G7_0 XI1988_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I211_MP4 (XI1988_I211_p1 XI1988_I211_An p31_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I211_MP2 (VDD I1988_pn8 XI1988_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I211_MP3 (XI1988_I211_p1 XI1988_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I211_MP0 (VDD I1988_pn8 XI1988_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I41_MP1 (VDD b31_9 XI1988_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1988_I41_MP5 (I1988_pn9 b31_9 XI1988_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I41_MP4 (XI1988_I41_p1 XI1988_I41_An I1988_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I41_MP2 (VDD p30_8 XI1988_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I41_MP3 (XI1988_I41_p1 XI1988_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I41_MP0 (VDD p30_8 XI1988_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I210_MP1 (VDD I1942_G6_0 XI1942_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I210_MP5 (p30_7 I1942_G6_0 XI1942_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I210_MP4 (XI1942_I210_p1 XI1942_I210_An p30_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I210_MP2 (VDD I1942_pn7 XI1942_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I210_MP3 (XI1942_I210_p1 XI1942_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I210_MP0 (VDD I1942_pn7 XI1942_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I209_MP1 (VDD I1942_G5_0 XI1942_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I209_MP5 (p30_6 I1942_G5_0 XI1942_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I209_MP4 (XI1942_I209_p1 XI1942_I209_An p30_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I209_MP2 (VDD I1942_pn6 XI1942_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I209_MP3 (XI1942_I209_p1 XI1942_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I209_MP0 (VDD I1942_pn6 XI1942_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I211_MP1 (VDD I1942_G7_0 XI1942_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I211_MP5 (p30_8 I1942_G7_0 XI1942_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I211_MP4 (XI1942_I211_p1 XI1942_I211_An p30_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I211_MP2 (VDD I1942_pn8 XI1942_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I211_MP3 (XI1942_I211_p1 XI1942_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I211_MP0 (VDD I1942_pn8 XI1942_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I39_MP1 (VDD b30_7 XI1942_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1942_I39_MP5 (I1942_pn7 b30_7 XI1942_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I39_MP4 (XI1942_I39_p1 XI1942_I39_An I1942_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I39_MP2 (VDD p29_6 XI1942_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I39_MP3 (XI1942_I39_p1 XI1942_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I39_MP0 (VDD p29_6 XI1942_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I208_MP1 (VDD I1896_G4_0 XI1896_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I208_MP5 (p29_5 I1896_G4_0 XI1896_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I208_MP4 (XI1896_I208_p1 XI1896_I208_An p29_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I208_MP2 (VDD I1896_pn5 XI1896_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I208_MP3 (XI1896_I208_p1 XI1896_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I208_MP0 (VDD I1896_pn5 XI1896_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I209_MP1 (VDD I1896_G5_0 XI1896_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I209_MP5 (p29_6 I1896_G5_0 XI1896_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I209_MP4 (XI1896_I209_p1 XI1896_I209_An p29_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I209_MP2 (VDD I1896_pn6 XI1896_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I209_MP3 (XI1896_I209_p1 XI1896_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I209_MP0 (VDD I1896_pn6 XI1896_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I40_MP1 (VDD b29_8 XI1896_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1896_I40_MP5 (I1896_pn8 b29_8 XI1896_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I40_MP4 (XI1896_I40_p1 XI1896_I40_An I1896_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I40_MP2 (VDD p28_7 XI1896_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I40_MP3 (XI1896_I40_p1 XI1896_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I40_MP0 (VDD p28_7 XI1896_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I209_MP1 (VDD I1850_G5_0 XI1850_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I209_MP5 (p28_6 I1850_G5_0 XI1850_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I209_MP4 (XI1850_I209_p1 XI1850_I209_An p28_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I209_MP2 (VDD I1850_pn6 XI1850_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I209_MP3 (XI1850_I209_p1 XI1850_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I209_MP0 (VDD I1850_pn6 XI1850_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I233_MP1 (VDD I1850_G29_0 XI1850_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1850_I233_MP5 (p28_30 I1850_G29_0 XI1850_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I233_MP4 (XI1850_I233_p1 XI1850_I233_An p28_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I233_MP2 (VDD I1850_pn30 XI1850_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I233_MP3 (XI1850_I233_p1 XI1850_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I233_MP0 (VDD I1850_pn30 XI1850_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I225_MP1 (VDD I700_G21_0 XI700_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I225_MP5 (p3_22 I700_G21_0 XI700_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I225_MP4 (XI700_I225_p1 XI700_I225_An p3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I225_MP2 (VDD I700_pn22 XI700_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I225_MP3 (XI700_I225_p1 XI700_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I225_MP0 (VDD I700_pn22 XI700_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I223_MP1 (VDD I700_G19_0 XI700_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I223_MP5 (p3_20 I700_G19_0 XI700_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I223_MP4 (XI700_I223_p1 XI700_I223_An p3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I223_MP2 (VDD I700_pn20 XI700_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I223_MP3 (XI700_I223_p1 XI700_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I223_MP0 (VDD I700_pn20 XI700_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I41_MP1 (VDD b3_9 XI700_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I41_MP5 (I700_pn9 b3_9 XI700_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I41_MP4 (XI700_I41_p1 XI700_I41_An I700_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I41_MP2 (VDD p2_8 XI700_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I41_MP3 (XI700_I41_p1 XI700_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I41_MP0 (VDD p2_8 XI700_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I39_MP1 (VDD b3_7 XI700_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I39_MP5 (I700_pn7 b3_7 XI700_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I39_MP4 (XI700_I39_p1 XI700_I39_An I700_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I39_MP2 (VDD p2_6 XI700_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I39_MP3 (XI700_I39_p1 XI700_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I39_MP0 (VDD p2_6 XI700_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I40_MP1 (VDD b3_8 XI700_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI700_I40_MP5 (I700_pn8 b3_8 XI700_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I40_MP4 (XI700_I40_p1 XI700_I40_An I700_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I40_MP2 (VDD p2_7 XI700_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I40_MP3 (XI700_I40_p1 XI700_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I40_MP0 (VDD p2_7 XI700_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I208_MP1 (VDD I654_G4_0 XI654_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I208_MP5 (p2_5 I654_G4_0 XI654_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I208_MP4 (XI654_I208_p1 XI654_I208_An p2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I208_MP2 (VDD I654_pn5 XI654_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I208_MP3 (XI654_I208_p1 XI654_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I208_MP0 (VDD I654_pn5 XI654_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I37_MP1 (VDD b2_5 XI654_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI654_I37_MP5 (I654_pn5 b2_5 XI654_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I37_MP4 (XI654_I37_p1 XI654_I37_An I654_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I37_MP2 (VDD p1_4 XI654_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I37_MP3 (XI654_I37_p1 XI654_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I37_MP0 (VDD p1_4 XI654_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I39_MP1 (VDD b1_7 XI608_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I39_MP5 (I608_pn7 b1_7 XI608_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I39_MP4 (XI608_I39_p1 XI608_I39_An I608_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I39_MP2 (VDD p0_6 XI608_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I39_MP3 (XI608_I39_p1 XI608_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I39_MP0 (VDD p0_6 XI608_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I37_MP1 (VDD b1_5 XI608_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I37_MP5 (I608_pn5 b1_5 XI608_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I37_MP4 (XI608_I37_p1 XI608_I37_An I608_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I37_MP2 (VDD p0_4 XI608_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I37_MP3 (XI608_I37_p1 XI608_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I37_MP0 (VDD p0_4 XI608_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I38_MP1 (VDD b1_6 XI608_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI608_I38_MP5 (I608_pn6 b1_6 XI608_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I38_MP4 (XI608_I38_p1 XI608_I38_An I608_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I38_MP2 (VDD p0_5 XI608_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I38_MP3 (XI608_I38_p1 XI608_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I38_MP0 (VDD p0_5 XI608_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I208_MP1 (VDD I562_G4_0 XI562_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I208_MP5 (p0_5 I562_G4_0 XI562_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I208_MP4 (XI562_I208_p1 XI562_I208_An p0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I208_MP2 (VDD I562_pn5 XI562_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I208_MP3 (XI562_I208_p1 XI562_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I208_MP0 (VDD I562_pn5 XI562_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I209_MP1 (VDD I562_G5_0 XI562_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI562_I209_MP5 (p0_6 I562_G5_0 XI562_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I209_MP4 (XI562_I209_p1 XI562_I209_An p0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I209_MP2 (VDD I562_pn6 XI562_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I209_MP3 (XI562_I209_p1 XI562_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I209_MP0 (VDD I562_pn6 XI562_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI181_MP1 (VDD nbkn5 XI181_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI181_MP5 (dd5 nbkn5 XI181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI181_MP4 (XI181_p1 XI181_An dd5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
