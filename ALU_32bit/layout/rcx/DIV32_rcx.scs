    I_MXI1896_I18_MP0 (VDD p28_17 I1896_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I19_MP1 (I1896_gn19 b29_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I19_MP0 (VDD p28_18 I1896_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I20_MP1 (I1896_gn20 b29_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I20_MP0 (VDD p28_19 I1896_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I178_XP_MP1 (I1896_P27_12n I1896_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I178_XP_MP0 (VDD I1896_P27_20 I1896_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I125_XP_MP1 (I700_P29_26n I700_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I125_XP_MP0 (VDD I700_P29_28 I700_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I123_XP_MP1 (I700_P27_24n I700_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I123_XP_MP0 (VDD I700_P27_26 I700_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I182_XP_MP1 (I700_P31_16n I700_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I182_XP_MP0 (VDD I700_P31_24 I700_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I18_MP1 (I700_gn18 b3_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I18_MP0 (VDD p2_17 I700_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I19_MP1 (I700_gn19 b3_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I19_MP0 (VDD p2_18 I700_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I17_MP1 (I700_gn17 b3_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I17_MP0 (VDD p2_16 I700_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I176_XP_MP1 (I654_P25_10n I654_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I176_XP_MP0 (VDD I654_P25_18 I654_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I111_XP_MP1 (I654_P15_12n I654_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I111_XP_MP0 (VDD I654_P15_14 I654_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I113_XP_MP1 (I654_P17_14n I654_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I113_XP_MP0 (VDD I654_P17_16 I654_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I171_XP_MP1 (I654_P20_5n I654_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I171_XP_MP0 (VDD I654_P20_13 I654_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I114_XP_MP1 (I654_P18_15n I654_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I114_XP_MP0 (VDD I654_P18_17 I654_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I17_MP1 (I654_gn17 b2_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I17_MP0 (VDD p1_16 I654_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I16_MP1 (I654_gn16 b2_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I16_MP0 (VDD p1_15 I654_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I113_XP_MP1 (I608_P17_14n I608_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I113_XP_MP0 (VDD I608_P17_16 I608_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I115_XP_MP1 (I608_P19_16n I608_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I115_XP_MP0 (VDD I608_P19_18 I608_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I177_XP_MP1 (I608_P26_11n I608_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I177_XP_MP0 (VDD I608_P26_19 I608_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I116_XP_MP1 (I608_P20_17n I608_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I116_XP_MP0 (VDD I608_P20_19 I608_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I17_MP1 (I608_gn17 b1_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I17_MP0 (VDD p0_16 I608_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I16_MP1 (I608_gn16 b1_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I16_MP0 (VDD p0_15 I608_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I18_MP1 (I562_gn18 b0_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I18_MP0 (VDD VSS I562_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I179_XP_MP1 (I562_P28_13n I562_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I179_XP_MP0 (VDD I562_P28_21 I562_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I177_XP_MP1 (I562_P26_11n I562_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I177_XP_MP0 (VDD I562_P26_19 I562_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I176_XP_MP1 (I562_P25_10n I562_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I176_XP_MP0 (VDD I562_P25_18 I562_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I115_XP_MP1 (I562_P19_16n I562_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I115_XP_MP0 (VDD I562_P19_18 I562_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I170_XP_MP1 (I2066_P19_4n I2066_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I170_XP_MP0 (VDD I2066_P19_12 I2066_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I113_XP_MP1 (I2066_P17_14n I2066_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I113_XP_MP0 (VDD I2066_P17_16 I2066_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I115_XP_MP1 (I2066_P19_16n I2066_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I115_XP_MP0 (VDD I2066_P19_18 I2066_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I179_XP_MP1 (I2066_P28_13n I2066_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I179_XP_MP0 (VDD I2066_P28_21 I2066_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I116_XP_MP1 (I2066_P20_17n I2066_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I116_XP_MP0 (VDD I2066_P20_19 I2066_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I17_MP1 (I2066_gn17 dm17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I17_MP0 (VDD p31_17 I2066_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I18_MP1 (I2066_gn18 dm18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I18_MP0 (VDD p31_18 I2066_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I173_XP_MP1 (I1988_P22_7n I1988_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I173_XP_MP0 (VDD I1988_P22_15 I1988_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2038_MP1 (dmn18 p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2038_MP0 (VDD dd18_b3_5 dmn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I116_XP_MP1 (I1988_P20_17n I1988_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I116_XP_MP0 (VDD I1988_P20_19 I1988_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I178_XP_MP1 (I1988_P27_12n I1988_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I178_XP_MP0 (VDD I1988_P27_20 I1988_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I117_XP_MP1 (I1988_P21_18n I1988_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I117_XP_MP0 (VDD I1988_P21_20 I1988_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I115_XP_MP1 (I1988_P19_16n I1988_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I115_XP_MP0 (VDD I1988_P19_18 I1988_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I18_MP1 (I1988_gn18 b31_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I18_MP0 (VDD p30_17 I1988_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I16_MP1 (I1988_gn16 b31_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I16_MP0 (VDD p30_15 I1988_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I17_MP1 (I1988_gn17 b31_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I17_MP0 (VDD p30_16 I1988_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I171_XP_MP1 (I1942_P20_5n I1942_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I171_XP_MP0 (VDD I1942_P20_13 I1942_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I114_XP_MP1 (I1942_P18_15n I1942_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I114_XP_MP0 (VDD I1942_P18_17 I1942_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I113_XP_MP1 (I1942_P17_14n I1942_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I113_XP_MP0 (VDD I1942_P17_16 I1942_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I14_MP1 (I1942_gn14 b30_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I14_MP0 (VDD p29_13 I1942_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I16_MP1 (I1942_gn16 b30_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I16_MP0 (VDD p29_15 I1942_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I18_MP1 (I1942_gn18 b30_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I18_MP0 (VDD p29_17 I1942_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I17_MP1 (I1942_gn17 b30_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I17_MP0 (VDD p29_16 I1942_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I15_MP1 (I1942_gn15 b30_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I15_MP0 (VDD p29_14 I1942_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I167_XP_MP1 (I1896_P16_1n I1896_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I167_XP_MP0 (VDD I1896_P16_9 I1896_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I168_XP_MP1 (I1896_P17_2n I1896_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I168_XP_MP0 (VDD I1896_P17_10 I1896_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I106_XP_MP1 (I1896_P10_7n I1896_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I106_XP_MP0 (VDD I1896_P10_9 I1896_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I108_XP_MP1 (I1896_P12_9n I1896_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I108_XP_MP0 (VDD I1896_P12_11 I1896_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I113_XP_MP1 (I1896_P17_14n I1896_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I113_XP_MP0 (VDD I1896_P17_16 I1896_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I115_XP_MP1 (I1896_P19_16n I1896_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I115_XP_MP0 (VDD I1896_P19_18 I1896_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I182_XP_MP1 (I1896_P31_16n I1896_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I182_XP_MP0 (VDD I1896_P31_24 I1896_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I121_XP_MP1 (I700_P25_22n I700_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I121_XP_MP0 (VDD I700_P25_24 I700_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I119_XP_MP1 (I700_P23_20n I700_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I119_XP_MP0 (VDD I700_P23_22 I700_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I109_XP_MP1 (I654_P13_10n I654_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I109_XP_MP0 (VDD I654_P13_12 I654_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I112_XP_MP1 (I654_P16_13n I654_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I112_XP_MP0 (VDD I654_P16_15 I654_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I15_MP1 (I654_gn15 b2_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I15_MP0 (VDD p1_14 I654_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I14_MP1 (I654_gn14 b2_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I14_MP0 (VDD p1_13 I654_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I170_XP_MP1 (I608_P19_4n I608_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I170_XP_MP0 (VDD I608_P19_12 I608_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I111_XP_MP1 (I608_P15_12n I608_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I111_XP_MP0 (VDD I608_P15_14 I608_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I171_XP_MP1 (I608_P20_5n I608_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I171_XP_MP0 (VDD I608_P20_13 I608_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I114_XP_MP1 (I608_P18_15n I608_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I114_XP_MP0 (VDD I608_P18_17 I608_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I112_XP_MP1 (I608_P16_13n I608_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I112_XP_MP0 (VDD I608_P16_15 I608_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I15_MP1 (I608_gn15 b1_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I15_MP0 (VDD p0_14 I608_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I17_MP1 (I562_gn17 b0_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I17_MP0 (VDD VSS I562_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I116_XP_MP1 (I562_P20_17n I562_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I116_XP_MP0 (VDD I562_P20_19 I562_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I16_MP1 (I562_gn16 b0_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I16_MP0 (VDD VSS I562_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I113_XP_MP1 (I562_P17_14n I562_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I113_XP_MP0 (VDD I562_P17_16 I562_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I111_XP_MP1 (I562_P15_12n I562_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I111_XP_MP0 (VDD I562_P15_14 I562_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I170_XP_MP1 (I562_P19_4n I562_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I170_XP_MP0 (VDD I562_P19_12 I562_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I176_XP_MP1 (I2066_P25_10n I2066_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I176_XP_MP0 (VDD I2066_P25_18 I2066_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I111_XP_MP1 (I2066_P15_12n I2066_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I111_XP_MP0 (VDD I2066_P15_14 I2066_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I171_XP_MP1 (I2066_P20_5n I2066_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I171_XP_MP0 (VDD I2066_P20_13 I2066_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I114_XP_MP1 (I2066_P18_15n I2066_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I114_XP_MP0 (VDD I2066_P18_17 I2066_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I112_XP_MP1 (I2066_P16_13n I2066_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I112_XP_MP0 (VDD I2066_P16_15 I2066_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I15_MP1 (I2066_gn15 dm15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I15_MP0 (VDD p31_15 I2066_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I16_MP1 (I2066_gn16 dm16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I16_MP0 (VDD p31_16 I2066_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2034_MP1 (dmn16 p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2034_MP0 (VDD dd16_b3_5 dmn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2036_MP1 (dmn17 p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2036_MP0 (VDD dd17_b3_5 dmn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I114_XP_MP1 (I1988_P18_15n I1988_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I114_XP_MP0 (VDD I1988_P18_17 I1988_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I172_XP_MP1 (I1988_P21_6n I1988_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I172_XP_MP0 (VDD I1988_P21_14 I1988_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I113_XP_MP1 (I1988_P17_14n I1988_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I113_XP_MP0 (VDD I1988_P17_16 I1988_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I111_XP_MP1 (I1988_P15_12n I1988_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I111_XP_MP0 (VDD I1988_P15_14 I1988_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I15_MP1 (I1988_gn15 b31_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I15_MP0 (VDD p30_14 I1988_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I110_XP_MP1 (I1942_P14_11n I1942_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I110_XP_MP0 (VDD I1942_P14_13 I1942_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I112_XP_MP1 (I1942_P16_13n I1942_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I112_XP_MP0 (VDD I1942_P16_15 I1942_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I170_XP_MP1 (I1942_P19_4n I1942_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I170_XP_MP0 (VDD I1942_P19_12 I1942_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I111_XP_MP1 (I1942_P15_12n I1942_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I111_XP_MP0 (VDD I1942_P15_14 I1942_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I13_MP1 (I1942_gn13 b30_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I13_MP0 (VDD p29_12 I1942_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I109_XP_MP1 (I1896_P13_10n I1896_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I109_XP_MP0 (VDD I1896_P13_12 I1896_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I111_XP_MP1 (I1896_P15_12n I1896_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I111_XP_MP0 (VDD I1896_P15_14 I1896_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I14_MP1 (I1896_gn14 b29_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I14_MP0 (VDD p28_13 I1896_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I17_MP1 (I1896_gn17 b29_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I17_MP0 (VDD p28_16 I1896_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I170_XP_MP1 (I1896_P19_4n I1896_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I170_XP_MP0 (VDD I1896_P19_12 I1896_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I174_XP_MP1 (I1896_P23_8n I1896_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I174_XP_MP0 (VDD I1896_P23_16 I1896_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I117_XP_MP1 (I700_P21_18n I700_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I117_XP_MP0 (VDD I700_P21_20 I700_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I115_XP_MP1 (I700_P19_16n I700_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I115_XP_MP0 (VDD I700_P19_18 I700_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I16_MP1 (I700_gn16 b3_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I16_MP0 (VDD p2_15 I700_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I14_MP1 (I700_gn14 b3_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I14_MP0 (VDD p2_13 I700_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I15_MP1 (I700_gn15 b3_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I15_MP0 (VDD p2_14 I700_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I168_XP_MP1 (I654_P17_2n I654_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I168_XP_MP0 (VDD I654_P17_10 I654_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I107_XP_MP1 (I654_P11_8n I654_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I107_XP_MP0 (VDD I654_P11_10 I654_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I169_XP_MP1 (I654_P18_3n I654_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I169_XP_MP0 (VDD I654_P18_11 I654_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I110_XP_MP1 (I654_P14_11n I654_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I110_XP_MP0 (VDD I654_P14_13 I654_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I13_MP1 (I654_gn13 b2_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I13_MP0 (VDD p1_12 I654_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I109_XP_MP1 (I608_P13_10n I608_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I109_XP_MP0 (VDD I608_P13_12 I608_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I169_XP_MP1 (I608_P18_3n I608_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I169_XP_MP0 (VDD I608_P18_11 I608_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I175_XP_MP1 (I608_P24_9n I608_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I175_XP_MP0 (VDD I608_P24_17 I608_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I110_XP_MP1 (I608_P14_11n I608_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I110_XP_MP0 (VDD I608_P14_13 I608_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I13_MP1 (I608_gn13 b1_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I13_MP0 (VDD p0_12 I608_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I14_MP1 (I608_gn14 b1_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I14_MP0 (VDD p0_13 I608_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I114_XP_MP1 (I562_P18_15n I562_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I114_XP_MP0 (VDD I562_P18_17 I562_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I15_MP1 (I562_gn15 b0_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I15_MP0 (VDD VSS I562_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I14_MP1 (I562_gn14 b0_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I14_MP0 (VDD VSS I562_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I109_XP_MP1 (I562_P13_10n I562_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I109_XP_MP0 (VDD I562_P13_12 I562_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I168_XP_MP1 (I2066_P17_2n I2066_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I168_XP_MP0 (VDD I2066_P17_10 I2066_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I109_XP_MP1 (I2066_P13_10n I2066_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I109_XP_MP0 (VDD I2066_P13_12 I2066_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I169_XP_MP1 (I2066_P18_3n I2066_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I169_XP_MP0 (VDD I2066_P18_11 I2066_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I110_XP_MP1 (I2066_P14_11n I2066_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I110_XP_MP0 (VDD I2066_P14_13 I2066_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I13_MP1 (I2066_gn13 dm13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I13_MP0 (VDD p31_13 I2066_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I14_MP1 (I2066_gn14 dm14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I14_MP0 (VDD p31_14 I2066_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2032_MP1 (dmn15 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2032_MP0 (VDD dd15_b3_5 dmn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2030_MP1 (dmn14 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2030_MP0 (VDD dd14_b3_5 dmn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I171_XP_MP1 (I1988_P20_5n I1988_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I171_XP_MP0 (VDD I1988_P20_13 I1988_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I112_XP_MP1 (I1988_P16_13n I1988_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I112_XP_MP0 (VDD I1988_P16_15 I1988_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I176_XP_MP1 (I1988_P25_10n I1988_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I176_XP_MP0 (VDD I1988_P25_18 I1988_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I14_MP1 (I1988_gn14 b31_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I14_MP0 (VDD p30_13 I1988_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I13_MP1 (I1988_gn13 b31_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I13_MP0 (VDD p30_12 I1988_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I169_XP_MP1 (I1942_P18_3n I1942_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I169_XP_MP0 (VDD I1942_P18_11 I1942_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I108_XP_MP1 (I1942_P12_9n I1942_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I108_XP_MP0 (VDD I1942_P12_11 I1942_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I109_XP_MP1 (I1942_P13_10n I1942_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I109_XP_MP0 (VDD I1942_P13_12 I1942_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I11_MP1 (I1942_gn11 b30_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I11_MP0 (VDD p29_10 I1942_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I12_MP1 (I1942_gn12 b30_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I12_MP0 (VDD p29_11 I1942_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I104_XP_MP1 (I1896_P8_5n I1896_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I104_XP_MP0 (VDD I1896_P8_7 I1896_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I105_XP_MP1 (I1896_P9_6n I1896_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I105_XP_MP0 (VDD I1896_P9_8 I1896_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I107_XP_MP1 (I1896_P11_8n I1896_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I107_XP_MP0 (VDD I1896_P11_10 I1896_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I13_MP1 (I1896_gn13 b29_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I13_MP0 (VDD p28_12 I1896_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I15_MP1 (I1896_gn15 b29_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I15_MP0 (VDD p28_14 I1896_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I16_MP1 (I1896_gn16 b29_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I16_MP0 (VDD p28_15 I1896_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I178_XP_MP1 (I700_P27_12n I700_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I178_XP_MP0 (VDD I700_P27_20 I700_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I180_XP_MP1 (I700_P29_14n I700_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I180_XP_MP0 (VDD I700_P29_22 I700_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I174_XP_MP1 (I700_P23_8n I700_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I174_XP_MP0 (VDD I700_P23_16 I700_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I113_XP_MP1 (I700_P17_14n I700_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I113_XP_MP0 (VDD I700_P17_16 I700_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I111_XP_MP1 (I700_P15_12n I700_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I111_XP_MP0 (VDD I700_P15_14 I700_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I13_MP1 (I700_gn13 b3_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I13_MP0 (VDD p2_12 I700_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I12_MP1 (I700_gn12 b3_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I12_MP0 (VDD p2_11 I700_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I108_XP_MP1 (I654_P12_9n I654_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I108_XP_MP0 (VDD I654_P12_11 I654_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I12_MP1 (I654_gn12 b2_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I12_MP0 (VDD p1_11 I654_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I11_MP1 (I654_gn11 b2_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I11_MP0 (VDD p1_10 I654_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I107_XP_MP1 (I608_P11_8n I608_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I107_XP_MP0 (VDD I608_P11_10 I608_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I108_XP_MP1 (I608_P12_9n I608_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I108_XP_MP0 (VDD I608_P12_11 I608_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I12_MP1 (I608_gn12 b1_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I12_MP0 (VDD p0_11 I608_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I171_XP_MP1 (I562_P20_5n I562_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I171_XP_MP0 (VDD I562_P20_13 I562_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I13_MP1 (I562_gn13 b0_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I13_MP0 (VDD VSS I562_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I112_XP_MP1 (I562_P16_13n I562_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I112_XP_MP0 (VDD I562_P16_15 I562_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I110_XP_MP1 (I562_P14_11n I562_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I110_XP_MP0 (VDD I562_P14_13 I562_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I168_XP_MP1 (I562_P17_2n I562_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I168_XP_MP0 (VDD I562_P17_10 I562_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I12_MP1 (I562_gn12 b0_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I12_MP0 (VDD VSS I562_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I107_XP_MP1 (I2066_P11_8n I2066_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I107_XP_MP0 (VDD I2066_P11_10 I2066_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I175_XP_MP1 (I2066_P24_9n I2066_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I175_XP_MP0 (VDD I2066_P24_17 I2066_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I108_XP_MP1 (I2066_P12_9n I2066_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I108_XP_MP0 (VDD I2066_P12_11 I2066_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I12_MP1 (I2066_gn12 dm12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I12_MP0 (VDD p31_12 I2066_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2028_MP1 (dmn13 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2028_MP0 (VDD dd13_b3_5 dmn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2026_MP1 (dmn12 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2026_MP0 (VDD dd12_b3_5 dmn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I175_XP_MP1 (I1988_P24_9n I1988_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I175_XP_MP0 (VDD I1988_P24_17 I1988_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I110_XP_MP1 (I1988_P14_11n I1988_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I110_XP_MP0 (VDD I1988_P14_13 I1988_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I170_XP_MP1 (I1988_P19_4n I1988_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I170_XP_MP0 (VDD I1988_P19_12 I1988_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I109_XP_MP1 (I1988_P13_10n I1988_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I109_XP_MP0 (VDD I1988_P13_12 I1988_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I12_MP1 (I1988_gn12 b31_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I12_MP0 (VDD p30_11 I1988_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I106_XP_MP1 (I1942_P10_7n I1942_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I106_XP_MP0 (VDD I1942_P10_9 I1942_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I168_XP_MP1 (I1942_P17_2n I1942_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I168_XP_MP0 (VDD I1942_P17_10 I1942_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I107_XP_MP1 (I1942_P11_8n I1942_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I107_XP_MP0 (VDD I1942_P11_10 I1942_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I10_MP1 (I1942_gn10 b30_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I10_MP0 (VDD p29_9 I1942_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I100_XP_MP1 (I1896_P4_1n I1896_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I100_XP_MP0 (VDD I1896_P4_3 I1896_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I102_XP_MP1 (I1896_P6_3n I1896_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I102_XP_MP0 (VDD I1896_P6_5 I1896_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I103_XP_MP1 (I1896_P7_4n I1896_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I103_XP_MP0 (VDD I1896_P7_6 I1896_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I9_MP1 (I1896_gn9 b29_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I9_MP0 (VDD p28_8 I1896_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I12_MP1 (I1896_gn12 b29_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I12_MP0 (VDD p28_11 I1896_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I170_XP_MP1 (I1850_P19_4n I1850_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I170_XP_MP0 (VDD I1850_P19_12 I1850_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I174_XP_MP1 (I1850_P23_8n I1850_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I174_XP_MP0 (VDD I1850_P23_16 I1850_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I178_XP_MP1 (I1850_P27_12n I1850_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I178_XP_MP0 (VDD I1850_P27_20 I1850_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I176_XP_MP1 (I700_P25_10n I700_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I176_XP_MP0 (VDD I700_P25_18 I700_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I109_XP_MP1 (I700_P13_10n I700_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I109_XP_MP0 (VDD I700_P13_12 I700_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I11_MP1 (I700_gn11 b3_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I11_MP0 (VDD p2_10 I700_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I103_XP_MP1 (I654_P7_4n I654_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I103_XP_MP0 (VDD I654_P7_6 I654_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I105_XP_MP1 (I654_P9_6n I654_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I105_XP_MP0 (VDD I654_P9_8 I654_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I101_XP_MP1 (I654_P5_2n I654_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I101_XP_MP0 (VDD I654_P5_4 I654_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I167_XP_MP1 (I654_P16_1n I654_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I167_XP_MP0 (VDD I654_P16_9 I654_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I106_XP_MP1 (I654_P10_7n I654_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I106_XP_MP0 (VDD I654_P10_9 I654_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I9_MP1 (I654_gn9 b2_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I9_MP0 (VDD p1_8 I654_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I10_MP1 (I654_gn10 b2_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I10_MP0 (VDD p1_9 I654_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I168_XP_MP1 (I608_P17_2n I608_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I168_XP_MP0 (VDD I608_P17_10 I608_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I167_XP_MP1 (I608_P16_1n I608_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I167_XP_MP0 (VDD I608_P16_9 I608_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I106_XP_MP1 (I608_P10_7n I608_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I106_XP_MP0 (VDD I608_P10_9 I608_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I11_MP1 (I608_gn11 b1_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I11_MP0 (VDD p0_10 I608_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I10_MP1 (I608_gn10 b1_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I10_MP0 (VDD p0_9 I608_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I175_XP_MP1 (I562_P24_9n I562_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I175_XP_MP0 (VDD I562_P24_17 I562_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I169_XP_MP1 (I562_P18_3n I562_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I169_XP_MP0 (VDD I562_P18_11 I562_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I108_XP_MP1 (I562_P12_9n I562_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I108_XP_MP0 (VDD I562_P12_11 I562_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I107_XP_MP1 (I562_P11_8n I562_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I107_XP_MP0 (VDD I562_P11_10 I562_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I11_MP1 (I562_gn11 b0_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I11_MP0 (VDD VSS I562_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I103_XP_MP1 (I2066_P7_4n I2066_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I103_XP_MP0 (VDD I2066_P7_6 I2066_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I105_XP_MP1 (I2066_P9_6n I2066_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I105_XP_MP0 (VDD I2066_P9_8 I2066_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I167_XP_MP1 (I2066_P16_1n I2066_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I167_XP_MP0 (VDD I2066_P16_9 I2066_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I106_XP_MP1 (I2066_P10_7n I2066_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I106_XP_MP0 (VDD I2066_P10_9 I2066_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I11_MP1 (I2066_gn11 dm11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I11_MP0 (VDD p31_11 I2066_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I10_MP1 (I2066_gn10 dm10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I10_MP0 (VDD p31_10 I2066_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2022_MP1 (dmn10 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2022_MP0 (VDD dd10_b3_5 dmn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I169_XP_MP1 (I1988_P18_3n I1988_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I169_XP_MP0 (VDD I1988_P18_11 I1988_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I108_XP_MP1 (I1988_P12_9n I1988_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I108_XP_MP0 (VDD I1988_P12_11 I1988_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I168_XP_MP1 (I1988_P17_2n I1988_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I168_XP_MP0 (VDD I1988_P17_10 I1988_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I107_XP_MP1 (I1988_P11_8n I1988_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I107_XP_MP0 (VDD I1988_P11_10 I1988_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I10_MP1 (I1988_gn10 b31_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I10_MP0 (VDD p30_9 I1988_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I11_MP1 (I1988_gn11 b31_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I11_MP0 (VDD p30_10 I1988_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I167_XP_MP1 (I1942_P16_1n I1942_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I167_XP_MP0 (VDD I1942_P16_9 I1942_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I105_XP_MP1 (I1942_P9_6n I1942_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I105_XP_MP0 (VDD I1942_P9_8 I1942_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I103_XP_MP1 (I1942_P7_4n I1942_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I103_XP_MP0 (VDD I1942_P7_6 I1942_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I8_MP1 (I1942_gn8 b30_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I8_MP0 (VDD p29_7 I1942_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I9_MP1 (I1942_gn9 b30_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I9_MP0 (VDD p29_8 I1942_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I101_XP_MP1 (I1896_P5_2n I1896_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I101_XP_MP0 (VDD I1896_P5_4 I1896_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I10_MP1 (I1896_gn10 b29_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I10_MP0 (VDD p28_9 I1896_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I11_MP1 (I1896_gn11 b29_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I11_MP0 (VDD p28_10 I1896_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I172_XP_MP1 (I1850_P21_6n I1850_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I172_XP_MP0 (VDD I1850_P21_14 I1850_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I182_XP_MP1 (I1850_P31_16n I1850_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I182_XP_MP0 (VDD I1850_P31_24 I1850_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I126_XP_MP1 (I700_P30_27n I700_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I126_XP_MP0 (VDD I700_P30_29 I700_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I172_XP_MP1 (I700_P21_6n I700_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I172_XP_MP0 (VDD I700_P21_14 I700_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I10_MP1 (I700_gn10 b3_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I10_MP0 (VDD p2_9 I700_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I102_XP_MP1 (I654_P6_3n I654_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I102_XP_MP0 (VDD I654_P6_5 I654_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I104_XP_MP1 (I654_P8_5n I654_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I104_XP_MP0 (VDD I654_P8_7 I654_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I7_MP1 (I654_gn7 b2_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I7_MP0 (VDD p1_6 I654_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I8_MP1 (I654_gn8 b2_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I8_MP0 (VDD p1_7 I654_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I6_MP1 (I654_gn6 b2_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I6_MP0 (VDD p1_5 I654_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I103_XP_MP1 (I608_P7_4n I608_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I103_XP_MP0 (VDD I608_P7_6 I608_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I105_XP_MP1 (I608_P9_6n I608_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I105_XP_MP0 (VDD I608_P9_8 I608_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I104_XP_MP1 (I608_P8_5n I608_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I104_XP_MP0 (VDD I608_P8_7 I608_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I7_MP1 (I608_gn7 b1_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I7_MP0 (VDD p0_6 I608_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I8_MP1 (I608_gn8 b1_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I8_MP0 (VDD p0_7 I608_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I9_MP1 (I608_gn9 b1_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I9_MP0 (VDD p0_8 I608_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I167_XP_MP1 (I562_P16_1n I562_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I167_XP_MP0 (VDD I562_P16_9 I562_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I104_XP_MP1 (I562_P8_5n I562_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I104_XP_MP0 (VDD I562_P8_7 I562_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I106_XP_MP1 (I562_P10_7n I562_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I106_XP_MP0 (VDD I562_P10_9 I562_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I105_XP_MP1 (I562_P9_6n I562_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I105_XP_MP0 (VDD I562_P9_8 I562_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I10_MP1 (I562_gn10 b0_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I10_MP0 (VDD VSS I562_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I101_XP_MP1 (I2066_P5_2n I2066_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I101_XP_MP0 (VDD I2066_P5_4 I2066_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I102_XP_MP1 (I2066_P6_3n I2066_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I102_XP_MP0 (VDD I2066_P6_5 I2066_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I104_XP_MP1 (I2066_P8_5n I2066_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I104_XP_MP0 (VDD I2066_P8_7 I2066_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I9_MP1 (I2066_gn9 dm9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I9_MP0 (VDD p31_9 I2066_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I8_MP1 (I2066_gn8 dm8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I8_MP0 (VDD p31_8 I2066_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2024_MP1 (dmn11 p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2024_MP0 (VDD dd11_b3_5 dmn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2020_MP1 (dmn9 p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2020_MP0 (VDD dd9_b3_5 dmn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I106_XP_MP1 (I1988_P10_7n I1988_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I106_XP_MP0 (VDD I1988_P10_9 I1988_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I105_XP_MP1 (I1988_P9_6n I1988_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I105_XP_MP0 (VDD I1988_P9_8 I1988_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I9_MP1 (I1988_gn9 b31_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I9_MP0 (VDD p30_8 I1988_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I104_XP_MP1 (I1942_P8_5n I1942_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I104_XP_MP0 (VDD I1942_P8_7 I1942_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I7_MP1 (I1942_gn7 b30_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I7_MP0 (VDD p29_6 I1942_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I6_MP1 (I1896_gn6 b29_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I6_MP0 (VDD p28_5 I1896_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I7_MP1 (I1896_gn7 b29_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I7_MP0 (VDD p28_6 I1896_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I103_XP_MP1 (I1850_P7_4n I1850_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I103_XP_MP0 (VDD I1850_P7_6 I1850_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I105_XP_MP1 (I1850_P9_6n I1850_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I105_XP_MP0 (VDD I1850_P9_8 I1850_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I107_XP_MP1 (I1850_P11_8n I1850_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I107_XP_MP0 (VDD I1850_P11_10 I1850_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I168_XP_MP1 (I1850_P17_2n I1850_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I168_XP_MP0 (VDD I1850_P17_10 I1850_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I109_XP_MP1 (I1850_P13_10n I1850_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I109_XP_MP0 (VDD I1850_P13_12 I1850_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I111_XP_MP1 (I1850_P15_12n I1850_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I111_XP_MP0 (VDD I1850_P15_14 I1850_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I113_XP_MP1 (I1850_P17_14n I1850_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I113_XP_MP0 (VDD I1850_P17_16 I1850_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I115_XP_MP1 (I1850_P19_16n I1850_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I115_XP_MP0 (VDD I1850_P19_18 I1850_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I117_XP_MP1 (I1850_P21_18n I1850_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I117_XP_MP0 (VDD I1850_P21_20 I1850_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I176_XP_MP1 (I1850_P25_10n I1850_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I176_XP_MP0 (VDD I1850_P25_18 I1850_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I180_XP_MP1 (I1850_P29_14n I1850_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I180_XP_MP0 (VDD I1850_P29_22 I1850_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I170_XP_MP1 (I700_P19_4n I700_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I170_XP_MP0 (VDD I700_P19_12 I700_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I168_XP_MP1 (I700_P17_2n I700_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I168_XP_MP0 (VDD I700_P17_10 I700_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I107_XP_MP1 (I700_P11_8n I700_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I107_XP_MP0 (VDD I700_P11_10 I700_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I105_XP_MP1 (I700_P9_6n I700_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I105_XP_MP0 (VDD I700_P9_8 I700_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I9_MP1 (I700_gn9 b3_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I9_MP0 (VDD p2_8 I700_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I8_MP1 (I700_gn8 b3_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I8_MP0 (VDD p2_7 I700_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I100_XP_MP1 (I654_P4_1n I654_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I100_XP_MP0 (VDD I654_P4_3 I654_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I5_MP1 (I654_gn5 b2_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I5_MP0 (VDD p1_4 I654_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I4_MP1 (I654_gn4 b2_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I4_MP0 (VDD p1_3 I654_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I101_XP_MP1 (I608_P5_2n I608_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I101_XP_MP0 (VDD I608_P5_4 I608_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I100_XP_MP1 (I608_P4_1n I608_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I100_XP_MP0 (VDD I608_P4_3 I608_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I102_XP_MP1 (I608_P6_3n I608_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I102_XP_MP0 (VDD I608_P6_5 I608_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I5_MP1 (I608_gn5 b1_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I5_MP0 (VDD p0_4 I608_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I6_MP1 (I608_gn6 b1_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I6_MP0 (VDD p0_5 I608_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I100_XP_MP1 (I562_P4_1n I562_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I100_XP_MP0 (VDD I562_P4_3 I562_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I102_XP_MP1 (I562_P6_3n I562_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I102_XP_MP0 (VDD I562_P6_5 I562_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I101_XP_MP1 (I562_P5_2n I562_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I101_XP_MP0 (VDD I562_P5_4 I562_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I103_XP_MP1 (I562_P7_4n I562_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I103_XP_MP0 (VDD I562_P7_6 I562_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I9_MP1 (I562_gn9 b0_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I9_MP0 (VDD VSS I562_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2279_MP1 (z1_1 z0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2279_MP0 (VDD z0_2 z1_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2278_MP1 (z1_0 z0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2278_MP0 (VDD z0_0 z1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2290_MP1 (z3_0 z2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2290_MP0 (VDD z2_0 z3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I100_XP_MP1 (I2066_P4_1n I2066_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I100_XP_MP0 (VDD I2066_P4_3 I2066_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I5_MP1 (I2066_gn5 dm5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I5_MP0 (VDD p31_5 I2066_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I7_MP1 (I2066_gn7 dm7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I7_MP0 (VDD p31_7 I2066_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I6_MP1 (I2066_gn6 dm6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I6_MP0 (VDD p31_6 I2066_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2016_MP1 (dmn7 p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2016_MP0 (VDD dd7_b3_5 dmn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2014_MP1 (dmn6 p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2014_MP0 (VDD dd6_b3_5 dmn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2018_MP1 (dmn8 p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2018_MP0 (VDD dd8_b3_5 dmn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I167_XP_MP1 (I1988_P16_1n I1988_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I167_XP_MP0 (VDD I1988_P16_9 I1988_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I102_XP_MP1 (I1988_P6_3n I1988_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I102_XP_MP0 (VDD I1988_P6_5 I1988_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I104_XP_MP1 (I1988_P8_5n I1988_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I104_XP_MP0 (VDD I1988_P8_7 I1988_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I101_XP_MP1 (I1988_P5_2n I1988_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I101_XP_MP0 (VDD I1988_P5_4 I1988_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I103_XP_MP1 (I1988_P7_4n I1988_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I103_XP_MP0 (VDD I1988_P7_6 I1988_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I7_MP1 (I1988_gn7 b31_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I7_MP0 (VDD p30_6 I1988_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I6_MP1 (I1988_gn6 b31_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I6_MP0 (VDD p30_5 I1988_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I8_MP1 (I1988_gn8 b31_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I8_MP0 (VDD p30_7 I1988_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I102_XP_MP1 (I1942_P6_3n I1942_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I102_XP_MP0 (VDD I1942_P6_5 I1942_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I100_XP_MP1 (I1942_P4_1n I1942_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I100_XP_MP0 (VDD I1942_P4_3 I1942_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I101_XP_MP1 (I1942_P5_2n I1942_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I101_XP_MP0 (VDD I1942_P5_4 I1942_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I6_MP1 (I1942_gn6 b30_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I6_MP0 (VDD p29_5 I1942_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I5_MP1 (I1896_gn5 b29_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I5_MP0 (VDD p28_4 I1896_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I8_MP1 (I1896_gn8 b29_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I8_MP0 (VDD p28_7 I1896_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I101_XP_MP1 (I1850_P5_2n I1850_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I101_XP_MP0 (VDD I1850_P5_4 I1850_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I119_XP_MP1 (I1850_P23_20n I1850_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I119_XP_MP0 (VDD I1850_P23_22 I1850_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I121_XP_MP1 (I1850_P25_22n I1850_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I121_XP_MP0 (VDD I1850_P25_24 I1850_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I123_XP_MP1 (I1850_P27_24n I1850_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I123_XP_MP0 (VDD I1850_P27_26 I1850_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I125_XP_MP1 (I1850_P29_26n I1850_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I125_XP_MP0 (VDD I1850_P29_28 I1850_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I127_XP_MP1 (I1850_P31_28n I1850_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I127_XP_MP0 (VDD I1850_P31_30 I1850_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I124_XP_MP1 (I700_P28_25n I700_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I124_XP_MP0 (VDD I700_P28_27 I700_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I122_XP_MP1 (I700_P26_23n I700_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I122_XP_MP0 (VDD I700_P26_25 I700_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I120_XP_MP1 (I700_P24_21n I700_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I120_XP_MP0 (VDD I700_P24_23 I700_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I118_XP_MP1 (I700_P22_19n I700_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I118_XP_MP0 (VDD I700_P22_21 I700_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I116_XP_MP1 (I700_P20_17n I700_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I116_XP_MP0 (VDD I700_P20_19 I700_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I103_XP_MP1 (I700_P7_4n I700_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I103_XP_MP0 (VDD I700_P7_6 I700_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I7_MP1 (I700_gn7 b3_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I7_MP0 (VDD p2_6 I700_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I6_MP1 (I700_gn6 b3_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I6_MP0 (VDD p2_5 I700_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I3_MP1 (I654_gn3 b2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I3_MP0 (VDD p1_2 I654_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I1_MP1 (I654_gn1 b2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I1_MP0 (VDD p1_0 I654_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I3_MP1 (I608_gn3 b1_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I3_MP0 (VDD p0_2 I608_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I4_MP1 (I608_gn4 b1_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I4_MP0 (VDD p0_3 I608_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2294_MP1 (vn sqn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2294_MP0 (VDD Q_31 vn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I1_MP1 (I562_gn1 b0_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I1_MP0 (VDD VSS I562_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I8_MP1 (I562_gn8 b0_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I8_MP0 (VDD VSS I562_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2280_MP1 (z1_2 z0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2280_MP0 (VDD z0_4 z1_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2170_MP1 (nrkn1 R_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2170_MP0 (VDD A_31_b3_5 nrkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I3_MP1 (I2066_gn3 dm3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I3_MP0 (VDD p31_3 I2066_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I4_MP1 (I2066_gn4 dm4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I4_MP0 (VDD p31_4 I2066_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2012_MP1 (dmn5 p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2012_MP0 (VDD dd5_b3_5 dmn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I100_XP_MP1 (I1988_P4_1n I1988_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I100_XP_MP0 (VDD I1988_P4_3 I1988_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I5_MP1 (I1988_gn5 b31_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I5_MP0 (VDD p30_4 I1988_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I3_MP1 (I1942_gn3 b30_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I3_MP0 (VDD p29_2 I1942_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I4_MP1 (I1942_gn4 b30_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I4_MP0 (VDD p29_3 I1942_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I5_MP1 (I1942_gn5 b30_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I5_MP0 (VDD p29_4 I1942_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I3_MP1 (I1896_gn3 b29_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I3_MP0 (VDD p28_2 I1896_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I4_MP1 (I1896_gn4 b29_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I4_MP0 (VDD p28_3 I1896_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I167_XP_MP1 (I1850_P16_1n I1850_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I167_XP_MP0 (VDD I1850_P16_9 I1850_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I169_XP_MP1 (I1850_P18_3n I1850_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I169_XP_MP0 (VDD I1850_P18_11 I1850_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I175_XP_MP1 (I1850_P24_9n I1850_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I175_XP_MP0 (VDD I1850_P24_17 I1850_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I181_XP_MP1 (I700_P30_15n I700_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I181_XP_MP0 (VDD I700_P30_23 I700_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I173_XP_MP1 (I700_P22_7n I700_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I173_XP_MP0 (VDD I700_P22_15 I700_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I114_XP_MP1 (I700_P18_15n I700_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I114_XP_MP0 (VDD I700_P18_17 I700_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I112_XP_MP1 (I700_P16_13n I700_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I112_XP_MP0 (VDD I700_P16_15 I700_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I110_XP_MP1 (I700_P14_11n I700_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I110_XP_MP0 (VDD I700_P14_13 I700_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I108_XP_MP1 (I700_P12_9n I700_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I108_XP_MP0 (VDD I700_P12_11 I700_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I101_XP_MP1 (I700_P5_2n I700_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I101_XP_MP0 (VDD I700_P5_4 I700_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I5_MP1 (I700_gn5 b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I5_MP0 (VDD p2_4 I700_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I4_MP1 (I700_gn4 b3_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I4_MP0 (VDD p2_3 I700_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I2_MP1 (I654_gn2 b2_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I2_MP0 (VDD p1_1 I654_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI654_I0_MP1 (I654_gn0 b2_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI654_I0_MP0 (VDD aa29 I654_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I2_MP1 (I608_gn2 b1_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I2_MP0 (VDD p0_1 I608_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I0_MP1 (I608_gn0 b1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I0_MP0 (VDD aa30 I608_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I2_MP1 (I562_gn2 b0_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I2_MP0 (VDD VSS I562_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I3_MP1 (I562_gn3 b0_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I3_MP0 (VDD VSS I562_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I6_MP1 (I562_gn6 b0_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I6_MP0 (VDD VSS I562_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I7_MP1 (I562_gn7 b0_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I7_MP0 (VDD VSS I562_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2281_MP1 (z1_3 z0_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2281_MP0 (VDD z0_6 z1_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2282_MP1 (z1_4 z0_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2282_MP0 (VDD z0_8 z1_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2291_MP1 (z3_1 z2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2291_MP0 (VDD z2_2 z3_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I1_MP1 (I2066_gn1 dm1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I1_MP0 (VDD p31_1 I2066_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2283_MP1 (z1_5 z0_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2283_MP0 (VDD z0_10 z1_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I2_MP1 (I2066_gn2 dm2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I2_MP0 (VDD p31_2 I2066_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2010_MP1 (dmn4 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2010_MP0 (VDD dd4_b3_5 dmn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2008_MP1 (dmn3 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2008_MP0 (VDD dd3_b3_5 dmn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I1_MP1 (I1988_gn1 b31_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I1_MP0 (VDD p30_0 I1988_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I3_MP1 (I1988_gn3 b31_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I3_MP0 (VDD p30_2 I1988_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I4_MP1 (I1988_gn4 b31_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I4_MP0 (VDD p30_3 I1988_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2078_MP1 (nqkn1 Q_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2078_MP0 (VDD sq_b3_0 nqkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I2_MP1 (I1942_gn2 b30_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I2_MP0 (VDD p29_1 I1942_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I1_MP1 (I1896_gn1 b29_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I1_MP0 (VDD p28_0 I1896_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I2_MP1 (I1896_gn2 b29_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I2_MP0 (VDD p28_1 I1896_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I100_XP_MP1 (I1850_P4_1n I1850_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I100_XP_MP0 (VDD I1850_P4_3 I1850_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I102_XP_MP1 (I1850_P6_3n I1850_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I102_XP_MP0 (VDD I1850_P6_5 I1850_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I104_XP_MP1 (I1850_P8_5n I1850_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I104_XP_MP0 (VDD I1850_P8_7 I1850_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I106_XP_MP1 (I1850_P10_7n I1850_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I106_XP_MP0 (VDD I1850_P10_9 I1850_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I108_XP_MP1 (I1850_P12_9n I1850_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I108_XP_MP0 (VDD I1850_P12_11 I1850_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I171_XP_MP1 (I1850_P20_5n I1850_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I171_XP_MP0 (VDD I1850_P20_13 I1850_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I173_XP_MP1 (I1850_P22_7n I1850_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I173_XP_MP0 (VDD I1850_P22_15 I1850_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I177_XP_MP1 (I1850_P26_11n I1850_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I177_XP_MP0 (VDD I1850_P26_19 I1850_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I179_XP_MP1 (I1850_P28_13n I1850_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I179_XP_MP0 (VDD I1850_P28_21 I1850_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I181_XP_MP1 (I1850_P30_15n I1850_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I181_XP_MP0 (VDD I1850_P30_23 I1850_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I106_XP_MP1 (I700_P10_7n I700_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I106_XP_MP0 (VDD I700_P10_9 I700_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I104_XP_MP1 (I700_P8_5n I700_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I104_XP_MP0 (VDD I700_P8_7 I700_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I102_XP_MP1 (I700_P6_3n I700_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I102_XP_MP0 (VDD I700_P6_5 I700_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I3_MP1 (I700_gn3 b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I3_MP0 (VDD p2_2 I700_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I2_MP1 (I700_gn2 b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I2_MP0 (VDD p2_1 I700_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I1_MP1 (I700_gn1 b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I1_MP0 (VDD p2_0 I700_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI608_I1_MP1 (I608_gn1 b1_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI608_I1_MP0 (VDD p0_0 I608_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I0_MP1 (I562_gn0 b0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I0_MP0 (VDD aa31 I562_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I4_MP1 (I562_gn4 b0_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I4_MP0 (VDD VSS I562_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI562_I5_MP1 (I562_gn5 b0_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI562_I5_MP0 (VDD VSS I562_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI128_MP1 (nbkn1 B_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI128_MP0 (VDD B_31_b3_0 nbkn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2066_I0_MP1 (I2066_gn0 dm0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2066_I0_MP0 (VDD p31_0 I2066_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2002_MP1 (dmn0 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2002_MP0 (VDD B_0_b3_5 dmn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2004_MP1 (dmn1 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2004_MP0 (VDD dd1_b3_5 dmn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2006_MP1 (dmn2 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2006_MP0 (VDD dd2_b3_5 dmn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I2_MP1 (I1988_gn2 b31_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I2_MP0 (VDD p30_1 I1988_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I0_MP1 (I1942_gn0 b30_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I0_MP0 (VDD aa1 I1942_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1942_I1_MP1 (I1942_gn1 b30_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1942_I1_MP0 (VDD p29_0 I1942_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I1_MP1 (I1850_gn1 b28_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I1_MP0 (VDD p27_0 I1850_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I2_MP1 (I1850_gn2 b28_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I2_MP0 (VDD p27_1 I1850_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I3_MP1 (I1850_gn3 b28_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I3_MP0 (VDD p27_2 I1850_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I4_MP1 (I1850_gn4 b28_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I4_MP0 (VDD p27_3 I1850_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I110_XP_MP1 (I1850_P14_11n I1850_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I110_XP_MP0 (VDD I1850_P14_13 I1850_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I112_XP_MP1 (I1850_P16_13n I1850_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I112_XP_MP0 (VDD I1850_P16_15 I1850_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I114_XP_MP1 (I1850_P18_15n I1850_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I114_XP_MP0 (VDD I1850_P18_17 I1850_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I116_XP_MP1 (I1850_P20_17n I1850_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I116_XP_MP0 (VDD I1850_P20_19 I1850_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I118_XP_MP1 (I1850_P22_19n I1850_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I118_XP_MP0 (VDD I1850_P22_21 I1850_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I120_XP_MP1 (I1850_P24_21n I1850_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I120_XP_MP0 (VDD I1850_P24_23 I1850_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I122_XP_MP1 (I1850_P26_23n I1850_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I122_XP_MP0 (VDD I1850_P26_25 I1850_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I124_XP_MP1 (I1850_P28_25n I1850_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I124_XP_MP0 (VDD I1850_P28_27 I1850_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I179_XP_MP1 (I700_P28_13n I700_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I179_XP_MP0 (VDD I700_P28_21 I700_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I177_XP_MP1 (I700_P26_11n I700_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I177_XP_MP0 (VDD I700_P26_19 I700_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I171_XP_MP1 (I700_P20_5n I700_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I171_XP_MP0 (VDD I700_P20_13 I700_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I175_XP_MP1 (I700_P24_9n I700_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I175_XP_MP0 (VDD I700_P24_17 I700_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I169_XP_MP1 (I700_P18_3n I700_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I169_XP_MP0 (VDD I700_P18_11 I700_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I167_XP_MP1 (I700_P16_1n I700_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I167_XP_MP0 (VDD I700_P16_9 I700_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I100_XP_MP1 (I700_P4_1n I700_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I100_XP_MP0 (VDD I700_P4_3 I700_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I3_MP1 (I746_gn3 b4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I3_MP0 (VDD p3_2 I746_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI700_I0_MP1 (I700_gn0 b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI700_I0_MP0 (VDD aa28 I700_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I0_MP1 (I746_gn0 b4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I0_MP0 (VDD aa27 I746_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2285_MP1 (z1_7 z0_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2285_MP0 (VDD z0_14 z1_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1988_I0_MP1 (I1988_gn0 b31_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1988_I0_MP0 (VDD A_0 I1988_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI36_MP1 (nakn1 A_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI36_MP0 (VDD A_31_b3_0 nakn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1896_I0_MP1 (I1896_gn0 b29_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1896_I0_MP0 (VDD aa2 I1896_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I0_MP1 (I1850_gn0 b28_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I0_MP0 (VDD aa3 I1850_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I5_MP1 (I1850_gn5 b28_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I5_MP0 (VDD p27_4 I1850_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I6_MP1 (I1850_gn6 b28_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I6_MP0 (VDD p27_5 I1850_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I10_MP1 (I1850_gn10 b28_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I10_MP0 (VDD p27_9 I1850_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I11_MP1 (I1850_gn11 b28_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I11_MP0 (VDD p27_10 I1850_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I14_MP1 (I1850_gn14 b28_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I14_MP0 (VDD p27_13 I1850_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I15_MP1 (I1850_gn15 b28_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I15_MP0 (VDD p27_14 I1850_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I126_XP_MP1 (I1850_P30_27n I1850_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I126_XP_MP0 (VDD I1850_P30_29 I1850_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I17_MP1 (I746_gn17 b4_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I17_MP0 (VDD p3_16 I746_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I11_MP1 (I746_gn11 b4_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I11_MP0 (VDD p3_10 I746_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I10_MP1 (I746_gn10 b4_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I10_MP0 (VDD p3_9 I746_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I4_MP1 (I746_gn4 b4_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I4_MP0 (VDD p3_3 I746_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I2_MP1 (I746_gn2 b4_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I2_MP0 (VDD p3_1 I746_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I1_MP1 (I746_gn1 b4_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I1_MP0 (VDD p3_0 I746_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I1_MP1 (I792_gn1 b5_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I1_MP0 (VDD p4_0 I792_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I0_MP1 (I792_gn0 b5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I0_MP0 (VDD aa26 I792_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I1_MP1 (I838_gn1 b6_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I1_MP0 (VDD p5_0 I838_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I0_MP1 (I838_gn0 b6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I0_MP0 (VDD aa25 I838_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI2284_MP1 (z1_6 z0_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI2284_MP0 (VDD z0_12 z1_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I7_MP1 (I1850_gn7 b28_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I7_MP0 (VDD p27_6 I1850_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I8_MP1 (I1850_gn8 b28_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I8_MP0 (VDD p27_7 I1850_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I9_MP1 (I1850_gn9 b28_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I9_MP0 (VDD p27_8 I1850_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I12_MP1 (I1850_gn12 b28_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I12_MP0 (VDD p27_11 I1850_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I16_MP1 (I1850_gn16 b28_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I16_MP0 (VDD p27_15 I1850_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I21_MP1 (I1850_gn21 b28_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I21_MP0 (VDD p27_20 I1850_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I22_MP1 (I1850_gn22 b28_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I22_MP0 (VDD p27_21 I1850_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I28_MP1 (I1850_gn28 b28_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I28_MP0 (VDD p27_27 I1850_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I21_MP1 (I746_gn21 b4_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I21_MP0 (VDD p3_20 I746_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I20_MP1 (I746_gn20 b4_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I20_MP0 (VDD p3_19 I746_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I16_MP1 (I746_gn16 b4_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I16_MP0 (VDD p3_15 I746_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I15_MP1 (I746_gn15 b4_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I15_MP0 (VDD p3_14 I746_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I9_MP1 (I746_gn9 b4_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I9_MP0 (VDD p3_8 I746_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I7_MP1 (I746_gn7 b4_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I7_MP0 (VDD p3_6 I746_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I6_MP1 (I746_gn6 b4_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I6_MP0 (VDD p3_5 I746_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I5_MP1 (I746_gn5 b4_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I5_MP0 (VDD p3_4 I746_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I3_MP1 (I792_gn3 b5_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I3_MP0 (VDD p4_2 I792_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I2_MP1 (I792_gn2 b5_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I2_MP0 (VDD p4_1 I792_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I3_MP1 (I838_gn3 b6_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I3_MP0 (VDD p5_2 I838_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I2_MP1 (I838_gn2 b6_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I2_MP0 (VDD p5_1 I838_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I1_MP1 (I884_gn1 b7_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I1_MP0 (VDD p6_0 I884_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I3_MP1 (I884_gn3 b7_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I3_MP0 (VDD p6_2 I884_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I2_MP1 (I884_gn2 b7_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I2_MP0 (VDD p6_1 I884_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I0_MP1 (I1712_gn0 b25_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I0_MP0 (VDD aa6 I1712_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I0_MP1 (I1758_gn0 b26_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I0_MP0 (VDD aa5 I1758_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I0_MP1 (I1804_gn0 b27_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I0_MP0 (VDD aa4 I1804_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I1_MP1 (I1804_gn1 b27_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I1_MP0 (VDD p26_0 I1804_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I2_MP1 (I1804_gn2 b27_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I2_MP0 (VDD p26_1 I1804_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I13_MP1 (I1850_gn13 b28_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I13_MP0 (VDD p27_12 I1850_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I17_MP1 (I1850_gn17 b28_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I17_MP0 (VDD p27_16 I1850_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I18_MP1 (I1850_gn18 b28_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I18_MP0 (VDD p27_17 I1850_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I19_MP1 (I1850_gn19 b28_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I19_MP0 (VDD p27_18 I1850_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I20_MP1 (I1850_gn20 b28_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I20_MP0 (VDD p27_19 I1850_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I23_MP1 (I1850_gn23 b28_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I23_MP0 (VDD p27_22 I1850_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I29_MP1 (I1850_gn29 b28_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I29_MP0 (VDD p27_28 I1850_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I22_MP1 (I746_gn22 b4_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I22_MP0 (VDD p3_21 I746_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I19_MP1 (I746_gn19 b4_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I19_MP0 (VDD p3_18 I746_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I14_MP1 (I746_gn14 b4_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I14_MP0 (VDD p3_13 I746_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I13_MP1 (I746_gn13 b4_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I13_MP0 (VDD p3_12 I746_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I12_MP1 (I746_gn12 b4_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I12_MP0 (VDD p3_11 I746_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I8_MP1 (I746_gn8 b4_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I8_MP0 (VDD p3_7 I746_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I7_MP1 (I792_gn7 b5_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I7_MP0 (VDD p4_6 I792_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I6_MP1 (I792_gn6 b5_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I6_MP0 (VDD p4_5 I792_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I5_MP1 (I792_gn5 b5_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I5_MP0 (VDD p4_4 I792_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I4_MP1 (I792_gn4 b5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I4_MP0 (VDD p4_3 I792_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I5_MP1 (I838_gn5 b6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I5_MP0 (VDD p5_4 I838_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I6_MP1 (I838_gn6 b6_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I6_MP0 (VDD p5_5 I838_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I4_MP1 (I838_gn4 b6_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I4_MP0 (VDD p5_3 I838_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I100_XP_MP1 (I838_P4_1n I838_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I100_XP_MP0 (VDD I838_P4_3 I838_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I0_MP1 (I884_gn0 b7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I0_MP0 (VDD aa24 I884_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I5_MP1 (I884_gn5 b7_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I5_MP0 (VDD p6_4 I884_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I4_MP1 (I884_gn4 b7_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I4_MP0 (VDD p6_3 I884_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I100_XP_MP1 (I1712_P4_1n I1712_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I100_XP_MP0 (VDD I1712_P4_3 I1712_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I2_MP1 (I1712_gn2 b25_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I2_MP0 (VDD p24_1 I1712_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I3_MP1 (I1712_gn3 b25_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I3_MP0 (VDD p24_2 I1712_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I1_MP1 (I1712_gn1 b25_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I1_MP0 (VDD p24_0 I1712_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I2_MP1 (I1758_gn2 b26_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I2_MP0 (VDD p25_1 I1758_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I3_MP1 (I1758_gn3 b26_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I3_MP0 (VDD p25_2 I1758_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I1_MP1 (I1758_gn1 b26_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I1_MP0 (VDD p25_0 I1758_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I3_MP1 (I1804_gn3 b27_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I3_MP0 (VDD p26_2 I1804_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I100_XP_MP1 (I1804_P4_1n I1804_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I100_XP_MP0 (VDD I1804_P4_3 I1804_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I102_XP_MP1 (I1804_P6_3n I1804_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I102_XP_MP0 (VDD I1804_P6_5 I1804_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I25_MP1 (I1850_gn25 b28_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I25_MP0 (VDD p27_24 I1850_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I27_MP1 (I1850_gn27 b28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I27_MP0 (VDD p27_26 I1850_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I26_MP1 (I1850_gn26 b28_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I26_MP0 (VDD p27_25 I1850_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I30_MP1 (I1850_gn30 b28_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I30_MP0 (VDD p27_29 I1850_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I23_MP1 (I746_gn23 b4_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I23_MP0 (VDD p3_22 I746_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I18_MP1 (I746_gn18 b4_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I18_MP0 (VDD p3_17 I746_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I105_XP_MP1 (I746_P9_6n I746_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I105_XP_MP0 (VDD I746_P9_8 I746_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I103_XP_MP1 (I746_P7_4n I746_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I103_XP_MP0 (VDD I746_P7_6 I746_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I101_XP_MP1 (I746_P5_2n I746_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I101_XP_MP0 (VDD I746_P5_4 I746_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I8_MP1 (I792_gn8 b5_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I8_MP0 (VDD p4_7 I792_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I9_MP1 (I792_gn9 b5_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I9_MP0 (VDD p4_8 I792_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I103_XP_MP1 (I792_P7_4n I792_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I103_XP_MP0 (VDD I792_P7_6 I792_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I101_XP_MP1 (I792_P5_2n I792_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I101_XP_MP0 (VDD I792_P5_4 I792_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I104_XP_MP1 (I792_P8_5n I792_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I104_XP_MP0 (VDD I792_P8_7 I792_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I102_XP_MP1 (I792_P6_3n I792_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I102_XP_MP0 (VDD I792_P6_5 I792_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I100_XP_MP1 (I792_P4_1n I792_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I100_XP_MP0 (VDD I792_P4_3 I792_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I7_MP1 (I838_gn7 b6_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I7_MP0 (VDD p5_6 I838_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I101_XP_MP1 (I838_P5_2n I838_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I101_XP_MP0 (VDD I838_P5_4 I838_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I104_XP_MP1 (I838_P8_5n I838_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I104_XP_MP0 (VDD I838_P8_7 I838_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I102_XP_MP1 (I838_P6_3n I838_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I102_XP_MP0 (VDD I838_P6_5 I838_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I6_MP1 (I884_gn6 b7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I6_MP0 (VDD p6_5 I884_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I100_XP_MP1 (I884_P4_1n I884_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I100_XP_MP0 (VDD I884_P4_3 I884_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I101_XP_MP1 (I884_P5_2n I884_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I101_XP_MP0 (VDD I884_P5_4 I884_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I103_XP_MP1 (I884_P7_4n I884_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I103_XP_MP0 (VDD I884_P7_6 I884_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I167_XP_MP1 (I1712_P16_1n I1712_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I167_XP_MP0 (VDD I1712_P16_9 I1712_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I102_XP_MP1 (I1712_P6_3n I1712_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I102_XP_MP0 (VDD I1712_P6_5 I1712_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I4_MP1 (I1712_gn4 b25_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I4_MP0 (VDD p24_3 I1712_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I101_XP_MP1 (I1712_P5_2n I1712_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I101_XP_MP0 (VDD I1712_P5_4 I1712_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I4_MP1 (I1758_gn4 b26_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I4_MP0 (VDD p25_3 I1758_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I5_MP1 (I1758_gn5 b26_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I5_MP0 (VDD p25_4 I1758_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I102_XP_MP1 (I1758_P6_3n I1758_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I102_XP_MP0 (VDD I1758_P6_5 I1758_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I100_XP_MP1 (I1758_P4_1n I1758_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I100_XP_MP0 (VDD I1758_P4_3 I1758_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I101_XP_MP1 (I1758_P5_2n I1758_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I101_XP_MP0 (VDD I1758_P5_4 I1758_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I4_MP1 (I1804_gn4 b27_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I4_MP0 (VDD p26_3 I1804_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I5_MP1 (I1804_gn5 b27_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I5_MP0 (VDD p26_4 I1804_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I101_XP_MP1 (I1804_P5_2n I1804_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I101_XP_MP0 (VDD I1804_P5_4 I1804_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I104_XP_MP1 (I1804_P8_5n I1804_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I104_XP_MP0 (VDD I1804_P8_7 I1804_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I167_XP_MP1 (I1804_P16_1n I1804_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I167_XP_MP0 (VDD I1804_P16_9 I1804_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I24_MP1 (I1850_gn24 b28_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I24_MP0 (VDD p27_23 I1850_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1850_I31_MP1 (I1850_gn31 b28_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1850_I31_MP0 (VDD p27_30 I1850_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I174_XP_MP1 (I746_P23_8n I746_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I174_XP_MP0 (VDD I746_P23_16 I746_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I111_XP_MP1 (I746_P15_12n I746_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I111_XP_MP0 (VDD I746_P15_14 I746_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I109_XP_MP1 (I746_P13_10n I746_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I109_XP_MP0 (VDD I746_P13_12 I746_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I107_XP_MP1 (I746_P11_8n I746_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I107_XP_MP0 (VDD I746_P11_10 I746_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I100_XP_MP1 (I746_P4_1n I746_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I100_XP_MP0 (VDD I746_P4_3 I746_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I11_MP1 (I792_gn11 b5_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I11_MP0 (VDD p4_10 I792_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I10_MP1 (I792_gn10 b5_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I10_MP0 (VDD p4_9 I792_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I105_XP_MP1 (I792_P9_6n I792_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I105_XP_MP0 (VDD I792_P9_8 I792_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I106_XP_MP1 (I792_P10_7n I792_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I106_XP_MP0 (VDD I792_P10_9 I792_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I9_MP1 (I838_gn9 b6_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I9_MP0 (VDD p5_8 I838_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I8_MP1 (I838_gn8 b6_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I8_MP0 (VDD p5_7 I838_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I105_XP_MP1 (I838_P9_6n I838_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I105_XP_MP0 (VDD I838_P9_8 I838_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I103_XP_MP1 (I838_P7_4n I838_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I103_XP_MP0 (VDD I838_P7_6 I838_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I106_XP_MP1 (I838_P10_7n I838_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I106_XP_MP0 (VDD I838_P10_9 I838_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I167_XP_MP1 (I838_P16_1n I838_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I167_XP_MP0 (VDD I838_P16_9 I838_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I8_MP1 (I884_gn8 b7_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I8_MP0 (VDD p6_7 I884_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I7_MP1 (I884_gn7 b7_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I7_MP0 (VDD p6_6 I884_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I104_XP_MP1 (I884_P8_5n I884_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I104_XP_MP0 (VDD I884_P8_7 I884_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I102_XP_MP1 (I884_P6_3n I884_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I102_XP_MP0 (VDD I884_P6_5 I884_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I104_XP_MP1 (I1712_P8_5n I1712_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I104_XP_MP0 (VDD I1712_P8_7 I1712_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I6_MP1 (I1712_gn6 b25_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I6_MP0 (VDD p24_5 I1712_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I5_MP1 (I1712_gn5 b25_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I5_MP0 (VDD p24_4 I1712_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I103_XP_MP1 (I1712_P7_4n I1712_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I103_XP_MP0 (VDD I1712_P7_6 I1712_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I6_MP1 (I1758_gn6 b26_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I6_MP0 (VDD p25_5 I1758_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I7_MP1 (I1758_gn7 b26_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I7_MP0 (VDD p25_6 I1758_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I104_XP_MP1 (I1758_P8_5n I1758_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I104_XP_MP0 (VDD I1758_P8_7 I1758_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I167_XP_MP1 (I1758_P16_1n I1758_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I167_XP_MP0 (VDD I1758_P16_9 I1758_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I103_XP_MP1 (I1758_P7_4n I1758_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I103_XP_MP0 (VDD I1758_P7_6 I1758_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I7_MP1 (I1804_gn7 b27_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I7_MP0 (VDD p26_6 I1804_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I6_MP1 (I1804_gn6 b27_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I6_MP0 (VDD p26_5 I1804_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I103_XP_MP1 (I1804_P7_4n I1804_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I103_XP_MP0 (VDD I1804_P7_6 I1804_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I106_XP_MP1 (I1804_P10_7n I1804_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I106_XP_MP0 (VDD I1804_P10_9 I1804_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I108_XP_MP1 (I1804_P12_9n I1804_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I108_XP_MP0 (VDD I1804_P12_11 I1804_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I169_XP_MP1 (I1804_P18_3n I1804_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I169_XP_MP0 (VDD I1804_P18_11 I1804_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I175_XP_MP1 (I1804_P24_9n I1804_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I175_XP_MP0 (VDD I1804_P24_17 I1804_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I170_XP_MP1 (I746_P19_4n I746_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I170_XP_MP0 (VDD I746_P19_12 I746_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I117_XP_MP1 (I746_P21_18n I746_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I117_XP_MP0 (VDD I746_P21_20 I746_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I115_XP_MP1 (I746_P19_16n I746_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I115_XP_MP0 (VDD I746_P19_18 I746_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I113_XP_MP1 (I746_P17_14n I746_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I113_XP_MP0 (VDD I746_P17_16 I746_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I168_XP_MP1 (I746_P17_2n I746_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I168_XP_MP0 (VDD I746_P17_10 I746_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I104_XP_MP1 (I746_P8_5n I746_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I104_XP_MP0 (VDD I746_P8_7 I746_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I102_XP_MP1 (I746_P6_3n I746_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I102_XP_MP0 (VDD I746_P6_5 I746_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I18_MP1 (I792_gn18 b5_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I18_MP0 (VDD p4_17 I792_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I17_MP1 (I792_gn17 b5_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I17_MP0 (VDD p4_16 I792_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I12_MP1 (I792_gn12 b5_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I12_MP0 (VDD p4_11 I792_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I13_MP1 (I792_gn13 b5_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I13_MP0 (VDD p4_12 I792_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I107_XP_MP1 (I792_P11_8n I792_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I107_XP_MP0 (VDD I792_P11_10 I792_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I168_XP_MP1 (I792_P17_2n I792_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I168_XP_MP0 (VDD I792_P17_10 I792_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I108_XP_MP1 (I792_P12_9n I792_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I108_XP_MP0 (VDD I792_P12_11 I792_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I167_XP_MP1 (I792_P16_1n I792_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I167_XP_MP0 (VDD I792_P16_9 I792_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I10_MP1 (I838_gn10 b6_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I10_MP0 (VDD p5_9 I838_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I109_XP_MP1 (I838_P13_10n I838_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I109_XP_MP0 (VDD I838_P13_12 I838_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I107_XP_MP1 (I838_P11_8n I838_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I107_XP_MP0 (VDD I838_P11_10 I838_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I168_XP_MP1 (I838_P17_2n I838_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I168_XP_MP0 (VDD I838_P17_10 I838_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I108_XP_MP1 (I838_P12_9n I838_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I108_XP_MP0 (VDD I838_P12_11 I838_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I175_XP_MP1 (I838_P24_9n I838_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I175_XP_MP0 (VDD I838_P24_17 I838_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I169_XP_MP1 (I838_P18_3n I838_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I169_XP_MP0 (VDD I838_P18_11 I838_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I9_MP1 (I884_gn9 b7_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I9_MP0 (VDD p6_8 I884_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I10_MP1 (I884_gn10 b7_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I10_MP0 (VDD p6_9 I884_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I106_XP_MP1 (I884_P10_7n I884_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I106_XP_MP0 (VDD I884_P10_9 I884_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I167_XP_MP1 (I884_P16_1n I884_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I167_XP_MP0 (VDD I884_P16_9 I884_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I105_XP_MP1 (I884_P9_6n I884_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I105_XP_MP0 (VDD I884_P9_8 I884_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I171_XP_MP1 (I1712_P20_5n I1712_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I171_XP_MP0 (VDD I1712_P20_13 I1712_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I106_XP_MP1 (I1712_P10_7n I1712_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I106_XP_MP0 (VDD I1712_P10_9 I1712_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I7_MP1 (I1712_gn7 b25_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I7_MP0 (VDD p24_6 I1712_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I105_XP_MP1 (I1712_P9_6n I1712_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I105_XP_MP0 (VDD I1712_P9_8 I1712_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I8_MP1 (I1758_gn8 b26_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I8_MP0 (VDD p25_7 I1758_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I9_MP1 (I1758_gn9 b26_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I9_MP0 (VDD p25_8 I1758_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I106_XP_MP1 (I1758_P10_7n I1758_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I106_XP_MP0 (VDD I1758_P10_9 I1758_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I105_XP_MP1 (I1758_P9_6n I1758_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I105_XP_MP0 (VDD I1758_P9_8 I1758_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I8_MP1 (I1804_gn8 b27_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I8_MP0 (VDD p26_7 I1804_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I105_XP_MP1 (I1804_P9_6n I1804_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I105_XP_MP0 (VDD I1804_P9_8 I1804_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I107_XP_MP1 (I1804_P11_8n I1804_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I107_XP_MP0 (VDD I1804_P11_10 I1804_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I168_XP_MP1 (I1804_P17_2n I1804_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I168_XP_MP0 (VDD I1804_P17_10 I1804_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I171_XP_MP1 (I1804_P20_5n I1804_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I171_XP_MP0 (VDD I1804_P20_13 I1804_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I179_XP_MP1 (I1804_P28_13n I1804_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I179_XP_MP0 (VDD I1804_P28_21 I1804_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I177_XP_MP1 (I1804_P26_11n I1804_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I177_XP_MP0 (VDD I1804_P26_19 I1804_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I182_XP_MP1 (I746_P31_16n I746_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I182_XP_MP0 (VDD I746_P31_24 I746_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I178_XP_MP1 (I746_P27_12n I746_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I178_XP_MP0 (VDD I746_P27_20 I746_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I119_XP_MP1 (I746_P23_20n I746_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I119_XP_MP0 (VDD I746_P23_22 I746_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I172_XP_MP1 (I746_P21_6n I746_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I172_XP_MP0 (VDD I746_P21_14 I746_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I176_XP_MP1 (I746_P25_10n I746_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I176_XP_MP0 (VDD I746_P25_18 I746_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I108_XP_MP1 (I746_P12_9n I746_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I108_XP_MP0 (VDD I746_P12_11 I746_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I106_XP_MP1 (I746_P10_7n I746_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I106_XP_MP0 (VDD I746_P10_9 I746_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I167_XP_MP1 (I746_P16_1n I746_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I167_XP_MP0 (VDD I746_P16_9 I746_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I15_MP1 (I792_gn15 b5_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I15_MP0 (VDD p4_14 I792_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I109_XP_MP1 (I792_P13_10n I792_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I109_XP_MP0 (VDD I792_P13_12 I792_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I110_XP_MP1 (I792_P14_11n I792_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I110_XP_MP0 (VDD I792_P14_13 I792_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I169_XP_MP1 (I792_P18_3n I792_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I169_XP_MP0 (VDD I792_P18_11 I792_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I11_MP1 (I838_gn11 b6_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I11_MP0 (VDD p5_10 I838_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I13_MP1 (I838_gn13 b6_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I13_MP0 (VDD p5_12 I838_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I12_MP1 (I838_gn12 b6_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I12_MP0 (VDD p5_11 I838_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I176_XP_MP1 (I838_P25_10n I838_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I176_XP_MP0 (VDD I838_P25_18 I838_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I110_XP_MP1 (I838_P14_11n I838_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I110_XP_MP0 (VDD I838_P14_13 I838_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I12_MP1 (I884_gn12 b7_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I12_MP0 (VDD p6_11 I884_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I11_MP1 (I884_gn11 b7_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I11_MP0 (VDD p6_10 I884_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I108_XP_MP1 (I884_P12_9n I884_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I108_XP_MP0 (VDD I884_P12_11 I884_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I110_XP_MP1 (I884_P14_11n I884_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I110_XP_MP0 (VDD I884_P14_13 I884_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I169_XP_MP1 (I884_P18_3n I884_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I169_XP_MP0 (VDD I884_P18_11 I884_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I175_XP_MP1 (I884_P24_9n I884_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I175_XP_MP0 (VDD I884_P24_17 I884_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I107_XP_MP1 (I884_P11_8n I884_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I107_XP_MP0 (VDD I884_P11_10 I884_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I168_XP_MP1 (I884_P17_2n I884_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I168_XP_MP0 (VDD I884_P17_10 I884_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I169_XP_MP1 (I1712_P18_3n I1712_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I169_XP_MP0 (VDD I1712_P18_11 I1712_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I175_XP_MP1 (I1712_P24_9n I1712_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I175_XP_MP0 (VDD I1712_P24_17 I1712_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I108_XP_MP1 (I1712_P12_9n I1712_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I108_XP_MP0 (VDD I1712_P12_11 I1712_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I10_MP1 (I1712_gn10 b25_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I10_MP0 (VDD p24_9 I1712_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I8_MP1 (I1712_gn8 b25_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I8_MP0 (VDD p24_7 I1712_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I9_MP1 (I1712_gn9 b25_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I9_MP0 (VDD p24_8 I1712_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I168_XP_MP1 (I1712_P17_2n I1712_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I168_XP_MP0 (VDD I1712_P17_10 I1712_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I10_MP1 (I1758_gn10 b26_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I10_MP0 (VDD p25_9 I1758_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I11_MP1 (I1758_gn11 b26_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I11_MP0 (VDD p25_10 I1758_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I108_XP_MP1 (I1758_P12_9n I1758_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I108_XP_MP0 (VDD I1758_P12_11 I1758_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I175_XP_MP1 (I1758_P24_9n I1758_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I175_XP_MP0 (VDD I1758_P24_17 I1758_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I169_XP_MP1 (I1758_P18_3n I1758_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I169_XP_MP0 (VDD I1758_P18_11 I1758_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I107_XP_MP1 (I1758_P11_8n I1758_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I107_XP_MP0 (VDD I1758_P11_10 I1758_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I168_XP_MP1 (I1758_P17_2n I1758_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I168_XP_MP0 (VDD I1758_P17_10 I1758_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I9_MP1 (I1804_gn9 b27_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I9_MP0 (VDD p26_8 I1804_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I11_MP1 (I1804_gn11 b27_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I11_MP0 (VDD p26_10 I1804_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I10_MP1 (I1804_gn10 b27_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I10_MP0 (VDD p26_9 I1804_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I170_XP_MP1 (I1804_P19_4n I1804_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I170_XP_MP0 (VDD I1804_P19_12 I1804_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I110_XP_MP1 (I1804_P14_11n I1804_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I110_XP_MP0 (VDD I1804_P14_13 I1804_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I173_XP_MP1 (I1804_P22_7n I1804_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I173_XP_MP0 (VDD I1804_P22_15 I1804_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I123_XP_MP1 (I746_P27_24n I746_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I123_XP_MP0 (VDD I746_P27_26 I746_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I121_XP_MP1 (I746_P25_22n I746_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I121_XP_MP0 (VDD I746_P25_24 I746_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I180_XP_MP1 (I746_P29_14n I746_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I180_XP_MP0 (VDD I746_P29_22 I746_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I114_XP_MP1 (I746_P18_15n I746_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I114_XP_MP0 (VDD I746_P18_17 I746_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I112_XP_MP1 (I746_P16_13n I746_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I112_XP_MP0 (VDD I746_P16_15 I746_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I110_XP_MP1 (I746_P14_11n I746_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I110_XP_MP0 (VDD I746_P14_13 I746_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I19_MP1 (I792_gn19 b5_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I19_MP0 (VDD p4_18 I792_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I16_MP1 (I792_gn16 b5_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I16_MP0 (VDD p4_15 I792_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I14_MP1 (I792_gn14 b5_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I14_MP0 (VDD p4_13 I792_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I113_XP_MP1 (I792_P17_14n I792_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I113_XP_MP0 (VDD I792_P17_16 I792_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I111_XP_MP1 (I792_P15_12n I792_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I111_XP_MP0 (VDD I792_P15_14 I792_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I170_XP_MP1 (I792_P19_4n I792_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I170_XP_MP0 (VDD I792_P19_12 I792_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I114_XP_MP1 (I792_P18_15n I792_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I114_XP_MP0 (VDD I792_P18_17 I792_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I112_XP_MP1 (I792_P16_13n I792_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I112_XP_MP0 (VDD I792_P16_15 I792_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I111_XP_MP1 (I838_P15_12n I838_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I111_XP_MP0 (VDD I838_P15_14 I838_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I170_XP_MP1 (I838_P19_4n I838_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I170_XP_MP0 (VDD I838_P19_12 I838_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I172_XP_MP1 (I838_P21_6n I838_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I172_XP_MP0 (VDD I838_P21_14 I838_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I112_XP_MP1 (I838_P16_13n I838_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I112_XP_MP0 (VDD I838_P16_15 I838_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I171_XP_MP1 (I838_P20_5n I838_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I171_XP_MP0 (VDD I838_P20_13 I838_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I177_XP_MP1 (I838_P26_11n I838_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I177_XP_MP0 (VDD I838_P26_19 I838_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I13_MP1 (I884_gn13 b7_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I13_MP0 (VDD p6_12 I884_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I14_MP1 (I884_gn14 b7_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I14_MP0 (VDD p6_13 I884_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I112_XP_MP1 (I884_P16_13n I884_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I112_XP_MP0 (VDD I884_P16_15 I884_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I177_XP_MP1 (I884_P26_11n I884_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I177_XP_MP0 (VDD I884_P26_19 I884_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I109_XP_MP1 (I884_P13_10n I884_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I109_XP_MP0 (VDD I884_P13_12 I884_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I176_XP_MP1 (I884_P25_10n I884_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I176_XP_MP0 (VDD I884_P25_18 I884_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I112_XP_MP1 (I1712_P16_13n I1712_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I112_XP_MP0 (VDD I1712_P16_15 I1712_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I110_XP_MP1 (I1712_P14_11n I1712_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I110_XP_MP0 (VDD I1712_P14_13 I1712_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I11_MP1 (I1712_gn11 b25_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I11_MP0 (VDD p24_10 I1712_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I107_XP_MP1 (I1712_P11_8n I1712_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I107_XP_MP0 (VDD I1712_P11_10 I1712_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I12_MP1 (I1758_gn12 b26_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I12_MP0 (VDD p25_11 I1758_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I110_XP_MP1 (I1758_P14_11n I1758_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I110_XP_MP0 (VDD I1758_P14_13 I1758_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I171_XP_MP1 (I1758_P20_5n I1758_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I171_XP_MP0 (VDD I1758_P20_13 I1758_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I109_XP_MP1 (I1758_P13_10n I1758_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I109_XP_MP0 (VDD I1758_P13_12 I1758_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I176_XP_MP1 (I1758_P25_10n I1758_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I176_XP_MP0 (VDD I1758_P25_18 I1758_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I13_MP1 (I1804_gn13 b27_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I13_MP0 (VDD p26_12 I1804_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I12_MP1 (I1804_gn12 b27_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I12_MP0 (VDD p26_11 I1804_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I109_XP_MP1 (I1804_P13_10n I1804_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I109_XP_MP0 (VDD I1804_P13_12 I1804_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I112_XP_MP1 (I1804_P16_13n I1804_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I112_XP_MP0 (VDD I1804_P16_15 I1804_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I114_XP_MP1 (I1804_P18_15n I1804_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I114_XP_MP0 (VDD I1804_P18_17 I1804_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I116_XP_MP1 (I1804_P20_17n I1804_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I116_XP_MP0 (VDD I1804_P20_19 I1804_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I181_XP_MP1 (I1804_P30_15n I1804_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I181_XP_MP0 (VDD I1804_P30_23 I1804_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I24_MP1 (I746_gn24 b4_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I24_MP0 (VDD p3_23 I746_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I25_MP1 (I746_gn25 b4_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I25_MP0 (VDD p3_24 I746_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I120_XP_MP1 (I746_P24_21n I746_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I120_XP_MP0 (VDD I746_P24_23 I746_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I118_XP_MP1 (I746_P22_19n I746_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I118_XP_MP0 (VDD I746_P22_21 I746_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I116_XP_MP1 (I746_P20_17n I746_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I116_XP_MP0 (VDD I746_P20_19 I746_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I175_XP_MP1 (I746_P24_9n I746_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I175_XP_MP0 (VDD I746_P24_17 I746_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I171_XP_MP1 (I746_P20_5n I746_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I171_XP_MP0 (VDD I746_P20_13 I746_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I169_XP_MP1 (I746_P18_3n I746_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I169_XP_MP0 (VDD I746_P18_11 I746_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I21_MP1 (I792_gn21 b5_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I21_MP0 (VDD p4_20 I792_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I20_MP1 (I792_gn20 b5_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I20_MP0 (VDD p4_19 I792_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I115_XP_MP1 (I792_P19_16n I792_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I115_XP_MP0 (VDD I792_P19_18 I792_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I116_XP_MP1 (I792_P20_17n I792_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I116_XP_MP0 (VDD I792_P20_19 I792_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I171_XP_MP1 (I792_P20_5n I792_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I171_XP_MP0 (VDD I792_P20_13 I792_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I175_XP_MP1 (I792_P24_9n I792_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I175_XP_MP0 (VDD I792_P24_17 I792_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I14_MP1 (I838_gn14 b6_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I14_MP0 (VDD p5_13 I838_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I113_XP_MP1 (I838_P17_14n I838_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I113_XP_MP0 (VDD I838_P17_16 I838_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I180_XP_MP1 (I838_P29_14n I838_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I180_XP_MP0 (VDD I838_P29_22 I838_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I114_XP_MP1 (I838_P18_15n I838_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I114_XP_MP0 (VDD I838_P18_17 I838_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I116_XP_MP1 (I838_P20_17n I838_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I116_XP_MP0 (VDD I838_P20_19 I838_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I15_MP1 (I884_gn15 b7_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I15_MP0 (VDD p6_14 I884_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I16_MP1 (I884_gn16 b7_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I16_MP0 (VDD p6_15 I884_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I114_XP_MP1 (I884_P18_15n I884_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I114_XP_MP0 (VDD I884_P18_17 I884_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I171_XP_MP1 (I884_P20_5n I884_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I171_XP_MP0 (VDD I884_P20_13 I884_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I111_XP_MP1 (I884_P15_12n I884_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I111_XP_MP0 (VDD I884_P15_14 I884_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I113_XP_MP1 (I884_P17_14n I884_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I113_XP_MP0 (VDD I884_P17_16 I884_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I172_XP_MP1 (I884_P21_6n I884_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I172_XP_MP0 (VDD I884_P21_14 I884_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I173_XP_MP1 (I1712_P22_7n I1712_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I173_XP_MP0 (VDD I1712_P22_15 I1712_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I179_XP_MP1 (I1712_P28_13n I1712_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I179_XP_MP0 (VDD I1712_P28_21 I1712_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I12_MP1 (I1712_gn12 b25_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I12_MP0 (VDD p24_11 I1712_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I13_MP1 (I1712_gn13 b25_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I13_MP0 (VDD p24_12 I1712_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I109_XP_MP1 (I1712_P13_10n I1712_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I109_XP_MP0 (VDD I1712_P13_12 I1712_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I176_XP_MP1 (I1712_P25_10n I1712_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I176_XP_MP0 (VDD I1712_P25_18 I1712_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I170_XP_MP1 (I1712_P19_4n I1712_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I170_XP_MP0 (VDD I1712_P19_12 I1712_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I14_MP1 (I1758_gn14 b26_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I14_MP0 (VDD p25_13 I1758_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I13_MP1 (I1758_gn13 b26_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I13_MP0 (VDD p25_12 I1758_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I112_XP_MP1 (I1758_P16_13n I1758_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I112_XP_MP0 (VDD I1758_P16_15 I1758_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I177_XP_MP1 (I1758_P26_11n I1758_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I177_XP_MP0 (VDD I1758_P26_19 I1758_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I111_XP_MP1 (I1758_P15_12n I1758_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I111_XP_MP0 (VDD I1758_P15_14 I1758_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I113_XP_MP1 (I1758_P17_14n I1758_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I113_XP_MP0 (VDD I1758_P17_16 I1758_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I172_XP_MP1 (I1758_P21_6n I1758_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I172_XP_MP0 (VDD I1758_P21_14 I1758_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I170_XP_MP1 (I1758_P19_4n I1758_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I170_XP_MP0 (VDD I1758_P19_12 I1758_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I15_MP1 (I1804_gn15 b27_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I15_MP0 (VDD p26_14 I1804_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I14_MP1 (I1804_gn14 b27_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I14_MP0 (VDD p26_13 I1804_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I111_XP_MP1 (I1804_P15_12n I1804_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I111_XP_MP0 (VDD I1804_P15_14 I1804_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I113_XP_MP1 (I1804_P17_14n I1804_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I113_XP_MP0 (VDD I1804_P17_16 I1804_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I176_XP_MP1 (I1804_P25_10n I1804_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I176_XP_MP0 (VDD I1804_P25_18 I1804_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I172_XP_MP1 (I1804_P21_6n I1804_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I172_XP_MP0 (VDD I1804_P21_14 I1804_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I118_XP_MP1 (I1804_P22_19n I1804_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I118_XP_MP0 (VDD I1804_P22_21 I1804_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I127_XP_MP1 (I746_P31_28n I746_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I127_XP_MP0 (VDD I746_P31_30 I746_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I125_XP_MP1 (I746_P29_26n I746_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I125_XP_MP0 (VDD I746_P29_28 I746_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I26_MP1 (I746_gn26 b4_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I26_MP0 (VDD p3_25 I746_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I124_XP_MP1 (I746_P28_25n I746_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I124_XP_MP0 (VDD I746_P28_27 I746_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I179_XP_MP1 (I746_P28_13n I746_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I179_XP_MP0 (VDD I746_P28_21 I746_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I173_XP_MP1 (I746_P22_7n I746_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I173_XP_MP0 (VDD I746_P22_15 I746_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I25_MP1 (I792_gn25 b5_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I25_MP0 (VDD p4_24 I792_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I23_MP1 (I792_gn23 b5_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I23_MP0 (VDD p4_22 I792_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I22_MP1 (I792_gn22 b5_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I22_MP0 (VDD p4_21 I792_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I117_XP_MP1 (I792_P21_18n I792_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I117_XP_MP0 (VDD I792_P21_20 I792_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I172_XP_MP1 (I792_P21_6n I792_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I172_XP_MP0 (VDD I792_P21_14 I792_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I176_XP_MP1 (I792_P25_10n I792_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I176_XP_MP0 (VDD I792_P25_18 I792_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I179_XP_MP1 (I792_P28_13n I792_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I179_XP_MP0 (VDD I792_P28_21 I792_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I15_MP1 (I838_gn15 b6_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I15_MP0 (VDD p5_14 I838_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I16_MP1 (I838_gn16 b6_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I16_MP0 (VDD p5_15 I838_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I115_XP_MP1 (I838_P19_16n I838_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I115_XP_MP0 (VDD I838_P19_18 I838_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I178_XP_MP1 (I838_P27_12n I838_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I178_XP_MP0 (VDD I838_P27_20 I838_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I117_XP_MP1 (I838_P21_18n I838_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I117_XP_MP0 (VDD I838_P21_20 I838_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I18_MP1 (I838_gn18 b6_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I18_MP0 (VDD p5_17 I838_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I179_XP_MP1 (I838_P28_13n I838_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I179_XP_MP0 (VDD I838_P28_21 I838_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I173_XP_MP1 (I838_P22_7n I838_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I173_XP_MP0 (VDD I838_P22_15 I838_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I116_XP_MP1 (I884_P20_17n I884_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I116_XP_MP0 (VDD I884_P20_19 I884_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I173_XP_MP1 (I884_P22_7n I884_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I173_XP_MP0 (VDD I884_P22_15 I884_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I115_XP_MP1 (I884_P19_16n I884_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I115_XP_MP0 (VDD I884_P19_18 I884_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I177_XP_MP1 (I1712_P26_11n I1712_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I177_XP_MP0 (VDD I1712_P26_19 I1712_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I114_XP_MP1 (I1712_P18_15n I1712_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I114_XP_MP0 (VDD I1712_P18_17 I1712_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I14_MP1 (I1712_gn14 b25_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I14_MP0 (VDD p24_13 I1712_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I15_MP1 (I1712_gn15 b25_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I15_MP0 (VDD p24_14 I1712_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I113_XP_MP1 (I1712_P17_14n I1712_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I113_XP_MP0 (VDD I1712_P17_16 I1712_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I111_XP_MP1 (I1712_P15_12n I1712_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I111_XP_MP0 (VDD I1712_P15_14 I1712_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I172_XP_MP1 (I1712_P21_6n I1712_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I172_XP_MP0 (VDD I1712_P21_14 I1712_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I16_MP1 (I1758_gn16 b26_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I16_MP0 (VDD p25_15 I1758_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I15_MP1 (I1758_gn15 b26_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I15_MP0 (VDD p25_14 I1758_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I114_XP_MP1 (I1758_P18_15n I1758_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I114_XP_MP0 (VDD I1758_P18_17 I1758_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I116_XP_MP1 (I1758_P20_17n I1758_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I116_XP_MP0 (VDD I1758_P20_19 I1758_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I179_XP_MP1 (I1758_P28_13n I1758_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I179_XP_MP0 (VDD I1758_P28_21 I1758_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I115_XP_MP1 (I1758_P19_16n I1758_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I115_XP_MP0 (VDD I1758_P19_18 I1758_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I16_MP1 (I1804_gn16 b27_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I16_MP0 (VDD p26_15 I1804_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I17_MP1 (I1804_gn17 b27_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I17_MP0 (VDD p26_16 I1804_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I178_XP_MP1 (I1804_P27_12n I1804_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I178_XP_MP0 (VDD I1804_P27_20 I1804_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I115_XP_MP1 (I1804_P19_16n I1804_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I115_XP_MP0 (VDD I1804_P19_18 I1804_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I120_XP_MP1 (I1804_P24_21n I1804_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I120_XP_MP0 (VDD I1804_P24_23 I1804_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I122_XP_MP1 (I1804_P26_23n I1804_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I122_XP_MP0 (VDD I1804_P26_25 I1804_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I31_MP1 (I746_gn31 b4_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I31_MP0 (VDD p3_30 I746_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I27_MP1 (I746_gn27 b4_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I27_MP0 (VDD p3_26 I746_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I122_XP_MP1 (I746_P26_23n I746_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I122_XP_MP0 (VDD I746_P26_25 I746_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I177_XP_MP1 (I746_P26_11n I746_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I177_XP_MP0 (VDD I746_P26_19 I746_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I24_MP1 (I792_gn24 b5_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I24_MP0 (VDD p4_23 I792_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I121_XP_MP1 (I792_P25_22n I792_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I121_XP_MP0 (VDD I792_P25_24 I792_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I119_XP_MP1 (I792_P23_20n I792_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I119_XP_MP0 (VDD I792_P23_22 I792_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I180_XP_MP1 (I792_P29_14n I792_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I180_XP_MP0 (VDD I792_P29_22 I792_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I120_XP_MP1 (I792_P24_21n I792_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I120_XP_MP0 (VDD I792_P24_23 I792_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I118_XP_MP1 (I792_P22_19n I792_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I118_XP_MP0 (VDD I792_P22_21 I792_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I173_XP_MP1 (I792_P22_7n I792_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I173_XP_MP0 (VDD I792_P22_15 I792_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I17_MP1 (I838_gn17 b6_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I17_MP0 (VDD p5_16 I838_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I182_XP_MP1 (I838_P31_16n I838_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I182_XP_MP0 (VDD I838_P31_24 I838_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I174_XP_MP1 (I838_P23_8n I838_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I174_XP_MP0 (VDD I838_P23_16 I838_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I19_MP1 (I838_gn19 b6_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I19_MP0 (VDD p5_18 I838_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I118_XP_MP1 (I838_P22_19n I838_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I118_XP_MP0 (VDD I838_P22_21 I838_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I17_MP1 (I884_gn17 b7_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I17_MP0 (VDD p6_16 I884_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I18_MP1 (I884_gn18 b7_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I18_MP0 (VDD p6_17 I884_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I118_XP_MP1 (I884_P22_19n I884_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I118_XP_MP0 (VDD I884_P22_21 I884_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I179_XP_MP1 (I884_P28_13n I884_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I179_XP_MP0 (VDD I884_P28_21 I884_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I117_XP_MP1 (I884_P21_18n I884_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I117_XP_MP0 (VDD I884_P21_20 I884_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I170_XP_MP1 (I884_P19_4n I884_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I170_XP_MP0 (VDD I884_P19_12 I884_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I116_XP_MP1 (I1712_P20_17n I1712_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I116_XP_MP0 (VDD I1712_P20_19 I1712_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I16_MP1 (I1712_gn16 b25_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I16_MP0 (VDD p24_15 I1712_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I178_XP_MP1 (I1712_P27_12n I1712_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I178_XP_MP0 (VDD I1712_P27_20 I1712_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I17_MP1 (I1758_gn17 b26_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I17_MP0 (VDD p25_16 I1758_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I18_MP1 (I1758_gn18 b26_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I18_MP0 (VDD p25_17 I1758_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I118_XP_MP1 (I1758_P22_19n I1758_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I118_XP_MP0 (VDD I1758_P22_21 I1758_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I173_XP_MP1 (I1758_P22_7n I1758_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I173_XP_MP0 (VDD I1758_P22_15 I1758_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I117_XP_MP1 (I1758_P21_18n I1758_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I117_XP_MP0 (VDD I1758_P21_20 I1758_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I178_XP_MP1 (I1758_P27_12n I1758_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I178_XP_MP0 (VDD I1758_P27_20 I1758_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I19_MP1 (I1804_gn19 b27_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I19_MP0 (VDD p26_18 I1804_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I18_MP1 (I1804_gn18 b27_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I18_MP0 (VDD p26_17 I1804_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I20_MP1 (I1804_gn20 b27_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I20_MP0 (VDD p26_19 I1804_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I174_XP_MP1 (I1804_P23_8n I1804_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I174_XP_MP0 (VDD I1804_P23_16 I1804_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I117_XP_MP1 (I1804_P21_18n I1804_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I117_XP_MP0 (VDD I1804_P21_20 I1804_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I180_XP_MP1 (I1804_P29_14n I1804_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I180_XP_MP0 (VDD I1804_P29_22 I1804_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I124_XP_MP1 (I1804_P28_25n I1804_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I124_XP_MP0 (VDD I1804_P28_27 I1804_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I126_XP_MP1 (I1804_P30_27n I1804_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I126_XP_MP0 (VDD I1804_P30_29 I1804_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I30_MP1 (I746_gn30 b4_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I30_MP0 (VDD p3_29 I746_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I28_MP1 (I746_gn28 b4_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I28_MP0 (VDD p3_27 I746_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I126_XP_MP1 (I746_P30_27n I746_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I126_XP_MP0 (VDD I746_P30_29 I746_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I181_XP_MP1 (I746_P30_15n I746_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I181_XP_MP0 (VDD I746_P30_23 I746_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I27_MP1 (I792_gn27 b5_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I27_MP0 (VDD p4_26 I792_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I26_MP1 (I792_gn26 b5_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I26_MP0 (VDD p4_25 I792_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I123_XP_MP1 (I792_P27_24n I792_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I123_XP_MP0 (VDD I792_P27_26 I792_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I178_XP_MP1 (I792_P27_12n I792_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I178_XP_MP0 (VDD I792_P27_20 I792_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I122_XP_MP1 (I792_P26_23n I792_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I122_XP_MP0 (VDD I792_P26_25 I792_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I124_XP_MP1 (I792_P28_25n I792_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I124_XP_MP0 (VDD I792_P28_27 I792_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I181_XP_MP1 (I792_P30_15n I792_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I181_XP_MP0 (VDD I792_P30_23 I792_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I177_XP_MP1 (I792_P26_11n I792_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I177_XP_MP0 (VDD I792_P26_19 I792_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I121_XP_MP1 (I838_P25_22n I838_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I121_XP_MP0 (VDD I838_P25_24 I838_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I119_XP_MP1 (I838_P23_20n I838_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I119_XP_MP0 (VDD I838_P23_22 I838_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I20_MP1 (I838_gn20 b6_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I20_MP0 (VDD p5_19 I838_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I21_MP1 (I838_gn21 b6_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I21_MP0 (VDD p5_20 I838_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I120_XP_MP1 (I838_P24_21n I838_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I120_XP_MP0 (VDD I838_P24_23 I838_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I181_XP_MP1 (I838_P30_15n I838_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I181_XP_MP0 (VDD I838_P30_23 I838_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I19_MP1 (I884_gn19 b7_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I19_MP0 (VDD p6_18 I884_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I21_MP1 (I884_gn21 b7_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I21_MP0 (VDD p6_20 I884_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I20_MP1 (I884_gn20 b7_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I20_MP0 (VDD p6_19 I884_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I181_XP_MP1 (I884_P30_15n I884_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I181_XP_MP0 (VDD I884_P30_23 I884_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I120_XP_MP1 (I884_P24_21n I884_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I120_XP_MP0 (VDD I884_P24_23 I884_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I119_XP_MP1 (I884_P23_20n I884_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I119_XP_MP0 (VDD I884_P23_22 I884_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I180_XP_MP1 (I884_P29_14n I884_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I180_XP_MP0 (VDD I884_P29_22 I884_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I178_XP_MP1 (I884_P27_12n I884_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I178_XP_MP0 (VDD I884_P27_20 I884_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I181_XP_MP1 (I1712_P30_15n I1712_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I181_XP_MP0 (VDD I1712_P30_23 I1712_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I120_XP_MP1 (I1712_P24_21n I1712_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I120_XP_MP0 (VDD I1712_P24_23 I1712_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I118_XP_MP1 (I1712_P22_19n I1712_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I118_XP_MP0 (VDD I1712_P22_21 I1712_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I17_MP1 (I1712_gn17 b25_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I17_MP0 (VDD p24_16 I1712_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I117_XP_MP1 (I1712_P21_18n I1712_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I117_XP_MP0 (VDD I1712_P21_20 I1712_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I115_XP_MP1 (I1712_P19_16n I1712_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I115_XP_MP0 (VDD I1712_P19_18 I1712_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I180_XP_MP1 (I1712_P29_14n I1712_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I180_XP_MP0 (VDD I1712_P29_22 I1712_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I174_XP_MP1 (I1712_P23_8n I1712_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I174_XP_MP0 (VDD I1712_P23_16 I1712_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I20_MP1 (I1758_gn20 b26_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I20_MP0 (VDD p25_19 I1758_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I19_MP1 (I1758_gn19 b26_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I19_MP0 (VDD p25_18 I1758_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I120_XP_MP1 (I1758_P24_21n I1758_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I120_XP_MP0 (VDD I1758_P24_23 I1758_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I181_XP_MP1 (I1758_P30_15n I1758_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I181_XP_MP0 (VDD I1758_P30_23 I1758_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I119_XP_MP1 (I1758_P23_20n I1758_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I119_XP_MP0 (VDD I1758_P23_22 I1758_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I180_XP_MP1 (I1758_P29_14n I1758_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I180_XP_MP0 (VDD I1758_P29_22 I1758_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I174_XP_MP1 (I1758_P23_8n I1758_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I174_XP_MP0 (VDD I1758_P23_16 I1758_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I21_MP1 (I1804_gn21 b27_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I21_MP0 (VDD p26_20 I1804_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I119_XP_MP1 (I1804_P23_20n I1804_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I119_XP_MP0 (VDD I1804_P23_22 I1804_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I121_XP_MP1 (I1804_P25_22n I1804_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I121_XP_MP0 (VDD I1804_P25_24 I1804_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I123_XP_MP1 (I1804_P27_24n I1804_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I123_XP_MP0 (VDD I1804_P27_26 I1804_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I125_XP_MP1 (I1804_P29_26n I1804_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I125_XP_MP0 (VDD I1804_P29_28 I1804_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI746_I29_MP1 (I746_gn29 b4_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI746_I29_MP0 (VDD p3_28 I746_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I31_MP1 (I792_gn31 b5_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I31_MP0 (VDD p4_30 I792_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I30_MP1 (I792_gn30 b5_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I30_MP0 (VDD p4_29 I792_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I28_MP1 (I792_gn28 b5_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I28_MP0 (VDD p4_27 I792_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I127_XP_MP1 (I792_P31_28n I792_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I127_XP_MP0 (VDD I792_P31_30 I792_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I125_XP_MP1 (I792_P29_26n I792_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I125_XP_MP0 (VDD I792_P29_28 I792_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I182_XP_MP1 (I792_P31_16n I792_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I182_XP_MP0 (VDD I792_P31_24 I792_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I174_XP_MP1 (I792_P23_8n I792_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I174_XP_MP0 (VDD I792_P23_16 I792_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I126_XP_MP1 (I792_P30_27n I792_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I126_XP_MP0 (VDD I792_P30_29 I792_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I127_XP_MP1 (I838_P31_28n I838_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I127_XP_MP0 (VDD I838_P31_30 I838_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I27_MP1 (I838_gn27 b6_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I27_MP0 (VDD p5_26 I838_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I125_XP_MP1 (I838_P29_26n I838_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I125_XP_MP0 (VDD I838_P29_28 I838_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I123_XP_MP1 (I838_P27_24n I838_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I123_XP_MP0 (VDD I838_P27_26 I838_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I23_MP1 (I838_gn23 b6_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I23_MP0 (VDD p5_22 I838_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I22_MP1 (I838_gn22 b6_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I22_MP0 (VDD p5_21 I838_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I122_XP_MP1 (I838_P26_23n I838_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I122_XP_MP0 (VDD I838_P26_25 I838_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I22_MP1 (I884_gn22 b7_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I22_MP0 (VDD p6_21 I884_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I23_MP1 (I884_gn23 b7_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I23_MP0 (VDD p6_22 I884_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I24_MP1 (I884_gn24 b7_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I24_MP0 (VDD p6_23 I884_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I122_XP_MP1 (I884_P26_23n I884_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I122_XP_MP0 (VDD I884_P26_25 I884_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I124_XP_MP1 (I884_P28_25n I884_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I124_XP_MP0 (VDD I884_P28_27 I884_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I121_XP_MP1 (I884_P25_22n I884_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I121_XP_MP0 (VDD I884_P25_24 I884_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I122_XP_MP1 (I1712_P26_23n I1712_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I122_XP_MP0 (VDD I1712_P26_25 I1712_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I18_MP1 (I1712_gn18 b25_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I18_MP0 (VDD p24_17 I1712_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I19_MP1 (I1712_gn19 b25_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I19_MP0 (VDD p24_18 I1712_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I121_XP_MP1 (I1712_P25_22n I1712_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I121_XP_MP0 (VDD I1712_P25_24 I1712_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I119_XP_MP1 (I1712_P23_20n I1712_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I119_XP_MP0 (VDD I1712_P23_22 I1712_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I182_XP_MP1 (I1712_P31_16n I1712_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I182_XP_MP0 (VDD I1712_P31_24 I1712_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I22_MP1 (I1758_gn22 b26_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I22_MP0 (VDD p25_21 I1758_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I21_MP1 (I1758_gn21 b26_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I21_MP0 (VDD p25_20 I1758_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I23_MP1 (I1758_gn23 b26_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I23_MP0 (VDD p25_22 I1758_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I122_XP_MP1 (I1758_P26_23n I1758_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I122_XP_MP0 (VDD I1758_P26_25 I1758_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I124_XP_MP1 (I1758_P28_25n I1758_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I124_XP_MP0 (VDD I1758_P28_27 I1758_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I126_XP_MP1 (I1758_P30_27n I1758_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I126_XP_MP0 (VDD I1758_P30_29 I1758_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I121_XP_MP1 (I1758_P25_22n I1758_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I121_XP_MP0 (VDD I1758_P25_24 I1758_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I125_XP_MP1 (I1758_P29_26n I1758_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I125_XP_MP0 (VDD I1758_P29_28 I1758_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I123_XP_MP1 (I1758_P27_24n I1758_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I123_XP_MP0 (VDD I1758_P27_26 I1758_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I182_XP_MP1 (I1758_P31_16n I1758_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I182_XP_MP0 (VDD I1758_P31_24 I1758_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I23_MP1 (I1804_gn23 b27_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I23_MP0 (VDD p26_22 I1804_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I182_XP_MP1 (I1804_P31_16n I1804_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I182_XP_MP0 (VDD I1804_P31_24 I1804_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I127_XP_MP1 (I1804_P31_28n I1804_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I127_XP_MP0 (VDD I1804_P31_30 I1804_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I25_MP1 (I1804_gn25 b27_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I25_MP0 (VDD p26_24 I1804_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I26_MP1 (I1804_gn26 b27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I26_MP0 (VDD p26_25 I1804_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI792_I29_MP1 (I792_gn29 b5_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI792_I29_MP0 (VDD p4_28 I792_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I31_MP1 (I838_gn31 b6_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I31_MP0 (VDD p5_30 I838_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I30_MP1 (I838_gn30 b6_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I30_MP0 (VDD p5_29 I838_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I28_MP1 (I838_gn28 b6_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I28_MP0 (VDD p5_27 I838_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I26_MP1 (I838_gn26 b6_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I26_MP0 (VDD p5_25 I838_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I24_MP1 (I838_gn24 b6_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I24_MP0 (VDD p5_23 I838_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I25_MP1 (I838_gn25 b6_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I25_MP0 (VDD p5_24 I838_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I124_XP_MP1 (I838_P28_25n I838_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I124_XP_MP0 (VDD I838_P28_27 I838_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I126_XP_MP1 (I838_P30_27n I838_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I126_XP_MP0 (VDD I838_P30_29 I838_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I25_MP1 (I884_gn25 b7_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I25_MP0 (VDD p6_24 I884_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I26_MP1 (I884_gn26 b7_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I26_MP0 (VDD p6_25 I884_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I126_XP_MP1 (I884_P30_27n I884_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I126_XP_MP0 (VDD I884_P30_29 I884_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I125_XP_MP1 (I884_P29_26n I884_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I125_XP_MP0 (VDD I884_P29_28 I884_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I123_XP_MP1 (I884_P27_24n I884_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I123_XP_MP0 (VDD I884_P27_26 I884_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I182_XP_MP1 (I884_P31_16n I884_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I182_XP_MP0 (VDD I884_P31_24 I884_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I174_XP_MP1 (I884_P23_8n I884_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I174_XP_MP0 (VDD I884_P23_16 I884_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I126_XP_MP1 (I1712_P30_27n I1712_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I126_XP_MP0 (VDD I1712_P30_29 I1712_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I124_XP_MP1 (I1712_P28_25n I1712_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I124_XP_MP0 (VDD I1712_P28_27 I1712_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I22_MP1 (I1712_gn22 b25_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I22_MP0 (VDD p24_21 I1712_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I20_MP1 (I1712_gn20 b25_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I20_MP0 (VDD p24_19 I1712_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I123_XP_MP1 (I1712_P27_24n I1712_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I123_XP_MP0 (VDD I1712_P27_26 I1712_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I125_XP_MP1 (I1712_P29_26n I1712_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I125_XP_MP0 (VDD I1712_P29_28 I1712_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I127_XP_MP1 (I1712_P31_28n I1712_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I127_XP_MP0 (VDD I1712_P31_30 I1712_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I25_MP1 (I1758_gn25 b26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I25_MP0 (VDD p25_24 I1758_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I24_MP1 (I1758_gn24 b26_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I24_MP0 (VDD p25_23 I1758_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I127_XP_MP1 (I1758_P31_28n I1758_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I127_XP_MP0 (VDD I1758_P31_30 I1758_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I22_MP1 (I1804_gn22 b27_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I22_MP0 (VDD p26_21 I1804_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I24_MP1 (I1804_gn24 b27_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I24_MP0 (VDD p26_23 I1804_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I29_MP1 (I1804_gn29 b27_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I29_MP0 (VDD p26_28 I1804_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I28_MP1 (I1804_gn28 b27_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I28_MP0 (VDD p26_27 I1804_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I27_MP1 (I1804_gn27 b27_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I27_MP0 (VDD p26_26 I1804_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I180_XP_MP1 (I1068_P29_14n I1068_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I180_XP_MP0 (VDD I1068_P29_22 I1068_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I176_XP_MP1 (I1068_P25_10n I1068_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I176_XP_MP0 (VDD I1068_P25_18 I1068_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I172_XP_MP1 (I1068_P21_6n I1068_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I172_XP_MP0 (VDD I1068_P21_14 I1068_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I168_XP_MP1 (I1068_P17_2n I1068_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I168_XP_MP0 (VDD I1068_P17_10 I1068_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I105_XP_MP1 (I1068_P9_6n I1068_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I105_XP_MP0 (VDD I1068_P9_8 I1068_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I101_XP_MP1 (I1068_P5_2n I1068_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I101_XP_MP0 (VDD I1068_P5_4 I1068_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I5_MP1 (I1068_gn5 b11_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I5_MP0 (VDD p10_4 I1068_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I4_MP1 (I1068_gn4 b11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I4_MP0 (VDD p10_3 I1068_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI838_I29_MP1 (I838_gn29 b6_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI838_I29_MP0 (VDD p5_28 I838_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I30_MP1 (I884_gn30 b7_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I30_MP0 (VDD p6_29 I884_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I127_XP_MP1 (I884_P31_28n I884_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I127_XP_MP0 (VDD I884_P31_30 I884_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I23_MP1 (I1712_gn23 b25_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I23_MP0 (VDD p24_22 I1712_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I21_MP1 (I1712_gn21 b25_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I21_MP0 (VDD p24_20 I1712_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I26_MP1 (I1758_gn26 b26_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I26_MP0 (VDD p25_25 I1758_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I27_MP1 (I1758_gn27 b26_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I27_MP0 (VDD p25_26 I1758_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I28_MP1 (I1758_gn28 b26_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I28_MP0 (VDD p25_27 I1758_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I29_MP1 (I1758_gn29 b26_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I29_MP0 (VDD p25_28 I1758_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I30_MP1 (I1758_gn30 b26_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I30_MP0 (VDD p25_29 I1758_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1758_I31_MP1 (I1758_gn31 b26_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1758_I31_MP0 (VDD p25_30 I1758_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I30_MP1 (I1804_gn30 b27_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I30_MP0 (VDD p26_29 I1804_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1804_I31_MP1 (I1804_gn31 b27_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1804_I31_MP0 (VDD p26_30 I1804_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I178_XP_MP1 (I1068_P27_12n I1068_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I178_XP_MP0 (VDD I1068_P27_20 I1068_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I174_XP_MP1 (I1068_P23_8n I1068_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I174_XP_MP0 (VDD I1068_P23_16 I1068_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I170_XP_MP1 (I1068_P19_4n I1068_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I170_XP_MP0 (VDD I1068_P19_12 I1068_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I107_XP_MP1 (I1068_P11_8n I1068_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I107_XP_MP0 (VDD I1068_P11_10 I1068_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I103_XP_MP1 (I1068_P7_4n I1068_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I103_XP_MP0 (VDD I1068_P7_6 I1068_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I6_MP1 (I1068_gn6 b11_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I6_MP0 (VDD p10_5 I1068_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I3_MP1 (I1068_gn3 b11_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I3_MP0 (VDD p10_2 I1068_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I0_MP1 (I1022_gn0 b10_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I0_MP0 (VDD aa21 I1022_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I0_MP1 (I976_gn0 b9_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I0_MP0 (VDD aa22 I976_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I0_MP1 (I930_gn0 b8_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I0_MP0 (VDD aa23 I930_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I31_MP1 (I884_gn31 b7_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I31_MP0 (VDD p6_30 I884_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I29_MP1 (I884_gn29 b7_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I29_MP0 (VDD p6_28 I884_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I28_MP1 (I884_gn28 b7_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I28_MP0 (VDD p6_27 I884_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI884_I27_MP1 (I884_gn27 b7_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI884_I27_MP0 (VDD p6_26 I884_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I26_MP1 (I1712_gn26 b25_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I26_MP0 (VDD p24_25 I1712_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I24_MP1 (I1712_gn24 b25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I24_MP0 (VDD p24_23 I1712_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I27_MP1 (I1712_gn27 b25_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I27_MP0 (VDD p24_26 I1712_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I28_MP1 (I1712_gn28 b25_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I28_MP0 (VDD p24_27 I1712_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I29_MP1 (I1712_gn29 b25_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I29_MP0 (VDD p24_28 I1712_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I31_MP1 (I1712_gn31 b25_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I31_MP0 (VDD p24_30 I1712_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I30_MP1 (I1712_gn30 b25_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I30_MP0 (VDD p24_29 I1712_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I0_MP1 (I1666_gn0 b24_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I0_MP0 (VDD aa7 I1666_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I0_MP1 (I1620_gn0 b23_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I0_MP0 (VDD aa8 I1620_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I1_MP1 (I1574_gn1 b22_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I1_MP0 (VDD p21_0 I1574_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I2_MP1 (I1574_gn2 b22_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I2_MP0 (VDD p21_1 I1574_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I3_MP1 (I1574_gn3 b22_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I3_MP0 (VDD p21_2 I1574_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I127_XP_MP1 (I1068_P31_28n I1068_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I127_XP_MP0 (VDD I1068_P31_30 I1068_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I125_XP_MP1 (I1068_P29_26n I1068_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I125_XP_MP0 (VDD I1068_P29_28 I1068_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I123_XP_MP1 (I1068_P27_24n I1068_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I123_XP_MP0 (VDD I1068_P27_26 I1068_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I121_XP_MP1 (I1068_P25_22n I1068_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I121_XP_MP0 (VDD I1068_P25_24 I1068_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I182_XP_MP1 (I1068_P31_16n I1068_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I182_XP_MP0 (VDD I1068_P31_24 I1068_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I115_XP_MP1 (I1068_P19_16n I1068_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I115_XP_MP0 (VDD I1068_P19_18 I1068_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I113_XP_MP1 (I1068_P17_14n I1068_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I113_XP_MP0 (VDD I1068_P17_16 I1068_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I111_XP_MP1 (I1068_P15_12n I1068_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I111_XP_MP0 (VDD I1068_P15_14 I1068_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I109_XP_MP1 (I1068_P13_10n I1068_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I109_XP_MP0 (VDD I1068_P13_12 I1068_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I8_MP1 (I1068_gn8 b11_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I8_MP0 (VDD p10_7 I1068_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I1_MP1 (I1068_gn1 b11_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I1_MP0 (VDD p10_0 I1068_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I2_MP1 (I1068_gn2 b11_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I2_MP0 (VDD p10_1 I1068_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I1_MP1 (I1022_gn1 b10_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I1_MP0 (VDD p9_0 I1022_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I2_MP1 (I1022_gn2 b10_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I2_MP0 (VDD p9_1 I1022_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I1_MP1 (I976_gn1 b9_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I1_MP0 (VDD p8_0 I976_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I1_MP1 (I930_gn1 b8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I1_MP0 (VDD p7_0 I930_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I2_MP1 (I930_gn2 b8_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I2_MP0 (VDD p7_1 I930_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I3_MP1 (I930_gn3 b8_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I3_MP0 (VDD p7_2 I930_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I4_MP1 (I930_gn4 b8_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I4_MP0 (VDD p7_3 I930_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I5_MP1 (I930_gn5 b8_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I5_MP0 (VDD p7_4 I930_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I7_MP1 (I930_gn7 b8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I7_MP0 (VDD p7_6 I930_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1712_I25_MP1 (I1712_gn25 b25_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1712_I25_MP0 (VDD p24_24 I1712_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I1_MP1 (I1666_gn1 b24_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I1_MP0 (VDD p23_0 I1666_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I2_MP1 (I1666_gn2 b24_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I2_MP0 (VDD p23_1 I1666_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I3_MP1 (I1666_gn3 b24_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I3_MP0 (VDD p23_2 I1666_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I2_MP1 (I1620_gn2 b23_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I2_MP0 (VDD p22_1 I1620_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I4_MP1 (I1620_gn4 b23_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I4_MP0 (VDD p22_3 I1620_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I0_MP1 (I1574_gn0 b22_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I0_MP0 (VDD aa9 I1574_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I4_MP1 (I1574_gn4 b22_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I4_MP0 (VDD p21_3 I1574_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I5_MP1 (I1574_gn5 b22_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I5_MP0 (VDD p21_4 I1574_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I100_XP_MP1 (I1574_P4_1n I1574_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I100_XP_MP0 (VDD I1574_P4_3 I1574_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I27_MP1 (I1068_gn27 b11_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I27_MP0 (VDD p10_26 I1068_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I119_XP_MP1 (I1068_P23_20n I1068_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I119_XP_MP0 (VDD I1068_P23_22 I1068_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I117_XP_MP1 (I1068_P21_18n I1068_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I117_XP_MP0 (VDD I1068_P21_20 I1068_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I177_XP_MP1 (I1068_P26_11n I1068_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I177_XP_MP0 (VDD I1068_P26_19 I1068_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I169_XP_MP1 (I1068_P18_3n I1068_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I169_XP_MP0 (VDD I1068_P18_11 I1068_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I106_XP_MP1 (I1068_P10_7n I1068_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I106_XP_MP0 (VDD I1068_P10_9 I1068_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I104_XP_MP1 (I1068_P8_5n I1068_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I104_XP_MP0 (VDD I1068_P8_7 I1068_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I102_XP_MP1 (I1068_P6_3n I1068_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I102_XP_MP0 (VDD I1068_P6_5 I1068_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I7_MP1 (I1068_gn7 b11_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I7_MP0 (VDD p10_6 I1068_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I100_XP_MP1 (I1068_P4_1n I1068_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I100_XP_MP0 (VDD I1068_P4_3 I1068_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I6_MP1 (I1022_gn6 b10_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I6_MP0 (VDD p9_5 I1022_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I4_MP1 (I1022_gn4 b10_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I4_MP0 (VDD p9_3 I1022_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I3_MP1 (I1022_gn3 b10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I3_MP0 (VDD p9_2 I1022_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I2_MP1 (I976_gn2 b9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I2_MP0 (VDD p8_1 I976_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I3_MP1 (I976_gn3 b9_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I3_MP0 (VDD p8_2 I976_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I4_MP1 (I976_gn4 b9_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I4_MP0 (VDD p8_3 I976_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I5_MP1 (I976_gn5 b9_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I5_MP0 (VDD p8_4 I976_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I6_MP1 (I930_gn6 b8_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I6_MP0 (VDD p7_5 I930_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I8_MP1 (I930_gn8 b8_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I8_MP0 (VDD p7_7 I930_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I101_XP_MP1 (I930_P5_2n I930_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I101_XP_MP0 (VDD I930_P5_4 I930_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I102_XP_MP1 (I1666_P6_3n I1666_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I102_XP_MP0 (VDD I1666_P6_5 I1666_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I100_XP_MP1 (I1666_P4_1n I1666_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I100_XP_MP0 (VDD I1666_P4_3 I1666_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I101_XP_MP1 (I1666_P5_2n I1666_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I101_XP_MP0 (VDD I1666_P5_4 I1666_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I5_MP1 (I1666_gn5 b24_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I5_MP0 (VDD p23_4 I1666_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I4_MP1 (I1666_gn4 b24_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I4_MP0 (VDD p23_3 I1666_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I101_XP_MP1 (I1620_P5_2n I1620_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I101_XP_MP0 (VDD I1620_P5_4 I1620_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I1_MP1 (I1620_gn1 b23_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I1_MP0 (VDD p22_0 I1620_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I3_MP1 (I1620_gn3 b23_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I3_MP0 (VDD p22_2 I1620_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I5_MP1 (I1620_gn5 b23_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I5_MP0 (VDD p22_4 I1620_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I6_MP1 (I1620_gn6 b23_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I6_MP0 (VDD p22_5 I1620_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I102_XP_MP1 (I1574_P6_3n I1574_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I102_XP_MP0 (VDD I1574_P6_5 I1574_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I104_XP_MP1 (I1574_P8_5n I1574_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I104_XP_MP0 (VDD I1574_P8_7 I1574_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I167_XP_MP1 (I1574_P16_1n I1574_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I167_XP_MP0 (VDD I1574_P16_9 I1574_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I26_MP1 (I1068_gn26 b11_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I26_MP0 (VDD p10_25 I1068_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I181_XP_MP1 (I1068_P30_15n I1068_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I181_XP_MP0 (VDD I1068_P30_23 I1068_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I173_XP_MP1 (I1068_P22_7n I1068_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I173_XP_MP0 (VDD I1068_P22_15 I1068_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I108_XP_MP1 (I1068_P12_9n I1068_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I108_XP_MP0 (VDD I1068_P12_11 I1068_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I101_XP_MP1 (I1022_P5_2n I1022_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I101_XP_MP0 (VDD I1022_P5_4 I1022_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I103_XP_MP1 (I1022_P7_4n I1022_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I103_XP_MP0 (VDD I1022_P7_6 I1022_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I100_XP_MP1 (I1022_P4_1n I1022_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I100_XP_MP0 (VDD I1022_P4_3 I1022_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I102_XP_MP1 (I1022_P6_3n I1022_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I102_XP_MP0 (VDD I1022_P6_5 I1022_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I5_MP1 (I1022_gn5 b10_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I5_MP0 (VDD p9_4 I1022_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I100_XP_MP1 (I976_P4_1n I976_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I100_XP_MP0 (VDD I976_P4_3 I976_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I6_MP1 (I976_gn6 b9_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I6_MP0 (VDD p8_5 I976_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I7_MP1 (I976_gn7 b9_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I7_MP0 (VDD p8_6 I976_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I100_XP_MP1 (I930_P4_1n I930_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I100_XP_MP0 (VDD I930_P4_3 I930_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I102_XP_MP1 (I930_P6_3n I930_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I102_XP_MP0 (VDD I930_P6_5 I930_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I104_XP_MP1 (I930_P8_5n I930_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I104_XP_MP0 (VDD I930_P8_7 I930_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I10_MP1 (I930_gn10 b8_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I10_MP0 (VDD p7_9 I930_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I9_MP1 (I930_gn9 b8_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I9_MP0 (VDD p7_8 I930_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I103_XP_MP1 (I930_P7_4n I930_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I103_XP_MP0 (VDD I930_P7_6 I930_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I175_XP_MP1 (I1666_P24_9n I1666_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I175_XP_MP0 (VDD I1666_P24_17 I1666_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I167_XP_MP1 (I1666_P16_1n I1666_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I167_XP_MP0 (VDD I1666_P16_9 I1666_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I104_XP_MP1 (I1666_P8_5n I1666_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I104_XP_MP0 (VDD I1666_P8_7 I1666_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I103_XP_MP1 (I1666_P7_4n I1666_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I103_XP_MP0 (VDD I1666_P7_6 I1666_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I7_MP1 (I1666_gn7 b24_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I7_MP0 (VDD p23_6 I1666_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I6_MP1 (I1666_gn6 b24_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I6_MP0 (VDD p23_5 I1666_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I103_XP_MP1 (I1620_P7_4n I1620_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I103_XP_MP0 (VDD I1620_P7_6 I1620_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I100_XP_MP1 (I1620_P4_1n I1620_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I100_XP_MP0 (VDD I1620_P4_3 I1620_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I102_XP_MP1 (I1620_P6_3n I1620_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I102_XP_MP0 (VDD I1620_P6_5 I1620_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I104_XP_MP1 (I1620_P8_5n I1620_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I104_XP_MP0 (VDD I1620_P8_7 I1620_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I7_MP1 (I1620_gn7 b23_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I7_MP0 (VDD p22_6 I1620_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I8_MP1 (I1620_gn8 b23_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I8_MP0 (VDD p22_7 I1620_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I101_XP_MP1 (I1574_P5_2n I1574_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I101_XP_MP0 (VDD I1574_P5_4 I1574_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I103_XP_MP1 (I1574_P7_4n I1574_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I103_XP_MP0 (VDD I1574_P7_6 I1574_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I6_MP1 (I1574_gn6 b22_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I6_MP0 (VDD p21_5 I1574_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I7_MP1 (I1574_gn7 b22_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I7_MP0 (VDD p21_6 I1574_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I106_XP_MP1 (I1574_P10_7n I1574_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I106_XP_MP0 (VDD I1574_P10_9 I1574_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I171_XP_MP1 (I1574_P20_5n I1574_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I171_XP_MP0 (VDD I1574_P20_13 I1574_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I28_MP1 (I1068_gn28 b11_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I28_MP0 (VDD p10_27 I1068_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I126_XP_MP1 (I1068_P30_27n I1068_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I126_XP_MP0 (VDD I1068_P30_29 I1068_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I122_XP_MP1 (I1068_P26_23n I1068_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I122_XP_MP0 (VDD I1068_P26_25 I1068_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I124_XP_MP1 (I1068_P28_25n I1068_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I124_XP_MP0 (VDD I1068_P28_27 I1068_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I120_XP_MP1 (I1068_P24_21n I1068_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I120_XP_MP0 (VDD I1068_P24_23 I1068_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I179_XP_MP1 (I1068_P28_13n I1068_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I179_XP_MP0 (VDD I1068_P28_21 I1068_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I171_XP_MP1 (I1068_P20_5n I1068_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I171_XP_MP0 (VDD I1068_P20_13 I1068_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I175_XP_MP1 (I1068_P24_9n I1068_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I175_XP_MP0 (VDD I1068_P24_17 I1068_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I110_XP_MP1 (I1068_P14_11n I1068_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I110_XP_MP0 (VDD I1068_P14_13 I1068_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I167_XP_MP1 (I1068_P16_1n I1068_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I167_XP_MP0 (VDD I1068_P16_9 I1068_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I9_MP1 (I1068_gn9 b11_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I9_MP0 (VDD p10_8 I1068_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I10_MP1 (I1068_gn10 b11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I10_MP0 (VDD p10_9 I1068_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I168_XP_MP1 (I1022_P17_2n I1022_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I168_XP_MP0 (VDD I1022_P17_10 I1022_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I105_XP_MP1 (I1022_P9_6n I1022_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I105_XP_MP0 (VDD I1022_P9_8 I1022_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I167_XP_MP1 (I1022_P16_1n I1022_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I167_XP_MP0 (VDD I1022_P16_9 I1022_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I104_XP_MP1 (I1022_P8_5n I1022_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I104_XP_MP0 (VDD I1022_P8_7 I1022_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I106_XP_MP1 (I1022_P10_7n I1022_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I106_XP_MP0 (VDD I1022_P10_9 I1022_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I7_MP1 (I1022_gn7 b10_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I7_MP0 (VDD p9_6 I1022_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I9_MP1 (I1022_gn9 b10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I9_MP0 (VDD p9_8 I1022_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I8_MP1 (I1022_gn8 b10_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I8_MP0 (VDD p9_7 I1022_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I104_XP_MP1 (I976_P8_5n I976_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I104_XP_MP0 (VDD I976_P8_7 I976_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I102_XP_MP1 (I976_P6_3n I976_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I102_XP_MP0 (VDD I976_P6_5 I976_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I101_XP_MP1 (I976_P5_2n I976_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I101_XP_MP0 (VDD I976_P5_4 I976_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I103_XP_MP1 (I976_P7_4n I976_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I103_XP_MP0 (VDD I976_P7_6 I976_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I8_MP1 (I976_gn8 b9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I8_MP0 (VDD p8_7 I976_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I10_MP1 (I976_gn10 b9_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I10_MP0 (VDD p8_9 I976_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I167_XP_MP1 (I930_P16_1n I930_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I167_XP_MP0 (VDD I930_P16_9 I930_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I108_XP_MP1 (I930_P12_9n I930_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I108_XP_MP0 (VDD I930_P12_11 I930_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I106_XP_MP1 (I930_P10_7n I930_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I106_XP_MP0 (VDD I930_P10_9 I930_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I11_MP1 (I930_gn11 b8_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I11_MP0 (VDD p7_10 I930_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I105_XP_MP1 (I930_P9_6n I930_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I105_XP_MP0 (VDD I930_P9_8 I930_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I169_XP_MP1 (I1666_P18_3n I1666_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I169_XP_MP0 (VDD I1666_P18_11 I1666_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I108_XP_MP1 (I1666_P12_9n I1666_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I108_XP_MP0 (VDD I1666_P12_11 I1666_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I106_XP_MP1 (I1666_P10_7n I1666_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I106_XP_MP0 (VDD I1666_P10_9 I1666_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I105_XP_MP1 (I1666_P9_6n I1666_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I105_XP_MP0 (VDD I1666_P9_8 I1666_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I10_MP1 (I1666_gn10 b24_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I10_MP0 (VDD p23_9 I1666_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I9_MP1 (I1666_gn9 b24_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I9_MP0 (VDD p23_8 I1666_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I8_MP1 (I1666_gn8 b24_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I8_MP0 (VDD p23_7 I1666_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I105_XP_MP1 (I1620_P9_6n I1620_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I105_XP_MP0 (VDD I1620_P9_8 I1620_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I106_XP_MP1 (I1620_P10_7n I1620_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I106_XP_MP0 (VDD I1620_P10_9 I1620_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I9_MP1 (I1620_gn9 b23_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I9_MP0 (VDD p22_8 I1620_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I8_MP1 (I1574_gn8 b22_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I8_MP0 (VDD p21_7 I1574_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I105_XP_MP1 (I1574_P9_6n I1574_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I105_XP_MP0 (VDD I1574_P9_8 I1574_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I10_MP1 (I1574_gn10 b22_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I10_MP0 (VDD p21_9 I1574_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I9_MP1 (I1574_gn9 b22_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I9_MP0 (VDD p21_8 I1574_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I108_XP_MP1 (I1574_P12_9n I1574_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I108_XP_MP0 (VDD I1574_P12_11 I1574_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I118_XP_MP1 (I1068_P22_19n I1068_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I118_XP_MP0 (VDD I1068_P22_21 I1068_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I116_XP_MP1 (I1068_P20_17n I1068_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I116_XP_MP0 (VDD I1068_P20_19 I1068_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I114_XP_MP1 (I1068_P18_15n I1068_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I114_XP_MP0 (VDD I1068_P18_17 I1068_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I112_XP_MP1 (I1068_P16_13n I1068_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I112_XP_MP0 (VDD I1068_P16_15 I1068_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I11_MP1 (I1068_gn11 b11_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I11_MP0 (VDD p10_10 I1068_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I107_XP_MP1 (I1022_P11_8n I1022_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I107_XP_MP0 (VDD I1022_P11_10 I1022_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I175_XP_MP1 (I1022_P24_9n I1022_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I175_XP_MP0 (VDD I1022_P24_17 I1022_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I108_XP_MP1 (I1022_P12_9n I1022_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I108_XP_MP0 (VDD I1022_P12_11 I1022_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I10_MP1 (I1022_gn10 b10_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I10_MP0 (VDD p9_9 I1022_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I11_MP1 (I1022_gn11 b10_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I11_MP0 (VDD p9_10 I1022_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I106_XP_MP1 (I976_P10_7n I976_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I106_XP_MP0 (VDD I976_P10_9 I976_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I105_XP_MP1 (I976_P9_6n I976_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I105_XP_MP0 (VDD I976_P9_8 I976_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I9_MP1 (I976_gn9 b9_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I9_MP0 (VDD p8_8 I976_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I11_MP1 (I976_gn11 b9_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I11_MP0 (VDD p8_10 I976_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I175_XP_MP1 (I930_P24_9n I930_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I175_XP_MP0 (VDD I930_P24_17 I930_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I12_MP1 (I930_gn12 b8_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I12_MP0 (VDD p7_11 I930_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I13_MP1 (I930_gn13 b8_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I13_MP0 (VDD p7_12 I930_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I107_XP_MP1 (I930_P11_8n I930_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I107_XP_MP0 (VDD I930_P11_10 I930_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I168_XP_MP1 (I930_P17_2n I930_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I168_XP_MP0 (VDD I930_P17_10 I930_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I171_XP_MP1 (I1666_P20_5n I1666_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I171_XP_MP0 (VDD I1666_P20_13 I1666_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I168_XP_MP1 (I1666_P17_2n I1666_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I168_XP_MP0 (VDD I1666_P17_10 I1666_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I107_XP_MP1 (I1666_P11_8n I1666_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I107_XP_MP0 (VDD I1666_P11_10 I1666_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I12_MP1 (I1666_gn12 b24_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I12_MP0 (VDD p23_11 I1666_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I11_MP1 (I1666_gn11 b24_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I11_MP0 (VDD p23_10 I1666_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I168_XP_MP1 (I1620_P17_2n I1620_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I168_XP_MP0 (VDD I1620_P17_10 I1620_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I107_XP_MP1 (I1620_P11_8n I1620_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I107_XP_MP0 (VDD I1620_P11_10 I1620_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I167_XP_MP1 (I1620_P16_1n I1620_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I167_XP_MP0 (VDD I1620_P16_9 I1620_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I108_XP_MP1 (I1620_P12_9n I1620_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I108_XP_MP0 (VDD I1620_P12_11 I1620_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I11_MP1 (I1620_gn11 b23_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I11_MP0 (VDD p22_10 I1620_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I10_MP1 (I1620_gn10 b23_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I10_MP0 (VDD p22_9 I1620_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I168_XP_MP1 (I1574_P17_2n I1574_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I168_XP_MP0 (VDD I1574_P17_10 I1574_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I107_XP_MP1 (I1574_P11_8n I1574_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I107_XP_MP0 (VDD I1574_P11_10 I1574_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I12_MP1 (I1574_gn12 b22_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I12_MP0 (VDD p21_11 I1574_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I11_MP1 (I1574_gn11 b22_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I11_MP0 (VDD p21_10 I1574_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I169_XP_MP1 (I1574_P18_3n I1574_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I169_XP_MP0 (VDD I1574_P18_11 I1574_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I175_XP_MP1 (I1574_P24_9n I1574_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I175_XP_MP0 (VDD I1574_P24_17 I1574_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I29_MP1 (I1068_gn29 b11_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I29_MP0 (VDD p10_28 I1068_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I25_MP1 (I1068_gn25 b11_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I25_MP0 (VDD p10_24 I1068_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I20_MP1 (I1068_gn20 b11_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I20_MP0 (VDD p10_19 I1068_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I19_MP1 (I1068_gn19 b11_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I19_MP0 (VDD p10_18 I1068_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I12_MP1 (I1068_gn12 b11_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I12_MP0 (VDD p10_11 I1068_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I13_MP1 (I1068_gn13 b11_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I13_MP0 (VDD p10_12 I1068_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I176_XP_MP1 (I1022_P25_10n I1022_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I176_XP_MP0 (VDD I1022_P25_18 I1022_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I109_XP_MP1 (I1022_P13_10n I1022_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I109_XP_MP0 (VDD I1022_P13_12 I1022_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I169_XP_MP1 (I1022_P18_3n I1022_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I169_XP_MP0 (VDD I1022_P18_11 I1022_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I12_MP1 (I1022_gn12 b10_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I12_MP0 (VDD p9_11 I1022_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I167_XP_MP1 (I976_P16_1n I976_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I167_XP_MP0 (VDD I976_P16_9 I976_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I108_XP_MP1 (I976_P12_9n I976_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I108_XP_MP0 (VDD I976_P12_11 I976_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I168_XP_MP1 (I976_P17_2n I976_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I168_XP_MP0 (VDD I976_P17_10 I976_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I107_XP_MP1 (I976_P11_8n I976_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I107_XP_MP0 (VDD I976_P11_10 I976_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I16_MP1 (I930_gn16 b8_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I16_MP0 (VDD p7_15 I930_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I171_XP_MP1 (I930_P20_5n I930_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I171_XP_MP0 (VDD I930_P20_13 I930_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I110_XP_MP1 (I930_P14_11n I930_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I110_XP_MP0 (VDD I930_P14_13 I930_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I14_MP1 (I930_gn14 b8_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I14_MP0 (VDD p7_13 I930_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I109_XP_MP1 (I930_P13_10n I930_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I109_XP_MP0 (VDD I930_P13_12 I930_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I177_XP_MP1 (I1666_P26_11n I1666_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I177_XP_MP0 (VDD I1666_P26_19 I1666_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I112_XP_MP1 (I1666_P16_13n I1666_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I112_XP_MP0 (VDD I1666_P16_15 I1666_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I110_XP_MP1 (I1666_P14_11n I1666_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I110_XP_MP0 (VDD I1666_P14_13 I1666_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I176_XP_MP1 (I1666_P25_10n I1666_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I176_XP_MP0 (VDD I1666_P25_18 I1666_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I170_XP_MP1 (I1666_P19_4n I1666_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I170_XP_MP0 (VDD I1666_P19_12 I1666_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I109_XP_MP1 (I1666_P13_10n I1666_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I109_XP_MP0 (VDD I1666_P13_12 I1666_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I13_MP1 (I1666_gn13 b24_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I13_MP0 (VDD p23_12 I1666_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I109_XP_MP1 (I1620_P13_10n I1620_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I109_XP_MP0 (VDD I1620_P13_12 I1620_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I175_XP_MP1 (I1620_P24_9n I1620_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I175_XP_MP0 (VDD I1620_P24_17 I1620_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I169_XP_MP1 (I1620_P18_3n I1620_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I169_XP_MP0 (VDD I1620_P18_11 I1620_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I110_XP_MP1 (I1620_P14_11n I1620_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I110_XP_MP0 (VDD I1620_P14_13 I1620_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I13_MP1 (I1620_gn13 b23_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I13_MP0 (VDD p22_12 I1620_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I12_MP1 (I1620_gn12 b23_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I12_MP0 (VDD p22_11 I1620_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I170_XP_MP1 (I1574_P19_4n I1574_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I170_XP_MP0 (VDD I1574_P19_12 I1574_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I109_XP_MP1 (I1574_P13_10n I1574_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I109_XP_MP0 (VDD I1574_P13_12 I1574_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I13_MP1 (I1574_gn13 b22_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I13_MP0 (VDD p21_12 I1574_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I110_XP_MP1 (I1574_P14_11n I1574_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I110_XP_MP0 (VDD I1574_P14_13 I1574_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I112_XP_MP1 (I1574_P16_13n I1574_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I112_XP_MP0 (VDD I1574_P16_15 I1574_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I177_XP_MP1 (I1574_P26_11n I1574_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I177_XP_MP0 (VDD I1574_P26_19 I1574_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I30_MP1 (I1068_gn30 b11_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I30_MP0 (VDD p10_29 I1068_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I24_MP1 (I1068_gn24 b11_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I24_MP0 (VDD p10_23 I1068_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I23_MP1 (I1068_gn23 b11_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I23_MP0 (VDD p10_22 I1068_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I22_MP1 (I1068_gn22 b11_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I22_MP0 (VDD p10_21 I1068_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I18_MP1 (I1068_gn18 b11_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I18_MP0 (VDD p10_17 I1068_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I16_MP1 (I1068_gn16 b11_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I16_MP0 (VDD p10_15 I1068_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I15_MP1 (I1068_gn15 b11_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I15_MP0 (VDD p10_14 I1068_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I17_MP1 (I1068_gn17 b11_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I17_MP0 (VDD p10_16 I1068_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I14_MP1 (I1068_gn14 b11_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I14_MP0 (VDD p10_13 I1068_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I170_XP_MP1 (I1022_P19_4n I1022_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I170_XP_MP0 (VDD I1022_P19_12 I1022_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I111_XP_MP1 (I1022_P15_12n I1022_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I111_XP_MP0 (VDD I1022_P15_14 I1022_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I171_XP_MP1 (I1022_P20_5n I1022_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I171_XP_MP0 (VDD I1022_P20_13 I1022_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I112_XP_MP1 (I1022_P16_13n I1022_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I112_XP_MP0 (VDD I1022_P16_15 I1022_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I110_XP_MP1 (I1022_P14_11n I1022_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I110_XP_MP0 (VDD I1022_P14_13 I1022_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I13_MP1 (I1022_gn13 b10_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I13_MP0 (VDD p9_12 I1022_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I14_MP1 (I1022_gn14 b10_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I14_MP0 (VDD p9_13 I1022_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I109_XP_MP1 (I976_P13_10n I976_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I109_XP_MP0 (VDD I976_P13_12 I976_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I12_MP1 (I976_gn12 b9_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I12_MP0 (VDD p8_11 I976_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I13_MP1 (I976_gn13 b9_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I13_MP0 (VDD p8_12 I976_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I14_MP1 (I976_gn14 b9_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I14_MP0 (VDD p8_13 I976_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I15_MP1 (I930_gn15 b8_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I15_MP0 (VDD p7_14 I930_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I112_XP_MP1 (I930_P16_13n I930_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I112_XP_MP0 (VDD I930_P16_15 I930_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I169_XP_MP1 (I930_P18_3n I930_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I169_XP_MP0 (VDD I930_P18_11 I930_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I111_XP_MP1 (I930_P15_12n I930_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I111_XP_MP0 (VDD I930_P15_14 I930_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I170_XP_MP1 (I930_P19_4n I930_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I170_XP_MP0 (VDD I930_P19_12 I930_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I176_XP_MP1 (I930_P25_10n I930_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I176_XP_MP0 (VDD I930_P25_18 I930_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I179_XP_MP1 (I1666_P28_13n I1666_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I179_XP_MP0 (VDD I1666_P28_21 I1666_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I114_XP_MP1 (I1666_P18_15n I1666_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I114_XP_MP0 (VDD I1666_P18_17 I1666_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I113_XP_MP1 (I1666_P17_14n I1666_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I113_XP_MP0 (VDD I1666_P17_16 I1666_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I111_XP_MP1 (I1666_P15_12n I1666_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I111_XP_MP0 (VDD I1666_P15_14 I1666_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I14_MP1 (I1666_gn14 b24_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I14_MP0 (VDD p23_13 I1666_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I15_MP1 (I1666_gn15 b24_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I15_MP0 (VDD p23_14 I1666_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I111_XP_MP1 (I1620_P15_12n I1620_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I111_XP_MP0 (VDD I1620_P15_14 I1620_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I112_XP_MP1 (I1620_P16_13n I1620_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I112_XP_MP0 (VDD I1620_P16_15 I1620_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I15_MP1 (I1620_gn15 b23_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I15_MP0 (VDD p22_14 I1620_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I14_MP1 (I1620_gn14 b23_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I14_MP0 (VDD p22_13 I1620_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I176_XP_MP1 (I1574_P25_10n I1574_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I176_XP_MP0 (VDD I1574_P25_18 I1574_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I111_XP_MP1 (I1574_P15_12n I1574_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I111_XP_MP0 (VDD I1574_P15_14 I1574_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I14_MP1 (I1574_gn14 b22_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I14_MP0 (VDD p21_13 I1574_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I15_MP1 (I1574_gn15 b22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I15_MP0 (VDD p21_14 I1574_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I114_XP_MP1 (I1574_P18_15n I1574_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I114_XP_MP0 (VDD I1574_P18_17 I1574_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I116_XP_MP1 (I1574_P20_17n I1574_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I116_XP_MP0 (VDD I1574_P20_19 I1574_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I179_XP_MP1 (I1574_P28_13n I1574_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I179_XP_MP0 (VDD I1574_P28_21 I1574_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I31_MP1 (I1068_gn31 b11_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I31_MP0 (VDD p10_30 I1068_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I21_MP1 (I1068_gn21 b11_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I21_MP0 (VDD p10_20 I1068_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I14_MP1 (I1114_gn14 b12_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I14_MP0 (VDD p11_13 I1114_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I172_XP_MP1 (I1022_P21_6n I1022_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I172_XP_MP0 (VDD I1022_P21_14 I1022_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I113_XP_MP1 (I1022_P17_14n I1022_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I113_XP_MP0 (VDD I1022_P17_16 I1022_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I177_XP_MP1 (I1022_P26_11n I1022_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I177_XP_MP0 (VDD I1022_P26_19 I1022_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I114_XP_MP1 (I1022_P18_15n I1022_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I114_XP_MP0 (VDD I1022_P18_17 I1022_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I16_MP1 (I1022_gn16 b10_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I16_MP0 (VDD p9_15 I1022_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I15_MP1 (I1022_gn15 b10_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I15_MP0 (VDD p9_14 I1022_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I110_XP_MP1 (I976_P14_11n I976_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I110_XP_MP0 (VDD I976_P14_13 I976_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I111_XP_MP1 (I976_P15_12n I976_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I111_XP_MP0 (VDD I976_P15_14 I976_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I17_MP1 (I976_gn17 b9_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I17_MP0 (VDD p8_16 I976_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I15_MP1 (I976_gn15 b9_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I15_MP0 (VDD p8_14 I976_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I17_MP1 (I930_gn17 b8_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I17_MP0 (VDD p7_16 I930_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I116_XP_MP1 (I930_P20_17n I930_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I116_XP_MP0 (VDD I930_P20_19 I930_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I114_XP_MP1 (I930_P18_15n I930_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I114_XP_MP0 (VDD I930_P18_17 I930_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I115_XP_MP1 (I930_P19_16n I930_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I115_XP_MP0 (VDD I930_P19_18 I930_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I113_XP_MP1 (I930_P17_14n I930_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I113_XP_MP0 (VDD I930_P17_16 I930_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I172_XP_MP1 (I930_P21_6n I930_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I172_XP_MP0 (VDD I930_P21_14 I930_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I173_XP_MP1 (I1666_P22_7n I1666_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I173_XP_MP0 (VDD I1666_P22_15 I1666_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I116_XP_MP1 (I1666_P20_17n I1666_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I116_XP_MP0 (VDD I1666_P20_19 I1666_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I172_XP_MP1 (I1666_P21_6n I1666_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I172_XP_MP0 (VDD I1666_P21_14 I1666_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I115_XP_MP1 (I1666_P19_16n I1666_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I115_XP_MP0 (VDD I1666_P19_18 I1666_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I16_MP1 (I1666_gn16 b24_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I16_MP0 (VDD p23_15 I1666_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I18_MP1 (I1666_gn18 b24_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I18_MP0 (VDD p23_17 I1666_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I17_MP1 (I1666_gn17 b24_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I17_MP0 (VDD p23_16 I1666_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I170_XP_MP1 (I1620_P19_4n I1620_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I170_XP_MP0 (VDD I1620_P19_12 I1620_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I113_XP_MP1 (I1620_P17_14n I1620_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I113_XP_MP0 (VDD I1620_P17_16 I1620_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I171_XP_MP1 (I1620_P20_5n I1620_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I171_XP_MP0 (VDD I1620_P20_13 I1620_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I177_XP_MP1 (I1620_P26_11n I1620_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I177_XP_MP0 (VDD I1620_P26_19 I1620_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I114_XP_MP1 (I1620_P18_15n I1620_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I114_XP_MP0 (VDD I1620_P18_17 I1620_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I116_XP_MP1 (I1620_P20_17n I1620_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I116_XP_MP0 (VDD I1620_P20_19 I1620_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I16_MP1 (I1620_gn16 b23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I16_MP0 (VDD p22_15 I1620_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I172_XP_MP1 (I1574_P21_6n I1574_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I172_XP_MP0 (VDD I1574_P21_14 I1574_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I113_XP_MP1 (I1574_P17_14n I1574_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I113_XP_MP0 (VDD I1574_P17_16 I1574_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I16_MP1 (I1574_gn16 b22_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I16_MP0 (VDD p21_15 I1574_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I173_XP_MP1 (I1574_P22_7n I1574_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I173_XP_MP0 (VDD I1574_P22_15 I1574_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I27_MP1 (I1114_gn27 b12_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I27_MP0 (VDD p11_26 I1114_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I26_MP1 (I1114_gn26 b12_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I26_MP0 (VDD p11_25 I1114_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I25_MP1 (I1114_gn25 b12_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I25_MP0 (VDD p11_24 I1114_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I22_MP1 (I1114_gn22 b12_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I22_MP0 (VDD p11_21 I1114_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I19_MP1 (I1114_gn19 b12_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I19_MP0 (VDD p11_18 I1114_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I18_MP1 (I1114_gn18 b12_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I18_MP0 (VDD p11_17 I1114_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I16_MP1 (I1114_gn16 b12_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I16_MP0 (VDD p11_15 I1114_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I12_MP1 (I1114_gn12 b12_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I12_MP0 (VDD p11_11 I1114_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I178_XP_MP1 (I1022_P27_12n I1022_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I178_XP_MP0 (VDD I1022_P27_20 I1022_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I115_XP_MP1 (I1022_P19_16n I1022_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I115_XP_MP0 (VDD I1022_P19_18 I1022_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I117_XP_MP1 (I1022_P21_18n I1022_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I117_XP_MP0 (VDD I1022_P21_20 I1022_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I116_XP_MP1 (I1022_P20_17n I1022_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I116_XP_MP0 (VDD I1022_P20_19 I1022_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I17_MP1 (I1022_gn17 b10_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I17_MP0 (VDD p9_16 I1022_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I19_MP1 (I1022_gn19 b10_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I19_MP0 (VDD p9_18 I1022_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I18_MP1 (I1022_gn18 b10_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I18_MP0 (VDD p9_17 I1022_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I169_XP_MP1 (I976_P18_3n I976_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I169_XP_MP0 (VDD I976_P18_11 I976_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I112_XP_MP1 (I976_P16_13n I976_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I112_XP_MP0 (VDD I976_P16_15 I976_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I113_XP_MP1 (I976_P17_14n I976_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I113_XP_MP0 (VDD I976_P17_16 I976_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I18_MP1 (I976_gn18 b9_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I18_MP0 (VDD p8_17 I976_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I16_MP1 (I976_gn16 b9_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I16_MP0 (VDD p8_15 I976_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I18_MP1 (I930_gn18 b8_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I18_MP0 (VDD p7_17 I930_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I19_MP1 (I930_gn19 b8_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I19_MP0 (VDD p7_18 I930_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I173_XP_MP1 (I930_P22_7n I930_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I173_XP_MP0 (VDD I930_P22_15 I930_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I177_XP_MP1 (I930_P26_11n I930_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I177_XP_MP0 (VDD I930_P26_19 I930_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I117_XP_MP1 (I930_P21_18n I930_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I117_XP_MP0 (VDD I930_P21_20 I930_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I182_XP_MP1 (I930_P31_16n I930_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I182_XP_MP0 (VDD I930_P31_24 I930_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I174_XP_MP1 (I930_P23_8n I930_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I174_XP_MP0 (VDD I930_P23_16 I930_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I120_XP_MP1 (I1666_P24_21n I1666_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I120_XP_MP0 (VDD I1666_P24_23 I1666_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I118_XP_MP1 (I1666_P22_19n I1666_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I118_XP_MP0 (VDD I1666_P22_21 I1666_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I180_XP_MP1 (I1666_P29_14n I1666_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I180_XP_MP0 (VDD I1666_P29_22 I1666_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I117_XP_MP1 (I1666_P21_18n I1666_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I117_XP_MP0 (VDD I1666_P21_20 I1666_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I20_MP1 (I1666_gn20 b24_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I20_MP0 (VDD p23_19 I1666_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I19_MP1 (I1666_gn19 b24_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I19_MP0 (VDD p23_18 I1666_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I172_XP_MP1 (I1620_P21_6n I1620_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I172_XP_MP0 (VDD I1620_P21_14 I1620_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I115_XP_MP1 (I1620_P19_16n I1620_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I115_XP_MP0 (VDD I1620_P19_18 I1620_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I173_XP_MP1 (I1620_P22_7n I1620_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I173_XP_MP0 (VDD I1620_P22_15 I1620_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I118_XP_MP1 (I1620_P22_19n I1620_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I118_XP_MP0 (VDD I1620_P22_21 I1620_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I17_MP1 (I1620_gn17 b23_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I17_MP0 (VDD p22_16 I1620_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I18_MP1 (I1620_gn18 b23_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I18_MP0 (VDD p22_17 I1620_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I19_MP1 (I1620_gn19 b23_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I19_MP0 (VDD p22_18 I1620_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I18_MP1 (I1574_gn18 b22_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I18_MP0 (VDD p21_17 I1574_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I115_XP_MP1 (I1574_P19_16n I1574_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I115_XP_MP0 (VDD I1574_P19_18 I1574_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I117_XP_MP1 (I1574_P21_18n I1574_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I117_XP_MP0 (VDD I1574_P21_20 I1574_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I19_MP1 (I1574_gn19 b22_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I19_MP0 (VDD p21_18 I1574_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I17_MP1 (I1574_gn17 b22_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I17_MP0 (VDD p21_16 I1574_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I118_XP_MP1 (I1574_P22_19n I1574_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I118_XP_MP0 (VDD I1574_P22_21 I1574_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I28_MP1 (I1114_gn28 b12_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I28_MP0 (VDD p11_27 I1114_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I24_MP1 (I1114_gn24 b12_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I24_MP0 (VDD p11_23 I1114_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I23_MP1 (I1114_gn23 b12_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I23_MP0 (VDD p11_22 I1114_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I21_MP1 (I1114_gn21 b12_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I21_MP0 (VDD p11_20 I1114_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I17_MP1 (I1114_gn17 b12_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I17_MP0 (VDD p11_16 I1114_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I15_MP1 (I1114_gn15 b12_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I15_MP0 (VDD p11_14 I1114_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I13_MP1 (I1114_gn13 b12_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I13_MP0 (VDD p11_12 I1114_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I10_MP1 (I1114_gn10 b12_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I10_MP0 (VDD p11_9 I1114_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I8_MP1 (I1114_gn8 b12_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I8_MP0 (VDD p11_7 I1114_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I180_XP_MP1 (I1022_P29_14n I1022_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I180_XP_MP0 (VDD I1022_P29_22 I1022_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I174_XP_MP1 (I1022_P23_8n I1022_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I174_XP_MP0 (VDD I1022_P23_16 I1022_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I119_XP_MP1 (I1022_P23_20n I1022_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I119_XP_MP0 (VDD I1022_P23_22 I1022_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I173_XP_MP1 (I1022_P22_7n I1022_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I173_XP_MP0 (VDD I1022_P22_15 I1022_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I118_XP_MP1 (I1022_P22_19n I1022_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I118_XP_MP0 (VDD I1022_P22_21 I1022_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I20_MP1 (I1022_gn20 b10_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I20_MP0 (VDD p9_19 I1022_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I171_XP_MP1 (I976_P20_5n I976_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I171_XP_MP0 (VDD I976_P20_13 I976_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I116_XP_MP1 (I976_P20_17n I976_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I116_XP_MP0 (VDD I976_P20_19 I976_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I114_XP_MP1 (I976_P18_15n I976_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I114_XP_MP0 (VDD I976_P18_17 I976_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I170_XP_MP1 (I976_P19_4n I976_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I170_XP_MP0 (VDD I976_P19_12 I976_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I176_XP_MP1 (I976_P25_10n I976_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I176_XP_MP0 (VDD I976_P25_18 I976_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I115_XP_MP1 (I976_P19_16n I976_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I115_XP_MP0 (VDD I976_P19_18 I976_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I19_MP1 (I976_gn19 b9_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I19_MP0 (VDD p8_18 I976_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I20_MP1 (I930_gn20 b8_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I20_MP0 (VDD p7_19 I930_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I118_XP_MP1 (I930_P22_19n I930_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I118_XP_MP0 (VDD I930_P22_21 I930_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I179_XP_MP1 (I930_P28_13n I930_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I179_XP_MP0 (VDD I930_P28_21 I930_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I21_MP1 (I930_gn21 b8_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I21_MP0 (VDD p7_20 I930_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I178_XP_MP1 (I930_P27_12n I930_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I178_XP_MP0 (VDD I930_P27_20 I930_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I180_XP_MP1 (I930_P29_14n I930_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I180_XP_MP0 (VDD I930_P29_22 I930_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I122_XP_MP1 (I1666_P26_23n I1666_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I122_XP_MP0 (VDD I1666_P26_25 I1666_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I124_XP_MP1 (I1666_P28_25n I1666_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I124_XP_MP0 (VDD I1666_P28_27 I1666_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I181_XP_MP1 (I1666_P30_15n I1666_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I181_XP_MP0 (VDD I1666_P30_23 I1666_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I178_XP_MP1 (I1666_P27_12n I1666_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I178_XP_MP0 (VDD I1666_P27_20 I1666_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I174_XP_MP1 (I1666_P23_8n I1666_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I174_XP_MP0 (VDD I1666_P23_16 I1666_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I21_MP1 (I1666_gn21 b24_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I21_MP0 (VDD p23_20 I1666_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I174_XP_MP1 (I1620_P23_8n I1620_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I174_XP_MP0 (VDD I1620_P23_16 I1620_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I176_XP_MP1 (I1620_P25_10n I1620_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I176_XP_MP0 (VDD I1620_P25_18 I1620_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I117_XP_MP1 (I1620_P21_18n I1620_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I117_XP_MP0 (VDD I1620_P21_20 I1620_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I179_XP_MP1 (I1620_P28_13n I1620_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I179_XP_MP0 (VDD I1620_P28_21 I1620_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I120_XP_MP1 (I1620_P24_21n I1620_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I120_XP_MP0 (VDD I1620_P24_23 I1620_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I20_MP1 (I1620_gn20 b23_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I20_MP0 (VDD p22_19 I1620_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I21_MP1 (I1620_gn21 b23_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I21_MP0 (VDD p22_20 I1620_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I174_XP_MP1 (I1574_P23_8n I1574_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I174_XP_MP0 (VDD I1574_P23_16 I1574_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I180_XP_MP1 (I1574_P29_14n I1574_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I180_XP_MP0 (VDD I1574_P29_22 I1574_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I20_MP1 (I1574_gn20 b22_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I20_MP0 (VDD p21_19 I1574_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I120_XP_MP1 (I1574_P24_21n I1574_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I120_XP_MP0 (VDD I1574_P24_23 I1574_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I181_XP_MP1 (I1574_P30_15n I1574_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I181_XP_MP0 (VDD I1574_P30_23 I1574_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I29_MP1 (I1114_gn29 b12_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I29_MP0 (VDD p11_28 I1114_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I20_MP1 (I1114_gn20 b12_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I20_MP0 (VDD p11_19 I1114_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I11_MP1 (I1114_gn11 b12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I11_MP0 (VDD p11_10 I1114_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I9_MP1 (I1114_gn9 b12_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I9_MP0 (VDD p11_8 I1114_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I7_MP1 (I1114_gn7 b12_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I7_MP0 (VDD p11_6 I1114_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I121_XP_MP1 (I1022_P25_22n I1022_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I121_XP_MP0 (VDD I1022_P25_24 I1022_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I179_XP_MP1 (I1022_P28_13n I1022_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I179_XP_MP0 (VDD I1022_P28_21 I1022_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I181_XP_MP1 (I1022_P30_15n I1022_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I181_XP_MP0 (VDD I1022_P30_23 I1022_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I120_XP_MP1 (I1022_P24_21n I1022_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I120_XP_MP0 (VDD I1022_P24_23 I1022_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I22_MP1 (I1022_gn22 b10_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I22_MP0 (VDD p9_21 I1022_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I21_MP1 (I1022_gn21 b10_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I21_MP0 (VDD p9_20 I1022_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I175_XP_MP1 (I976_P24_9n I976_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I175_XP_MP0 (VDD I976_P24_17 I976_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I172_XP_MP1 (I976_P21_6n I976_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I172_XP_MP0 (VDD I976_P21_14 I976_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I117_XP_MP1 (I976_P21_18n I976_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I117_XP_MP0 (VDD I976_P21_20 I976_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I20_MP1 (I976_gn20 b9_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I20_MP0 (VDD p8_19 I976_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I21_MP1 (I976_gn21 b9_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I21_MP0 (VDD p8_20 I976_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I120_XP_MP1 (I930_P24_21n I930_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I120_XP_MP0 (VDD I930_P24_23 I930_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I22_MP1 (I930_gn22 b8_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I22_MP0 (VDD p7_21 I930_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I119_XP_MP1 (I930_P23_20n I930_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I119_XP_MP0 (VDD I930_P23_22 I930_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I121_XP_MP1 (I930_P25_22n I930_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I121_XP_MP0 (VDD I930_P25_24 I930_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I24_MP1 (I1666_gn24 b24_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I24_MP0 (VDD p23_23 I1666_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I126_XP_MP1 (I1666_P30_27n I1666_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I126_XP_MP0 (VDD I1666_P30_29 I1666_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I121_XP_MP1 (I1666_P25_22n I1666_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I121_XP_MP0 (VDD I1666_P25_24 I1666_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I125_XP_MP1 (I1666_P29_26n I1666_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I125_XP_MP0 (VDD I1666_P29_28 I1666_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I123_XP_MP1 (I1666_P27_24n I1666_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I123_XP_MP0 (VDD I1666_P27_26 I1666_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I119_XP_MP1 (I1666_P23_20n I1666_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I119_XP_MP0 (VDD I1666_P23_22 I1666_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I23_MP1 (I1666_gn23 b24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I23_MP0 (VDD p23_22 I1666_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I22_MP1 (I1666_gn22 b24_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I22_MP0 (VDD p23_21 I1666_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I178_XP_MP1 (I1620_P27_12n I1620_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I178_XP_MP0 (VDD I1620_P27_20 I1620_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I180_XP_MP1 (I1620_P29_14n I1620_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I180_XP_MP0 (VDD I1620_P29_22 I1620_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I121_XP_MP1 (I1620_P25_22n I1620_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I121_XP_MP0 (VDD I1620_P25_24 I1620_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I119_XP_MP1 (I1620_P23_20n I1620_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I119_XP_MP0 (VDD I1620_P23_22 I1620_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I181_XP_MP1 (I1620_P30_15n I1620_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I181_XP_MP0 (VDD I1620_P30_23 I1620_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I122_XP_MP1 (I1620_P26_23n I1620_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I122_XP_MP0 (VDD I1620_P26_25 I1620_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I22_MP1 (I1620_gn22 b23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I22_MP0 (VDD p22_21 I1620_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I23_MP1 (I1620_gn23 b23_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I23_MP0 (VDD p22_22 I1620_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I178_XP_MP1 (I1574_P27_12n I1574_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I178_XP_MP0 (VDD I1574_P27_20 I1574_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I119_XP_MP1 (I1574_P23_20n I1574_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I119_XP_MP0 (VDD I1574_P23_22 I1574_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I121_XP_MP1 (I1574_P25_22n I1574_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I121_XP_MP0 (VDD I1574_P25_24 I1574_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I21_MP1 (I1574_gn21 b22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I21_MP0 (VDD p21_20 I1574_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I22_MP1 (I1574_gn22 b22_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I22_MP0 (VDD p21_21 I1574_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I122_XP_MP1 (I1574_P26_23n I1574_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I122_XP_MP0 (VDD I1574_P26_25 I1574_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I30_MP1 (I1114_gn30 b12_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I30_MP0 (VDD p11_29 I1114_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I124_XP_MP1 (I1114_P28_25n I1114_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I124_XP_MP0 (VDD I1114_P28_27 I1114_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I122_XP_MP1 (I1114_P26_23n I1114_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I122_XP_MP0 (VDD I1114_P26_25 I1114_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I120_XP_MP1 (I1114_P24_21n I1114_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I120_XP_MP0 (VDD I1114_P24_23 I1114_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I118_XP_MP1 (I1114_P22_19n I1114_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I118_XP_MP0 (VDD I1114_P22_21 I1114_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I116_XP_MP1 (I1114_P20_17n I1114_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I116_XP_MP0 (VDD I1114_P20_19 I1114_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I114_XP_MP1 (I1114_P18_15n I1114_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I114_XP_MP0 (VDD I1114_P18_17 I1114_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I112_XP_MP1 (I1114_P16_13n I1114_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I112_XP_MP0 (VDD I1114_P16_15 I1114_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I110_XP_MP1 (I1114_P14_11n I1114_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I110_XP_MP0 (VDD I1114_P14_13 I1114_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I108_XP_MP1 (I1114_P12_9n I1114_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I108_XP_MP0 (VDD I1114_P12_11 I1114_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I6_MP1 (I1114_gn6 b12_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I6_MP0 (VDD p11_5 I1114_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I5_MP1 (I1114_gn5 b12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I5_MP0 (VDD p11_4 I1114_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I182_XP_MP1 (I1022_P31_16n I1022_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I182_XP_MP0 (VDD I1022_P31_24 I1022_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I123_XP_MP1 (I1022_P27_24n I1022_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I123_XP_MP0 (VDD I1022_P27_26 I1022_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I125_XP_MP1 (I1022_P29_26n I1022_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I125_XP_MP0 (VDD I1022_P29_28 I1022_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I124_XP_MP1 (I1022_P28_25n I1022_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I124_XP_MP0 (VDD I1022_P28_27 I1022_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I122_XP_MP1 (I1022_P26_23n I1022_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I122_XP_MP0 (VDD I1022_P26_25 I1022_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I24_MP1 (I1022_gn24 b10_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I24_MP0 (VDD p9_23 I1022_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I23_MP1 (I1022_gn23 b10_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I23_MP0 (VDD p9_22 I1022_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I173_XP_MP1 (I976_P22_7n I976_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I173_XP_MP0 (VDD I976_P22_15 I976_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I118_XP_MP1 (I976_P22_19n I976_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I118_XP_MP0 (VDD I976_P22_21 I976_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I174_XP_MP1 (I976_P23_8n I976_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I174_XP_MP0 (VDD I976_P23_16 I976_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I119_XP_MP1 (I976_P23_20n I976_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I119_XP_MP0 (VDD I976_P23_22 I976_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I22_MP1 (I976_gn22 b9_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I22_MP0 (VDD p8_21 I976_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I23_MP1 (I976_gn23 b9_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I23_MP0 (VDD p8_22 I976_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I122_XP_MP1 (I930_P26_23n I930_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I122_XP_MP0 (VDD I930_P26_25 I930_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I24_MP1 (I930_gn24 b8_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I24_MP0 (VDD p7_23 I930_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I23_MP1 (I930_gn23 b8_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I23_MP0 (VDD p7_22 I930_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I25_MP1 (I930_gn25 b8_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I25_MP0 (VDD p7_24 I930_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I123_XP_MP1 (I930_P27_24n I930_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I123_XP_MP0 (VDD I930_P27_26 I930_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I25_MP1 (I1666_gn25 b24_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I25_MP0 (VDD p23_24 I1666_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I26_MP1 (I1666_gn26 b24_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I26_MP0 (VDD p23_25 I1666_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I127_XP_MP1 (I1666_P31_28n I1666_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I127_XP_MP0 (VDD I1666_P31_30 I1666_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I182_XP_MP1 (I1666_P31_16n I1666_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I182_XP_MP0 (VDD I1666_P31_24 I1666_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I182_XP_MP1 (I1620_P31_16n I1620_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I182_XP_MP0 (VDD I1620_P31_24 I1620_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I123_XP_MP1 (I1620_P27_24n I1620_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I123_XP_MP0 (VDD I1620_P27_26 I1620_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I124_XP_MP1 (I1620_P28_25n I1620_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I124_XP_MP0 (VDD I1620_P28_27 I1620_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I24_MP1 (I1620_gn24 b23_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I24_MP0 (VDD p22_23 I1620_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I25_MP1 (I1620_gn25 b23_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I25_MP0 (VDD p22_24 I1620_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I182_XP_MP1 (I1574_P31_16n I1574_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I182_XP_MP0 (VDD I1574_P31_24 I1574_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I125_XP_MP1 (I1574_P29_26n I1574_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I125_XP_MP0 (VDD I1574_P29_28 I1574_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I123_XP_MP1 (I1574_P27_24n I1574_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I123_XP_MP0 (VDD I1574_P27_26 I1574_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I24_MP1 (I1574_gn24 b22_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I24_MP0 (VDD p21_23 I1574_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I23_MP1 (I1574_gn23 b22_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I23_MP0 (VDD p21_22 I1574_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I124_XP_MP1 (I1574_P28_25n I1574_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I124_XP_MP0 (VDD I1574_P28_27 I1574_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I31_MP1 (I1114_gn31 b12_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I31_MP0 (VDD p11_30 I1114_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I126_XP_MP1 (I1114_P30_27n I1114_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I126_XP_MP0 (VDD I1114_P30_29 I1114_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I181_XP_MP1 (I1114_P30_15n I1114_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I181_XP_MP0 (VDD I1114_P30_23 I1114_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I179_XP_MP1 (I1114_P28_13n I1114_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I179_XP_MP0 (VDD I1114_P28_21 I1114_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I173_XP_MP1 (I1114_P22_7n I1114_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I173_XP_MP0 (VDD I1114_P22_15 I1114_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I177_XP_MP1 (I1114_P26_11n I1114_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I177_XP_MP0 (VDD I1114_P26_19 I1114_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I171_XP_MP1 (I1114_P20_5n I1114_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I171_XP_MP0 (VDD I1114_P20_13 I1114_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I106_XP_MP1 (I1114_P10_7n I1114_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I106_XP_MP0 (VDD I1114_P10_9 I1114_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I104_XP_MP1 (I1114_P8_5n I1114_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I104_XP_MP0 (VDD I1114_P8_7 I1114_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I4_MP1 (I1114_gn4 b12_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I4_MP0 (VDD p11_3 I1114_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I3_MP1 (I1114_gn3 b12_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I3_MP0 (VDD p11_2 I1114_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I127_XP_MP1 (I1022_P31_28n I1022_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I127_XP_MP0 (VDD I1022_P31_30 I1022_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I126_XP_MP1 (I1022_P30_27n I1022_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I126_XP_MP0 (VDD I1022_P30_29 I1022_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I26_MP1 (I1022_gn26 b10_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I26_MP0 (VDD p9_25 I1022_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I25_MP1 (I1022_gn25 b10_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I25_MP0 (VDD p9_24 I1022_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I177_XP_MP1 (I976_P26_11n I976_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I177_XP_MP0 (VDD I976_P26_19 I976_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I120_XP_MP1 (I976_P24_21n I976_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I120_XP_MP0 (VDD I976_P24_23 I976_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I122_XP_MP1 (I976_P26_23n I976_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I122_XP_MP0 (VDD I976_P26_25 I976_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I178_XP_MP1 (I976_P27_12n I976_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I178_XP_MP0 (VDD I976_P27_20 I976_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I121_XP_MP1 (I976_P25_22n I976_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I121_XP_MP0 (VDD I976_P25_24 I976_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I24_MP1 (I976_gn24 b9_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I24_MP0 (VDD p8_23 I976_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I181_XP_MP1 (I930_P30_15n I930_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I181_XP_MP0 (VDD I930_P30_23 I930_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I124_XP_MP1 (I930_P28_25n I930_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I124_XP_MP0 (VDD I930_P28_27 I930_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I26_MP1 (I930_gn26 b8_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I26_MP0 (VDD p7_25 I930_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I125_XP_MP1 (I930_P29_26n I930_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I125_XP_MP0 (VDD I930_P29_28 I930_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I27_MP1 (I1666_gn27 b24_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I27_MP0 (VDD p23_26 I1666_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I28_MP1 (I1666_gn28 b24_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I28_MP0 (VDD p23_27 I1666_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I29_MP1 (I1666_gn29 b24_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I29_MP0 (VDD p23_28 I1666_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I30_MP1 (I1666_gn30 b24_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I30_MP0 (VDD p23_29 I1666_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1666_I31_MP1 (I1666_gn31 b24_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1666_I31_MP0 (VDD p23_30 I1666_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I127_XP_MP1 (I1620_P31_28n I1620_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I127_XP_MP0 (VDD I1620_P31_30 I1620_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I125_XP_MP1 (I1620_P29_26n I1620_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I125_XP_MP0 (VDD I1620_P29_28 I1620_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I126_XP_MP1 (I1620_P30_27n I1620_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I126_XP_MP0 (VDD I1620_P30_29 I1620_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I27_MP1 (I1620_gn27 b23_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I27_MP0 (VDD p22_26 I1620_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I26_MP1 (I1620_gn26 b23_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I26_MP0 (VDD p22_25 I1620_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I127_XP_MP1 (I1574_P31_28n I1574_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I127_XP_MP0 (VDD I1574_P31_30 I1574_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I25_MP1 (I1574_gn25 b22_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I25_MP0 (VDD p21_24 I1574_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I126_XP_MP1 (I1574_P30_27n I1574_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I126_XP_MP0 (VDD I1574_P30_29 I1574_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I175_XP_MP1 (I1114_P24_9n I1114_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I175_XP_MP0 (VDD I1114_P24_17 I1114_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I169_XP_MP1 (I1114_P18_3n I1114_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I169_XP_MP0 (VDD I1114_P18_11 I1114_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I167_XP_MP1 (I1114_P16_1n I1114_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I167_XP_MP0 (VDD I1114_P16_9 I1114_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I102_XP_MP1 (I1114_P6_3n I1114_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I102_XP_MP0 (VDD I1114_P6_5 I1114_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I100_XP_MP1 (I1114_P4_1n I1114_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I100_XP_MP0 (VDD I1114_P4_3 I1114_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I2_MP1 (I1114_gn2 b12_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I2_MP0 (VDD p11_1 I1114_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1068_I0_MP1 (I1068_gn0 b11_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1068_I0_MP0 (VDD aa20 I1068_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I31_MP1 (I1022_gn31 b10_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I31_MP0 (VDD p9_30 I1022_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I28_MP1 (I1022_gn28 b10_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I28_MP0 (VDD p9_27 I1022_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1022_I27_MP1 (I1022_gn27 b10_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1022_I27_MP0 (VDD p9_26 I1022_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I179_XP_MP1 (I976_P28_13n I976_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I179_XP_MP0 (VDD I976_P28_21 I976_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I181_XP_MP1 (I976_P30_15n I976_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I181_XP_MP0 (VDD I976_P30_23 I976_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I124_XP_MP1 (I976_P28_25n I976_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I124_XP_MP0 (VDD I976_P28_27 I976_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I180_XP_MP1 (I976_P29_14n I976_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I180_XP_MP0 (VDD I976_P29_22 I976_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I123_XP_MP1 (I976_P27_24n I976_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I123_XP_MP0 (VDD I976_P27_26 I976_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I125_XP_MP1 (I976_P29_26n I976_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I125_XP_MP0 (VDD I976_P29_28 I976_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I26_MP1 (I976_gn26 b9_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I26_MP0 (VDD p8_25 I976_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I27_MP1 (I976_gn27 b9_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I27_MP0 (VDD p8_26 I976_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI976_I25_MP1 (I976_gn25 b9_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI976_I25_MP0 (VDD p8_24 I976_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I31_MP1 (I930_gn31 b8_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I31_MP0 (VDD p7_30 I930_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I126_XP_MP1 (I930_P30_27n I930_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I126_XP_MP0 (VDD I930_P30_29 I930_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I28_MP1 (I930_gn28 b8_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I28_MP0 (VDD p7_27 I930_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I27_MP1 (I930_gn27 b8_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I27_MP0 (VDD p7_26 I930_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI930_I127_XP_MP1 (I930_P31_28n I930_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI930_I127_XP_MP0 (VDD I930_P31_30 I930_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I31_MP1 (I1620_gn31 b23_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I31_MP0 (VDD p22_30 I1620_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I30_MP1 (I1620_gn30 b23_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I30_MP0 (VDD p22_29 I1620_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I29_MP1 (I1620_gn29 b23_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I29_MP0 (VDD p22_28 I1620_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1620_I28_MP1 (I1620_gn28 b23_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1620_I28_MP0 (VDD p22_27 I1620_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1528_I0_MP1 (I1528_gn0 b21_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1528_I0_MP0 (VDD aa10 I1528_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I31_MP1 (I1574_gn31 b22_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I31_MP0 (VDD p21_30 I1574_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I30_MP1 (I1574_gn30 b22_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I30_MP0 (VDD p21_29 I1574_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1574_I27_MP1 (I1574_gn27 b22_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1574_I27_MP0 (VDD p21_26 I1574_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I127_XP_MP1 (I1114_P31_28n I1114_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I127_XP_MP0 (VDD I1114_P31_30 I1114_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I125_XP_MP1 (I1114_P29_26n I1114_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I125_XP_MP0 (VDD I1114_P29_28 I1114_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I123_XP_MP1 (I1114_P27_24n I1114_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I123_XP_MP0 (VDD I1114_P27_26 I1114_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I121_XP_MP1 (I1114_P25_22n I1114_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I121_XP_MP0 (VDD I1114_P25_24 I1114_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I119_XP_MP1 (I1114_P23_20n I1114_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I119_XP_MP0 (VDD I1114_P23_22 I1114_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I117_XP_MP1 (I1114_P21_18n I1114_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
    I_MXI1114_I117_XP_MP0 (VDD I1114_P21_20 I1114_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.16u ps=0.68u
    I_MXI1114_I111_XP_MP1 (I1114_P15_12n I1114_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.68u ps=1.16u
