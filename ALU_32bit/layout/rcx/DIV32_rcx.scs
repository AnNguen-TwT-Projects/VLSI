    I_MXI1160_I175_XG_MP0 (VDD I1160_P24_17 XI1160_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I175_XG_MP1 (XI1160_I175_XG_p1 I1160_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I171_XG_MP2 (XI1160_I171_XG_p1 I1160_G20_13 I1160_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I171_XG_MP0 (VDD I1160_P20_13 XI1160_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I171_XG_MP1 (XI1160_I171_XG_p1 I1160_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I163_XG_MP2 (XI1160_I163_XG_p1 I1160_G12_5 I1160_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I163_XG_MP0 (VDD I1160_P12_5 XI1160_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I163_XG_MP1 (XI1160_I163_XG_p1 I1160_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I105_XG_MP2 (XI1206_I105_XG_p1 I1206_G9_8 I1206_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I105_XG_MP0 (VDD I1206_P9_8 XI1206_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I105_XG_MP1 (XI1206_I105_XG_p1 I1206_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I106_XG_MP2 (XI1206_I106_XG_p1 I1206_G10_9 I1206_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I106_XG_MP0 (VDD I1206_P10_9 XI1206_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I106_XG_MP1 (XI1206_I106_XG_p1 I1206_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I167_XG_MP2 (XI1206_I167_XG_p1 I1206_G16_9 I1206_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I167_XG_MP0 (VDD I1206_P16_9 XI1206_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I167_XG_MP1 (XI1206_I167_XG_p1 I1206_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I112_XG_MP2 (XI1252_I112_XG_p1 I1252_G16_15 I1252_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I112_XG_MP0 (VDD I1252_P16_15 XI1252_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I112_XG_MP1 (XI1252_I112_XG_p1 I1252_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I110_XG_MP2 (XI1252_I110_XG_p1 I1252_G14_13 I1252_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I110_XG_MP0 (VDD I1252_P14_13 XI1252_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I110_XG_MP1 (XI1252_I110_XG_p1 I1252_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I171_XG_MP2 (XI1252_I171_XG_p1 I1252_G20_13 I1252_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I171_XG_MP0 (VDD I1252_P20_13 XI1252_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I171_XG_MP1 (XI1252_I171_XG_p1 I1252_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I111_XG_MP2 (XI1252_I111_XG_p1 I1252_G15_14 I1252_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I111_XG_MP0 (VDD I1252_P15_14 XI1252_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I111_XG_MP1 (XI1252_I111_XG_p1 I1252_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I176_XG_MP2 (XI1252_I176_XG_p1 I1252_G25_18 I1252_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I176_XG_MP0 (VDD I1252_P25_18 XI1252_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I176_XG_MP1 (XI1252_I176_XG_p1 I1252_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I114_XG_MP2 (XI1298_I114_XG_p1 I1298_G18_17 I1298_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I114_XG_MP0 (VDD I1298_P18_17 XI1298_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I114_XG_MP1 (XI1298_I114_XG_p1 I1298_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I171_XG_MP2 (XI1298_I171_XG_p1 I1298_G20_13 I1298_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I171_XG_MP0 (VDD I1298_P20_13 XI1298_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I171_XG_MP1 (XI1298_I171_XG_p1 I1298_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I165_XG_MP2 (XI1298_I165_XG_p1 I1298_G14_7 I1298_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I165_XG_MP0 (VDD I1298_P14_7 XI1298_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I165_XG_MP1 (XI1298_I165_XG_p1 I1298_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I113_XG_MP2 (XI1298_I113_XG_p1 I1298_G17_16 I1298_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I113_XG_MP0 (VDD I1298_P17_16 XI1298_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I113_XG_MP1 (XI1298_I113_XG_p1 I1298_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I164_XG_MP2 (XI1298_I164_XG_p1 I1298_G13_6 I1298_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I164_XG_MP0 (VDD I1298_P13_6 XI1298_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I164_XG_MP1 (XI1298_I164_XG_p1 I1298_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I165_XG_MP2 (XI1344_I165_XG_p1 I1344_G14_7 I1344_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I165_XG_MP0 (VDD I1344_P14_7 XI1344_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I165_XG_MP1 (XI1344_I165_XG_p1 I1344_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I114_XG_MP2 (XI1344_I114_XG_p1 I1344_G18_17 I1344_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I114_XG_MP0 (VDD I1344_P18_17 XI1344_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I114_XG_MP1 (XI1344_I114_XG_p1 I1344_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I113_XG_MP2 (XI1344_I113_XG_p1 I1344_G17_16 I1344_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I113_XG_MP0 (VDD I1344_P17_16 XI1344_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I113_XG_MP1 (XI1344_I113_XG_p1 I1344_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I164_XG_MP2 (XI1344_I164_XG_p1 I1344_G13_6 I1344_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I164_XG_MP0 (VDD I1344_P13_6 XI1344_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I164_XG_MP1 (XI1344_I164_XG_p1 I1344_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I114_XG_MP2 (XI1390_I114_XG_p1 I1390_G18_17 I1390_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I114_XG_MP0 (VDD I1390_P18_17 XI1390_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I114_XG_MP1 (XI1390_I114_XG_p1 I1390_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I177_XG_MP2 (XI1390_I177_XG_p1 I1390_G26_19 I1390_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I177_XG_MP0 (VDD I1390_P26_19 XI1390_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I177_XG_MP1 (XI1390_I177_XG_p1 I1390_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I165_XG_MP2 (XI1390_I165_XG_p1 I1390_G14_7 I1390_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I165_XG_MP0 (VDD I1390_P14_7 XI1390_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I165_XG_MP1 (XI1390_I165_XG_p1 I1390_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I113_XG_MP2 (XI1390_I113_XG_p1 I1390_G17_16 I1390_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I113_XG_MP0 (VDD I1390_P17_16 XI1390_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I113_XG_MP1 (XI1390_I113_XG_p1 I1390_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I164_XG_MP2 (XI1390_I164_XG_p1 I1390_G13_6 I1390_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I164_XG_MP0 (VDD I1390_P13_6 XI1390_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I164_XG_MP1 (XI1390_I164_XG_p1 I1390_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I114_XG_MP2 (XI1436_I114_XG_p1 I1436_G18_17 I1436_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I114_XG_MP0 (VDD I1436_P18_17 XI1436_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I114_XG_MP1 (XI1436_I114_XG_p1 I1436_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I165_XG_MP2 (XI1436_I165_XG_p1 I1436_G14_7 I1436_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I165_XG_MP0 (VDD I1436_P14_7 XI1436_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I165_XG_MP1 (XI1436_I165_XG_p1 I1436_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I113_XG_MP2 (XI1436_I113_XG_p1 I1436_G17_16 I1436_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I113_XG_MP0 (VDD I1436_P17_16 XI1436_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I113_XG_MP1 (XI1436_I113_XG_p1 I1436_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I164_XG_MP2 (XI1436_I164_XG_p1 I1436_G13_6 I1436_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I164_XG_MP0 (VDD I1436_P13_6 XI1436_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I164_XG_MP1 (XI1436_I164_XG_p1 I1436_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I113_XG_MP2 (XI1482_I113_XG_p1 I1482_G17_16 I1482_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I113_XG_MP0 (VDD I1482_P17_16 XI1482_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I113_XG_MP1 (XI1482_I113_XG_p1 I1482_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I112_XG_MP2 (XI1482_I112_XG_p1 I1482_G16_15 I1482_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I112_XG_MP0 (VDD I1482_P16_15 XI1482_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I112_XG_MP1 (XI1482_I112_XG_p1 I1482_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I171_XG_MP2 (XI1482_I171_XG_p1 I1482_G20_13 I1482_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I171_XG_MP0 (VDD I1482_P20_13 XI1482_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I171_XG_MP1 (XI1482_I171_XG_p1 I1482_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I118_XG_MP2 (XI1528_I118_XG_p1 I1528_G22_21 I1528_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I118_XG_MP0 (VDD I1528_P22_21 XI1528_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I118_XG_MP1 (XI1528_I118_XG_p1 I1528_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I181_XG_MP2 (XI1528_I181_XG_p1 I1528_G30_23 I1528_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I181_XG_MP0 (VDD I1528_P30_23 XI1528_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I181_XG_MP1 (XI1528_I181_XG_p1 I1528_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I126_XG_MP2 (XI1160_I126_XG_p1 I1160_G30_29 I1160_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I126_XG_MP0 (VDD I1160_P30_29 XI1160_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I126_XG_MP1 (XI1160_I126_XG_p1 I1160_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I124_XG_MP2 (XI1160_I124_XG_p1 I1160_G28_27 I1160_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I124_XG_MP0 (VDD I1160_P28_27 XI1160_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I124_XG_MP1 (XI1160_I124_XG_p1 I1160_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I122_XG_MP2 (XI1160_I122_XG_p1 I1160_G26_25 I1160_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I122_XG_MP0 (VDD I1160_P26_25 XI1160_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I122_XG_MP1 (XI1160_I122_XG_p1 I1160_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I177_XG_MP2 (XI1160_I177_XG_p1 I1160_G26_19 I1160_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I177_XG_MP0 (VDD I1160_P26_19 XI1160_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I177_XG_MP1 (XI1160_I177_XG_p1 I1160_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I169_XG_MP2 (XI1160_I169_XG_p1 I1160_G18_11 I1160_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I169_XG_MP0 (VDD I1160_P18_11 XI1160_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I169_XG_MP1 (XI1160_I169_XG_p1 I1160_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I160_XG_MP2 (XI1160_I160_XG_p1 I1160_G10_3 I1160_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I160_XG_MP0 (VDD I1160_P10_3 XI1160_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I160_XG_MP1 (XI1160_I160_XG_p1 I1160_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I109_XG_MP2 (XI1206_I109_XG_p1 I1206_G13_12 I1206_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I109_XG_MP0 (VDD I1206_P13_12 XI1206_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I109_XG_MP1 (XI1206_I109_XG_p1 I1206_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I107_XG_MP2 (XI1206_I107_XG_p1 I1206_G11_10 I1206_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I107_XG_MP0 (VDD I1206_P11_10 XI1206_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I107_XG_MP1 (XI1206_I107_XG_p1 I1206_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I158_XG_MP2 (XI1206_I158_XG_p1 I1206_G9_2 I1206_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I158_XG_MP0 (VDD I1206_P9_2 XI1206_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I158_XG_MP1 (XI1206_I158_XG_p1 I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I110_XG_MP2 (XI1206_I110_XG_p1 I1206_G14_13 I1206_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I110_XG_MP0 (VDD I1206_P14_13 XI1206_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I110_XG_MP1 (XI1206_I110_XG_p1 I1206_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I108_XG_MP2 (XI1206_I108_XG_p1 I1206_G12_11 I1206_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I108_XG_MP0 (VDD I1206_P12_11 XI1206_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I108_XG_MP1 (XI1206_I108_XG_p1 I1206_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I163_XG_MP2 (XI1206_I163_XG_p1 I1206_G12_5 I1206_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I163_XG_MP0 (VDD I1206_P12_5 XI1206_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I163_XG_MP1 (XI1206_I163_XG_p1 I1206_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I114_XG_MP2 (XI1252_I114_XG_p1 I1252_G18_17 I1252_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I114_XG_MP0 (VDD I1252_P18_17 XI1252_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I114_XG_MP1 (XI1252_I114_XG_p1 I1252_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I165_XG_MP2 (XI1252_I165_XG_p1 I1252_G14_7 I1252_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I165_XG_MP0 (VDD I1252_P14_7 XI1252_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I165_XG_MP1 (XI1252_I165_XG_p1 I1252_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I113_XG_MP2 (XI1252_I113_XG_p1 I1252_G17_16 I1252_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I113_XG_MP0 (VDD I1252_P17_16 XI1252_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I113_XG_MP1 (XI1252_I113_XG_p1 I1252_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I164_XG_MP2 (XI1252_I164_XG_p1 I1252_G13_6 I1252_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I164_XG_MP0 (VDD I1252_P13_6 XI1252_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I164_XG_MP1 (XI1252_I164_XG_p1 I1252_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I116_XG_MP2 (XI1298_I116_XG_p1 I1298_G20_19 I1298_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I116_XG_MP0 (VDD I1298_P20_19 XI1298_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I116_XG_MP1 (XI1298_I116_XG_p1 I1298_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I177_XG_MP2 (XI1298_I177_XG_p1 I1298_G26_19 I1298_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I177_XG_MP0 (VDD I1298_P26_19 XI1298_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I177_XG_MP1 (XI1298_I177_XG_p1 I1298_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I115_XG_MP2 (XI1298_I115_XG_p1 I1298_G19_18 I1298_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I115_XG_MP0 (VDD I1298_P19_18 XI1298_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I115_XG_MP1 (XI1298_I115_XG_p1 I1298_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I172_XG_MP2 (XI1298_I172_XG_p1 I1298_G21_14 I1298_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I172_XG_MP0 (VDD I1298_P21_14 XI1298_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I172_XG_MP1 (XI1298_I172_XG_p1 I1298_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I173_XG_MP2 (XI1344_I173_XG_p1 I1344_G22_15 I1344_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I173_XG_MP0 (VDD I1344_P22_15 XI1344_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I173_XG_MP1 (XI1344_I173_XG_p1 I1344_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I116_XG_MP2 (XI1344_I116_XG_p1 I1344_G20_19 I1344_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I116_XG_MP0 (VDD I1344_P20_19 XI1344_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I116_XG_MP1 (XI1344_I116_XG_p1 I1344_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I115_XG_MP2 (XI1344_I115_XG_p1 I1344_G19_18 I1344_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I115_XG_MP0 (VDD I1344_P19_18 XI1344_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I115_XG_MP1 (XI1344_I115_XG_p1 I1344_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I172_XG_MP2 (XI1344_I172_XG_p1 I1344_G21_14 I1344_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I172_XG_MP0 (VDD I1344_P21_14 XI1344_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I172_XG_MP1 (XI1344_I172_XG_p1 I1344_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I116_XG_MP2 (XI1390_I116_XG_p1 I1390_G20_19 I1390_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I116_XG_MP0 (VDD I1390_P20_19 XI1390_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I116_XG_MP1 (XI1390_I116_XG_p1 I1390_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I173_XG_MP2 (XI1390_I173_XG_p1 I1390_G22_15 I1390_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I173_XG_MP0 (VDD I1390_P22_15 XI1390_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I173_XG_MP1 (XI1390_I173_XG_p1 I1390_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I115_XG_MP2 (XI1390_I115_XG_p1 I1390_G19_18 I1390_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I115_XG_MP0 (VDD I1390_P19_18 XI1390_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I115_XG_MP1 (XI1390_I115_XG_p1 I1390_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I117_XG_MP2 (XI1390_I117_XG_p1 I1390_G21_20 I1390_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I117_XG_MP0 (VDD I1390_P21_20 XI1390_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I117_XG_MP1 (XI1390_I117_XG_p1 I1390_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I172_XG_MP2 (XI1390_I172_XG_p1 I1390_G21_14 I1390_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I172_XG_MP0 (VDD I1390_P21_14 XI1390_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I172_XG_MP1 (XI1390_I172_XG_p1 I1390_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I116_XG_MP2 (XI1436_I116_XG_p1 I1436_G20_19 I1436_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I116_XG_MP0 (VDD I1436_P20_19 XI1436_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I116_XG_MP1 (XI1436_I116_XG_p1 I1436_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I177_XG_MP2 (XI1436_I177_XG_p1 I1436_G26_19 I1436_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I177_XG_MP0 (VDD I1436_P26_19 XI1436_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I177_XG_MP1 (XI1436_I177_XG_p1 I1436_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I115_XG_MP2 (XI1436_I115_XG_p1 I1436_G19_18 I1436_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I115_XG_MP0 (VDD I1436_P19_18 XI1436_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I115_XG_MP1 (XI1436_I115_XG_p1 I1436_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I164_XG_MP2 (XI1482_I164_XG_p1 I1482_G13_6 I1482_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I164_XG_MP0 (VDD I1482_P13_6 XI1482_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I164_XG_MP1 (XI1482_I164_XG_p1 I1482_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I114_XG_MP2 (XI1482_I114_XG_p1 I1482_G18_17 I1482_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I114_XG_MP0 (VDD I1482_P18_17 XI1482_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I114_XG_MP1 (XI1482_I114_XG_p1 I1482_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I175_XG_MP2 (XI1482_I175_XG_p1 I1482_G24_17 I1482_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I175_XG_MP0 (VDD I1482_P24_17 XI1482_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I175_XG_MP1 (XI1482_I175_XG_p1 I1482_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I177_XG_MP2 (XI1482_I177_XG_p1 I1482_G26_19 I1482_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I177_XG_MP0 (VDD I1482_P26_19 XI1482_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I177_XG_MP1 (XI1482_I177_XG_p1 I1482_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I165_XG_MP2 (XI1482_I165_XG_p1 I1482_G14_7 I1482_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I165_XG_MP0 (VDD I1482_P14_7 XI1482_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I165_XG_MP1 (XI1482_I165_XG_p1 I1482_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I120_XG_MP2 (XI1528_I120_XG_p1 I1528_G24_23 I1528_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I120_XG_MP0 (VDD I1528_P24_23 XI1528_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I120_XG_MP1 (XI1528_I120_XG_p1 I1528_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I119_XG_MP2 (XI1528_I119_XG_p1 I1528_G23_22 I1528_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I119_XG_MP0 (VDD I1528_P23_22 XI1528_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I119_XG_MP1 (XI1528_I119_XG_p1 I1528_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I182_XG_MP2 (XI1528_I182_XG_p1 I1528_G31_24 I1528_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I182_XG_MP0 (VDD I1528_P31_24 XI1528_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I182_XG_MP1 (XI1528_I182_XG_p1 I1528_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I181_XG_MP2 (XI1160_I181_XG_p1 I1160_G30_23 I1160_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I181_XG_MP0 (VDD I1160_P30_23 XI1160_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I181_XG_MP1 (XI1160_I181_XG_p1 I1160_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I173_XG_MP2 (XI1160_I173_XG_p1 I1160_G22_15 I1160_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I173_XG_MP0 (VDD I1160_P22_15 XI1160_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I173_XG_MP1 (XI1160_I173_XG_p1 I1160_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_I165_XG_MP2 (XI1160_I165_XG_p1 I1160_G14_7 I1160_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_I165_XG_MP0 (VDD I1160_P14_7 XI1160_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1160_I165_XG_MP1 (XI1160_I165_XG_p1 I1160_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I111_XG_MP2 (XI1206_I111_XG_p1 I1206_G15_14 I1206_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I111_XG_MP0 (VDD I1206_P15_14 XI1206_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I111_XG_MP1 (XI1206_I111_XG_p1 I1206_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I168_XG_MP2 (XI1206_I168_XG_p1 I1206_G17_10 I1206_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I168_XG_MP0 (VDD I1206_P17_10 XI1206_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I168_XG_MP1 (XI1206_I168_XG_p1 I1206_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I112_XG_MP2 (XI1206_I112_XG_p1 I1206_G16_15 I1206_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I112_XG_MP0 (VDD I1206_P16_15 XI1206_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I112_XG_MP1 (XI1206_I112_XG_p1 I1206_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I160_XG_MP2 (XI1206_I160_XG_p1 I1206_G10_3 I1206_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I160_XG_MP0 (VDD I1206_P10_3 XI1206_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I160_XG_MP1 (XI1206_I160_XG_p1 I1206_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I116_XG_MP2 (XI1252_I116_XG_p1 I1252_G20_19 I1252_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I116_XG_MP0 (VDD I1252_P20_19 XI1252_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I116_XG_MP1 (XI1252_I116_XG_p1 I1252_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I177_XG_MP2 (XI1252_I177_XG_p1 I1252_G26_19 I1252_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I177_XG_MP0 (VDD I1252_P26_19 XI1252_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I177_XG_MP1 (XI1252_I177_XG_p1 I1252_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I115_XG_MP2 (XI1252_I115_XG_p1 I1252_G19_18 I1252_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I115_XG_MP0 (VDD I1252_P19_18 XI1252_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I115_XG_MP1 (XI1252_I115_XG_p1 I1252_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I172_XG_MP2 (XI1252_I172_XG_p1 I1252_G21_14 I1252_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I172_XG_MP0 (VDD I1252_P21_14 XI1252_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I172_XG_MP1 (XI1252_I172_XG_p1 I1252_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I173_XG_MP2 (XI1298_I173_XG_p1 I1298_G22_15 I1298_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I173_XG_MP0 (VDD I1298_P22_15 XI1298_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I173_XG_MP1 (XI1298_I173_XG_p1 I1298_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I176_XG_MP2 (XI1298_I176_XG_p1 I1298_G25_18 I1298_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I176_XG_MP0 (VDD I1298_P25_18 XI1298_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I176_XG_MP1 (XI1298_I176_XG_p1 I1298_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I118_XG_MP2 (XI1344_I118_XG_p1 I1344_G22_21 I1344_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I118_XG_MP0 (VDD I1344_P22_21 XI1344_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I118_XG_MP1 (XI1344_I118_XG_p1 I1344_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I117_XG_MP2 (XI1344_I117_XG_p1 I1344_G21_20 I1344_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I117_XG_MP0 (VDD I1344_P21_20 XI1344_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I117_XG_MP1 (XI1344_I117_XG_p1 I1344_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I178_XG_MP2 (XI1344_I178_XG_p1 I1344_G27_20 I1344_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I178_XG_MP0 (VDD I1344_P27_20 XI1344_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I178_XG_MP1 (XI1344_I178_XG_p1 I1344_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I166_XG_MP2 (XI1344_I166_XG_p1 I1344_G15_8 I1344_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I166_XG_MP0 (VDD I1344_P15_8 XI1344_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I166_XG_MP1 (XI1344_I166_XG_p1 I1344_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I118_XG_MP2 (XI1390_I118_XG_p1 I1390_G22_21 I1390_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I118_XG_MP0 (VDD I1390_P22_21 XI1390_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I118_XG_MP1 (XI1390_I118_XG_p1 I1390_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I178_XG_MP2 (XI1390_I178_XG_p1 I1390_G27_20 I1390_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I178_XG_MP0 (VDD I1390_P27_20 XI1390_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I178_XG_MP1 (XI1390_I178_XG_p1 I1390_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I166_XG_MP2 (XI1390_I166_XG_p1 I1390_G15_8 I1390_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I166_XG_MP0 (VDD I1390_P15_8 XI1390_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I166_XG_MP1 (XI1390_I166_XG_p1 I1390_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I173_XG_MP2 (XI1436_I173_XG_p1 I1436_G22_15 I1436_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I173_XG_MP0 (VDD I1436_P22_15 XI1436_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I173_XG_MP1 (XI1436_I173_XG_p1 I1436_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I172_XG_MP2 (XI1436_I172_XG_p1 I1436_G21_14 I1436_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I172_XG_MP0 (VDD I1436_P21_14 XI1436_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I172_XG_MP1 (XI1436_I172_XG_p1 I1436_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I115_XG_MP2 (XI1482_I115_XG_p1 I1482_G19_18 I1482_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I115_XG_MP0 (VDD I1482_P19_18 XI1482_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I115_XG_MP1 (XI1482_I115_XG_p1 I1482_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I170_XG_MP2 (XI1482_I170_XG_p1 I1482_G19_12 I1482_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I170_XG_MP0 (VDD I1482_P19_12 XI1482_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I170_XG_MP1 (XI1482_I170_XG_p1 I1482_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I172_XG_MP2 (XI1482_I172_XG_p1 I1482_G21_14 I1482_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I172_XG_MP0 (VDD I1482_P21_14 XI1482_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I172_XG_MP1 (XI1482_I172_XG_p1 I1482_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I116_XG_MP2 (XI1482_I116_XG_p1 I1482_G20_19 I1482_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I116_XG_MP0 (VDD I1482_P20_19 XI1482_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I116_XG_MP1 (XI1482_I116_XG_p1 I1482_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I173_XG_MP2 (XI1482_I173_XG_p1 I1482_G22_15 I1482_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I173_XG_MP0 (VDD I1482_P22_15 XI1482_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I173_XG_MP1 (XI1482_I173_XG_p1 I1482_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I122_XG_MP2 (XI1528_I122_XG_p1 I1528_G26_25 I1528_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I122_XG_MP0 (VDD I1528_P26_25 XI1528_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I122_XG_MP1 (XI1528_I122_XG_p1 I1528_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I121_XG_MP2 (XI1528_I121_XG_p1 I1528_G25_24 I1528_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I121_XG_MP0 (VDD I1528_P25_24 XI1528_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I121_XG_MP1 (XI1528_I121_XG_p1 I1528_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I113_XG_MP2 (XI1206_I113_XG_p1 I1206_G17_16 I1206_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I113_XG_MP0 (VDD I1206_P17_16 XI1206_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I113_XG_MP1 (XI1206_I113_XG_p1 I1206_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I170_XG_MP2 (XI1206_I170_XG_p1 I1206_G19_12 I1206_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I170_XG_MP0 (VDD I1206_P19_12 XI1206_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I170_XG_MP1 (XI1206_I170_XG_p1 I1206_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I162_XG_MP2 (XI1206_I162_XG_p1 I1206_G11_4 I1206_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I162_XG_MP0 (VDD I1206_P11_4 XI1206_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I162_XG_MP1 (XI1206_I162_XG_p1 I1206_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I114_XG_MP2 (XI1206_I114_XG_p1 I1206_G18_17 I1206_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I114_XG_MP0 (VDD I1206_P18_17 XI1206_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I114_XG_MP1 (XI1206_I114_XG_p1 I1206_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I171_XG_MP2 (XI1206_I171_XG_p1 I1206_G20_13 I1206_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I171_XG_MP0 (VDD I1206_P20_13 XI1206_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I171_XG_MP1 (XI1206_I171_XG_p1 I1206_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I169_XG_MP2 (XI1206_I169_XG_p1 I1206_G18_11 I1206_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I169_XG_MP0 (VDD I1206_P18_11 XI1206_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I169_XG_MP1 (XI1206_I169_XG_p1 I1206_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I118_XG_MP2 (XI1252_I118_XG_p1 I1252_G22_21 I1252_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I118_XG_MP0 (VDD I1252_P22_21 XI1252_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I118_XG_MP1 (XI1252_I118_XG_p1 I1252_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I173_XG_MP2 (XI1252_I173_XG_p1 I1252_G22_15 I1252_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I173_XG_MP0 (VDD I1252_P22_15 XI1252_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I173_XG_MP1 (XI1252_I173_XG_p1 I1252_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I117_XG_MP2 (XI1252_I117_XG_p1 I1252_G21_20 I1252_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I117_XG_MP0 (VDD I1252_P21_20 XI1252_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I117_XG_MP1 (XI1252_I117_XG_p1 I1252_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I178_XG_MP2 (XI1252_I178_XG_p1 I1252_G27_20 I1252_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I178_XG_MP0 (VDD I1252_P27_20 XI1252_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I178_XG_MP1 (XI1252_I178_XG_p1 I1252_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I166_XG_MP2 (XI1252_I166_XG_p1 I1252_G15_8 I1252_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I166_XG_MP0 (VDD I1252_P15_8 XI1252_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I166_XG_MP1 (XI1252_I166_XG_p1 I1252_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I118_XG_MP2 (XI1298_I118_XG_p1 I1298_G22_21 I1298_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I118_XG_MP0 (VDD I1298_P22_21 XI1298_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I118_XG_MP1 (XI1298_I118_XG_p1 I1298_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I179_XG_MP2 (XI1298_I179_XG_p1 I1298_G28_21 I1298_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I179_XG_MP0 (VDD I1298_P28_21 XI1298_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I179_XG_MP1 (XI1298_I179_XG_p1 I1298_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I117_XG_MP2 (XI1298_I117_XG_p1 I1298_G21_20 I1298_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I117_XG_MP0 (VDD I1298_P21_20 XI1298_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I117_XG_MP1 (XI1298_I117_XG_p1 I1298_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I166_XG_MP2 (XI1298_I166_XG_p1 I1298_G15_8 I1298_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I166_XG_MP0 (VDD I1298_P15_8 XI1298_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I166_XG_MP1 (XI1298_I166_XG_p1 I1298_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I181_XG_MP2 (XI1344_I181_XG_p1 I1344_G30_23 I1344_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I181_XG_MP0 (VDD I1344_P30_23 XI1344_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I181_XG_MP1 (XI1344_I181_XG_p1 I1344_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I179_XG_MP2 (XI1344_I179_XG_p1 I1344_G28_21 I1344_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I179_XG_MP0 (VDD I1344_P28_21 XI1344_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I179_XG_MP1 (XI1344_I179_XG_p1 I1344_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I120_XG_MP2 (XI1344_I120_XG_p1 I1344_G24_23 I1344_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I120_XG_MP0 (VDD I1344_P24_23 XI1344_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I120_XG_MP1 (XI1344_I120_XG_p1 I1344_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I174_XG_MP2 (XI1344_I174_XG_p1 I1344_G23_16 I1344_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I174_XG_MP0 (VDD I1344_P23_16 XI1344_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I174_XG_MP1 (XI1344_I174_XG_p1 I1344_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I120_XG_MP2 (XI1390_I120_XG_p1 I1390_G24_23 I1390_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I120_XG_MP0 (VDD I1390_P24_23 XI1390_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I120_XG_MP1 (XI1390_I120_XG_p1 I1390_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I179_XG_MP2 (XI1390_I179_XG_p1 I1390_G28_21 I1390_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I179_XG_MP0 (VDD I1390_P28_21 XI1390_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I179_XG_MP1 (XI1390_I179_XG_p1 I1390_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I119_XG_MP2 (XI1390_I119_XG_p1 I1390_G23_22 I1390_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I119_XG_MP0 (VDD I1390_P23_22 XI1390_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I119_XG_MP1 (XI1390_I119_XG_p1 I1390_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I174_XG_MP2 (XI1390_I174_XG_p1 I1390_G23_16 I1390_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I174_XG_MP0 (VDD I1390_P23_16 XI1390_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I174_XG_MP1 (XI1390_I174_XG_p1 I1390_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I118_XG_MP2 (XI1436_I118_XG_p1 I1436_G22_21 I1436_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I118_XG_MP0 (VDD I1436_P22_21 XI1436_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I118_XG_MP1 (XI1436_I118_XG_p1 I1436_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I179_XG_MP2 (XI1436_I179_XG_p1 I1436_G28_21 I1436_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I179_XG_MP0 (VDD I1436_P28_21 XI1436_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I179_XG_MP1 (XI1436_I179_XG_p1 I1436_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I117_XG_MP2 (XI1436_I117_XG_p1 I1436_G21_20 I1436_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I117_XG_MP0 (VDD I1436_P21_20 XI1436_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I117_XG_MP1 (XI1436_I117_XG_p1 I1436_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I176_XG_MP2 (XI1436_I176_XG_p1 I1436_G25_18 I1436_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I176_XG_MP0 (VDD I1436_P25_18 XI1436_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I176_XG_MP1 (XI1436_I176_XG_p1 I1436_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I166_XG_MP2 (XI1436_I166_XG_p1 I1436_G15_8 I1436_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I166_XG_MP0 (VDD I1436_P15_8 XI1436_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I166_XG_MP1 (XI1436_I166_XG_p1 I1436_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I117_XG_MP2 (XI1482_I117_XG_p1 I1482_G21_20 I1482_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I117_XG_MP0 (VDD I1482_P21_20 XI1482_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I117_XG_MP1 (XI1482_I117_XG_p1 I1482_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I166_XG_MP2 (XI1482_I166_XG_p1 I1482_G15_8 I1482_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I166_XG_MP0 (VDD I1482_P15_8 XI1482_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I166_XG_MP1 (XI1482_I166_XG_p1 I1482_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I176_XG_MP2 (XI1482_I176_XG_p1 I1482_G25_18 I1482_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I176_XG_MP0 (VDD I1482_P25_18 XI1482_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I176_XG_MP1 (XI1482_I176_XG_p1 I1482_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I118_XG_MP2 (XI1482_I118_XG_p1 I1482_G22_21 I1482_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I118_XG_MP0 (VDD I1482_P22_21 XI1482_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I118_XG_MP1 (XI1482_I118_XG_p1 I1482_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I179_XG_MP2 (XI1482_I179_XG_p1 I1482_G28_21 I1482_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I179_XG_MP0 (VDD I1482_P28_21 XI1482_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I179_XG_MP1 (XI1482_I179_XG_p1 I1482_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I181_XG_MP2 (XI1482_I181_XG_p1 I1482_G30_23 I1482_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I181_XG_MP0 (VDD I1482_P30_23 XI1482_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I181_XG_MP1 (XI1482_I181_XG_p1 I1482_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I124_XG_MP2 (XI1528_I124_XG_p1 I1528_G28_27 I1528_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I124_XG_MP0 (VDD I1528_P28_27 XI1528_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I124_XG_MP1 (XI1528_I124_XG_p1 I1528_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I126_XG_MP2 (XI1528_I126_XG_p1 I1528_G30_29 I1528_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I126_XG_MP0 (VDD I1528_P30_29 XI1528_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I126_XG_MP1 (XI1528_I126_XG_p1 I1528_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I123_XG_MP2 (XI1528_I123_XG_p1 I1528_G27_26 I1528_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I123_XG_MP0 (VDD I1528_P27_26 XI1528_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I123_XG_MP1 (XI1528_I123_XG_p1 I1528_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I125_XG_MP2 (XI1528_I125_XG_p1 I1528_G29_28 I1528_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I125_XG_MP0 (VDD I1528_P29_28 XI1528_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I125_XG_MP1 (XI1528_I125_XG_p1 I1528_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I115_XG_MP2 (XI1206_I115_XG_p1 I1206_G19_18 I1206_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I115_XG_MP0 (VDD I1206_P19_18 XI1206_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I115_XG_MP1 (XI1206_I115_XG_p1 I1206_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I166_XG_MP2 (XI1206_I166_XG_p1 I1206_G15_8 I1206_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I166_XG_MP0 (VDD I1206_P15_8 XI1206_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I166_XG_MP1 (XI1206_I166_XG_p1 I1206_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I164_XG_MP2 (XI1206_I164_XG_p1 I1206_G13_6 I1206_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I164_XG_MP0 (VDD I1206_P13_6 XI1206_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I164_XG_MP1 (XI1206_I164_XG_p1 I1206_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I172_XG_MP2 (XI1206_I172_XG_p1 I1206_G21_14 I1206_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I172_XG_MP0 (VDD I1206_P21_14 XI1206_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I172_XG_MP1 (XI1206_I172_XG_p1 I1206_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I116_XG_MP2 (XI1206_I116_XG_p1 I1206_G20_19 I1206_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I116_XG_MP0 (VDD I1206_P20_19 XI1206_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I116_XG_MP1 (XI1206_I116_XG_p1 I1206_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I175_XG_MP2 (XI1206_I175_XG_p1 I1206_G24_17 I1206_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I175_XG_MP0 (VDD I1206_P24_17 XI1206_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I175_XG_MP1 (XI1206_I175_XG_p1 I1206_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I120_XG_MP2 (XI1252_I120_XG_p1 I1252_G24_23 I1252_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I120_XG_MP0 (VDD I1252_P24_23 XI1252_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I120_XG_MP1 (XI1252_I120_XG_p1 I1252_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I179_XG_MP2 (XI1252_I179_XG_p1 I1252_G28_21 I1252_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I179_XG_MP0 (VDD I1252_P28_21 XI1252_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I179_XG_MP1 (XI1252_I179_XG_p1 I1252_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I119_XG_MP2 (XI1252_I119_XG_p1 I1252_G23_22 I1252_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I119_XG_MP0 (VDD I1252_P23_22 XI1252_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I119_XG_MP1 (XI1252_I119_XG_p1 I1252_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I174_XG_MP2 (XI1252_I174_XG_p1 I1252_G23_16 I1252_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I174_XG_MP0 (VDD I1252_P23_16 XI1252_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I174_XG_MP1 (XI1252_I174_XG_p1 I1252_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I120_XG_MP2 (XI1298_I120_XG_p1 I1298_G24_23 I1298_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I120_XG_MP0 (VDD I1298_P24_23 XI1298_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I120_XG_MP1 (XI1298_I120_XG_p1 I1298_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I181_XG_MP2 (XI1298_I181_XG_p1 I1298_G30_23 I1298_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I181_XG_MP0 (VDD I1298_P30_23 XI1298_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I181_XG_MP1 (XI1298_I181_XG_p1 I1298_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I119_XG_MP2 (XI1298_I119_XG_p1 I1298_G23_22 I1298_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I119_XG_MP0 (VDD I1298_P23_22 XI1298_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I119_XG_MP1 (XI1298_I119_XG_p1 I1298_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I178_XG_MP2 (XI1298_I178_XG_p1 I1298_G27_20 I1298_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I178_XG_MP0 (VDD I1298_P27_20 XI1298_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I178_XG_MP1 (XI1298_I178_XG_p1 I1298_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I174_XG_MP2 (XI1298_I174_XG_p1 I1298_G23_16 I1298_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I174_XG_MP0 (VDD I1298_P23_16 XI1298_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I174_XG_MP1 (XI1298_I174_XG_p1 I1298_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I119_XG_MP2 (XI1344_I119_XG_p1 I1344_G23_22 I1344_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I119_XG_MP0 (VDD I1344_P23_22 XI1344_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I119_XG_MP1 (XI1344_I119_XG_p1 I1344_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I181_XG_MP2 (XI1390_I181_XG_p1 I1390_G30_23 I1390_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I181_XG_MP0 (VDD I1390_P30_23 XI1390_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I181_XG_MP1 (XI1390_I181_XG_p1 I1390_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I121_XG_MP2 (XI1390_I121_XG_p1 I1390_G25_24 I1390_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I121_XG_MP0 (VDD I1390_P25_24 XI1390_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I121_XG_MP1 (XI1390_I121_XG_p1 I1390_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I180_XG_MP2 (XI1390_I180_XG_p1 I1390_G29_22 I1390_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I180_XG_MP0 (VDD I1390_P29_22 XI1390_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I180_XG_MP1 (XI1390_I180_XG_p1 I1390_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I120_XG_MP2 (XI1436_I120_XG_p1 I1436_G24_23 I1436_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I120_XG_MP0 (VDD I1436_P24_23 XI1436_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I120_XG_MP1 (XI1436_I120_XG_p1 I1436_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I181_XG_MP2 (XI1436_I181_XG_p1 I1436_G30_23 I1436_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I181_XG_MP0 (VDD I1436_P30_23 XI1436_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I181_XG_MP1 (XI1436_I181_XG_p1 I1436_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I119_XG_MP2 (XI1436_I119_XG_p1 I1436_G23_22 I1436_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I119_XG_MP0 (VDD I1436_P23_22 XI1436_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I119_XG_MP1 (XI1436_I119_XG_p1 I1436_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I180_XG_MP2 (XI1436_I180_XG_p1 I1436_G29_22 I1436_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I180_XG_MP0 (VDD I1436_P29_22 XI1436_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I180_XG_MP1 (XI1436_I180_XG_p1 I1436_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I174_XG_MP2 (XI1436_I174_XG_p1 I1436_G23_16 I1436_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I174_XG_MP0 (VDD I1436_P23_16 XI1436_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I174_XG_MP1 (XI1436_I174_XG_p1 I1436_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I174_XG_MP2 (XI1482_I174_XG_p1 I1482_G23_16 I1482_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I174_XG_MP0 (VDD I1482_P23_16 XI1482_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I174_XG_MP1 (XI1482_I174_XG_p1 I1482_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I120_XG_MP2 (XI1482_I120_XG_p1 I1482_G24_23 I1482_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I120_XG_MP0 (VDD I1482_P24_23 XI1482_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I120_XG_MP1 (XI1482_I120_XG_p1 I1482_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I122_XG_MP2 (XI1482_I122_XG_p1 I1482_G26_25 I1482_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I122_XG_MP0 (VDD I1482_P26_25 XI1482_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I122_XG_MP1 (XI1482_I122_XG_p1 I1482_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1528_I127_XG_MP2 (XI1528_I127_XG_p1 I1528_G31_30 I1528_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1528_I127_XG_MP0 (VDD I1528_P31_30 XI1528_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1528_I127_XG_MP1 (XI1528_I127_XG_p1 I1528_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I117_XG_MP2 (XI1206_I117_XG_p1 I1206_G21_20 I1206_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I117_XG_MP0 (VDD I1206_P21_20 XI1206_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I117_XG_MP1 (XI1206_I117_XG_p1 I1206_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I176_XG_MP2 (XI1206_I176_XG_p1 I1206_G25_18 I1206_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I176_XG_MP0 (VDD I1206_P25_18 XI1206_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I176_XG_MP1 (XI1206_I176_XG_p1 I1206_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I120_XG_MP2 (XI1206_I120_XG_p1 I1206_G24_23 I1206_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I120_XG_MP0 (VDD I1206_P24_23 XI1206_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I120_XG_MP1 (XI1206_I120_XG_p1 I1206_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I118_XG_MP2 (XI1206_I118_XG_p1 I1206_G22_21 I1206_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I118_XG_MP0 (VDD I1206_P22_21 XI1206_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I118_XG_MP1 (XI1206_I118_XG_p1 I1206_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I165_XG_MP2 (XI1206_I165_XG_p1 I1206_G14_7 I1206_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I165_XG_MP0 (VDD I1206_P14_7 XI1206_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I165_XG_MP1 (XI1206_I165_XG_p1 I1206_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I181_XG_MP2 (XI1252_I181_XG_p1 I1252_G30_23 I1252_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I181_XG_MP0 (VDD I1252_P30_23 XI1252_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I181_XG_MP1 (XI1252_I181_XG_p1 I1252_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I121_XG_MP2 (XI1252_I121_XG_p1 I1252_G25_24 I1252_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I121_XG_MP0 (VDD I1252_P25_24 XI1252_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I121_XG_MP1 (XI1252_I121_XG_p1 I1252_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I180_XG_MP2 (XI1252_I180_XG_p1 I1252_G29_22 I1252_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I180_XG_MP0 (VDD I1252_P29_22 XI1252_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I180_XG_MP1 (XI1252_I180_XG_p1 I1252_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I122_XG_MP2 (XI1298_I122_XG_p1 I1298_G26_25 I1298_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I122_XG_MP0 (VDD I1298_P26_25 XI1298_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I122_XG_MP1 (XI1298_I122_XG_p1 I1298_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I121_XG_MP2 (XI1298_I121_XG_p1 I1298_G25_24 I1298_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I121_XG_MP0 (VDD I1298_P25_24 XI1298_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I121_XG_MP1 (XI1298_I121_XG_p1 I1298_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I123_XG_MP2 (XI1298_I123_XG_p1 I1298_G27_26 I1298_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I123_XG_MP0 (VDD I1298_P27_26 XI1298_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I123_XG_MP1 (XI1298_I123_XG_p1 I1298_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I180_XG_MP2 (XI1298_I180_XG_p1 I1298_G29_22 I1298_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I180_XG_MP0 (VDD I1298_P29_22 XI1298_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I180_XG_MP1 (XI1298_I180_XG_p1 I1298_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I122_XG_MP2 (XI1344_I122_XG_p1 I1344_G26_25 I1344_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I122_XG_MP0 (VDD I1344_P26_25 XI1344_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I122_XG_MP1 (XI1344_I122_XG_p1 I1344_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I124_XG_MP2 (XI1344_I124_XG_p1 I1344_G28_27 I1344_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I124_XG_MP0 (VDD I1344_P28_27 XI1344_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I124_XG_MP1 (XI1344_I124_XG_p1 I1344_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I121_XG_MP2 (XI1344_I121_XG_p1 I1344_G25_24 I1344_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I121_XG_MP0 (VDD I1344_P25_24 XI1344_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I121_XG_MP1 (XI1344_I121_XG_p1 I1344_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I180_XG_MP2 (XI1344_I180_XG_p1 I1344_G29_22 I1344_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I180_XG_MP0 (VDD I1344_P29_22 XI1344_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I180_XG_MP1 (XI1344_I180_XG_p1 I1344_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I122_XG_MP2 (XI1390_I122_XG_p1 I1390_G26_25 I1390_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I122_XG_MP0 (VDD I1390_P26_25 XI1390_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I122_XG_MP1 (XI1390_I122_XG_p1 I1390_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I123_XG_MP2 (XI1390_I123_XG_p1 I1390_G27_26 I1390_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I123_XG_MP0 (VDD I1390_P27_26 XI1390_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I123_XG_MP1 (XI1390_I123_XG_p1 I1390_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I182_XG_MP2 (XI1390_I182_XG_p1 I1390_G31_24 I1390_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I182_XG_MP0 (VDD I1390_P31_24 XI1390_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I182_XG_MP1 (XI1390_I182_XG_p1 I1390_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I122_XG_MP2 (XI1436_I122_XG_p1 I1436_G26_25 I1436_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I122_XG_MP0 (VDD I1436_P26_25 XI1436_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I122_XG_MP1 (XI1436_I122_XG_p1 I1436_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I121_XG_MP2 (XI1436_I121_XG_p1 I1436_G25_24 I1436_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I121_XG_MP0 (VDD I1436_P25_24 XI1436_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I121_XG_MP1 (XI1436_I121_XG_p1 I1436_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I178_XG_MP2 (XI1436_I178_XG_p1 I1436_G27_20 I1436_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I178_XG_MP0 (VDD I1436_P27_20 XI1436_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I178_XG_MP1 (XI1436_I178_XG_p1 I1436_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I119_XG_MP2 (XI1482_I119_XG_p1 I1482_G23_22 I1482_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I119_XG_MP0 (VDD I1482_P23_22 XI1482_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I119_XG_MP1 (XI1482_I119_XG_p1 I1482_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I178_XG_MP2 (XI1482_I178_XG_p1 I1482_G27_20 I1482_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I178_XG_MP0 (VDD I1482_P27_20 XI1482_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I178_XG_MP1 (XI1482_I178_XG_p1 I1482_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I180_XG_MP2 (XI1482_I180_XG_p1 I1482_G29_22 I1482_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I180_XG_MP0 (VDD I1482_P29_22 XI1482_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I180_XG_MP1 (XI1482_I180_XG_p1 I1482_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I124_XG_MP2 (XI1482_I124_XG_p1 I1482_G28_27 I1482_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I124_XG_MP0 (VDD I1482_P28_27 XI1482_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I124_XG_MP1 (XI1482_I124_XG_p1 I1482_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I121_XG_MP2 (XI1206_I121_XG_p1 I1206_G25_24 I1206_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I121_XG_MP0 (VDD I1206_P25_24 XI1206_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I121_XG_MP1 (XI1206_I121_XG_p1 I1206_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I182_XG_MP2 (XI1206_I182_XG_p1 I1206_G31_24 I1206_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I182_XG_MP0 (VDD I1206_P31_24 XI1206_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I182_XG_MP1 (XI1206_I182_XG_p1 I1206_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I119_XG_MP2 (XI1206_I119_XG_p1 I1206_G23_22 I1206_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I119_XG_MP0 (VDD I1206_P23_22 XI1206_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I119_XG_MP1 (XI1206_I119_XG_p1 I1206_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I178_XG_MP2 (XI1206_I178_XG_p1 I1206_G27_20 I1206_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I178_XG_MP0 (VDD I1206_P27_20 XI1206_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I178_XG_MP1 (XI1206_I178_XG_p1 I1206_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I174_XG_MP2 (XI1206_I174_XG_p1 I1206_G23_16 I1206_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I174_XG_MP0 (VDD I1206_P23_16 XI1206_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I174_XG_MP1 (XI1206_I174_XG_p1 I1206_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I177_XG_MP2 (XI1206_I177_XG_p1 I1206_G26_19 I1206_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I177_XG_MP0 (VDD I1206_P26_19 XI1206_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I177_XG_MP1 (XI1206_I177_XG_p1 I1206_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I173_XG_MP2 (XI1206_I173_XG_p1 I1206_G22_15 I1206_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I173_XG_MP0 (VDD I1206_P22_15 XI1206_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I173_XG_MP1 (XI1206_I173_XG_p1 I1206_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I122_XG_MP2 (XI1252_I122_XG_p1 I1252_G26_25 I1252_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I122_XG_MP0 (VDD I1252_P26_25 XI1252_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I122_XG_MP1 (XI1252_I122_XG_p1 I1252_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I124_XG_MP2 (XI1252_I124_XG_p1 I1252_G28_27 I1252_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I124_XG_MP0 (VDD I1252_P28_27 XI1252_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I124_XG_MP1 (XI1252_I124_XG_p1 I1252_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I123_XG_MP2 (XI1252_I123_XG_p1 I1252_G27_26 I1252_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I123_XG_MP0 (VDD I1252_P27_26 XI1252_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I123_XG_MP1 (XI1252_I123_XG_p1 I1252_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I182_XG_MP2 (XI1252_I182_XG_p1 I1252_G31_24 I1252_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I182_XG_MP0 (VDD I1252_P31_24 XI1252_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I182_XG_MP1 (XI1252_I182_XG_p1 I1252_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I124_XG_MP2 (XI1298_I124_XG_p1 I1298_G28_27 I1298_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I124_XG_MP0 (VDD I1298_P28_27 XI1298_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I124_XG_MP1 (XI1298_I124_XG_p1 I1298_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I126_XG_MP2 (XI1298_I126_XG_p1 I1298_G30_29 I1298_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I126_XG_MP0 (VDD I1298_P30_29 XI1298_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I126_XG_MP1 (XI1298_I126_XG_p1 I1298_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I125_XG_MP2 (XI1298_I125_XG_p1 I1298_G29_28 I1298_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I125_XG_MP0 (VDD I1298_P29_28 XI1298_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I125_XG_MP1 (XI1298_I125_XG_p1 I1298_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I126_XG_MP2 (XI1344_I126_XG_p1 I1344_G30_29 I1344_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I126_XG_MP0 (VDD I1344_P30_29 XI1344_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I126_XG_MP1 (XI1344_I126_XG_p1 I1344_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I123_XG_MP2 (XI1344_I123_XG_p1 I1344_G27_26 I1344_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I123_XG_MP0 (VDD I1344_P27_26 XI1344_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I123_XG_MP1 (XI1344_I123_XG_p1 I1344_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I125_XG_MP2 (XI1344_I125_XG_p1 I1344_G29_28 I1344_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I125_XG_MP0 (VDD I1344_P29_28 XI1344_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I125_XG_MP1 (XI1344_I125_XG_p1 I1344_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I182_XG_MP2 (XI1344_I182_XG_p1 I1344_G31_24 I1344_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I182_XG_MP0 (VDD I1344_P31_24 XI1344_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I182_XG_MP1 (XI1344_I182_XG_p1 I1344_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I124_XG_MP2 (XI1390_I124_XG_p1 I1390_G28_27 I1390_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I124_XG_MP0 (VDD I1390_P28_27 XI1390_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I124_XG_MP1 (XI1390_I124_XG_p1 I1390_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I126_XG_MP2 (XI1390_I126_XG_p1 I1390_G30_29 I1390_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I126_XG_MP0 (VDD I1390_P30_29 XI1390_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I126_XG_MP1 (XI1390_I126_XG_p1 I1390_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I125_XG_MP2 (XI1390_I125_XG_p1 I1390_G29_28 I1390_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I125_XG_MP0 (VDD I1390_P29_28 XI1390_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I125_XG_MP1 (XI1390_I125_XG_p1 I1390_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I124_XG_MP2 (XI1436_I124_XG_p1 I1436_G28_27 I1436_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I124_XG_MP0 (VDD I1436_P28_27 XI1436_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I124_XG_MP1 (XI1436_I124_XG_p1 I1436_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I123_XG_MP2 (XI1436_I123_XG_p1 I1436_G27_26 I1436_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I123_XG_MP0 (VDD I1436_P27_26 XI1436_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I123_XG_MP1 (XI1436_I123_XG_p1 I1436_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I125_XG_MP2 (XI1436_I125_XG_p1 I1436_G29_28 I1436_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I125_XG_MP0 (VDD I1436_P29_28 XI1436_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I125_XG_MP1 (XI1436_I125_XG_p1 I1436_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I182_XG_MP2 (XI1436_I182_XG_p1 I1436_G31_24 I1436_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I182_XG_MP0 (VDD I1436_P31_24 XI1436_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I182_XG_MP1 (XI1436_I182_XG_p1 I1436_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I182_XG_MP2 (XI1482_I182_XG_p1 I1482_G31_24 I1482_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I182_XG_MP0 (VDD I1482_P31_24 XI1482_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I182_XG_MP1 (XI1482_I182_XG_p1 I1482_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I121_XG_MP2 (XI1482_I121_XG_p1 I1482_G25_24 I1482_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I121_XG_MP0 (VDD I1482_P25_24 XI1482_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I121_XG_MP1 (XI1482_I121_XG_p1 I1482_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I123_XG_MP2 (XI1482_I123_XG_p1 I1482_G27_26 I1482_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I123_XG_MP0 (VDD I1482_P27_26 XI1482_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I123_XG_MP1 (XI1482_I123_XG_p1 I1482_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I125_XG_MP2 (XI1206_I125_XG_p1 I1206_G29_28 I1206_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I125_XG_MP0 (VDD I1206_P29_28 XI1206_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I125_XG_MP1 (XI1206_I125_XG_p1 I1206_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I123_XG_MP2 (XI1206_I123_XG_p1 I1206_G27_26 I1206_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I123_XG_MP0 (VDD I1206_P27_26 XI1206_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I123_XG_MP1 (XI1206_I123_XG_p1 I1206_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I180_XG_MP2 (XI1206_I180_XG_p1 I1206_G29_22 I1206_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I180_XG_MP0 (VDD I1206_P29_22 XI1206_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I180_XG_MP1 (XI1206_I180_XG_p1 I1206_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I124_XG_MP2 (XI1206_I124_XG_p1 I1206_G28_27 I1206_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I124_XG_MP0 (VDD I1206_P28_27 XI1206_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I124_XG_MP1 (XI1206_I124_XG_p1 I1206_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I122_XG_MP2 (XI1206_I122_XG_p1 I1206_G26_25 I1206_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I122_XG_MP0 (VDD I1206_P26_25 XI1206_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I122_XG_MP1 (XI1206_I122_XG_p1 I1206_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I181_XG_MP2 (XI1206_I181_XG_p1 I1206_G30_23 I1206_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I181_XG_MP0 (VDD I1206_P30_23 XI1206_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I181_XG_MP1 (XI1206_I181_XG_p1 I1206_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I179_XG_MP2 (XI1206_I179_XG_p1 I1206_G28_21 I1206_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I179_XG_MP0 (VDD I1206_P28_21 XI1206_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I179_XG_MP1 (XI1206_I179_XG_p1 I1206_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I126_XG_MP2 (XI1252_I126_XG_p1 I1252_G30_29 I1252_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I126_XG_MP0 (VDD I1252_P30_29 XI1252_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I126_XG_MP1 (XI1252_I126_XG_p1 I1252_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I127_XG_MP2 (XI1252_I127_XG_p1 I1252_G31_30 I1252_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I127_XG_MP0 (VDD I1252_P31_30 XI1252_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I127_XG_MP1 (XI1252_I127_XG_p1 I1252_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1252_I125_XG_MP2 (XI1252_I125_XG_p1 I1252_G29_28 I1252_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1252_I125_XG_MP0 (VDD I1252_P29_28 XI1252_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1252_I125_XG_MP1 (XI1252_I125_XG_p1 I1252_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I127_XG_MP2 (XI1298_I127_XG_p1 I1298_G31_30 I1298_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I127_XG_MP0 (VDD I1298_P31_30 XI1298_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I127_XG_MP1 (XI1298_I127_XG_p1 I1298_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1298_I182_XG_MP2 (XI1298_I182_XG_p1 I1298_G31_24 I1298_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1298_I182_XG_MP0 (VDD I1298_P31_24 XI1298_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1298_I182_XG_MP1 (XI1298_I182_XG_p1 I1298_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1344_I127_XG_MP2 (XI1344_I127_XG_p1 I1344_G31_30 I1344_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1344_I127_XG_MP0 (VDD I1344_P31_30 XI1344_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1344_I127_XG_MP1 (XI1344_I127_XG_p1 I1344_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1390_I127_XG_MP2 (XI1390_I127_XG_p1 I1390_G31_30 I1390_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1390_I127_XG_MP0 (VDD I1390_P31_30 XI1390_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1390_I127_XG_MP1 (XI1390_I127_XG_p1 I1390_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I126_XG_MP2 (XI1436_I126_XG_p1 I1436_G30_29 I1436_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I126_XG_MP0 (VDD I1436_P30_29 XI1436_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I126_XG_MP1 (XI1436_I126_XG_p1 I1436_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1436_I127_XG_MP2 (XI1436_I127_XG_p1 I1436_G31_30 I1436_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1436_I127_XG_MP0 (VDD I1436_P31_30 XI1436_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1436_I127_XG_MP1 (XI1436_I127_XG_p1 I1436_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I127_XG_MP2 (XI1482_I127_XG_p1 I1482_G31_30 I1482_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I127_XG_MP0 (VDD I1482_P31_30 XI1482_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I127_XG_MP1 (XI1482_I127_XG_p1 I1482_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I125_XG_MP2 (XI1482_I125_XG_p1 I1482_G29_28 I1482_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I125_XG_MP0 (VDD I1482_P29_28 XI1482_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I125_XG_MP1 (XI1482_I125_XG_p1 I1482_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1482_I126_XG_MP2 (XI1482_I126_XG_p1 I1482_G30_29 I1482_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1482_I126_XG_MP0 (VDD I1482_P30_29 XI1482_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1482_I126_XG_MP1 (XI1482_I126_XG_p1 I1482_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I127_XG_MP2 (XI1206_I127_XG_p1 I1206_G31_30 I1206_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I127_XG_MP0 (VDD I1206_P31_30 XI1206_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I127_XG_MP1 (XI1206_I127_XG_p1 I1206_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_I126_XG_MP2 (XI1206_I126_XG_p1 I1206_G30_29 I1206_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_I126_XG_MP0 (VDD I1206_P30_29 XI1206_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1206_I126_XG_MP1 (XI1206_I126_XG_p1 I1206_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I96_XG_MP2 (VDD I654_gn30 I654_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I96_XG_MP0 (XI654_I96_XG_p1 I654_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I96_XG_MP1 (I654_G30_29 I654_gn29 XI654_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I97_XG_MP2 (VDD I654_gn31 I654_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I97_XG_MP0 (XI654_I97_XG_p1 I654_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I97_XG_MP1 (I654_G31_30 I654_gn30 XI654_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I95_XG_MP2 (VDD I654_gn29 I654_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I95_XG_MP0 (XI654_I95_XG_p1 I654_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I95_XG_MP1 (I654_G29_28 I654_gn28 XI654_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I94_XG_MP2 (VDD I654_gn28 I654_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I94_XG_MP0 (XI654_I94_XG_p1 I654_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I94_XG_MP1 (I654_G28_27 I654_gn27 XI654_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I97_XG_MP2 (VDD I608_gn31 I608_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I97_XG_MP0 (XI608_I97_XG_p1 I608_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I97_XG_MP1 (I608_G31_30 I608_gn30 XI608_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I96_XG_MP2 (VDD I608_gn30 I608_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I96_XG_MP0 (XI608_I96_XG_p1 I608_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I96_XG_MP1 (I608_G30_29 I608_gn29 XI608_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I95_XG_MP2 (VDD I608_gn29 I608_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I95_XG_MP0 (XI608_I95_XG_p1 I608_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I95_XG_MP1 (I608_G29_28 I608_gn28 XI608_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I94_XG_MP2 (VDD I608_gn28 I608_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I94_XG_MP0 (XI608_I94_XG_p1 I608_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I94_XG_MP1 (I608_G28_27 I608_gn27 XI608_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I97_XG_MP2 (VDD I562_gn31 I562_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I97_XG_MP0 (XI562_I97_XG_p1 I562_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I97_XG_MP1 (I562_G31_30 I562_gn30 XI562_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I96_XG_MP2 (VDD I562_gn30 I562_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I96_XG_MP0 (XI562_I96_XG_p1 I562_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I96_XG_MP1 (I562_G30_29 I562_gn29 XI562_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I95_XG_MP2 (VDD I562_gn29 I562_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I95_XG_MP0 (XI562_I95_XG_p1 I562_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I95_XG_MP1 (I562_G29_28 I562_gn28 XI562_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I95_XG_MP2 (VDD I2066_gn29 I2066_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I95_XG_MP0 (XI2066_I95_XG_p1 I2066_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I95_XG_MP1 (I2066_G29_28 I2066_gn28 XI2066_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I96_XG_MP2 (VDD I2066_gn30 I2066_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I96_XG_MP0 (XI2066_I96_XG_p1 I2066_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I96_XG_MP1 (I2066_G30_29 I2066_gn29 XI2066_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I97_XG_MP2 (VDD I2066_gn31 I2066_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I97_XG_MP0 (XI2066_I97_XG_p1 I2066_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I97_XG_MP1 (I2066_G31_30 I2066_gn30 XI2066_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I96_XG_MP2 (VDD I1988_gn30 I1988_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I96_XG_MP0 (XI1988_I96_XG_p1 I1988_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I96_XG_MP1 (I1988_G30_29 I1988_gn29 XI1988_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I97_XG_MP2 (VDD I1988_gn31 I1988_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I97_XG_MP0 (XI1988_I97_XG_p1 I1988_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I97_XG_MP1 (I1988_G31_30 I1988_gn30 XI1988_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I95_XG_MP2 (VDD I1988_gn29 I1988_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I95_XG_MP0 (XI1988_I95_XG_p1 I1988_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I95_XG_MP1 (I1988_G29_28 I1988_gn28 XI1988_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I96_XG_MP2 (VDD I1942_gn30 I1942_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I96_XG_MP0 (XI1942_I96_XG_p1 I1942_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I96_XG_MP1 (I1942_G30_29 I1942_gn29 XI1942_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I97_XG_MP2 (VDD I1942_gn31 I1942_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I97_XG_MP0 (XI1942_I97_XG_p1 I1942_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I97_XG_MP1 (I1942_G31_30 I1942_gn30 XI1942_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I95_XG_MP2 (VDD I1942_gn29 I1942_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I95_XG_MP0 (XI1942_I95_XG_p1 I1942_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I95_XG_MP1 (I1942_G29_28 I1942_gn28 XI1942_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I94_XG_MP2 (VDD I1942_gn28 I1942_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I94_XG_MP0 (XI1942_I94_XG_p1 I1942_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I94_XG_MP1 (I1942_G28_27 I1942_gn27 XI1942_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I201_XG_MP2 (VDD I1896_G30_15n c29_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I201_XG_MP0 (XI1896_I201_XG_p1 I1896_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I201_XG_MP1 (c29_m I1896_G14_0n XI1896_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I155_XG_MP2 (VDD I1896_G30_27n I1896_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I155_XG_MP0 (XI1896_I155_XG_p1 I1896_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I155_XG_MP1 (I1896_G30_23 I1896_G26_23n XI1896_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I93_XG_MP2 (VDD I1896_gn27 I1896_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I93_XG_MP0 (XI1896_I93_XG_p1 I1896_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I93_XG_MP1 (I1896_G27_26 I1896_gn26 XI1896_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I94_XG_MP2 (VDD I1896_gn28 I1896_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I94_XG_MP0 (XI1896_I94_XG_p1 I1896_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I94_XG_MP1 (I1896_G28_27 I1896_gn27 XI1896_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I96_XG_MP2 (VDD I700_gn30 I700_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I96_XG_MP0 (XI700_I96_XG_p1 I700_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I96_XG_MP1 (I700_G30_29 I700_gn29 XI700_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I97_XG_MP2 (VDD I700_gn31 I700_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I97_XG_MP0 (XI700_I97_XG_p1 I700_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I97_XG_MP1 (I700_G31_30 I700_gn30 XI700_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I202_XG_MP2 (VDD I654_G31_16n c2_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I202_XG_MP0 (XI654_I202_XG_p1 I654_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I202_XG_MP1 (c2_o I654_G15_0n XI654_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I152_XG_MP2 (VDD I654_G27_24n I654_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I152_XG_MP0 (XI654_I152_XG_p1 I654_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I152_XG_MP1 (I654_G27_20 I654_G23_20n XI654_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I156_XG_MP2 (VDD I654_G31_28n I654_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I156_XG_MP0 (XI654_I156_XG_p1 I654_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I156_XG_MP1 (I654_G31_24 I654_G27_24n XI654_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I93_XG_MP2 (VDD I654_gn27 I654_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I93_XG_MP0 (XI654_I93_XG_p1 I654_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I93_XG_MP1 (I654_G27_26 I654_gn26 XI654_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I92_XG_MP2 (VDD I654_gn26 I654_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I92_XG_MP0 (XI654_I92_XG_p1 I654_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I92_XG_MP1 (I654_G26_25 I654_gn25 XI654_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I202_XG_MP2 (VDD I608_G31_16n c1_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I202_XG_MP0 (XI608_I202_XG_p1 I608_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I202_XG_MP1 (c1_o I608_G15_0n XI608_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I198_XG_MP2 (VDD I608_G27_12n I608_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I198_XG_MP0 (XI608_I198_XG_p1 I608_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I198_XG_MP1 (I608_G27_0 I608_G11_0n XI608_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I156_XG_MP2 (VDD I608_G31_28n I608_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I156_XG_MP0 (XI608_I156_XG_p1 I608_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I156_XG_MP1 (I608_G31_24 I608_G27_24n XI608_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I93_XG_MP2 (VDD I608_gn27 I608_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I93_XG_MP0 (XI608_I93_XG_p1 I608_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I93_XG_MP1 (I608_G27_26 I608_gn26 XI608_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I92_XG_MP2 (VDD I608_gn26 I608_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I92_XG_MP0 (XI608_I92_XG_p1 I608_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I92_XG_MP1 (I608_G26_25 I608_gn25 XI608_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I91_XG_MP2 (VDD I608_gn25 I608_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I91_XG_MP0 (XI608_I91_XG_p1 I608_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I91_XG_MP1 (I608_G25_24 I608_gn24 XI608_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I94_XG_MP2 (VDD I562_gn28 I562_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I94_XG_MP0 (XI562_I94_XG_p1 I562_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I94_XG_MP1 (I562_G28_27 I562_gn27 XI562_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I93_XG_MP2 (VDD I562_gn27 I562_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I93_XG_MP0 (XI562_I93_XG_p1 I562_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I93_XG_MP1 (I562_G27_26 I562_gn26 XI562_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I156_XG_MP2 (VDD I2066_G31_28n I2066_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I156_XG_MP0 (XI2066_I156_XG_p1 I2066_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I156_XG_MP1 (I2066_G31_24 I2066_G27_24n XI2066_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I93_XG_MP2 (VDD I2066_gn27 I2066_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I93_XG_MP0 (XI2066_I93_XG_p1 I2066_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I93_XG_MP1 (I2066_G27_26 I2066_gn26 XI2066_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I94_XG_MP2 (VDD I2066_gn28 I2066_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I94_XG_MP0 (XI2066_I94_XG_p1 I2066_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I94_XG_MP1 (I2066_G28_27 I2066_gn27 XI2066_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I94_XG_MP2 (VDD I1988_gn28 I1988_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I94_XG_MP0 (XI1988_I94_XG_p1 I1988_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I94_XG_MP1 (I1988_G28_27 I1988_gn27 XI1988_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I93_XG_MP2 (VDD I1988_gn27 I1988_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I93_XG_MP0 (XI1988_I93_XG_p1 I1988_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I93_XG_MP1 (I1988_G27_26 I1988_gn26 XI1988_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I201_XG_MP2 (VDD I1942_G30_15n c30_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I201_XG_MP0 (XI1942_I201_XG_p1 I1942_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I201_XG_MP1 (c30_m I1942_G14_0n XI1942_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I155_XG_MP2 (VDD I1942_G30_27n I1942_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I155_XG_MP0 (XI1942_I155_XG_p1 I1942_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I155_XG_MP1 (I1942_G30_23 I1942_G26_23n XI1942_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I202_XG_MP2 (VDD I1942_G31_16n c30_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I202_XG_MP0 (XI1942_I202_XG_p1 I1942_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I202_XG_MP1 (c30_o I1942_G15_0n XI1942_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I156_XG_MP2 (VDD I1942_G31_28n I1942_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I156_XG_MP0 (XI1942_I156_XG_p1 I1942_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I156_XG_MP1 (I1942_G31_24 I1942_G27_24n XI1942_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I91_XG_MP2 (VDD I1942_gn25 I1942_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I91_XG_MP0 (XI1942_I91_XG_p1 I1942_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I91_XG_MP1 (I1942_G25_24 I1942_gn24 XI1942_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I92_XG_MP2 (VDD I1942_gn26 I1942_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I92_XG_MP0 (XI1942_I92_XG_p1 I1942_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I92_XG_MP1 (I1942_G26_25 I1942_gn25 XI1942_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I93_XG_MP2 (VDD I1942_gn27 I1942_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I93_XG_MP0 (XI1942_I93_XG_p1 I1942_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I93_XG_MP1 (I1942_G27_26 I1942_gn26 XI1942_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I197_XG_MP2 (VDD I1896_G26_11n I1896_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I197_XG_MP0 (XI1896_I197_XG_p1 I1896_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I197_XG_MP1 (I1896_G26_0 I1896_G10_0n XI1896_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I199_XG_MP2 (VDD I1896_G28_13n I1896_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I199_XG_MP0 (XI1896_I199_XG_p1 I1896_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I199_XG_MP1 (I1896_G28_0 I1896_G12_0n XI1896_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I151_XG_MP2 (VDD I1896_G26_23n I1896_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I151_XG_MP0 (XI1896_I151_XG_p1 I1896_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I151_XG_MP1 (I1896_G26_19 I1896_G22_19n XI1896_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I153_XG_MP2 (VDD I1896_G28_25n I1896_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I153_XG_MP0 (XI1896_I153_XG_p1 I1896_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I153_XG_MP1 (I1896_G28_21 I1896_G24_21n XI1896_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I92_XG_MP2 (VDD I1896_gn26 I1896_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I92_XG_MP0 (XI1896_I92_XG_p1 I1896_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I92_XG_MP1 (I1896_G26_25 I1896_gn25 XI1896_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I91_XG_MP2 (VDD I1896_gn25 I1896_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I91_XG_MP0 (XI1896_I91_XG_p1 I1896_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I91_XG_MP1 (I1896_G25_24 I1896_gn24 XI1896_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I95_XG_MP2 (VDD I1896_gn29 I1896_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I95_XG_MP0 (XI1896_I95_XG_p1 I1896_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I95_XG_MP1 (I1896_G29_28 I1896_gn28 XI1896_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I96_XG_MP2 (VDD I1896_gn30 I1896_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I96_XG_MP0 (XI1896_I96_XG_p1 I1896_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I96_XG_MP1 (I1896_G30_29 I1896_gn29 XI1896_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I95_XG_MP2 (VDD I700_gn29 I700_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I95_XG_MP0 (XI700_I95_XG_p1 I700_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I95_XG_MP1 (I700_G29_28 I700_gn28 XI700_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I94_XG_MP2 (VDD I700_gn28 I700_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I94_XG_MP0 (XI700_I94_XG_p1 I700_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I94_XG_MP1 (I700_G28_27 I700_gn27 XI700_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I198_XG_MP2 (VDD I654_G27_12n I654_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I198_XG_MP0 (XI654_I198_XG_p1 I654_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I198_XG_MP1 (I654_G27_0 I654_G11_0n XI654_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I154_XG_MP2 (VDD I654_G29_26n I654_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I154_XG_MP0 (XI654_I154_XG_p1 I654_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I154_XG_MP1 (I654_G29_22 I654_G25_22n XI654_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I201_XG_MP2 (VDD I654_G30_15n c2_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I201_XG_MP0 (XI654_I201_XG_p1 I654_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I201_XG_MP1 (c2_m I654_G14_0n XI654_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I155_XG_MP2 (VDD I654_G30_27n I654_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I155_XG_MP0 (XI654_I155_XG_p1 I654_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I155_XG_MP1 (I654_G30_23 I654_G26_23n XI654_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I153_XG_MP2 (VDD I654_G28_25n I654_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I153_XG_MP0 (XI654_I153_XG_p1 I654_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I153_XG_MP1 (I654_G28_21 I654_G24_21n XI654_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I91_XG_MP2 (VDD I654_gn25 I654_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I91_XG_MP0 (XI654_I91_XG_p1 I654_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I91_XG_MP1 (I654_G25_24 I654_gn24 XI654_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I90_XG_MP2 (VDD I654_gn24 I654_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I90_XG_MP0 (XI654_I90_XG_p1 I654_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I90_XG_MP1 (I654_G24_23 I654_gn23 XI654_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I194_XG_MP2 (VDD I608_G23_8n I608_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I194_XG_MP0 (XI608_I194_XG_p1 I608_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I194_XG_MP1 (I608_G23_0 I608_G7_0n XI608_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I148_XG_MP2 (VDD I608_G23_20n I608_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I148_XG_MP0 (XI608_I148_XG_p1 I608_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I148_XG_MP1 (I608_G23_16 I608_G19_16n XI608_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I152_XG_MP2 (VDD I608_G27_24n I608_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I152_XG_MP0 (XI608_I152_XG_p1 I608_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I152_XG_MP1 (I608_G27_20 I608_G23_20n XI608_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I154_XG_MP2 (VDD I608_G29_26n I608_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I154_XG_MP0 (XI608_I154_XG_p1 I608_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I154_XG_MP1 (I608_G29_22 I608_G25_22n XI608_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I155_XG_MP2 (VDD I608_G30_27n I608_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I155_XG_MP0 (XI608_I155_XG_p1 I608_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I155_XG_MP1 (I608_G30_23 I608_G26_23n XI608_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I90_XG_MP2 (VDD I608_gn24 I608_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I90_XG_MP0 (XI608_I90_XG_p1 I608_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I90_XG_MP1 (I608_G24_23 I608_gn23 XI608_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I90_XG_MP2 (VDD I562_gn24 I562_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I90_XG_MP0 (XI562_I90_XG_p1 I562_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I90_XG_MP1 (I562_G24_23 I562_gn23 XI562_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I91_XG_MP2 (VDD I562_gn25 I562_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I91_XG_MP0 (XI562_I91_XG_p1 I562_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I91_XG_MP1 (I562_G25_24 I562_gn24 XI562_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I92_XG_MP2 (VDD I562_gn26 I562_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I92_XG_MP0 (XI562_I92_XG_p1 I562_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I92_XG_MP1 (I562_G26_25 I562_gn25 XI562_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I156_XG_MP2 (VDD I562_G31_28n I562_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I156_XG_MP0 (XI562_I156_XG_p1 I562_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I156_XG_MP1 (I562_G31_24 I562_G27_24n XI562_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I202_XG_MP2 (VDD I2066_G31_16n rco VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I202_XG_MP0 (XI2066_I202_XG_p1 I2066_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I202_XG_MP1 (rco I2066_G15_0n XI2066_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I200_XG_MP2 (VDD I2066_G29_14n I2066_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I200_XG_MP0 (XI2066_I200_XG_p1 I2066_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I200_XG_MP1 (I2066_G29_0 I2066_G13_0n XI2066_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I154_XG_MP2 (VDD I2066_G29_26n I2066_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I154_XG_MP0 (XI2066_I154_XG_p1 I2066_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I154_XG_MP1 (I2066_G29_22 I2066_G25_22n XI2066_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I155_XG_MP2 (VDD I2066_G30_27n I2066_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I155_XG_MP0 (XI2066_I155_XG_p1 I2066_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I155_XG_MP1 (I2066_G30_23 I2066_G26_23n XI2066_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I91_XG_MP2 (VDD I2066_gn25 I2066_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I91_XG_MP0 (XI2066_I91_XG_p1 I2066_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I91_XG_MP1 (I2066_G25_24 I2066_gn24 XI2066_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I92_XG_MP2 (VDD I2066_gn26 I2066_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I92_XG_MP0 (XI2066_I92_XG_p1 I2066_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I92_XG_MP1 (I2066_G26_25 I2066_gn25 XI2066_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I155_XG_MP2 (VDD I1988_G30_27n I1988_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I155_XG_MP0 (XI1988_I155_XG_p1 I1988_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I155_XG_MP1 (I1988_G30_23 I1988_G26_23n XI1988_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I202_XG_MP2 (VDD I1988_G31_16n c31_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I202_XG_MP0 (XI1988_I202_XG_p1 I1988_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I202_XG_MP1 (c31_o I1988_G15_0n XI1988_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I156_XG_MP2 (VDD I1988_G31_28n I1988_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I156_XG_MP0 (XI1988_I156_XG_p1 I1988_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I156_XG_MP1 (I1988_G31_24 I1988_G27_24n XI1988_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I92_XG_MP2 (VDD I1988_gn26 I1988_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I92_XG_MP0 (XI1988_I92_XG_p1 I1988_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I92_XG_MP1 (I1988_G26_25 I1988_gn25 XI1988_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I91_XG_MP2 (VDD I1988_gn25 I1988_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I91_XG_MP0 (XI1988_I91_XG_p1 I1988_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I91_XG_MP1 (I1988_G25_24 I1988_gn24 XI1988_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I199_XG_MP2 (VDD I1942_G28_13n I1942_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I199_XG_MP0 (XI1942_I199_XG_p1 I1942_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I199_XG_MP1 (I1942_G28_0 I1942_G12_0n XI1942_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I153_XG_MP2 (VDD I1942_G28_25n I1942_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I153_XG_MP0 (XI1942_I153_XG_p1 I1942_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I153_XG_MP1 (I1942_G28_21 I1942_G24_21n XI1942_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I200_XG_MP2 (VDD I1942_G29_14n I1942_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I200_XG_MP0 (XI1942_I200_XG_p1 I1942_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I200_XG_MP1 (I1942_G29_0 I1942_G13_0n XI1942_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I154_XG_MP2 (VDD I1942_G29_26n I1942_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I154_XG_MP0 (XI1942_I154_XG_p1 I1942_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I154_XG_MP1 (I1942_G29_22 I1942_G25_22n XI1942_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I89_XG_MP2 (VDD I1942_gn23 I1942_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I89_XG_MP0 (XI1942_I89_XG_p1 I1942_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I89_XG_MP1 (I1942_G23_22 I1942_gn22 XI1942_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I90_XG_MP2 (VDD I1942_gn24 I1942_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I90_XG_MP0 (XI1942_I90_XG_p1 I1942_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I90_XG_MP1 (I1942_G24_23 I1942_gn23 XI1942_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I195_XG_MP2 (VDD I1896_G24_9n I1896_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I195_XG_MP0 (XI1896_I195_XG_p1 I1896_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I195_XG_MP1 (I1896_G24_0 I1896_G8_0n XI1896_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I192_XG_MP2 (VDD I1896_G22_7n I1896_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I192_XG_MP0 (XI1896_I192_XG_p1 I1896_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I192_XG_MP1 (I1896_G22_0 I1896_G6_0n XI1896_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I149_XG_MP2 (VDD I1896_G24_21n I1896_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I149_XG_MP0 (XI1896_I149_XG_p1 I1896_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I149_XG_MP1 (I1896_G24_17 I1896_G20_17n XI1896_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I147_XG_MP2 (VDD I1896_G22_19n I1896_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I147_XG_MP0 (XI1896_I147_XG_p1 I1896_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I147_XG_MP1 (I1896_G22_15 I1896_G18_15n XI1896_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I200_XG_MP2 (VDD I1896_G29_14n I1896_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I200_XG_MP0 (XI1896_I200_XG_p1 I1896_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I200_XG_MP1 (I1896_G29_0 I1896_G13_0n XI1896_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I154_XG_MP2 (VDD I1896_G29_26n I1896_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I154_XG_MP0 (XI1896_I154_XG_p1 I1896_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I154_XG_MP1 (I1896_G29_22 I1896_G25_22n XI1896_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I90_XG_MP2 (VDD I1896_gn24 I1896_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I90_XG_MP0 (XI1896_I90_XG_p1 I1896_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I90_XG_MP1 (I1896_G24_23 I1896_gn23 XI1896_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I93_XG_MP2 (VDD I700_gn27 I700_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I93_XG_MP0 (XI700_I93_XG_p1 I700_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I93_XG_MP1 (I700_G27_26 I700_gn26 XI700_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I194_XG_MP2 (VDD I654_G23_8n I654_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I194_XG_MP0 (XI654_I194_XG_p1 I654_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I194_XG_MP1 (I654_G23_0 I654_G7_0n XI654_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I148_XG_MP2 (VDD I654_G23_20n I654_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I148_XG_MP0 (XI654_I148_XG_p1 I654_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I148_XG_MP1 (I654_G23_16 I654_G19_16n XI654_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I200_XG_MP2 (VDD I654_G29_14n I654_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I200_XG_MP0 (XI654_I200_XG_p1 I654_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I200_XG_MP1 (I654_G29_0 I654_G13_0n XI654_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I199_XG_MP2 (VDD I654_G28_13n I654_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I199_XG_MP0 (XI654_I199_XG_p1 I654_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I199_XG_MP1 (I654_G28_0 I654_G12_0n XI654_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I151_XG_MP2 (VDD I654_G26_23n I654_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I151_XG_MP0 (XI654_I151_XG_p1 I654_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I151_XG_MP1 (I654_G26_19 I654_G22_19n XI654_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I88_XG_MP2 (VDD I654_gn22 I654_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I88_XG_MP0 (XI654_I88_XG_p1 I654_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I88_XG_MP1 (I654_G22_21 I654_gn21 XI654_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I89_XG_MP2 (VDD I654_gn23 I654_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I89_XG_MP0 (XI654_I89_XG_p1 I654_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I89_XG_MP1 (I654_G23_22 I654_gn22 XI654_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I200_XG_MP2 (VDD I608_G29_14n I608_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I200_XG_MP0 (XI608_I200_XG_p1 I608_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I200_XG_MP1 (I608_G29_0 I608_G13_0n XI608_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I201_XG_MP2 (VDD I608_G30_15n c1_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I201_XG_MP0 (XI608_I201_XG_p1 I608_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I201_XG_MP1 (c1_m I608_G14_0n XI608_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I153_XG_MP2 (VDD I608_G28_25n I608_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I153_XG_MP0 (XI608_I153_XG_p1 I608_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I153_XG_MP1 (I608_G28_21 I608_G24_21n XI608_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I89_XG_MP2 (VDD I608_gn23 I608_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I89_XG_MP0 (XI608_I89_XG_p1 I608_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I89_XG_MP1 (I608_G23_22 I608_gn22 XI608_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I88_XG_MP2 (VDD I608_gn22 I608_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I88_XG_MP0 (XI608_I88_XG_p1 I608_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I88_XG_MP1 (I608_G22_21 I608_gn21 XI608_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I89_XG_MP2 (VDD I562_gn23 I562_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I89_XG_MP0 (XI562_I89_XG_p1 I562_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I89_XG_MP1 (I562_G23_22 I562_gn22 XI562_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I155_XG_MP2 (VDD I562_G30_27n I562_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I155_XG_MP0 (XI562_I155_XG_p1 I562_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I155_XG_MP1 (I562_G30_23 I562_G26_23n XI562_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I154_XG_MP2 (VDD I562_G29_26n I562_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I154_XG_MP0 (XI562_I154_XG_p1 I562_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I154_XG_MP1 (I562_G29_22 I562_G25_22n XI562_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I194_XG_MP2 (VDD I2066_G23_8n I2066_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I194_XG_MP0 (XI2066_I194_XG_p1 I2066_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I194_XG_MP1 (I2066_G23_0 I2066_G7_0n XI2066_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I148_XG_MP2 (VDD I2066_G23_20n I2066_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I148_XG_MP0 (XI2066_I148_XG_p1 I2066_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I148_XG_MP1 (I2066_G23_16 I2066_G19_16n XI2066_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I152_XG_MP2 (VDD I2066_G27_24n I2066_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I152_XG_MP0 (XI2066_I152_XG_p1 I2066_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I152_XG_MP1 (I2066_G27_20 I2066_G23_20n XI2066_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I201_XG_MP2 (VDD I2066_G30_15n rcm VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I201_XG_MP0 (XI2066_I201_XG_p1 I2066_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I201_XG_MP1 (rcm I2066_G14_0n XI2066_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I90_XG_MP2 (VDD I2066_gn24 I2066_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I90_XG_MP0 (XI2066_I90_XG_p1 I2066_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I90_XG_MP1 (I2066_G24_23 I2066_gn23 XI2066_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I89_XG_MP2 (VDD I2066_gn23 I2066_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I89_XG_MP0 (XI2066_I89_XG_p1 I2066_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I89_XG_MP1 (I2066_G23_22 I2066_gn22 XI2066_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I201_XG_MP2 (VDD I1988_G30_15n c31_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I201_XG_MP0 (XI1988_I201_XG_p1 I1988_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I201_XG_MP1 (c31_m I1988_G14_0n XI1988_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I200_XG_MP2 (VDD I1988_G29_14n I1988_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I200_XG_MP0 (XI1988_I200_XG_p1 I1988_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I200_XG_MP1 (I1988_G29_0 I1988_G13_0n XI1988_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I154_XG_MP2 (VDD I1988_G29_26n I1988_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I154_XG_MP0 (XI1988_I154_XG_p1 I1988_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I154_XG_MP1 (I1988_G29_22 I1988_G25_22n XI1988_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I89_XG_MP2 (VDD I1988_gn23 I1988_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I89_XG_MP0 (XI1988_I89_XG_p1 I1988_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I89_XG_MP1 (I1988_G23_22 I1988_gn22 XI1988_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I90_XG_MP2 (VDD I1988_gn24 I1988_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I90_XG_MP0 (XI1988_I90_XG_p1 I1988_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I90_XG_MP1 (I1988_G24_23 I1988_gn23 XI1988_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I197_XG_MP2 (VDD I1942_G26_11n I1942_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I197_XG_MP0 (XI1942_I197_XG_p1 I1942_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I197_XG_MP1 (I1942_G26_0 I1942_G10_0n XI1942_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I192_XG_MP2 (VDD I1942_G22_7n I1942_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I192_XG_MP0 (XI1942_I192_XG_p1 I1942_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I192_XG_MP1 (I1942_G22_0 I1942_G6_0n XI1942_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I147_XG_MP2 (VDD I1942_G22_19n I1942_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I147_XG_MP0 (XI1942_I147_XG_p1 I1942_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I147_XG_MP1 (I1942_G22_15 I1942_G18_15n XI1942_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I151_XG_MP2 (VDD I1942_G26_23n I1942_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I151_XG_MP0 (XI1942_I151_XG_p1 I1942_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I151_XG_MP1 (I1942_G26_19 I1942_G22_19n XI1942_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I198_XG_MP2 (VDD I1942_G27_12n I1942_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I198_XG_MP0 (XI1942_I198_XG_p1 I1942_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I198_XG_MP1 (I1942_G27_0 I1942_G11_0n XI1942_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I194_XG_MP2 (VDD I1942_G23_8n I1942_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I194_XG_MP0 (XI1942_I194_XG_p1 I1942_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I194_XG_MP1 (I1942_G23_0 I1942_G7_0n XI1942_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I152_XG_MP2 (VDD I1942_G27_24n I1942_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I152_XG_MP0 (XI1942_I152_XG_p1 I1942_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I152_XG_MP1 (I1942_G27_20 I1942_G23_20n XI1942_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I148_XG_MP2 (VDD I1942_G23_20n I1942_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I148_XG_MP0 (XI1942_I148_XG_p1 I1942_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I148_XG_MP1 (I1942_G23_16 I1942_G19_16n XI1942_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I88_XG_MP2 (VDD I1942_gn22 I1942_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I88_XG_MP0 (XI1942_I88_XG_p1 I1942_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I88_XG_MP1 (I1942_G22_21 I1942_gn21 XI1942_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I188_XG_MP2 (VDD I1896_G20_5n I1896_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I188_XG_MP0 (XI1896_I188_XG_p1 I1896_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I188_XG_MP1 (I1896_G20_0 I1896_G4_0n XI1896_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I196_XG_MP2 (VDD I1896_G25_10n I1896_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I196_XG_MP0 (XI1896_I196_XG_p1 I1896_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I196_XG_MP1 (I1896_G25_0 I1896_G9_0n XI1896_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I145_XG_MP2 (VDD I1896_G20_17n I1896_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I145_XG_MP0 (XI1896_I145_XG_p1 I1896_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I145_XG_MP1 (I1896_G20_13 I1896_G16_13n XI1896_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I150_XG_MP2 (VDD I1896_G25_22n I1896_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I150_XG_MP0 (XI1896_I150_XG_p1 I1896_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I150_XG_MP1 (I1896_G25_18 I1896_G21_18n XI1896_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I87_XG_MP2 (VDD I1896_gn21 I1896_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I87_XG_MP0 (XI1896_I87_XG_p1 I1896_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I87_XG_MP1 (I1896_G21_20 I1896_gn20 XI1896_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I88_XG_MP2 (VDD I1896_gn22 I1896_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I88_XG_MP0 (XI1896_I88_XG_p1 I1896_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I88_XG_MP1 (I1896_G22_21 I1896_gn21 XI1896_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I89_XG_MP2 (VDD I1896_gn23 I1896_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I89_XG_MP0 (XI1896_I89_XG_p1 I1896_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I89_XG_MP1 (I1896_G23_22 I1896_gn22 XI1896_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I97_XG_MP2 (VDD I1896_gn31 I1896_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I97_XG_MP0 (XI1896_I97_XG_p1 I1896_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I97_XG_MP1 (I1896_G31_30 I1896_gn30 XI1896_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I92_XG_MP2 (VDD I700_gn26 I700_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I92_XG_MP0 (XI700_I92_XG_p1 I700_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I92_XG_MP1 (I700_G26_25 I700_gn25 XI700_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I91_XG_MP2 (VDD I700_gn25 I700_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I91_XG_MP0 (XI700_I91_XG_p1 I700_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I91_XG_MP1 (I700_G25_24 I700_gn24 XI700_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I90_XG_MP2 (VDD I700_gn24 I700_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I90_XG_MP0 (XI700_I90_XG_p1 I700_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I90_XG_MP1 (I700_G24_23 I700_gn23 XI700_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I144_XG_MP2 (VDD I654_G19_16n I654_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I144_XG_MP0 (XI654_I144_XG_p1 I654_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I144_XG_MP1 (I654_G19_12 I654_G15_12n XI654_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I150_XG_MP2 (VDD I654_G25_22n I654_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I150_XG_MP0 (XI654_I150_XG_p1 I654_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I150_XG_MP1 (I654_G25_18 I654_G21_18n XI654_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I146_XG_MP2 (VDD I654_G21_18n I654_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I146_XG_MP0 (XI654_I146_XG_p1 I654_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I146_XG_MP1 (I654_G21_14 I654_G17_14n XI654_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I192_XG_MP2 (VDD I654_G22_7n I654_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I192_XG_MP0 (XI654_I192_XG_p1 I654_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I192_XG_MP1 (I654_G22_0 I654_G6_0n XI654_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I147_XG_MP2 (VDD I654_G22_19n I654_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I147_XG_MP0 (XI654_I147_XG_p1 I654_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I147_XG_MP1 (I654_G22_15 I654_G18_15n XI654_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I86_XG_MP2 (VDD I654_gn20 I654_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I86_XG_MP0 (XI654_I86_XG_p1 I654_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I86_XG_MP1 (I654_G20_19 I654_gn19 XI654_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I87_XG_MP2 (VDD I654_gn21 I654_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I87_XG_MP0 (XI654_I87_XG_p1 I654_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I87_XG_MP1 (I654_G21_20 I654_gn20 XI654_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I190_XG_MP2 (VDD I608_G21_6n I608_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I190_XG_MP0 (XI608_I190_XG_p1 I608_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I190_XG_MP1 (I608_G21_0 I608_G5_0n XI608_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I146_XG_MP2 (VDD I608_G21_18n I608_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I146_XG_MP0 (XI608_I146_XG_p1 I608_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I146_XG_MP1 (I608_G21_14 I608_G17_14n XI608_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I150_XG_MP2 (VDD I608_G25_22n I608_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I150_XG_MP0 (XI608_I150_XG_p1 I608_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I150_XG_MP1 (I608_G25_18 I608_G21_18n XI608_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I199_XG_MP2 (VDD I608_G28_13n I608_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I199_XG_MP0 (XI608_I199_XG_p1 I608_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I199_XG_MP1 (I608_G28_0 I608_G12_0n XI608_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I151_XG_MP2 (VDD I608_G26_23n I608_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I151_XG_MP0 (XI608_I151_XG_p1 I608_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I151_XG_MP1 (I608_G26_19 I608_G22_19n XI608_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I147_XG_MP2 (VDD I608_G22_19n I608_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I147_XG_MP0 (XI608_I147_XG_p1 I608_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I147_XG_MP1 (I608_G22_15 I608_G18_15n XI608_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I86_XG_MP2 (VDD I608_gn20 I608_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I86_XG_MP0 (XI608_I86_XG_p1 I608_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I86_XG_MP1 (I608_G20_19 I608_gn19 XI608_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I87_XG_MP2 (VDD I608_gn21 I608_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I87_XG_MP0 (XI608_I87_XG_p1 I608_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I87_XG_MP1 (I608_G21_20 I608_gn20 XI608_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I87_XG_MP2 (VDD I562_gn21 I562_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I87_XG_MP0 (XI562_I87_XG_p1 I562_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I87_XG_MP1 (I562_G21_20 I562_gn20 XI562_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I88_XG_MP2 (VDD I562_gn22 I562_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I88_XG_MP0 (XI562_I88_XG_p1 I562_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I88_XG_MP1 (I562_G22_21 I562_gn21 XI562_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I201_XG_MP2 (VDD I562_G30_15n c0_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I201_XG_MP0 (XI562_I201_XG_p1 I562_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I201_XG_MP1 (c0_m I562_G14_0n XI562_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I200_XG_MP2 (VDD I562_G29_14n I562_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I200_XG_MP0 (XI562_I200_XG_p1 I562_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I200_XG_MP1 (I562_G29_0 I562_G13_0n XI562_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I150_XG_MP2 (VDD I562_G25_22n I562_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I150_XG_MP0 (XI562_I150_XG_p1 I562_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I150_XG_MP1 (I562_G25_18 I562_G21_18n XI562_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I148_XG_MP2 (VDD I562_G23_20n I562_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I148_XG_MP0 (XI562_I148_XG_p1 I562_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I148_XG_MP1 (I562_G23_16 I562_G19_16n XI562_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I152_XG_MP2 (VDD I562_G27_24n I562_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I152_XG_MP0 (XI562_I152_XG_p1 I562_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I152_XG_MP1 (I562_G27_20 I562_G23_20n XI562_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I202_XG_MP2 (VDD I562_G31_16n c0_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I202_XG_MP0 (XI562_I202_XG_p1 I562_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I202_XG_MP1 (c0_o I562_G15_0n XI562_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I194_XG_MP2 (VDD I562_G23_8n I562_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I194_XG_MP0 (XI562_I194_XG_p1 I562_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I194_XG_MP1 (I562_G23_0 I562_G7_0n XI562_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I198_XG_MP2 (VDD I2066_G27_12n I2066_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I198_XG_MP0 (XI2066_I198_XG_p1 I2066_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I198_XG_MP1 (I2066_G27_0 I2066_G11_0n XI2066_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I150_XG_MP2 (VDD I2066_G25_22n I2066_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I150_XG_MP0 (XI2066_I150_XG_p1 I2066_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I150_XG_MP1 (I2066_G25_18 I2066_G21_18n XI2066_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I192_XG_MP2 (VDD I2066_G22_7n I2066_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I192_XG_MP0 (XI2066_I192_XG_p1 I2066_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I192_XG_MP1 (I2066_G22_0 I2066_G6_0n XI2066_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I151_XG_MP2 (VDD I2066_G26_23n I2066_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I151_XG_MP0 (XI2066_I151_XG_p1 I2066_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I151_XG_MP1 (I2066_G26_19 I2066_G22_19n XI2066_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I153_XG_MP2 (VDD I2066_G28_25n I2066_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I153_XG_MP0 (XI2066_I153_XG_p1 I2066_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I153_XG_MP1 (I2066_G28_21 I2066_G24_21n XI2066_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I88_XG_MP2 (VDD I2066_gn22 I2066_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I88_XG_MP0 (XI2066_I88_XG_p1 I2066_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I88_XG_MP1 (I2066_G22_21 I2066_gn21 XI2066_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I87_XG_MP2 (VDD I2066_gn21 I2066_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I87_XG_MP0 (XI2066_I87_XG_p1 I2066_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I87_XG_MP1 (I2066_G21_20 I2066_gn20 XI2066_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I199_XG_MP2 (VDD I1988_G28_13n I1988_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I199_XG_MP0 (XI1988_I199_XG_p1 I1988_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I199_XG_MP1 (I1988_G28_0 I1988_G12_0n XI1988_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I151_XG_MP2 (VDD I1988_G26_23n I1988_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I151_XG_MP0 (XI1988_I151_XG_p1 I1988_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I151_XG_MP1 (I1988_G26_19 I1988_G22_19n XI1988_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I153_XG_MP2 (VDD I1988_G28_25n I1988_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I153_XG_MP0 (XI1988_I153_XG_p1 I1988_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I153_XG_MP1 (I1988_G28_21 I1988_G24_21n XI1988_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I194_XG_MP2 (VDD I1988_G23_8n I1988_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I194_XG_MP0 (XI1988_I194_XG_p1 I1988_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I194_XG_MP1 (I1988_G23_0 I1988_G7_0n XI1988_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I152_XG_MP2 (VDD I1988_G27_24n I1988_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I152_XG_MP0 (XI1988_I152_XG_p1 I1988_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I152_XG_MP1 (I1988_G27_20 I1988_G23_20n XI1988_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I148_XG_MP2 (VDD I1988_G23_20n I1988_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I148_XG_MP0 (XI1988_I148_XG_p1 I1988_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I148_XG_MP1 (I1988_G23_16 I1988_G19_16n XI1988_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I87_XG_MP2 (VDD I1988_gn21 I1988_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I87_XG_MP0 (XI1988_I87_XG_p1 I1988_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I87_XG_MP1 (I1988_G21_20 I1988_gn20 XI1988_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I88_XG_MP2 (VDD I1988_gn22 I1988_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I88_XG_MP0 (XI1988_I88_XG_p1 I1988_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I88_XG_MP1 (I1988_G22_21 I1988_gn21 XI1988_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I149_XG_MP2 (VDD I1942_G24_21n I1942_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I149_XG_MP0 (XI1942_I149_XG_p1 I1942_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I149_XG_MP1 (I1942_G24_17 I1942_G20_17n XI1942_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I196_XG_MP2 (VDD I1942_G25_10n I1942_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I196_XG_MP0 (XI1942_I196_XG_p1 I1942_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I196_XG_MP1 (I1942_G25_0 I1942_G9_0n XI1942_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I150_XG_MP2 (VDD I1942_G25_22n I1942_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I150_XG_MP0 (XI1942_I150_XG_p1 I1942_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I150_XG_MP1 (I1942_G25_18 I1942_G21_18n XI1942_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I86_XG_MP2 (VDD I1942_gn20 I1942_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I86_XG_MP0 (XI1942_I86_XG_p1 I1942_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I86_XG_MP1 (I1942_G20_19 I1942_gn19 XI1942_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I87_XG_MP2 (VDD I1942_gn21 I1942_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I87_XG_MP0 (XI1942_I87_XG_p1 I1942_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I87_XG_MP1 (I1942_G21_20 I1942_gn20 XI1942_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I185_XG_MP2 (VDD I1896_G18_3n I1896_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I185_XG_MP0 (XI1896_I185_XG_p1 I1896_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I185_XG_MP1 (I1896_G18_0 I1896_G2_0n XI1896_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I139_XG_MP2 (VDD I1896_G14_11n I1896_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I139_XG_MP0 (XI1896_I139_XG_p1 I1896_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I139_XG_MP1 (I1896_G14_7 I1896_G10_7n XI1896_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I143_XG_MP2 (VDD I1896_G18_15n I1896_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I143_XG_MP0 (XI1896_I143_XG_p1 I1896_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I143_XG_MP1 (I1896_G18_11 I1896_G14_11n XI1896_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I190_XG_MP2 (VDD I1896_G21_6n I1896_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I190_XG_MP0 (XI1896_I190_XG_p1 I1896_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I190_XG_MP1 (I1896_G21_0 I1896_G5_0n XI1896_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I84_XG_MP2 (VDD I1896_gn18 I1896_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I84_XG_MP0 (XI1896_I84_XG_p1 I1896_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I84_XG_MP1 (I1896_G18_17 I1896_gn17 XI1896_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I85_XG_MP2 (VDD I1896_gn19 I1896_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I85_XG_MP0 (XI1896_I85_XG_p1 I1896_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I85_XG_MP1 (I1896_G19_18 I1896_gn18 XI1896_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I146_XG_MP2 (VDD I1896_G21_18n I1896_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I146_XG_MP0 (XI1896_I146_XG_p1 I1896_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I146_XG_MP1 (I1896_G21_14 I1896_G17_14n XI1896_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I86_XG_MP2 (VDD I1896_gn20 I1896_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I86_XG_MP0 (XI1896_I86_XG_p1 I1896_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I86_XG_MP1 (I1896_G20_19 I1896_gn19 XI1896_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I152_XG_MP2 (VDD I1896_G27_24n I1896_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I152_XG_MP0 (XI1896_I152_XG_p1 I1896_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I152_XG_MP1 (I1896_G27_20 I1896_G23_20n XI1896_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I156_XG_MP2 (VDD I1896_G31_28n I1896_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I156_XG_MP0 (XI1896_I156_XG_p1 I1896_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I156_XG_MP1 (I1896_G31_24 I1896_G27_24n XI1896_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I156_XG_MP2 (VDD I700_G31_28n I700_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I156_XG_MP0 (XI700_I156_XG_p1 I700_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I156_XG_MP1 (I700_G31_24 I700_G27_24n XI700_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I89_XG_MP2 (VDD I700_gn23 I700_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I89_XG_MP0 (XI700_I89_XG_p1 I700_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I89_XG_MP1 (I700_G23_22 I700_gn22 XI700_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I88_XG_MP2 (VDD I700_gn22 I700_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I88_XG_MP0 (XI700_I88_XG_p1 I700_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I88_XG_MP1 (I700_G22_21 I700_gn21 XI700_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I87_XG_MP2 (VDD I700_gn21 I700_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I87_XG_MP0 (XI700_I87_XG_p1 I700_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I87_XG_MP1 (I700_G21_20 I700_gn20 XI700_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I186_XG_MP2 (VDD I654_G19_4n I654_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I186_XG_MP0 (XI654_I186_XG_p1 I654_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I186_XG_MP1 (I654_G19_0 I654_G3_0n XI654_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I190_XG_MP2 (VDD I654_G21_6n I654_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I190_XG_MP0 (XI654_I190_XG_p1 I654_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I190_XG_MP1 (I654_G21_0 I654_G5_0n XI654_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I196_XG_MP2 (VDD I654_G25_10n I654_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I196_XG_MP0 (XI654_I196_XG_p1 I654_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I196_XG_MP1 (I654_G25_0 I654_G9_0n XI654_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I197_XG_MP2 (VDD I654_G26_11n I654_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I197_XG_MP0 (XI654_I197_XG_p1 I654_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I197_XG_MP1 (I654_G26_0 I654_G10_0n XI654_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I195_XG_MP2 (VDD I654_G24_9n I654_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I195_XG_MP0 (XI654_I195_XG_p1 I654_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I195_XG_MP1 (I654_G24_0 I654_G8_0n XI654_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I149_XG_MP2 (VDD I654_G24_21n I654_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I149_XG_MP0 (XI654_I149_XG_p1 I654_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I149_XG_MP1 (I654_G24_17 I654_G20_17n XI654_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I85_XG_MP2 (VDD I654_gn19 I654_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I85_XG_MP0 (XI654_I85_XG_p1 I654_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I85_XG_MP1 (I654_G19_18 I654_gn18 XI654_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I84_XG_MP2 (VDD I654_gn18 I654_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I84_XG_MP0 (XI654_I84_XG_p1 I654_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I84_XG_MP1 (I654_G18_17 I654_gn17 XI654_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I196_XG_MP2 (VDD I608_G25_10n I608_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I196_XG_MP0 (XI608_I196_XG_p1 I608_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I196_XG_MP1 (I608_G25_0 I608_G9_0n XI608_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I192_XG_MP2 (VDD I608_G22_7n I608_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I192_XG_MP0 (XI608_I192_XG_p1 I608_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I192_XG_MP1 (I608_G22_0 I608_G6_0n XI608_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I197_XG_MP2 (VDD I608_G26_11n I608_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I197_XG_MP0 (XI608_I197_XG_p1 I608_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I197_XG_MP1 (I608_G26_0 I608_G10_0n XI608_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I149_XG_MP2 (VDD I608_G24_21n I608_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I149_XG_MP0 (XI608_I149_XG_p1 I608_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I149_XG_MP1 (I608_G24_17 I608_G20_17n XI608_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I85_XG_MP2 (VDD I608_gn19 I608_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I85_XG_MP0 (XI608_I85_XG_p1 I608_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I85_XG_MP1 (I608_G19_18 I608_gn18 XI608_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I85_XG_MP2 (VDD I562_gn19 I562_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I85_XG_MP0 (XI562_I85_XG_p1 I562_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I85_XG_MP1 (I562_G19_18 I562_gn18 XI562_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I86_XG_MP2 (VDD I562_gn20 I562_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I86_XG_MP0 (XI562_I86_XG_p1 I562_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I86_XG_MP1 (I562_G20_19 I562_gn19 XI562_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I192_XG_MP2 (VDD I562_G22_7n I562_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I192_XG_MP0 (XI562_I192_XG_p1 I562_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I192_XG_MP1 (I562_G22_0 I562_G6_0n XI562_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I153_XG_MP2 (VDD I562_G28_25n I562_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I153_XG_MP0 (XI562_I153_XG_p1 I562_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I153_XG_MP1 (I562_G28_21 I562_G24_21n XI562_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I147_XG_MP2 (VDD I562_G22_19n I562_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I147_XG_MP0 (XI562_I147_XG_p1 I562_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I147_XG_MP1 (I562_G22_15 I562_G18_15n XI562_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I151_XG_MP2 (VDD I562_G26_23n I562_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I151_XG_MP0 (XI562_I151_XG_p1 I562_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I151_XG_MP1 (I562_G26_19 I562_G22_19n XI562_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I190_XG_MP2 (VDD I562_G21_6n I562_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I190_XG_MP0 (XI562_I190_XG_p1 I562_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I190_XG_MP1 (I562_G21_0 I562_G5_0n XI562_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I146_XG_MP2 (VDD I562_G21_18n I562_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I146_XG_MP0 (XI562_I146_XG_p1 I562_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I146_XG_MP1 (I562_G21_14 I562_G17_14n XI562_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I198_XG_MP2 (VDD I562_G27_12n I562_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I198_XG_MP0 (XI562_I198_XG_p1 I562_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I198_XG_MP1 (I562_G27_0 I562_G11_0n XI562_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I190_XG_MP2 (VDD I2066_G21_6n I2066_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I190_XG_MP0 (XI2066_I190_XG_p1 I2066_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I190_XG_MP1 (I2066_G21_0 I2066_G5_0n XI2066_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I146_XG_MP2 (VDD I2066_G21_18n I2066_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I146_XG_MP0 (XI2066_I146_XG_p1 I2066_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I146_XG_MP1 (I2066_G21_14 I2066_G17_14n XI2066_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I197_XG_MP2 (VDD I2066_G26_11n I2066_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I197_XG_MP0 (XI2066_I197_XG_p1 I2066_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I197_XG_MP1 (I2066_G26_0 I2066_G10_0n XI2066_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I199_XG_MP2 (VDD I2066_G28_13n I2066_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I199_XG_MP0 (XI2066_I199_XG_p1 I2066_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I199_XG_MP1 (I2066_G28_0 I2066_G12_0n XI2066_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I149_XG_MP2 (VDD I2066_G24_21n I2066_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I149_XG_MP0 (XI2066_I149_XG_p1 I2066_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I149_XG_MP1 (I2066_G24_17 I2066_G20_17n XI2066_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I147_XG_MP2 (VDD I2066_G22_19n I2066_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I147_XG_MP0 (XI2066_I147_XG_p1 I2066_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I147_XG_MP1 (I2066_G22_15 I2066_G18_15n XI2066_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I86_XG_MP2 (VDD I2066_gn20 I2066_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I86_XG_MP0 (XI2066_I86_XG_p1 I2066_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I86_XG_MP1 (I2066_G20_19 I2066_gn19 XI2066_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I85_XG_MP2 (VDD I2066_gn19 I2066_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I85_XG_MP0 (XI2066_I85_XG_p1 I2066_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I85_XG_MP1 (I2066_G19_18 I2066_gn18 XI2066_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I197_XG_MP2 (VDD I1988_G26_11n I1988_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I197_XG_MP0 (XI1988_I197_XG_p1 I1988_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I197_XG_MP1 (I1988_G26_0 I1988_G10_0n XI1988_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I147_XG_MP2 (VDD I1988_G22_19n I1988_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I147_XG_MP0 (XI1988_I147_XG_p1 I1988_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I147_XG_MP1 (I1988_G22_15 I1988_G18_15n XI1988_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I198_XG_MP2 (VDD I1988_G27_12n I1988_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I198_XG_MP0 (XI1988_I198_XG_p1 I1988_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I198_XG_MP1 (I1988_G27_0 I1988_G11_0n XI1988_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I150_XG_MP2 (VDD I1988_G25_22n I1988_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I150_XG_MP0 (XI1988_I150_XG_p1 I1988_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I150_XG_MP1 (I1988_G25_18 I1988_G21_18n XI1988_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I146_XG_MP2 (VDD I1988_G21_18n I1988_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I146_XG_MP0 (XI1988_I146_XG_p1 I1988_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I146_XG_MP1 (I1988_G21_14 I1988_G17_14n XI1988_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I86_XG_MP2 (VDD I1988_gn20 I1988_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I86_XG_MP0 (XI1988_I86_XG_p1 I1988_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I86_XG_MP1 (I1988_G20_19 I1988_gn19 XI1988_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I85_XG_MP2 (VDD I1988_gn19 I1988_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I85_XG_MP0 (XI1988_I85_XG_p1 I1988_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I85_XG_MP1 (I1988_G19_18 I1988_gn18 XI1988_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I188_XG_MP2 (VDD I1942_G20_5n I1942_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I188_XG_MP0 (XI1942_I188_XG_p1 I1942_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I188_XG_MP1 (I1942_G20_0 I1942_G4_0n XI1942_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I195_XG_MP2 (VDD I1942_G24_9n I1942_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I195_XG_MP0 (XI1942_I195_XG_p1 I1942_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I195_XG_MP1 (I1942_G24_0 I1942_G8_0n XI1942_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I145_XG_MP2 (VDD I1942_G20_17n I1942_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I145_XG_MP0 (XI1942_I145_XG_p1 I1942_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I145_XG_MP1 (I1942_G20_13 I1942_G16_13n XI1942_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I190_XG_MP2 (VDD I1942_G21_6n I1942_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I190_XG_MP0 (XI1942_I190_XG_p1 I1942_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I190_XG_MP1 (I1942_G21_0 I1942_G5_0n XI1942_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I144_XG_MP2 (VDD I1942_G19_16n I1942_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I144_XG_MP0 (XI1942_I144_XG_p1 I1942_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I144_XG_MP1 (I1942_G19_12 I1942_G15_12n XI1942_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I146_XG_MP2 (VDD I1942_G21_18n I1942_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I146_XG_MP0 (XI1942_I146_XG_p1 I1942_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I146_XG_MP1 (I1942_G21_14 I1942_G17_14n XI1942_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I85_XG_MP2 (VDD I1942_gn19 I1942_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I85_XG_MP0 (XI1942_I85_XG_p1 I1942_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I85_XG_MP1 (I1942_G19_18 I1942_gn18 XI1942_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I84_XG_MP2 (VDD I1942_gn18 I1942_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I84_XG_MP0 (XI1942_I84_XG_p1 I1942_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I84_XG_MP1 (I1942_G18_17 I1942_gn17 XI1942_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I131_XG_MP2 (VDD I1896_G6_3n I1896_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I131_XG_MP0 (XI1896_I131_XG_p1 I1896_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I131_XG_MP1 (I1896_G6_0 I1896_G2_0n XI1896_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I135_XG_MP2 (VDD I1896_G10_7n I1896_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I135_XG_MP0 (XI1896_I135_XG_p1 I1896_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I135_XG_MP1 (I1896_G10_3 I1896_G6_3n XI1896_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I141_XG_MP2 (VDD I1896_G16_13n I1896_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I141_XG_MP0 (XI1896_I141_XG_p1 I1896_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I141_XG_MP1 (I1896_G16_9 I1896_G12_9n XI1896_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I198_XG_MP2 (VDD I1896_G27_12n I1896_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I198_XG_MP0 (XI1896_I198_XG_p1 I1896_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I198_XG_MP1 (I1896_G27_0 I1896_G11_0n XI1896_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I148_XG_MP2 (VDD I1896_G23_20n I1896_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I148_XG_MP0 (XI1896_I148_XG_p1 I1896_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I148_XG_MP1 (I1896_G23_16 I1896_G19_16n XI1896_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I86_XG_MP2 (VDD I700_gn20 I700_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I86_XG_MP0 (XI700_I86_XG_p1 I700_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I86_XG_MP1 (I700_G20_19 I700_gn19 XI700_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I202_XG_MP2 (VDD I700_G31_16n c3_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I202_XG_MP0 (XI700_I202_XG_p1 I700_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I202_XG_MP1 (c3_o I700_G15_0n XI700_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I85_XG_MP2 (VDD I700_gn19 I700_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I85_XG_MP0 (XI700_I85_XG_p1 I700_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I85_XG_MP1 (I700_G19_18 I700_gn18 XI700_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I140_XG_MP2 (VDD I654_G15_12n I654_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I140_XG_MP0 (XI654_I140_XG_p1 I654_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I140_XG_MP1 (I654_G15_8 I654_G11_8n XI654_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I136_XG_MP2 (VDD I654_G11_8n I654_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I136_XG_MP0 (XI654_I136_XG_p1 I654_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I136_XG_MP1 (I654_G11_4 I654_G7_4n XI654_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I142_XG_MP2 (VDD I654_G17_14n I654_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I142_XG_MP0 (XI654_I142_XG_p1 I654_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I142_XG_MP1 (I654_G17_10 I654_G13_10n XI654_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I188_XG_MP2 (VDD I654_G20_5n I654_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I188_XG_MP0 (XI654_I188_XG_p1 I654_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I188_XG_MP1 (I654_G20_0 I654_G4_0n XI654_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I145_XG_MP2 (VDD I654_G20_17n I654_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I145_XG_MP0 (XI654_I145_XG_p1 I654_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I145_XG_MP1 (I654_G20_13 I654_G16_13n XI654_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I83_XG_MP2 (VDD I654_gn17 I654_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I83_XG_MP0 (XI654_I83_XG_p1 I654_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I83_XG_MP1 (I654_G17_16 I654_gn16 XI654_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I82_XG_MP2 (VDD I654_gn16 I654_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I82_XG_MP0 (XI654_I82_XG_p1 I654_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I82_XG_MP1 (I654_G16_15 I654_gn15 XI654_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I144_XG_MP2 (VDD I608_G19_16n I608_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I144_XG_MP0 (XI608_I144_XG_p1 I608_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I144_XG_MP1 (I608_G19_12 I608_G15_12n XI608_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I145_XG_MP2 (VDD I608_G20_17n I608_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I145_XG_MP0 (XI608_I145_XG_p1 I608_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I145_XG_MP1 (I608_G20_13 I608_G16_13n XI608_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I84_XG_MP2 (VDD I608_gn18 I608_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I84_XG_MP0 (XI608_I84_XG_p1 I608_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I84_XG_MP1 (I608_G18_17 I608_gn17 XI608_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I83_XG_MP2 (VDD I608_gn17 I608_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I83_XG_MP0 (XI608_I83_XG_p1 I608_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I83_XG_MP1 (I608_G17_16 I608_gn16 XI608_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I199_XG_MP2 (VDD I562_G28_13n I562_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I199_XG_MP0 (XI562_I199_XG_p1 I562_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I199_XG_MP1 (I562_G28_0 I562_G12_0n XI562_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I197_XG_MP2 (VDD I562_G26_11n I562_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I197_XG_MP0 (XI562_I197_XG_p1 I562_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I197_XG_MP1 (I562_G26_0 I562_G10_0n XI562_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I196_XG_MP2 (VDD I562_G25_10n I562_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I196_XG_MP0 (XI562_I196_XG_p1 I562_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I196_XG_MP1 (I562_G25_0 I562_G9_0n XI562_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I144_XG_MP2 (VDD I562_G19_16n I562_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I144_XG_MP0 (XI562_I144_XG_p1 I562_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I144_XG_MP1 (I562_G19_12 I562_G15_12n XI562_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I140_XG_MP2 (VDD I562_G15_12n I562_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I140_XG_MP0 (XI562_I140_XG_p1 I562_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I140_XG_MP1 (I562_G15_8 I562_G11_8n XI562_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I186_XG_MP2 (VDD I2066_G19_4n I2066_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I186_XG_MP0 (XI2066_I186_XG_p1 I2066_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I186_XG_MP1 (I2066_G19_0 I2066_G3_0n XI2066_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I144_XG_MP2 (VDD I2066_G19_16n I2066_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I144_XG_MP0 (XI2066_I144_XG_p1 I2066_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I144_XG_MP1 (I2066_G19_12 I2066_G15_12n XI2066_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I188_XG_MP2 (VDD I2066_G20_5n I2066_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I188_XG_MP0 (XI2066_I188_XG_p1 I2066_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I188_XG_MP1 (I2066_G20_0 I2066_G4_0n XI2066_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I145_XG_MP2 (VDD I2066_G20_17n I2066_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I145_XG_MP0 (XI2066_I145_XG_p1 I2066_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I145_XG_MP1 (I2066_G20_13 I2066_G16_13n XI2066_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I83_XG_MP2 (VDD I2066_gn17 I2066_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I83_XG_MP0 (XI2066_I83_XG_p1 I2066_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I83_XG_MP1 (I2066_G17_16 I2066_gn16 XI2066_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I84_XG_MP2 (VDD I2066_gn18 I2066_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I84_XG_MP0 (XI2066_I84_XG_p1 I2066_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I84_XG_MP1 (I2066_G18_17 I2066_gn17 XI2066_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I192_XG_MP2 (VDD I1988_G22_7n I1988_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I192_XG_MP0 (XI1988_I192_XG_p1 I1988_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I192_XG_MP1 (I1988_G22_0 I1988_G6_0n XI1988_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I149_XG_MP2 (VDD I1988_G24_21n I1988_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I149_XG_MP0 (XI1988_I149_XG_p1 I1988_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I149_XG_MP1 (I1988_G24_17 I1988_G20_17n XI1988_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I190_XG_MP2 (VDD I1988_G21_6n I1988_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I190_XG_MP0 (XI1988_I190_XG_p1 I1988_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I190_XG_MP1 (I1988_G21_0 I1988_G5_0n XI1988_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I144_XG_MP2 (VDD I1988_G19_16n I1988_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I144_XG_MP0 (XI1988_I144_XG_p1 I1988_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I144_XG_MP1 (I1988_G19_12 I1988_G15_12n XI1988_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I84_XG_MP2 (VDD I1988_gn18 I1988_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I84_XG_MP0 (XI1988_I84_XG_p1 I1988_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I84_XG_MP1 (I1988_G18_17 I1988_gn17 XI1988_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I83_XG_MP2 (VDD I1988_gn17 I1988_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I83_XG_MP0 (XI1988_I83_XG_p1 I1988_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I83_XG_MP1 (I1988_G17_16 I1988_gn16 XI1988_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I143_XG_MP2 (VDD I1942_G18_15n I1942_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I143_XG_MP0 (XI1942_I143_XG_p1 I1942_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I143_XG_MP1 (I1942_G18_11 I1942_G14_11n XI1942_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I140_XG_MP2 (VDD I1942_G15_12n I1942_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I140_XG_MP0 (XI1942_I140_XG_p1 I1942_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I140_XG_MP1 (I1942_G15_8 I1942_G11_8n XI1942_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I142_XG_MP2 (VDD I1942_G17_14n I1942_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I142_XG_MP0 (XI1942_I142_XG_p1 I1942_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I142_XG_MP1 (I1942_G17_10 I1942_G13_10n XI1942_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I82_XG_MP2 (VDD I1942_gn16 I1942_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I82_XG_MP0 (XI1942_I82_XG_p1 I1942_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I82_XG_MP1 (I1942_G16_15 I1942_gn15 XI1942_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I83_XG_MP2 (VDD I1942_gn17 I1942_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1942_I83_XG_MP0 (XI1942_I83_XG_p1 I1942_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1942_I83_XG_MP1 (I1942_G17_16 I1942_gn16 XI1942_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I183_XG_MP2 (VDD I1896_G16_1n I1896_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I183_XG_MP0 (XI1896_I183_XG_p1 I1896_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I183_XG_MP1 (I1896_G16_0 I1896_G0_0n XI1896_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I184_XG_MP2 (VDD I1896_G17_2n I1896_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I184_XG_MP0 (XI1896_I184_XG_p1 I1896_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I184_XG_MP1 (I1896_G17_0 I1896_G1_0n XI1896_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I137_XG_MP2 (VDD I1896_G12_9n I1896_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I137_XG_MP0 (XI1896_I137_XG_p1 I1896_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I137_XG_MP1 (I1896_G12_5 I1896_G8_5n XI1896_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I138_XG_MP2 (VDD I1896_G13_10n I1896_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I138_XG_MP0 (XI1896_I138_XG_p1 I1896_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I138_XG_MP1 (I1896_G13_6 I1896_G9_6n XI1896_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I142_XG_MP2 (VDD I1896_G17_14n I1896_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I142_XG_MP0 (XI1896_I142_XG_p1 I1896_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I142_XG_MP1 (I1896_G17_10 I1896_G13_10n XI1896_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I82_XG_MP2 (VDD I1896_gn16 I1896_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I82_XG_MP0 (XI1896_I82_XG_p1 I1896_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I82_XG_MP1 (I1896_G16_15 I1896_gn15 XI1896_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I83_XG_MP2 (VDD I1896_gn17 I1896_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I83_XG_MP0 (XI1896_I83_XG_p1 I1896_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I83_XG_MP1 (I1896_G17_16 I1896_gn16 XI1896_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I144_XG_MP2 (VDD I1896_G19_16n I1896_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I144_XG_MP0 (XI1896_I144_XG_p1 I1896_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I144_XG_MP1 (I1896_G19_12 I1896_G15_12n XI1896_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I202_XG_MP2 (VDD I1896_G31_16n c29_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1896_I202_XG_MP0 (XI1896_I202_XG_p1 I1896_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1896_I202_XG_MP1 (c29_o I1896_G15_0n XI1896_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I154_XG_MP2 (VDD I700_G29_26n I700_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I154_XG_MP0 (XI700_I154_XG_p1 I700_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I154_XG_MP1 (I700_G29_22 I700_G25_22n XI700_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I152_XG_MP2 (VDD I700_G27_24n I700_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I152_XG_MP0 (XI700_I152_XG_p1 I700_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I152_XG_MP1 (I700_G27_20 I700_G23_20n XI700_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I148_XG_MP2 (VDD I700_G23_20n I700_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I148_XG_MP0 (XI700_I148_XG_p1 I700_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I148_XG_MP1 (I700_G23_16 I700_G19_16n XI700_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I84_XG_MP2 (VDD I700_gn18 I700_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I84_XG_MP0 (XI700_I84_XG_p1 I700_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I84_XG_MP1 (I700_G18_17 I700_gn17 XI700_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I83_XG_MP2 (VDD I700_gn17 I700_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI700_I83_XG_MP0 (XI700_I83_XG_p1 I700_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI700_I83_XG_MP1 (I700_G17_16 I700_gn16 XI700_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I132_XG_MP2 (VDD I654_G7_4n I654_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I132_XG_MP0 (XI654_I132_XG_p1 I654_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I132_XG_MP1 (I654_G7_0 I654_G3_0n XI654_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I138_XG_MP2 (VDD I654_G13_10n I654_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I138_XG_MP0 (XI654_I138_XG_p1 I654_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I138_XG_MP1 (I654_G13_6 I654_G9_6n XI654_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I139_XG_MP2 (VDD I654_G14_11n I654_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I139_XG_MP0 (XI654_I139_XG_p1 I654_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I139_XG_MP1 (I654_G14_7 I654_G10_7n XI654_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I143_XG_MP2 (VDD I654_G18_15n I654_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I143_XG_MP0 (XI654_I143_XG_p1 I654_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I143_XG_MP1 (I654_G18_11 I654_G14_11n XI654_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I141_XG_MP2 (VDD I654_G16_13n I654_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I141_XG_MP0 (XI654_I141_XG_p1 I654_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I141_XG_MP1 (I654_G16_9 I654_G12_9n XI654_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I80_XG_MP2 (VDD I654_gn14 I654_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I80_XG_MP0 (XI654_I80_XG_p1 I654_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I80_XG_MP1 (I654_G14_13 I654_gn13 XI654_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I81_XG_MP2 (VDD I654_gn15 I654_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI654_I81_XG_MP0 (XI654_I81_XG_p1 I654_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI654_I81_XG_MP1 (I654_G15_14 I654_gn14 XI654_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I186_XG_MP2 (VDD I608_G19_4n I608_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I186_XG_MP0 (XI608_I186_XG_p1 I608_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I186_XG_MP1 (I608_G19_0 I608_G3_0n XI608_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I140_XG_MP2 (VDD I608_G15_12n I608_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I140_XG_MP0 (XI608_I140_XG_p1 I608_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I140_XG_MP1 (I608_G15_8 I608_G11_8n XI608_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I142_XG_MP2 (VDD I608_G17_14n I608_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I142_XG_MP0 (XI608_I142_XG_p1 I608_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I142_XG_MP1 (I608_G17_10 I608_G13_10n XI608_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I188_XG_MP2 (VDD I608_G20_5n I608_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I188_XG_MP0 (XI608_I188_XG_p1 I608_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I188_XG_MP1 (I608_G20_0 I608_G4_0n XI608_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I143_XG_MP2 (VDD I608_G18_15n I608_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I143_XG_MP0 (XI608_I143_XG_p1 I608_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I143_XG_MP1 (I608_G18_11 I608_G14_11n XI608_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I81_XG_MP2 (VDD I608_gn15 I608_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I81_XG_MP0 (XI608_I81_XG_p1 I608_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I81_XG_MP1 (I608_G15_14 I608_gn14 XI608_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I82_XG_MP2 (VDD I608_gn16 I608_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI608_I82_XG_MP0 (XI608_I82_XG_p1 I608_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI608_I82_XG_MP1 (I608_G16_15 I608_gn15 XI608_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I84_XG_MP2 (VDD I562_gn18 I562_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I84_XG_MP0 (XI562_I84_XG_p1 I562_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I84_XG_MP1 (I562_G18_17 I562_gn17 XI562_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I83_XG_MP2 (VDD I562_gn17 I562_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I83_XG_MP0 (XI562_I83_XG_p1 I562_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I83_XG_MP1 (I562_G17_16 I562_gn16 XI562_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I142_XG_MP2 (VDD I562_G17_14n I562_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I142_XG_MP0 (XI562_I142_XG_p1 I562_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I142_XG_MP1 (I562_G17_10 I562_G13_10n XI562_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I186_XG_MP2 (VDD I562_G19_4n I562_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI562_I186_XG_MP0 (XI562_I186_XG_p1 I562_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI562_I186_XG_MP1 (I562_G19_0 I562_G3_0n XI562_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I140_XG_MP2 (VDD I2066_G15_12n I2066_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I140_XG_MP0 (XI2066_I140_XG_p1 I2066_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I140_XG_MP1 (I2066_G15_8 I2066_G11_8n XI2066_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I196_XG_MP2 (VDD I2066_G25_10n I2066_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I196_XG_MP0 (XI2066_I196_XG_p1 I2066_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I196_XG_MP1 (I2066_G25_0 I2066_G9_0n XI2066_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I142_XG_MP2 (VDD I2066_G17_14n I2066_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I142_XG_MP0 (XI2066_I142_XG_p1 I2066_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I142_XG_MP1 (I2066_G17_10 I2066_G13_10n XI2066_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I143_XG_MP2 (VDD I2066_G18_15n I2066_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I143_XG_MP0 (XI2066_I143_XG_p1 I2066_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I143_XG_MP1 (I2066_G18_11 I2066_G14_11n XI2066_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I82_XG_MP2 (VDD I2066_gn16 I2066_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I82_XG_MP0 (XI2066_I82_XG_p1 I2066_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I82_XG_MP1 (I2066_G16_15 I2066_gn15 XI2066_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I81_XG_MP2 (VDD I2066_gn15 I2066_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2066_I81_XG_MP0 (XI2066_I81_XG_p1 I2066_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2066_I81_XG_MP1 (I2066_G15_14 I2066_gn14 XI2066_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I143_XG_MP2 (VDD I1988_G18_15n I1988_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I143_XG_MP0 (XI1988_I143_XG_p1 I1988_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I143_XG_MP1 (I1988_G18_11 I1988_G14_11n XI1988_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I145_XG_MP2 (VDD I1988_G20_17n I1988_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I145_XG_MP0 (XI1988_I145_XG_p1 I1988_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I145_XG_MP1 (I1988_G20_13 I1988_G16_13n XI1988_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I140_XG_MP2 (VDD I1988_G15_12n I1988_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I140_XG_MP0 (XI1988_I140_XG_p1 I1988_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I140_XG_MP1 (I1988_G15_8 I1988_G11_8n XI1988_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I82_XG_MP2 (VDD I1988_gn16 I1988_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1988_I82_XG_MP0 (XI1988_I82_XG_p1 I1988_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1988_I82_XG_MP1 (I1988_G16_15 I1988_gn15 XI1988_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I139_XG_MP2 (VDD I1942_G14_11n I1942_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I139_XG_MP0 (XI1942_I139_XG_p1 I1942_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I139_XG_MP1 (I1942_G14_7 I1942_G10_7n XI1942_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I141_XG_MP2 (VDD I1942_G16_13n I1942_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I141_XG_MP0 (XI1942_I141_XG_p1 I1942_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I141_XG_MP1 (I1942_G16_9 I1942_G12_9n XI1942_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I186_XG_MP2 (VDD I1942_G19_4n I1942_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I186_XG_MP0 (XI1942_I186_XG_p1 I1942_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I186_XG_MP1 (I1942_G19_0 I1942_G3_0n XI1942_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I138_XG_MP2 (VDD I1942_G13_10n I1942_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I138_XG_MP0 (XI1942_I138_XG_p1 I1942_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I138_XG_MP1 (I1942_G13_6 I1942_G9_6n XI1942_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I79_XG_MP2 (VDD I1942_gn13 I1942_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I79_XG_MP0 (XI1942_I79_XG_p1 I1942_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I79_XG_MP1 (I1942_G13_12 I1942_gn12 XI1942_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I80_XG_MP2 (VDD I1942_gn14 I1942_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I80_XG_MP0 (XI1942_I80_XG_p1 I1942_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I80_XG_MP1 (I1942_G14_13 I1942_gn13 XI1942_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I81_XG_MP2 (VDD I1942_gn15 I1942_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I81_XG_MP0 (XI1942_I81_XG_p1 I1942_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I81_XG_MP1 (I1942_G15_14 I1942_gn14 XI1942_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I130_XG_MP2 (VDD I1896_G5_2n I1896_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I130_XG_MP0 (XI1896_I130_XG_p1 I1896_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I130_XG_MP1 (I1896_G5_0 I1896_G1_0n XI1896_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I134_XG_MP2 (VDD I1896_G9_6n I1896_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I134_XG_MP0 (XI1896_I134_XG_p1 I1896_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I134_XG_MP1 (I1896_G9_2 I1896_G5_2n XI1896_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I80_XG_MP2 (VDD I1896_gn14 I1896_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I80_XG_MP0 (XI1896_I80_XG_p1 I1896_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I80_XG_MP1 (I1896_G14_13 I1896_gn13 XI1896_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I81_XG_MP2 (VDD I1896_gn15 I1896_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I81_XG_MP0 (XI1896_I81_XG_p1 I1896_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I81_XG_MP1 (I1896_G15_14 I1896_gn14 XI1896_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I186_XG_MP2 (VDD I1896_G19_4n I1896_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I186_XG_MP0 (XI1896_I186_XG_p1 I1896_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I186_XG_MP1 (I1896_G19_0 I1896_G3_0n XI1896_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I140_XG_MP2 (VDD I1896_G15_12n I1896_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I140_XG_MP0 (XI1896_I140_XG_p1 I1896_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I140_XG_MP1 (I1896_G15_8 I1896_G11_8n XI1896_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I136_XG_MP2 (VDD I1896_G11_8n I1896_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I136_XG_MP0 (XI1896_I136_XG_p1 I1896_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I136_XG_MP1 (I1896_G11_4 I1896_G7_4n XI1896_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I194_XG_MP2 (VDD I1896_G23_8n I1896_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I194_XG_MP0 (XI1896_I194_XG_p1 I1896_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I194_XG_MP1 (I1896_G23_0 I1896_G7_0n XI1896_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I150_XG_MP2 (VDD I700_G25_22n I700_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I150_XG_MP0 (XI700_I150_XG_p1 I700_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I150_XG_MP1 (I700_G25_18 I700_G21_18n XI700_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I146_XG_MP2 (VDD I700_G21_18n I700_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I146_XG_MP0 (XI700_I146_XG_p1 I700_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I146_XG_MP1 (I700_G21_14 I700_G17_14n XI700_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I144_XG_MP2 (VDD I700_G19_16n I700_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I144_XG_MP0 (XI700_I144_XG_p1 I700_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I144_XG_MP1 (I700_G19_12 I700_G15_12n XI700_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I82_XG_MP2 (VDD I700_gn16 I700_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I82_XG_MP0 (XI700_I82_XG_p1 I700_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I82_XG_MP1 (I700_G16_15 I700_gn15 XI700_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I81_XG_MP2 (VDD I700_gn15 I700_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I81_XG_MP0 (XI700_I81_XG_p1 I700_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I81_XG_MP1 (I700_G15_14 I700_gn14 XI700_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I184_XG_MP2 (VDD I654_G17_2n I654_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I184_XG_MP0 (XI654_I184_XG_p1 I654_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I184_XG_MP1 (I654_G17_0 I654_G1_0n XI654_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I185_XG_MP2 (VDD I654_G18_3n I654_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I185_XG_MP0 (XI654_I185_XG_p1 I654_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I185_XG_MP1 (I654_G18_0 I654_G2_0n XI654_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I137_XG_MP2 (VDD I654_G12_9n I654_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I137_XG_MP0 (XI654_I137_XG_p1 I654_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I137_XG_MP1 (I654_G12_5 I654_G8_5n XI654_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I78_XG_MP2 (VDD I654_gn12 I654_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I78_XG_MP0 (XI654_I78_XG_p1 I654_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I78_XG_MP1 (I654_G12_11 I654_gn11 XI654_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I79_XG_MP2 (VDD I654_gn13 I654_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I79_XG_MP0 (XI654_I79_XG_p1 I654_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I79_XG_MP1 (I654_G13_12 I654_gn12 XI654_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I138_XG_MP2 (VDD I608_G13_10n I608_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I138_XG_MP0 (XI608_I138_XG_p1 I608_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I138_XG_MP1 (I608_G13_6 I608_G9_6n XI608_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I185_XG_MP2 (VDD I608_G18_3n I608_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I185_XG_MP0 (XI608_I185_XG_p1 I608_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I185_XG_MP1 (I608_G18_0 I608_G2_0n XI608_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I195_XG_MP2 (VDD I608_G24_9n I608_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I195_XG_MP0 (XI608_I195_XG_p1 I608_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I195_XG_MP1 (I608_G24_0 I608_G8_0n XI608_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I139_XG_MP2 (VDD I608_G14_11n I608_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I139_XG_MP0 (XI608_I139_XG_p1 I608_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I139_XG_MP1 (I608_G14_7 I608_G10_7n XI608_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I141_XG_MP2 (VDD I608_G16_13n I608_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I141_XG_MP0 (XI608_I141_XG_p1 I608_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I141_XG_MP1 (I608_G16_9 I608_G12_9n XI608_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I79_XG_MP2 (VDD I608_gn13 I608_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I79_XG_MP0 (XI608_I79_XG_p1 I608_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I79_XG_MP1 (I608_G13_12 I608_gn12 XI608_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I80_XG_MP2 (VDD I608_gn14 I608_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I80_XG_MP0 (XI608_I80_XG_p1 I608_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I80_XG_MP1 (I608_G14_13 I608_gn13 XI608_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I149_XG_MP2 (VDD I562_G24_21n I562_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I149_XG_MP0 (XI562_I149_XG_p1 I562_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I149_XG_MP1 (I562_G24_17 I562_G20_17n XI562_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I145_XG_MP2 (VDD I562_G20_17n I562_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I145_XG_MP0 (XI562_I145_XG_p1 I562_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I145_XG_MP1 (I562_G20_13 I562_G16_13n XI562_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I82_XG_MP2 (VDD I562_gn16 I562_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I82_XG_MP0 (XI562_I82_XG_p1 I562_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I82_XG_MP1 (I562_G16_15 I562_gn15 XI562_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I143_XG_MP2 (VDD I562_G18_15n I562_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I143_XG_MP0 (XI562_I143_XG_p1 I562_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I143_XG_MP1 (I562_G18_11 I562_G14_11n XI562_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I81_XG_MP2 (VDD I562_gn15 I562_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I81_XG_MP0 (XI562_I81_XG_p1 I562_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I81_XG_MP1 (I562_G15_14 I562_gn14 XI562_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I80_XG_MP2 (VDD I562_gn14 I562_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I80_XG_MP0 (XI562_I80_XG_p1 I562_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I80_XG_MP1 (I562_G14_13 I562_gn13 XI562_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I138_XG_MP2 (VDD I562_G13_10n I562_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I138_XG_MP0 (XI562_I138_XG_p1 I562_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I138_XG_MP1 (I562_G13_6 I562_G9_6n XI562_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I132_XG_MP2 (VDD I2066_G7_4n I2066_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I132_XG_MP0 (XI2066_I132_XG_p1 I2066_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I132_XG_MP1 (I2066_G7_0 I2066_G3_0n XI2066_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I136_XG_MP2 (VDD I2066_G11_8n I2066_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I136_XG_MP0 (XI2066_I136_XG_p1 I2066_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I136_XG_MP1 (I2066_G11_4 I2066_G7_4n XI2066_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I184_XG_MP2 (VDD I2066_G17_2n I2066_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I184_XG_MP0 (XI2066_I184_XG_p1 I2066_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I184_XG_MP1 (I2066_G17_0 I2066_G1_0n XI2066_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I138_XG_MP2 (VDD I2066_G13_10n I2066_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I138_XG_MP0 (XI2066_I138_XG_p1 I2066_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I138_XG_MP1 (I2066_G13_6 I2066_G9_6n XI2066_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I185_XG_MP2 (VDD I2066_G18_3n I2066_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I185_XG_MP0 (XI2066_I185_XG_p1 I2066_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I185_XG_MP1 (I2066_G18_0 I2066_G2_0n XI2066_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I195_XG_MP2 (VDD I2066_G24_9n I2066_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I195_XG_MP0 (XI2066_I195_XG_p1 I2066_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I195_XG_MP1 (I2066_G24_0 I2066_G8_0n XI2066_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I141_XG_MP2 (VDD I2066_G16_13n I2066_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I141_XG_MP0 (XI2066_I141_XG_p1 I2066_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I141_XG_MP1 (I2066_G16_9 I2066_G12_9n XI2066_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I139_XG_MP2 (VDD I2066_G14_11n I2066_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I139_XG_MP0 (XI2066_I139_XG_p1 I2066_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I139_XG_MP1 (I2066_G14_7 I2066_G10_7n XI2066_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I80_XG_MP2 (VDD I2066_gn14 I2066_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I80_XG_MP0 (XI2066_I80_XG_p1 I2066_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I80_XG_MP1 (I2066_G14_13 I2066_gn13 XI2066_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I79_XG_MP2 (VDD I2066_gn13 I2066_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I79_XG_MP0 (XI2066_I79_XG_p1 I2066_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I79_XG_MP1 (I2066_G13_12 I2066_gn12 XI2066_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I188_XG_MP2 (VDD I1988_G20_5n I1988_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I188_XG_MP0 (XI1988_I188_XG_p1 I1988_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I188_XG_MP1 (I1988_G20_0 I1988_G4_0n XI1988_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I139_XG_MP2 (VDD I1988_G14_11n I1988_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I139_XG_MP0 (XI1988_I139_XG_p1 I1988_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I139_XG_MP1 (I1988_G14_7 I1988_G10_7n XI1988_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I196_XG_MP2 (VDD I1988_G25_10n I1988_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I196_XG_MP0 (XI1988_I196_XG_p1 I1988_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I196_XG_MP1 (I1988_G25_0 I1988_G9_0n XI1988_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I142_XG_MP2 (VDD I1988_G17_14n I1988_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I142_XG_MP0 (XI1988_I142_XG_p1 I1988_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I142_XG_MP1 (I1988_G17_10 I1988_G13_10n XI1988_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I80_XG_MP2 (VDD I1988_gn14 I1988_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I80_XG_MP0 (XI1988_I80_XG_p1 I1988_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I80_XG_MP1 (I1988_G14_13 I1988_gn13 XI1988_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I81_XG_MP2 (VDD I1988_gn15 I1988_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I81_XG_MP0 (XI1988_I81_XG_p1 I1988_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I81_XG_MP1 (I1988_G15_14 I1988_gn14 XI1988_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I185_XG_MP2 (VDD I1942_G18_3n I1942_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I185_XG_MP0 (XI1942_I185_XG_p1 I1942_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I185_XG_MP1 (I1942_G18_0 I1942_G2_0n XI1942_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I137_XG_MP2 (VDD I1942_G12_9n I1942_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I137_XG_MP0 (XI1942_I137_XG_p1 I1942_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I137_XG_MP1 (I1942_G12_5 I1942_G8_5n XI1942_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I136_XG_MP2 (VDD I1942_G11_8n I1942_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I136_XG_MP0 (XI1942_I136_XG_p1 I1942_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I136_XG_MP1 (I1942_G11_4 I1942_G7_4n XI1942_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I78_XG_MP2 (VDD I1942_gn12 I1942_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I78_XG_MP0 (XI1942_I78_XG_p1 I1942_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I78_XG_MP1 (I1942_G12_11 I1942_gn11 XI1942_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I133_XG_MP2 (VDD I1896_G8_5n I1896_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I133_XG_MP0 (XI1896_I133_XG_p1 I1896_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I133_XG_MP1 (I1896_G8_1 I1896_G4_1n XI1896_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I78_XG_MP2 (VDD I1896_gn12 I1896_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I78_XG_MP0 (XI1896_I78_XG_p1 I1896_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I78_XG_MP1 (I1896_G12_11 I1896_gn11 XI1896_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I79_XG_MP2 (VDD I1896_gn13 I1896_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I79_XG_MP0 (XI1896_I79_XG_p1 I1896_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I79_XG_MP1 (I1896_G13_12 I1896_gn12 XI1896_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I132_XG_MP2 (VDD I1896_G7_4n I1896_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I132_XG_MP0 (XI1896_I132_XG_p1 I1896_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I132_XG_MP1 (I1896_G7_0 I1896_G3_0n XI1896_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I200_XG_MP2 (VDD I700_G29_14n I700_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I200_XG_MP0 (XI700_I200_XG_p1 I700_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I200_XG_MP1 (I700_G29_0 I700_G13_0n XI700_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I198_XG_MP2 (VDD I700_G27_12n I700_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I198_XG_MP0 (XI700_I198_XG_p1 I700_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I198_XG_MP1 (I700_G27_0 I700_G11_0n XI700_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I194_XG_MP2 (VDD I700_G23_8n I700_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I194_XG_MP0 (XI700_I194_XG_p1 I700_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I194_XG_MP1 (I700_G23_0 I700_G7_0n XI700_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I140_XG_MP2 (VDD I700_G15_12n I700_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I140_XG_MP0 (XI700_I140_XG_p1 I700_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I140_XG_MP1 (I700_G15_8 I700_G11_8n XI700_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I130_XG_MP2 (VDD I654_G5_2n I654_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I130_XG_MP0 (XI654_I130_XG_p1 I654_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I130_XG_MP1 (I654_G5_0 I654_G1_0n XI654_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I134_XG_MP2 (VDD I654_G9_6n I654_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I134_XG_MP0 (XI654_I134_XG_p1 I654_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I134_XG_MP1 (I654_G9_2 I654_G5_2n XI654_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I135_XG_MP2 (VDD I654_G10_7n I654_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I135_XG_MP0 (XI654_I135_XG_p1 I654_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I135_XG_MP1 (I654_G10_3 I654_G6_3n XI654_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I183_XG_MP2 (VDD I654_G16_1n I654_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I183_XG_MP0 (XI654_I183_XG_p1 I654_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I183_XG_MP1 (I654_G16_0 I654_G0_0n XI654_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I76_XG_MP2 (VDD I654_gn10 I654_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I76_XG_MP0 (XI654_I76_XG_p1 I654_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I76_XG_MP1 (I654_G10_9 I654_gn9 XI654_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I77_XG_MP2 (VDD I654_gn11 I654_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I77_XG_MP0 (XI654_I77_XG_p1 I654_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I77_XG_MP1 (I654_G11_10 I654_gn10 XI654_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I184_XG_MP2 (VDD I608_G17_2n I608_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I184_XG_MP0 (XI608_I184_XG_p1 I608_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I184_XG_MP1 (I608_G17_0 I608_G1_0n XI608_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I136_XG_MP2 (VDD I608_G11_8n I608_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I136_XG_MP0 (XI608_I136_XG_p1 I608_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I136_XG_MP1 (I608_G11_4 I608_G7_4n XI608_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I137_XG_MP2 (VDD I608_G12_9n I608_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I137_XG_MP0 (XI608_I137_XG_p1 I608_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I137_XG_MP1 (I608_G12_5 I608_G8_5n XI608_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I78_XG_MP2 (VDD I608_gn12 I608_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I78_XG_MP0 (XI608_I78_XG_p1 I608_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I78_XG_MP1 (I608_G12_11 I608_gn11 XI608_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I188_XG_MP2 (VDD I562_G20_5n I562_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I188_XG_MP0 (XI562_I188_XG_p1 I562_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I188_XG_MP1 (I562_G20_0 I562_G4_0n XI562_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I185_XG_MP2 (VDD I562_G18_3n I562_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I185_XG_MP0 (XI562_I185_XG_p1 I562_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I185_XG_MP1 (I562_G18_0 I562_G2_0n XI562_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I139_XG_MP2 (VDD I562_G14_11n I562_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I139_XG_MP0 (XI562_I139_XG_p1 I562_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I139_XG_MP1 (I562_G14_7 I562_G10_7n XI562_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I184_XG_MP2 (VDD I562_G17_2n I562_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I184_XG_MP0 (XI562_I184_XG_p1 I562_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I184_XG_MP1 (I562_G17_0 I562_G1_0n XI562_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I79_XG_MP2 (VDD I562_gn13 I562_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I79_XG_MP0 (XI562_I79_XG_p1 I562_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I79_XG_MP1 (I562_G13_12 I562_gn12 XI562_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I78_XG_MP2 (VDD I562_gn12 I562_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I78_XG_MP0 (XI562_I78_XG_p1 I562_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I78_XG_MP1 (I562_G12_11 I562_gn11 XI562_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I136_XG_MP2 (VDD I562_G11_8n I562_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I136_XG_MP0 (XI562_I136_XG_p1 I562_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I136_XG_MP1 (I562_G11_4 I562_G7_4n XI562_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I134_XG_MP2 (VDD I2066_G9_6n I2066_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I134_XG_MP0 (XI2066_I134_XG_p1 I2066_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I134_XG_MP1 (I2066_G9_2 I2066_G5_2n XI2066_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I135_XG_MP2 (VDD I2066_G10_7n I2066_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I135_XG_MP0 (XI2066_I135_XG_p1 I2066_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I135_XG_MP1 (I2066_G10_3 I2066_G6_3n XI2066_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I137_XG_MP2 (VDD I2066_G12_9n I2066_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I137_XG_MP0 (XI2066_I137_XG_p1 I2066_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I137_XG_MP1 (I2066_G12_5 I2066_G8_5n XI2066_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I77_XG_MP2 (VDD I2066_gn11 I2066_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I77_XG_MP0 (XI2066_I77_XG_p1 I2066_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I77_XG_MP1 (I2066_G11_10 I2066_gn10 XI2066_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I78_XG_MP2 (VDD I2066_gn12 I2066_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I78_XG_MP0 (XI2066_I78_XG_p1 I2066_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I78_XG_MP1 (I2066_G12_11 I2066_gn11 XI2066_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I185_XG_MP2 (VDD I1988_G18_3n I1988_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I185_XG_MP0 (XI1988_I185_XG_p1 I1988_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I185_XG_MP1 (I1988_G18_0 I1988_G2_0n XI1988_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I195_XG_MP2 (VDD I1988_G24_9n I1988_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I195_XG_MP0 (XI1988_I195_XG_p1 I1988_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I195_XG_MP1 (I1988_G24_0 I1988_G8_0n XI1988_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I141_XG_MP2 (VDD I1988_G16_13n I1988_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I141_XG_MP0 (XI1988_I141_XG_p1 I1988_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I141_XG_MP1 (I1988_G16_9 I1988_G12_9n XI1988_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I186_XG_MP2 (VDD I1988_G19_4n I1988_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I186_XG_MP0 (XI1988_I186_XG_p1 I1988_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I186_XG_MP1 (I1988_G19_0 I1988_G3_0n XI1988_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I138_XG_MP2 (VDD I1988_G13_10n I1988_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I138_XG_MP0 (XI1988_I138_XG_p1 I1988_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I138_XG_MP1 (I1988_G13_6 I1988_G9_6n XI1988_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I78_XG_MP2 (VDD I1988_gn12 I1988_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I78_XG_MP0 (XI1988_I78_XG_p1 I1988_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I78_XG_MP1 (I1988_G12_11 I1988_gn11 XI1988_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I79_XG_MP2 (VDD I1988_gn13 I1988_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I79_XG_MP0 (XI1988_I79_XG_p1 I1988_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I79_XG_MP1 (I1988_G13_12 I1988_gn12 XI1988_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I135_XG_MP2 (VDD I1942_G10_7n I1942_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I135_XG_MP0 (XI1942_I135_XG_p1 I1942_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I135_XG_MP1 (I1942_G10_3 I1942_G6_3n XI1942_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I184_XG_MP2 (VDD I1942_G17_2n I1942_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I184_XG_MP0 (XI1942_I184_XG_p1 I1942_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I184_XG_MP1 (I1942_G17_0 I1942_G1_0n XI1942_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I132_XG_MP2 (VDD I1942_G7_4n I1942_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I132_XG_MP0 (XI1942_I132_XG_p1 I1942_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I132_XG_MP1 (I1942_G7_0 I1942_G3_0n XI1942_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I77_XG_MP2 (VDD I1942_gn11 I1942_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I77_XG_MP0 (XI1942_I77_XG_p1 I1942_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I77_XG_MP1 (I1942_G11_10 I1942_gn10 XI1942_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I76_XG_MP2 (VDD I1942_gn10 I1942_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I76_XG_MP0 (XI1942_I76_XG_p1 I1942_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I76_XG_MP1 (I1942_G10_9 I1942_gn9 XI1942_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I128_XG_MP2 (VDD I1896_G4_1n I1896_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I128_XG_MP0 (XI1896_I128_XG_p1 I1896_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I128_XG_MP1 (I1896_G4_0 I1896_G0_0n XI1896_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I75_XG_MP2 (VDD I1896_gn9 I1896_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I75_XG_MP0 (XI1896_I75_XG_p1 I1896_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I75_XG_MP1 (I1896_G9_8 I1896_gn8 XI1896_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I76_XG_MP2 (VDD I1896_gn10 I1896_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I76_XG_MP0 (XI1896_I76_XG_p1 I1896_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I76_XG_MP1 (I1896_G10_9 I1896_gn9 XI1896_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I77_XG_MP2 (VDD I1896_gn11 I1896_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I77_XG_MP0 (XI1896_I77_XG_p1 I1896_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I77_XG_MP1 (I1896_G11_10 I1896_gn10 XI1896_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I186_XG_MP2 (VDD I1850_G19_4n I1850_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I186_XG_MP0 (XI1850_I186_XG_p1 I1850_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I186_XG_MP1 (I1850_G19_0 I1850_G3_0n XI1850_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I194_XG_MP2 (VDD I1850_G23_8n I1850_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I194_XG_MP0 (XI1850_I194_XG_p1 I1850_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I194_XG_MP1 (I1850_G23_0 I1850_G7_0n XI1850_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I198_XG_MP2 (VDD I1850_G27_12n I1850_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I198_XG_MP0 (XI1850_I198_XG_p1 I1850_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I198_XG_MP1 (I1850_G27_0 I1850_G11_0n XI1850_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I202_XG_MP2 (VDD I1850_G31_16n c28_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I202_XG_MP0 (XI1850_I202_XG_p1 I1850_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I202_XG_MP1 (c28_o I1850_G15_0n XI1850_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I142_XG_MP2 (VDD I700_G17_14n I700_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I142_XG_MP0 (XI700_I142_XG_p1 I700_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I142_XG_MP1 (I700_G17_10 I700_G13_10n XI700_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I138_XG_MP2 (VDD I700_G13_10n I700_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I138_XG_MP0 (XI700_I138_XG_p1 I700_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I138_XG_MP1 (I700_G13_6 I700_G9_6n XI700_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I80_XG_MP2 (VDD I700_gn14 I700_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I80_XG_MP0 (XI700_I80_XG_p1 I700_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I80_XG_MP1 (I700_G14_13 I700_gn13 XI700_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I79_XG_MP2 (VDD I700_gn13 I700_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I79_XG_MP0 (XI700_I79_XG_p1 I700_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I79_XG_MP1 (I700_G13_12 I700_gn12 XI700_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I78_XG_MP2 (VDD I700_gn12 I700_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I78_XG_MP0 (XI700_I78_XG_p1 I700_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I78_XG_MP1 (I700_G12_11 I700_gn11 XI700_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I133_XG_MP2 (VDD I654_G8_5n I654_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I133_XG_MP0 (XI654_I133_XG_p1 I654_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I133_XG_MP1 (I654_G8_1 I654_G4_1n XI654_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I74_XG_MP2 (VDD I654_gn8 I654_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I74_XG_MP0 (XI654_I74_XG_p1 I654_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I74_XG_MP1 (I654_G8_7 I654_gn7 XI654_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I75_XG_MP2 (VDD I654_gn9 I654_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I75_XG_MP0 (XI654_I75_XG_p1 I654_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I75_XG_MP1 (I654_G9_8 I654_gn8 XI654_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I132_XG_MP2 (VDD I608_G7_4n I608_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I132_XG_MP0 (XI608_I132_XG_p1 I608_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I132_XG_MP1 (I608_G7_0 I608_G3_0n XI608_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I130_XG_MP2 (VDD I608_G5_2n I608_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I130_XG_MP0 (XI608_I130_XG_p1 I608_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I130_XG_MP1 (I608_G5_0 I608_G1_0n XI608_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I134_XG_MP2 (VDD I608_G9_6n I608_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I134_XG_MP0 (XI608_I134_XG_p1 I608_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I134_XG_MP1 (I608_G9_2 I608_G5_2n XI608_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I183_XG_MP2 (VDD I608_G16_1n I608_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I183_XG_MP0 (XI608_I183_XG_p1 I608_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I183_XG_MP1 (I608_G16_0 I608_G0_0n XI608_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I131_XG_MP2 (VDD I608_G6_3n I608_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I131_XG_MP0 (XI608_I131_XG_p1 I608_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I131_XG_MP1 (I608_G6_0 I608_G2_0n XI608_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I135_XG_MP2 (VDD I608_G10_7n I608_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I135_XG_MP0 (XI608_I135_XG_p1 I608_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I135_XG_MP1 (I608_G10_3 I608_G6_3n XI608_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I76_XG_MP2 (VDD I608_gn10 I608_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I76_XG_MP0 (XI608_I76_XG_p1 I608_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I76_XG_MP1 (I608_G10_9 I608_gn9 XI608_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I75_XG_MP2 (VDD I608_gn9 I608_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I75_XG_MP0 (XI608_I75_XG_p1 I608_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I75_XG_MP1 (I608_G9_8 I608_gn8 XI608_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I77_XG_MP2 (VDD I608_gn11 I608_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I77_XG_MP0 (XI608_I77_XG_p1 I608_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I77_XG_MP1 (I608_G11_10 I608_gn10 XI608_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I195_XG_MP2 (VDD I562_G24_9n I562_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I195_XG_MP0 (XI562_I195_XG_p1 I562_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I195_XG_MP1 (I562_G24_0 I562_G8_0n XI562_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I141_XG_MP2 (VDD I562_G16_13n I562_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I141_XG_MP0 (XI562_I141_XG_p1 I562_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I141_XG_MP1 (I562_G16_9 I562_G12_9n XI562_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I137_XG_MP2 (VDD I562_G12_9n I562_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I137_XG_MP0 (XI562_I137_XG_p1 I562_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I137_XG_MP1 (I562_G12_5 I562_G8_5n XI562_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I130_XG_MP2 (VDD I562_G5_2n I562_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I130_XG_MP0 (XI562_I130_XG_p1 I562_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I130_XG_MP1 (I562_G5_0 I562_G1_0n XI562_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I134_XG_MP2 (VDD I562_G9_6n I562_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I134_XG_MP0 (XI562_I134_XG_p1 I562_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I134_XG_MP1 (I562_G9_2 I562_G5_2n XI562_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I77_XG_MP2 (VDD I562_gn11 I562_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I77_XG_MP0 (XI562_I77_XG_p1 I562_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I77_XG_MP1 (I562_G11_10 I562_gn10 XI562_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I130_XG_MP2 (VDD I2066_G5_2n I2066_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I130_XG_MP0 (XI2066_I130_XG_p1 I2066_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I130_XG_MP1 (I2066_G5_0 I2066_G1_0n XI2066_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I183_XG_MP2 (VDD I2066_G16_1n I2066_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I183_XG_MP0 (XI2066_I183_XG_p1 I2066_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I183_XG_MP1 (I2066_G16_0 I2066_G0_0n XI2066_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I131_XG_MP2 (VDD I2066_G6_3n I2066_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I131_XG_MP0 (XI2066_I131_XG_p1 I2066_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I131_XG_MP1 (I2066_G6_0 I2066_G2_0n XI2066_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I75_XG_MP2 (VDD I2066_gn9 I2066_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I75_XG_MP0 (XI2066_I75_XG_p1 I2066_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I75_XG_MP1 (I2066_G9_8 I2066_gn8 XI2066_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I76_XG_MP2 (VDD I2066_gn10 I2066_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I76_XG_MP0 (XI2066_I76_XG_p1 I2066_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I76_XG_MP1 (I2066_G10_9 I2066_gn9 XI2066_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I135_XG_MP2 (VDD I1988_G10_7n I1988_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I135_XG_MP0 (XI1988_I135_XG_p1 I1988_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I135_XG_MP1 (I1988_G10_3 I1988_G6_3n XI1988_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I137_XG_MP2 (VDD I1988_G12_9n I1988_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I137_XG_MP0 (XI1988_I137_XG_p1 I1988_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I137_XG_MP1 (I1988_G12_5 I1988_G8_5n XI1988_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I184_XG_MP2 (VDD I1988_G17_2n I1988_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I184_XG_MP0 (XI1988_I184_XG_p1 I1988_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I184_XG_MP1 (I1988_G17_0 I1988_G1_0n XI1988_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I136_XG_MP2 (VDD I1988_G11_8n I1988_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I136_XG_MP0 (XI1988_I136_XG_p1 I1988_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I136_XG_MP1 (I1988_G11_4 I1988_G7_4n XI1988_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I76_XG_MP2 (VDD I1988_gn10 I1988_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I76_XG_MP0 (XI1988_I76_XG_p1 I1988_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I76_XG_MP1 (I1988_G10_9 I1988_gn9 XI1988_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I77_XG_MP2 (VDD I1988_gn11 I1988_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I77_XG_MP0 (XI1988_I77_XG_p1 I1988_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I77_XG_MP1 (I1988_G11_10 I1988_gn10 XI1988_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I183_XG_MP2 (VDD I1942_G16_1n I1942_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I183_XG_MP0 (XI1942_I183_XG_p1 I1942_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I183_XG_MP1 (I1942_G16_0 I1942_G0_0n XI1942_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I133_XG_MP2 (VDD I1942_G8_5n I1942_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I133_XG_MP0 (XI1942_I133_XG_p1 I1942_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I133_XG_MP1 (I1942_G8_1 I1942_G4_1n XI1942_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I130_XG_MP2 (VDD I1942_G5_2n I1942_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I130_XG_MP0 (XI1942_I130_XG_p1 I1942_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I130_XG_MP1 (I1942_G5_0 I1942_G1_0n XI1942_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I134_XG_MP2 (VDD I1942_G9_6n I1942_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I134_XG_MP0 (XI1942_I134_XG_p1 I1942_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I134_XG_MP1 (I1942_G9_2 I1942_G5_2n XI1942_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I74_XG_MP2 (VDD I1942_gn8 I1942_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I74_XG_MP0 (XI1942_I74_XG_p1 I1942_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I74_XG_MP1 (I1942_G8_7 I1942_gn7 XI1942_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I75_XG_MP2 (VDD I1942_gn9 I1942_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I75_XG_MP0 (XI1942_I75_XG_p1 I1942_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I75_XG_MP1 (I1942_G9_8 I1942_gn8 XI1942_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I73_XG_MP2 (VDD I1896_gn7 I1896_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I73_XG_MP0 (XI1896_I73_XG_p1 I1896_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I73_XG_MP1 (I1896_G7_6 I1896_gn6 XI1896_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I74_XG_MP2 (VDD I1896_gn8 I1896_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I74_XG_MP0 (XI1896_I74_XG_p1 I1896_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I74_XG_MP1 (I1896_G8_7 I1896_gn7 XI1896_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I132_XG_MP2 (VDD I1850_G7_4n I1850_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I132_XG_MP0 (XI1850_I132_XG_p1 I1850_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I132_XG_MP1 (I1850_G7_0 I1850_G3_0n XI1850_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I136_XG_MP2 (VDD I1850_G11_8n I1850_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I136_XG_MP0 (XI1850_I136_XG_p1 I1850_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I136_XG_MP1 (I1850_G11_4 I1850_G7_4n XI1850_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I140_XG_MP2 (VDD I1850_G15_12n I1850_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I140_XG_MP0 (XI1850_I140_XG_p1 I1850_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I140_XG_MP1 (I1850_G15_8 I1850_G11_8n XI1850_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I190_XG_MP2 (VDD I1850_G21_6n I1850_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I190_XG_MP0 (XI1850_I190_XG_p1 I1850_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I190_XG_MP1 (I1850_G21_0 I1850_G5_0n XI1850_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I144_XG_MP2 (VDD I1850_G19_16n I1850_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I144_XG_MP0 (XI1850_I144_XG_p1 I1850_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I144_XG_MP1 (I1850_G19_12 I1850_G15_12n XI1850_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I148_XG_MP2 (VDD I1850_G23_20n I1850_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I148_XG_MP0 (XI1850_I148_XG_p1 I1850_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I148_XG_MP1 (I1850_G23_16 I1850_G19_16n XI1850_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I196_XG_MP2 (VDD I1850_G25_10n I1850_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I196_XG_MP0 (XI1850_I196_XG_p1 I1850_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I196_XG_MP1 (I1850_G25_0 I1850_G9_0n XI1850_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I152_XG_MP2 (VDD I1850_G27_24n I1850_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I152_XG_MP0 (XI1850_I152_XG_p1 I1850_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I152_XG_MP1 (I1850_G27_20 I1850_G23_20n XI1850_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I200_XG_MP2 (VDD I1850_G29_14n I1850_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I200_XG_MP0 (XI1850_I200_XG_p1 I1850_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I200_XG_MP1 (I1850_G29_0 I1850_G13_0n XI1850_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I156_XG_MP2 (VDD I1850_G31_28n I1850_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I156_XG_MP0 (XI1850_I156_XG_p1 I1850_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I156_XG_MP1 (I1850_G31_24 I1850_G27_24n XI1850_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I190_XG_MP2 (VDD I700_G21_6n I700_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I190_XG_MP0 (XI700_I190_XG_p1 I700_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I190_XG_MP1 (I700_G21_0 I700_G5_0n XI700_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I196_XG_MP2 (VDD I700_G25_10n I700_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I196_XG_MP0 (XI700_I196_XG_p1 I700_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I196_XG_MP1 (I700_G25_0 I700_G9_0n XI700_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I136_XG_MP2 (VDD I700_G11_8n I700_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I136_XG_MP0 (XI700_I136_XG_p1 I700_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I136_XG_MP1 (I700_G11_4 I700_G7_4n XI700_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I77_XG_MP2 (VDD I700_gn11 I700_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I77_XG_MP0 (XI700_I77_XG_p1 I700_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I77_XG_MP1 (I700_G11_10 I700_gn10 XI700_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I131_XG_MP2 (VDD I654_G6_3n I654_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I131_XG_MP0 (XI654_I131_XG_p1 I654_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I131_XG_MP1 (I654_G6_0 I654_G2_0n XI654_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I128_XG_MP2 (VDD I654_G4_1n I654_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I128_XG_MP0 (XI654_I128_XG_p1 I654_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I128_XG_MP1 (I654_G4_0 I654_G0_0n XI654_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I72_XG_MP2 (VDD I654_gn6 I654_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I72_XG_MP0 (XI654_I72_XG_p1 I654_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I72_XG_MP1 (I654_G6_5 I654_gn5 XI654_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I73_XG_MP2 (VDD I654_gn7 I654_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I73_XG_MP0 (XI654_I73_XG_p1 I654_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I73_XG_MP1 (I654_G7_6 I654_gn6 XI654_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I128_XG_MP2 (VDD I608_G4_1n I608_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I128_XG_MP0 (XI608_I128_XG_p1 I608_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I128_XG_MP1 (I608_G4_0 I608_G0_0n XI608_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I133_XG_MP2 (VDD I608_G8_5n I608_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I133_XG_MP0 (XI608_I133_XG_p1 I608_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I133_XG_MP1 (I608_G8_1 I608_G4_1n XI608_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I73_XG_MP2 (VDD I608_gn7 I608_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I73_XG_MP0 (XI608_I73_XG_p1 I608_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I73_XG_MP1 (I608_G7_6 I608_gn6 XI608_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I74_XG_MP2 (VDD I608_gn8 I608_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I74_XG_MP0 (XI608_I74_XG_p1 I608_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I74_XG_MP1 (I608_G8_7 I608_gn7 XI608_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I183_XG_MP2 (VDD I562_G16_1n I562_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I183_XG_MP0 (XI562_I183_XG_p1 I562_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I183_XG_MP1 (I562_G16_0 I562_G0_0n XI562_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I133_XG_MP2 (VDD I562_G8_5n I562_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I133_XG_MP0 (XI562_I133_XG_p1 I562_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I133_XG_MP1 (I562_G8_1 I562_G4_1n XI562_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I131_XG_MP2 (VDD I562_G6_3n I562_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I131_XG_MP0 (XI562_I131_XG_p1 I562_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I131_XG_MP1 (I562_G6_0 I562_G2_0n XI562_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I135_XG_MP2 (VDD I562_G10_7n I562_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I135_XG_MP0 (XI562_I135_XG_p1 I562_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I135_XG_MP1 (I562_G10_3 I562_G6_3n XI562_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I76_XG_MP2 (VDD I562_gn10 I562_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I76_XG_MP0 (XI562_I76_XG_p1 I562_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I76_XG_MP1 (I562_G10_9 I562_gn9 XI562_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I132_XG_MP2 (VDD I562_G7_4n I562_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I132_XG_MP0 (XI562_I132_XG_p1 I562_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I132_XG_MP1 (I562_G7_0 I562_G3_0n XI562_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I128_XG_MP2 (VDD I2066_G4_1n I2066_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I128_XG_MP0 (XI2066_I128_XG_p1 I2066_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I128_XG_MP1 (I2066_G4_0 I2066_G0_0n XI2066_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I133_XG_MP2 (VDD I2066_G8_5n I2066_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I133_XG_MP0 (XI2066_I133_XG_p1 I2066_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I133_XG_MP1 (I2066_G8_1 I2066_G4_1n XI2066_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I73_XG_MP2 (VDD I2066_gn7 I2066_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I73_XG_MP0 (XI2066_I73_XG_p1 I2066_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I73_XG_MP1 (I2066_G7_6 I2066_gn6 XI2066_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I74_XG_MP2 (VDD I2066_gn8 I2066_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I74_XG_MP0 (XI2066_I74_XG_p1 I2066_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I74_XG_MP1 (I2066_G8_7 I2066_gn7 XI2066_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I183_XG_MP2 (VDD I1988_G16_1n I1988_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I183_XG_MP0 (XI1988_I183_XG_p1 I1988_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I183_XG_MP1 (I1988_G16_0 I1988_G0_0n XI1988_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I131_XG_MP2 (VDD I1988_G6_3n I1988_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I131_XG_MP0 (XI1988_I131_XG_p1 I1988_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I131_XG_MP1 (I1988_G6_0 I1988_G2_0n XI1988_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I134_XG_MP2 (VDD I1988_G9_6n I1988_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I134_XG_MP0 (XI1988_I134_XG_p1 I1988_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I134_XG_MP1 (I1988_G9_2 I1988_G5_2n XI1988_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I74_XG_MP2 (VDD I1988_gn8 I1988_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I74_XG_MP0 (XI1988_I74_XG_p1 I1988_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I74_XG_MP1 (I1988_G8_7 I1988_gn7 XI1988_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I75_XG_MP2 (VDD I1988_gn9 I1988_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I75_XG_MP0 (XI1988_I75_XG_p1 I1988_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I75_XG_MP1 (I1988_G9_8 I1988_gn8 XI1988_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I131_XG_MP2 (VDD I1942_G6_3n I1942_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I131_XG_MP0 (XI1942_I131_XG_p1 I1942_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I131_XG_MP1 (I1942_G6_0 I1942_G2_0n XI1942_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I73_XG_MP2 (VDD I1942_gn7 I1942_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I73_XG_MP0 (XI1942_I73_XG_p1 I1942_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I73_XG_MP1 (I1942_G7_6 I1942_gn6 XI1942_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I70_XG_MP2 (VDD I1896_gn4 I1896_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I70_XG_MP0 (XI1896_I70_XG_p1 I1896_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I70_XG_MP1 (I1896_G4_3 I1896_gn3 XI1896_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I71_XG_MP2 (VDD I1896_gn5 I1896_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I71_XG_MP0 (XI1896_I71_XG_p1 I1896_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I71_XG_MP1 (I1896_G5_4 I1896_gn4 XI1896_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I72_XG_MP2 (VDD I1896_gn6 I1896_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I72_XG_MP0 (XI1896_I72_XG_p1 I1896_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I72_XG_MP1 (I1896_G6_5 I1896_gn5 XI1896_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I130_XG_MP2 (VDD I1850_G5_2n I1850_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I130_XG_MP0 (XI1850_I130_XG_p1 I1850_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I130_XG_MP1 (I1850_G5_0 I1850_G1_0n XI1850_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I134_XG_MP2 (VDD I1850_G9_6n I1850_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I134_XG_MP0 (XI1850_I134_XG_p1 I1850_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I134_XG_MP1 (I1850_G9_2 I1850_G5_2n XI1850_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I184_XG_MP2 (VDD I1850_G17_2n I1850_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I184_XG_MP0 (XI1850_I184_XG_p1 I1850_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I184_XG_MP1 (I1850_G17_0 I1850_G1_0n XI1850_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I138_XG_MP2 (VDD I1850_G13_10n I1850_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I138_XG_MP0 (XI1850_I138_XG_p1 I1850_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I138_XG_MP1 (I1850_G13_6 I1850_G9_6n XI1850_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I142_XG_MP2 (VDD I1850_G17_14n I1850_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I142_XG_MP0 (XI1850_I142_XG_p1 I1850_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I142_XG_MP1 (I1850_G17_10 I1850_G13_10n XI1850_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I146_XG_MP2 (VDD I1850_G21_18n I1850_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I146_XG_MP0 (XI1850_I146_XG_p1 I1850_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I146_XG_MP1 (I1850_G21_14 I1850_G17_14n XI1850_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I150_XG_MP2 (VDD I1850_G25_22n I1850_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I150_XG_MP0 (XI1850_I150_XG_p1 I1850_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I150_XG_MP1 (I1850_G25_18 I1850_G21_18n XI1850_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I155_XG_MP2 (VDD I700_G30_27n I700_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I155_XG_MP0 (XI700_I155_XG_p1 I700_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I155_XG_MP1 (I700_G30_23 I700_G26_23n XI700_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I186_XG_MP2 (VDD I700_G19_4n I700_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I186_XG_MP0 (XI700_I186_XG_p1 I700_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I186_XG_MP1 (I700_G19_0 I700_G3_0n XI700_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I184_XG_MP2 (VDD I700_G17_2n I700_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I184_XG_MP0 (XI700_I184_XG_p1 I700_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I184_XG_MP1 (I700_G17_0 I700_G1_0n XI700_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I134_XG_MP2 (VDD I700_G9_6n I700_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I134_XG_MP0 (XI700_I134_XG_p1 I700_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I134_XG_MP1 (I700_G9_2 I700_G5_2n XI700_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I76_XG_MP2 (VDD I700_gn10 I700_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I76_XG_MP0 (XI700_I76_XG_p1 I700_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I76_XG_MP1 (I700_G10_9 I700_gn9 XI700_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I75_XG_MP2 (VDD I700_gn9 I700_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I75_XG_MP0 (XI700_I75_XG_p1 I700_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I75_XG_MP1 (I700_G9_8 I700_gn8 XI700_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I71_XG_MP2 (VDD I654_gn5 I654_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I71_XG_MP0 (XI654_I71_XG_p1 I654_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I71_XG_MP1 (I654_G5_4 I654_gn4 XI654_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I70_XG_MP2 (VDD I654_gn4 I654_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I70_XG_MP0 (XI654_I70_XG_p1 I654_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I70_XG_MP1 (I654_G4_3 I654_gn3 XI654_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I71_XG_MP2 (VDD I608_gn5 I608_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I71_XG_MP0 (XI608_I71_XG_p1 I608_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I71_XG_MP1 (I608_G5_4 I608_gn4 XI608_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I72_XG_MP2 (VDD I608_gn6 I608_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I72_XG_MP0 (XI608_I72_XG_p1 I608_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I72_XG_MP1 (I608_G6_5 I608_gn5 XI608_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I128_XG_MP2 (VDD I562_G4_1n I562_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I128_XG_MP0 (XI562_I128_XG_p1 I562_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I128_XG_MP1 (I562_G4_0 I562_G0_0n XI562_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I75_XG_MP2 (VDD I562_gn9 I562_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I75_XG_MP0 (XI562_I75_XG_p1 I562_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I75_XG_MP1 (I562_G9_8 I562_gn8 XI562_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I67_XG_MP2 (VDD I2066_gn1 I2066_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I67_XG_MP0 (XI2066_I67_XG_p1 I2066_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I67_XG_MP1 (I2066_G1_0 I2066_G0_0n XI2066_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I72_XG_MP2 (VDD I2066_gn6 I2066_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I72_XG_MP0 (XI2066_I72_XG_p1 I2066_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I72_XG_MP1 (I2066_G6_5 I2066_gn5 XI2066_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I71_XG_MP2 (VDD I2066_gn5 I2066_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I71_XG_MP0 (XI2066_I71_XG_p1 I2066_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I71_XG_MP1 (I2066_G5_4 I2066_gn4 XI2066_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I133_XG_MP2 (VDD I1988_G8_5n I1988_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I133_XG_MP0 (XI1988_I133_XG_p1 I1988_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I133_XG_MP1 (I1988_G8_1 I1988_G4_1n XI1988_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I130_XG_MP2 (VDD I1988_G5_2n I1988_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I130_XG_MP0 (XI1988_I130_XG_p1 I1988_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I130_XG_MP1 (I1988_G5_0 I1988_G1_0n XI1988_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I132_XG_MP2 (VDD I1988_G7_4n I1988_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I132_XG_MP0 (XI1988_I132_XG_p1 I1988_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I132_XG_MP1 (I1988_G7_0 I1988_G3_0n XI1988_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I73_XG_MP2 (VDD I1988_gn7 I1988_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I73_XG_MP0 (XI1988_I73_XG_p1 I1988_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I73_XG_MP1 (I1988_G7_6 I1988_gn6 XI1988_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I128_XG_MP2 (VDD I1942_G4_1n I1942_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I128_XG_MP0 (XI1942_I128_XG_p1 I1942_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I128_XG_MP1 (I1942_G4_0 I1942_G0_0n XI1942_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I71_XG_MP2 (VDD I1942_gn5 I1942_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I71_XG_MP0 (XI1942_I71_XG_p1 I1942_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I71_XG_MP1 (I1942_G5_4 I1942_gn4 XI1942_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I72_XG_MP2 (VDD I1942_gn6 I1942_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I72_XG_MP0 (XI1942_I72_XG_p1 I1942_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I72_XG_MP1 (I1942_G6_5 I1942_gn5 XI1942_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I67_XG_MP2 (VDD I1896_gn1 I1896_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I67_XG_MP0 (XI1896_I67_XG_p1 I1896_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I67_XG_MP1 (I1896_G1_0 I1896_G0_0n XI1896_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I68_XG_MP2 (VDD I1896_gn2 I1896_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I68_XG_MP0 (XI1896_I68_XG_p1 I1896_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I68_XG_MP1 (I1896_G2_1 I1896_gn1 XI1896_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I69_XG_MP2 (VDD I1896_gn3 I1896_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I69_XG_MP0 (XI1896_I69_XG_p1 I1896_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I69_XG_MP1 (I1896_G3_2 I1896_gn2 XI1896_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I154_XG_MP2 (VDD I1850_G29_26n I1850_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I154_XG_MP0 (XI1850_I154_XG_p1 I1850_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I154_XG_MP1 (I1850_G29_22 I1850_G25_22n XI1850_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I153_XG_MP2 (VDD I700_G28_25n I700_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I153_XG_MP0 (XI700_I153_XG_p1 I700_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I153_XG_MP1 (I700_G28_21 I700_G24_21n XI700_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I151_XG_MP2 (VDD I700_G26_23n I700_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I151_XG_MP0 (XI700_I151_XG_p1 I700_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I151_XG_MP1 (I700_G26_19 I700_G22_19n XI700_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I147_XG_MP2 (VDD I700_G22_19n I700_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I147_XG_MP0 (XI700_I147_XG_p1 I700_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I147_XG_MP1 (I700_G22_15 I700_G18_15n XI700_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I132_XG_MP2 (VDD I700_G7_4n I700_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I132_XG_MP0 (XI700_I132_XG_p1 I700_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I132_XG_MP1 (I700_G7_0 I700_G3_0n XI700_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I130_XG_MP2 (VDD I700_G5_2n I700_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I130_XG_MP0 (XI700_I130_XG_p1 I700_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I130_XG_MP1 (I700_G5_0 I700_G1_0n XI700_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I74_XG_MP2 (VDD I700_gn8 I700_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I74_XG_MP0 (XI700_I74_XG_p1 I700_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I74_XG_MP1 (I700_G8_7 I700_gn7 XI700_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I73_XG_MP2 (VDD I700_gn7 I700_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I73_XG_MP0 (XI700_I73_XG_p1 I700_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I73_XG_MP1 (I700_G7_6 I700_gn6 XI700_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I67_XG_MP2 (VDD I654_gn1 I654_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I67_XG_MP0 (XI654_I67_XG_p1 I654_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I67_XG_MP1 (I654_G1_0 I654_G0_0n XI654_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I69_XG_MP2 (VDD I654_gn3 I654_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I69_XG_MP0 (XI654_I69_XG_p1 I654_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I69_XG_MP1 (I654_G3_2 I654_gn2 XI654_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I68_XG_MP2 (VDD I654_gn2 I654_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I68_XG_MP0 (XI654_I68_XG_p1 I654_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I68_XG_MP1 (I654_G2_1 I654_gn1 XI654_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I67_XG_MP2 (VDD I608_gn1 I608_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I67_XG_MP0 (XI608_I67_XG_p1 I608_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I67_XG_MP1 (I608_G1_0 I608_G0_0n XI608_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I68_XG_MP2 (VDD I608_gn2 I608_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I68_XG_MP0 (XI608_I68_XG_p1 I608_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I68_XG_MP1 (I608_G2_1 I608_gn1 XI608_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I69_XG_MP2 (VDD I608_gn3 I608_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I69_XG_MP0 (XI608_I69_XG_p1 I608_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I69_XG_MP1 (I608_G3_2 I608_gn2 XI608_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I70_XG_MP2 (VDD I608_gn4 I608_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I70_XG_MP0 (XI608_I70_XG_p1 I608_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I70_XG_MP1 (I608_G4_3 I608_gn3 XI608_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I67_XG_MP2 (VDD I562_gn1 I562_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I67_XG_MP0 (XI562_I67_XG_p1 I562_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I67_XG_MP1 (I562_G1_0 I562_G0_0n XI562_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I68_XG_MP2 (VDD I562_gn2 I562_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I68_XG_MP0 (XI562_I68_XG_p1 I562_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I68_XG_MP1 (I562_G2_1 I562_gn1 XI562_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I69_XG_MP2 (VDD I562_gn3 I562_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I69_XG_MP0 (XI562_I69_XG_p1 I562_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I69_XG_MP1 (I562_G3_2 I562_gn2 XI562_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I72_XG_MP2 (VDD I562_gn6 I562_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I72_XG_MP0 (XI562_I72_XG_p1 I562_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I72_XG_MP1 (I562_G6_5 I562_gn5 XI562_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I73_XG_MP2 (VDD I562_gn7 I562_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I73_XG_MP0 (XI562_I73_XG_p1 I562_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I73_XG_MP1 (I562_G7_6 I562_gn6 XI562_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I74_XG_MP2 (VDD I562_gn8 I562_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I74_XG_MP0 (XI562_I74_XG_p1 I562_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I74_XG_MP1 (I562_G8_7 I562_gn7 XI562_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I68_XG_MP2 (VDD I2066_gn2 I2066_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I68_XG_MP0 (XI2066_I68_XG_p1 I2066_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I68_XG_MP1 (I2066_G2_1 I2066_gn1 XI2066_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I69_XG_MP2 (VDD I2066_gn3 I2066_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I69_XG_MP0 (XI2066_I69_XG_p1 I2066_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I69_XG_MP1 (I2066_G3_2 I2066_gn2 XI2066_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I70_XG_MP2 (VDD I2066_gn4 I2066_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I70_XG_MP0 (XI2066_I70_XG_p1 I2066_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I70_XG_MP1 (I2066_G4_3 I2066_gn3 XI2066_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I128_XG_MP2 (VDD I1988_G4_1n I1988_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I128_XG_MP0 (XI1988_I128_XG_p1 I1988_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I128_XG_MP1 (I1988_G4_0 I1988_G0_0n XI1988_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I70_XG_MP2 (VDD I1988_gn4 I1988_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I70_XG_MP0 (XI1988_I70_XG_p1 I1988_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I70_XG_MP1 (I1988_G4_3 I1988_gn3 XI1988_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I71_XG_MP2 (VDD I1988_gn5 I1988_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I71_XG_MP0 (XI1988_I71_XG_p1 I1988_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I71_XG_MP1 (I1988_G5_4 I1988_gn4 XI1988_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I72_XG_MP2 (VDD I1988_gn6 I1988_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I72_XG_MP0 (XI1988_I72_XG_p1 I1988_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I72_XG_MP1 (I1988_G6_5 I1988_gn5 XI1988_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I69_XG_MP2 (VDD I1942_gn3 I1942_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I69_XG_MP0 (XI1942_I69_XG_p1 I1942_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I69_XG_MP1 (I1942_G3_2 I1942_gn2 XI1942_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I70_XG_MP2 (VDD I1942_gn4 I1942_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I70_XG_MP0 (XI1942_I70_XG_p1 I1942_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I70_XG_MP1 (I1942_G4_3 I1942_gn3 XI1942_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I183_XG_MP2 (VDD I1850_G16_1n I1850_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I183_XG_MP0 (XI1850_I183_XG_p1 I1850_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I183_XG_MP1 (I1850_G16_0 I1850_G0_0n XI1850_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I185_XG_MP2 (VDD I1850_G18_3n I1850_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I185_XG_MP0 (XI1850_I185_XG_p1 I1850_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I185_XG_MP1 (I1850_G18_0 I1850_G2_0n XI1850_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I195_XG_MP2 (VDD I1850_G24_9n I1850_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I195_XG_MP0 (XI1850_I195_XG_p1 I1850_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I195_XG_MP1 (I1850_G24_0 I1850_G8_0n XI1850_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I188_XG_MP2 (VDD I1850_G20_5n I1850_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I188_XG_MP0 (XI1850_I188_XG_p1 I1850_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I188_XG_MP1 (I1850_G20_0 I1850_G4_0n XI1850_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I192_XG_MP2 (VDD I1850_G22_7n I1850_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I192_XG_MP0 (XI1850_I192_XG_p1 I1850_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I192_XG_MP1 (I1850_G22_0 I1850_G6_0n XI1850_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I197_XG_MP2 (VDD I1850_G26_11n I1850_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I197_XG_MP0 (XI1850_I197_XG_p1 I1850_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I197_XG_MP1 (I1850_G26_0 I1850_G10_0n XI1850_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I201_XG_MP2 (VDD I700_G30_15n c3_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I201_XG_MP0 (XI700_I201_XG_p1 I700_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I201_XG_MP1 (c3_m I700_G14_0n XI700_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I192_XG_MP2 (VDD I700_G22_7n I700_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I192_XG_MP0 (XI700_I192_XG_p1 I700_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I192_XG_MP1 (I700_G22_0 I700_G6_0n XI700_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I149_XG_MP2 (VDD I700_G24_21n I700_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I149_XG_MP0 (XI700_I149_XG_p1 I700_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I149_XG_MP1 (I700_G24_17 I700_G20_17n XI700_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I145_XG_MP2 (VDD I700_G20_17n I700_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I145_XG_MP0 (XI700_I145_XG_p1 I700_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I145_XG_MP1 (I700_G20_13 I700_G16_13n XI700_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I143_XG_MP2 (VDD I700_G18_15n I700_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I143_XG_MP0 (XI700_I143_XG_p1 I700_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I143_XG_MP1 (I700_G18_11 I700_G14_11n XI700_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I139_XG_MP2 (VDD I700_G14_11n I700_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I139_XG_MP0 (XI700_I139_XG_p1 I700_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I139_XG_MP1 (I700_G14_7 I700_G10_7n XI700_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I72_XG_MP2 (VDD I700_gn6 I700_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I72_XG_MP0 (XI700_I72_XG_p1 I700_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I72_XG_MP1 (I700_G6_5 I700_gn5 XI700_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I71_XG_MP2 (VDD I700_gn5 I700_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I71_XG_MP0 (XI700_I71_XG_p1 I700_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I71_XG_MP1 (I700_G5_4 I700_gn4 XI700_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI654_I65_XG_MP2 (VDD I654_gn0 I654_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI654_I65_XG_MP0 (XI654_I65_XG_p1 I654_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI654_I65_XG_MP1 (I654_G0_0 I654_cinn XI654_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI608_I65_XG_MP2 (VDD I608_gn0 I608_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI608_I65_XG_MP0 (XI608_I65_XG_p1 I608_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI608_I65_XG_MP1 (I608_G0_0 I608_cinn XI608_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I70_XG_MP2 (VDD I562_gn4 I562_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I70_XG_MP0 (XI562_I70_XG_p1 I562_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I70_XG_MP1 (I562_G4_3 I562_gn3 XI562_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I71_XG_MP2 (VDD I562_gn5 I562_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I71_XG_MP0 (XI562_I71_XG_p1 I562_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I71_XG_MP1 (I562_G5_4 I562_gn4 XI562_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I67_XG_MP2 (VDD I1988_gn1 I1988_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I67_XG_MP0 (XI1988_I67_XG_p1 I1988_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I67_XG_MP1 (I1988_G1_0 I1988_G0_0n XI1988_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I68_XG_MP2 (VDD I1988_gn2 I1988_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I68_XG_MP0 (XI1988_I68_XG_p1 I1988_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I68_XG_MP1 (I1988_G2_1 I1988_gn1 XI1988_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I69_XG_MP2 (VDD I1988_gn3 I1988_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I69_XG_MP0 (XI1988_I69_XG_p1 I1988_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I69_XG_MP1 (I1988_G3_2 I1988_gn2 XI1988_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I67_XG_MP2 (VDD I1942_gn1 I1942_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I67_XG_MP0 (XI1942_I67_XG_p1 I1942_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I67_XG_MP1 (I1942_G1_0 I1942_G0_0n XI1942_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I68_XG_MP2 (VDD I1942_gn2 I1942_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I68_XG_MP0 (XI1942_I68_XG_p1 I1942_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I68_XG_MP1 (I1942_G2_1 I1942_gn1 XI1942_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I67_XG_MP2 (VDD I1850_gn1 I1850_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I67_XG_MP0 (XI1850_I67_XG_p1 I1850_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I67_XG_MP1 (I1850_G1_0 I1850_G0_0n XI1850_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I128_XG_MP2 (VDD I1850_G4_1n I1850_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I128_XG_MP0 (XI1850_I128_XG_p1 I1850_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I128_XG_MP1 (I1850_G4_0 I1850_G0_0n XI1850_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I131_XG_MP2 (VDD I1850_G6_3n I1850_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I131_XG_MP0 (XI1850_I131_XG_p1 I1850_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I131_XG_MP1 (I1850_G6_0 I1850_G2_0n XI1850_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I133_XG_MP2 (VDD I1850_G8_5n I1850_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I133_XG_MP0 (XI1850_I133_XG_p1 I1850_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I133_XG_MP1 (I1850_G8_1 I1850_G4_1n XI1850_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I135_XG_MP2 (VDD I1850_G10_7n I1850_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I135_XG_MP0 (XI1850_I135_XG_p1 I1850_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I135_XG_MP1 (I1850_G10_3 I1850_G6_3n XI1850_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I137_XG_MP2 (VDD I1850_G12_9n I1850_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I137_XG_MP0 (XI1850_I137_XG_p1 I1850_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I137_XG_MP1 (I1850_G12_5 I1850_G8_5n XI1850_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I141_XG_MP2 (VDD I1850_G16_13n I1850_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I141_XG_MP0 (XI1850_I141_XG_p1 I1850_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I141_XG_MP1 (I1850_G16_9 I1850_G12_9n XI1850_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I139_XG_MP2 (VDD I1850_G14_11n I1850_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I139_XG_MP0 (XI1850_I139_XG_p1 I1850_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I139_XG_MP1 (I1850_G14_7 I1850_G10_7n XI1850_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I143_XG_MP2 (VDD I1850_G18_15n I1850_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I143_XG_MP0 (XI1850_I143_XG_p1 I1850_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I143_XG_MP1 (I1850_G18_11 I1850_G14_11n XI1850_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I199_XG_MP2 (VDD I1850_G28_13n I1850_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I199_XG_MP0 (XI1850_I199_XG_p1 I1850_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I199_XG_MP1 (I1850_G28_0 I1850_G12_0n XI1850_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I201_XG_MP2 (VDD I1850_G30_15n c28_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I201_XG_MP0 (XI1850_I201_XG_p1 I1850_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I201_XG_MP1 (c28_m I1850_G14_0n XI1850_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I141_XG_MP2 (VDD I700_G16_13n I700_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I141_XG_MP0 (XI700_I141_XG_p1 I700_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I141_XG_MP1 (I700_G16_9 I700_G12_9n XI700_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I137_XG_MP2 (VDD I700_G12_9n I700_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I137_XG_MP0 (XI700_I137_XG_p1 I700_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I137_XG_MP1 (I700_G12_5 I700_G8_5n XI700_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I135_XG_MP2 (VDD I700_G10_7n I700_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I135_XG_MP0 (XI700_I135_XG_p1 I700_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I135_XG_MP1 (I700_G10_3 I700_G6_3n XI700_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I133_XG_MP2 (VDD I700_G8_5n I700_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I133_XG_MP0 (XI700_I133_XG_p1 I700_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I133_XG_MP1 (I700_G8_1 I700_G4_1n XI700_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I131_XG_MP2 (VDD I700_G6_3n I700_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I131_XG_MP0 (XI700_I131_XG_p1 I700_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I131_XG_MP1 (I700_G6_0 I700_G2_0n XI700_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I70_XG_MP2 (VDD I700_gn4 I700_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I70_XG_MP0 (XI700_I70_XG_p1 I700_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I70_XG_MP1 (I700_G4_3 I700_gn3 XI700_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I69_XG_MP2 (VDD I700_gn3 I700_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I69_XG_MP0 (XI700_I69_XG_p1 I700_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I69_XG_MP1 (I700_G3_2 I700_gn2 XI700_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I68_XG_MP2 (VDD I700_gn2 I700_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I68_XG_MP0 (XI700_I68_XG_p1 I700_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I68_XG_MP1 (I700_G2_1 I700_gn1 XI700_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI562_I65_XG_MP2 (VDD I562_gn0 I562_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI562_I65_XG_MP0 (XI562_I65_XG_p1 I562_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI562_I65_XG_MP1 (I562_G0_0 I562_cinn XI562_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI2066_I65_XG_MP2 (VDD I2066_gn0 I2066_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI2066_I65_XG_MP0 (XI2066_I65_XG_p1 I2066_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI2066_I65_XG_MP1 (I2066_G0_0 I2066_cinn XI2066_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1942_I65_XG_MP2 (VDD I1942_gn0 I1942_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1942_I65_XG_MP0 (XI1942_I65_XG_p1 I1942_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1942_I65_XG_MP1 (I1942_G0_0 I1942_cinn XI1942_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I68_XG_MP2 (VDD I1850_gn2 I1850_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I68_XG_MP0 (XI1850_I68_XG_p1 I1850_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I68_XG_MP1 (I1850_G2_1 I1850_gn1 XI1850_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I69_XG_MP2 (VDD I1850_gn3 I1850_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I69_XG_MP0 (XI1850_I69_XG_p1 I1850_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I69_XG_MP1 (I1850_G3_2 I1850_gn2 XI1850_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I70_XG_MP2 (VDD I1850_gn4 I1850_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I70_XG_MP0 (XI1850_I70_XG_p1 I1850_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I70_XG_MP1 (I1850_G4_3 I1850_gn3 XI1850_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I71_XG_MP2 (VDD I1850_gn5 I1850_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I71_XG_MP0 (XI1850_I71_XG_p1 I1850_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I71_XG_MP1 (I1850_G5_4 I1850_gn4 XI1850_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I72_XG_MP2 (VDD I1850_gn6 I1850_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I72_XG_MP0 (XI1850_I72_XG_p1 I1850_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I72_XG_MP1 (I1850_G6_5 I1850_gn5 XI1850_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I75_XG_MP2 (VDD I1850_gn9 I1850_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I75_XG_MP0 (XI1850_I75_XG_p1 I1850_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I75_XG_MP1 (I1850_G9_8 I1850_gn8 XI1850_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I76_XG_MP2 (VDD I1850_gn10 I1850_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I76_XG_MP0 (XI1850_I76_XG_p1 I1850_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I76_XG_MP1 (I1850_G10_9 I1850_gn9 XI1850_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I77_XG_MP2 (VDD I1850_gn11 I1850_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I77_XG_MP0 (XI1850_I77_XG_p1 I1850_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I77_XG_MP1 (I1850_G11_10 I1850_gn10 XI1850_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I145_XG_MP2 (VDD I1850_G20_17n I1850_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I145_XG_MP0 (XI1850_I145_XG_p1 I1850_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I145_XG_MP1 (I1850_G20_13 I1850_G16_13n XI1850_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I149_XG_MP2 (VDD I1850_G24_21n I1850_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I149_XG_MP0 (XI1850_I149_XG_p1 I1850_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I149_XG_MP1 (I1850_G24_17 I1850_G20_17n XI1850_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I147_XG_MP2 (VDD I1850_G22_19n I1850_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I147_XG_MP0 (XI1850_I147_XG_p1 I1850_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I147_XG_MP1 (I1850_G22_15 I1850_G18_15n XI1850_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I151_XG_MP2 (VDD I1850_G26_23n I1850_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I151_XG_MP0 (XI1850_I151_XG_p1 I1850_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I151_XG_MP1 (I1850_G26_19 I1850_G22_19n XI1850_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I153_XG_MP2 (VDD I1850_G28_25n I1850_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I153_XG_MP0 (XI1850_I153_XG_p1 I1850_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I153_XG_MP1 (I1850_G28_21 I1850_G24_21n XI1850_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I155_XG_MP2 (VDD I1850_G30_27n I1850_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I155_XG_MP0 (XI1850_I155_XG_p1 I1850_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I155_XG_MP1 (I1850_G30_23 I1850_G26_23n XI1850_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I199_XG_MP2 (VDD I700_G28_13n I700_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I199_XG_MP0 (XI700_I199_XG_p1 I700_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I199_XG_MP1 (I700_G28_0 I700_G12_0n XI700_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I197_XG_MP2 (VDD I700_G26_11n I700_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I197_XG_MP0 (XI700_I197_XG_p1 I700_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I197_XG_MP1 (I700_G26_0 I700_G10_0n XI700_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I195_XG_MP2 (VDD I700_G24_9n I700_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I195_XG_MP0 (XI700_I195_XG_p1 I700_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I195_XG_MP1 (I700_G24_0 I700_G8_0n XI700_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I185_XG_MP2 (VDD I700_G18_3n I700_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I185_XG_MP0 (XI700_I185_XG_p1 I700_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I185_XG_MP1 (I700_G18_0 I700_G2_0n XI700_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I183_XG_MP2 (VDD I700_G16_1n I700_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I183_XG_MP0 (XI700_I183_XG_p1 I700_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I183_XG_MP1 (I700_G16_0 I700_G0_0n XI700_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I128_XG_MP2 (VDD I700_G4_1n I700_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I128_XG_MP0 (XI700_I128_XG_p1 I700_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I128_XG_MP1 (I700_G4_0 I700_G0_0n XI700_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I67_XG_MP2 (VDD I700_gn1 I700_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I67_XG_MP0 (XI700_I67_XG_p1 I700_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I67_XG_MP1 (I700_G1_0 I700_G0_0n XI700_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I65_XG_MP2 (VDD I700_gn0 I700_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I65_XG_MP0 (XI700_I65_XG_p1 I700_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I65_XG_MP1 (I700_G0_0 I700_cinn XI700_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1988_I65_XG_MP2 (VDD I1988_gn0 I1988_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1988_I65_XG_MP0 (XI1988_I65_XG_p1 I1988_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1988_I65_XG_MP1 (I1988_G0_0 I1988_cinn XI1988_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1896_I65_XG_MP2 (VDD I1896_gn0 I1896_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1896_I65_XG_MP0 (XI1896_I65_XG_p1 I1896_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1896_I65_XG_MP1 (I1896_G0_0 I1896_cinn XI1896_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I65_XG_MP2 (VDD I1850_gn0 I1850_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I65_XG_MP0 (XI1850_I65_XG_p1 I1850_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I65_XG_MP1 (I1850_G0_0 I1850_cinn XI1850_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I73_XG_MP2 (VDD I1850_gn7 I1850_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I73_XG_MP0 (XI1850_I73_XG_p1 I1850_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I73_XG_MP1 (I1850_G7_6 I1850_gn6 XI1850_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I74_XG_MP2 (VDD I1850_gn8 I1850_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I74_XG_MP0 (XI1850_I74_XG_p1 I1850_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I74_XG_MP1 (I1850_G8_7 I1850_gn7 XI1850_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I78_XG_MP2 (VDD I1850_gn12 I1850_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I78_XG_MP0 (XI1850_I78_XG_p1 I1850_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I78_XG_MP1 (I1850_G12_11 I1850_gn11 XI1850_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I79_XG_MP2 (VDD I1850_gn13 I1850_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I79_XG_MP0 (XI1850_I79_XG_p1 I1850_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I79_XG_MP1 (I1850_G13_12 I1850_gn12 XI1850_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I80_XG_MP2 (VDD I1850_gn14 I1850_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I80_XG_MP0 (XI1850_I80_XG_p1 I1850_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I80_XG_MP1 (I1850_G14_13 I1850_gn13 XI1850_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I83_XG_MP2 (VDD I1850_gn17 I1850_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I83_XG_MP0 (XI1850_I83_XG_p1 I1850_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I83_XG_MP1 (I1850_G17_16 I1850_gn16 XI1850_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I81_XG_MP2 (VDD I1850_gn15 I1850_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I81_XG_MP0 (XI1850_I81_XG_p1 I1850_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I81_XG_MP1 (I1850_G15_14 I1850_gn14 XI1850_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I82_XG_MP2 (VDD I1850_gn16 I1850_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I82_XG_MP0 (XI1850_I82_XG_p1 I1850_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I82_XG_MP1 (I1850_G16_15 I1850_gn15 XI1850_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I84_XG_MP2 (VDD I1850_gn18 I1850_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I84_XG_MP0 (XI1850_I84_XG_p1 I1850_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I84_XG_MP1 (I1850_G18_17 I1850_gn17 XI1850_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I86_XG_MP2 (VDD I1850_gn20 I1850_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I86_XG_MP0 (XI1850_I86_XG_p1 I1850_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I86_XG_MP1 (I1850_G20_19 I1850_gn19 XI1850_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I87_XG_MP2 (VDD I1850_gn21 I1850_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I87_XG_MP0 (XI1850_I87_XG_p1 I1850_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I87_XG_MP1 (I1850_G21_20 I1850_gn20 XI1850_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I89_XG_MP2 (VDD I1850_gn23 I1850_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I89_XG_MP0 (XI1850_I89_XG_p1 I1850_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I89_XG_MP1 (I1850_G23_22 I1850_gn22 XI1850_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI700_I188_XG_MP2 (VDD I700_G20_5n I700_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI700_I188_XG_MP0 (XI700_I188_XG_p1 I700_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI700_I188_XG_MP1 (I700_G20_0 I700_G4_0n XI700_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I65_XG_MP2 (VDD I746_gn0 I746_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I65_XG_MP0 (XI746_I65_XG_p1 I746_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I65_XG_MP1 (I746_G0_0 I746_cinn XI746_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I65_XG_MP2 (VDD I792_gn0 I792_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I65_XG_MP0 (XI792_I65_XG_p1 I792_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I65_XG_MP1 (I792_G0_0 I792_cinn XI792_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I65_XG_MP2 (VDD I838_gn0 I838_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I65_XG_MP0 (XI838_I65_XG_p1 I838_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I65_XG_MP1 (I838_G0_0 I838_cinn XI838_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I65_XG_MP2 (VDD I1804_gn0 I1804_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I65_XG_MP0 (XI1804_I65_XG_p1 I1804_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I65_XG_MP1 (I1804_G0_0 I1804_cinn XI1804_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I85_XG_MP2 (VDD I1850_gn19 I1850_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I85_XG_MP0 (XI1850_I85_XG_p1 I1850_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I85_XG_MP1 (I1850_G19_18 I1850_gn18 XI1850_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I88_XG_MP2 (VDD I1850_gn22 I1850_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I88_XG_MP0 (XI1850_I88_XG_p1 I1850_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I88_XG_MP1 (I1850_G22_21 I1850_gn21 XI1850_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I91_XG_MP2 (VDD I1850_gn25 I1850_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I91_XG_MP0 (XI1850_I91_XG_p1 I1850_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I91_XG_MP1 (I1850_G25_24 I1850_gn24 XI1850_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I90_XG_MP2 (VDD I1850_gn24 I1850_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I90_XG_MP0 (XI1850_I90_XG_p1 I1850_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I90_XG_MP1 (I1850_G24_23 I1850_gn23 XI1850_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I93_XG_MP2 (VDD I1850_gn27 I1850_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I93_XG_MP0 (XI1850_I93_XG_p1 I1850_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I93_XG_MP1 (I1850_G27_26 I1850_gn26 XI1850_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I92_XG_MP2 (VDD I1850_gn26 I1850_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I92_XG_MP0 (XI1850_I92_XG_p1 I1850_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I92_XG_MP1 (I1850_G26_25 I1850_gn25 XI1850_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I94_XG_MP2 (VDD I1850_gn28 I1850_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I94_XG_MP0 (XI1850_I94_XG_p1 I1850_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I94_XG_MP1 (I1850_G28_27 I1850_gn27 XI1850_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I95_XG_MP2 (VDD I1850_gn29 I1850_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I95_XG_MP0 (XI1850_I95_XG_p1 I1850_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I95_XG_MP1 (I1850_G29_28 I1850_gn28 XI1850_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I70_XG_MP2 (VDD I746_gn4 I746_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I70_XG_MP0 (XI746_I70_XG_p1 I746_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I70_XG_MP1 (I746_G4_3 I746_gn3 XI746_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I69_XG_MP2 (VDD I746_gn3 I746_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I69_XG_MP0 (XI746_I69_XG_p1 I746_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I69_XG_MP1 (I746_G3_2 I746_gn2 XI746_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I69_XG_MP2 (VDD I792_gn3 I792_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I69_XG_MP0 (XI792_I69_XG_p1 I792_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I69_XG_MP1 (I792_G3_2 I792_gn2 XI792_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I68_XG_MP2 (VDD I792_gn2 I792_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I68_XG_MP0 (XI792_I68_XG_p1 I792_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I68_XG_MP1 (I792_G2_1 I792_gn1 XI792_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I67_XG_MP2 (VDD I792_gn1 I792_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I67_XG_MP0 (XI792_I67_XG_p1 I792_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I67_XG_MP1 (I792_G1_0 I792_G0_0n XI792_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I68_XG_MP2 (VDD I838_gn2 I838_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I68_XG_MP0 (XI838_I68_XG_p1 I838_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I68_XG_MP1 (I838_G2_1 I838_gn1 XI838_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I65_XG_MP2 (VDD I1712_gn0 I1712_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I65_XG_MP0 (XI1712_I65_XG_p1 I1712_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I65_XG_MP1 (I1712_G0_0 I1712_cinn XI1712_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I65_XG_MP2 (VDD I1758_gn0 I1758_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I65_XG_MP0 (XI1758_I65_XG_p1 I1758_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I65_XG_MP1 (I1758_G0_0 I1758_cinn XI1758_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I68_XG_MP2 (VDD I1804_gn2 I1804_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I68_XG_MP0 (XI1804_I68_XG_p1 I1804_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I68_XG_MP1 (I1804_G2_1 I1804_gn1 XI1804_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I96_XG_MP2 (VDD I1850_gn30 I1850_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I96_XG_MP0 (XI1850_I96_XG_p1 I1850_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I96_XG_MP1 (I1850_G30_29 I1850_gn29 XI1850_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I76_XG_MP2 (VDD I746_gn10 I746_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I76_XG_MP0 (XI746_I76_XG_p1 I746_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I76_XG_MP1 (I746_G10_9 I746_gn9 XI746_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I75_XG_MP2 (VDD I746_gn9 I746_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I75_XG_MP0 (XI746_I75_XG_p1 I746_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I75_XG_MP1 (I746_G9_8 I746_gn8 XI746_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I74_XG_MP2 (VDD I746_gn8 I746_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I74_XG_MP0 (XI746_I74_XG_p1 I746_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I74_XG_MP1 (I746_G8_7 I746_gn7 XI746_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I73_XG_MP2 (VDD I746_gn7 I746_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I73_XG_MP0 (XI746_I73_XG_p1 I746_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I73_XG_MP1 (I746_G7_6 I746_gn6 XI746_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I72_XG_MP2 (VDD I746_gn6 I746_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I72_XG_MP0 (XI746_I72_XG_p1 I746_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I72_XG_MP1 (I746_G6_5 I746_gn5 XI746_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I71_XG_MP2 (VDD I746_gn5 I746_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I71_XG_MP0 (XI746_I71_XG_p1 I746_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I71_XG_MP1 (I746_G5_4 I746_gn4 XI746_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I68_XG_MP2 (VDD I746_gn2 I746_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I68_XG_MP0 (XI746_I68_XG_p1 I746_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I68_XG_MP1 (I746_G2_1 I746_gn1 XI746_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I73_XG_MP2 (VDD I792_gn7 I792_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I73_XG_MP0 (XI792_I73_XG_p1 I792_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I73_XG_MP1 (I792_G7_6 I792_gn6 XI792_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I71_XG_MP2 (VDD I792_gn5 I792_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I71_XG_MP0 (XI792_I71_XG_p1 I792_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I71_XG_MP1 (I792_G5_4 I792_gn4 XI792_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I72_XG_MP2 (VDD I792_gn6 I792_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I72_XG_MP0 (XI792_I72_XG_p1 I792_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I72_XG_MP1 (I792_G6_5 I792_gn5 XI792_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I70_XG_MP2 (VDD I792_gn4 I792_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I70_XG_MP0 (XI792_I70_XG_p1 I792_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I70_XG_MP1 (I792_G4_3 I792_gn3 XI792_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I71_XG_MP2 (VDD I838_gn5 I838_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I71_XG_MP0 (XI838_I71_XG_p1 I838_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I71_XG_MP1 (I838_G5_4 I838_gn4 XI838_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I70_XG_MP2 (VDD I838_gn4 I838_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I70_XG_MP0 (XI838_I70_XG_p1 I838_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I70_XG_MP1 (I838_G4_3 I838_gn3 XI838_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I69_XG_MP2 (VDD I838_gn3 I838_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I69_XG_MP0 (XI838_I69_XG_p1 I838_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I69_XG_MP1 (I838_G3_2 I838_gn2 XI838_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I67_XG_MP2 (VDD I838_gn1 I838_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I67_XG_MP0 (XI838_I67_XG_p1 I838_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I67_XG_MP1 (I838_G1_0 I838_G0_0n XI838_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I71_XG_MP2 (VDD I884_gn5 I884_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I71_XG_MP0 (XI884_I71_XG_p1 I884_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I71_XG_MP1 (I884_G5_4 I884_gn4 XI884_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I70_XG_MP2 (VDD I884_gn4 I884_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I70_XG_MP0 (XI884_I70_XG_p1 I884_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I70_XG_MP1 (I884_G4_3 I884_gn3 XI884_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I69_XG_MP2 (VDD I884_gn3 I884_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I69_XG_MP0 (XI884_I69_XG_p1 I884_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I69_XG_MP1 (I884_G3_2 I884_gn2 XI884_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I68_XG_MP2 (VDD I884_gn2 I884_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I68_XG_MP0 (XI884_I68_XG_p1 I884_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I68_XG_MP1 (I884_G2_1 I884_gn1 XI884_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I67_XG_MP2 (VDD I884_gn1 I884_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I67_XG_MP0 (XI884_I67_XG_p1 I884_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I67_XG_MP1 (I884_G1_0 I884_G0_0n XI884_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I68_XG_MP2 (VDD I1712_gn2 I1712_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I68_XG_MP0 (XI1712_I68_XG_p1 I1712_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I68_XG_MP1 (I1712_G2_1 I1712_gn1 XI1712_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I67_XG_MP2 (VDD I1712_gn1 I1712_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I67_XG_MP0 (XI1712_I67_XG_p1 I1712_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I67_XG_MP1 (I1712_G1_0 I1712_G0_0n XI1712_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I69_XG_MP2 (VDD I1758_gn3 I1758_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I69_XG_MP0 (XI1758_I69_XG_p1 I1758_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I69_XG_MP1 (I1758_G3_2 I1758_gn2 XI1758_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I68_XG_MP2 (VDD I1758_gn2 I1758_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I68_XG_MP0 (XI1758_I68_XG_p1 I1758_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I68_XG_MP1 (I1758_G2_1 I1758_gn1 XI1758_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I67_XG_MP2 (VDD I1758_gn1 I1758_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I67_XG_MP0 (XI1758_I67_XG_p1 I1758_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I67_XG_MP1 (I1758_G1_0 I1758_G0_0n XI1758_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I69_XG_MP2 (VDD I1804_gn3 I1804_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I69_XG_MP0 (XI1804_I69_XG_p1 I1804_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I69_XG_MP1 (I1804_G3_2 I1804_gn2 XI1804_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I67_XG_MP2 (VDD I1804_gn1 I1804_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I67_XG_MP0 (XI1804_I67_XG_p1 I1804_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I67_XG_MP1 (I1804_G1_0 I1804_G0_0n XI1804_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I88_XG_MP2 (VDD I746_gn22 I746_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I88_XG_MP0 (XI746_I88_XG_p1 I746_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I88_XG_MP1 (I746_G22_21 I746_gn21 XI746_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I87_XG_MP2 (VDD I746_gn21 I746_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I87_XG_MP0 (XI746_I87_XG_p1 I746_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I87_XG_MP1 (I746_G21_20 I746_gn20 XI746_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I86_XG_MP2 (VDD I746_gn20 I746_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I86_XG_MP0 (XI746_I86_XG_p1 I746_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I86_XG_MP1 (I746_G20_19 I746_gn19 XI746_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I85_XG_MP2 (VDD I746_gn19 I746_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I85_XG_MP0 (XI746_I85_XG_p1 I746_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I85_XG_MP1 (I746_G19_18 I746_gn18 XI746_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I84_XG_MP2 (VDD I746_gn18 I746_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I84_XG_MP0 (XI746_I84_XG_p1 I746_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I84_XG_MP1 (I746_G18_17 I746_gn17 XI746_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I81_XG_MP2 (VDD I746_gn15 I746_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I81_XG_MP0 (XI746_I81_XG_p1 I746_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I81_XG_MP1 (I746_G15_14 I746_gn14 XI746_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I80_XG_MP2 (VDD I746_gn14 I746_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I80_XG_MP0 (XI746_I80_XG_p1 I746_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I80_XG_MP1 (I746_G14_13 I746_gn13 XI746_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I79_XG_MP2 (VDD I746_gn13 I746_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I79_XG_MP0 (XI746_I79_XG_p1 I746_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I79_XG_MP1 (I746_G13_12 I746_gn12 XI746_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I78_XG_MP2 (VDD I746_gn12 I746_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I78_XG_MP0 (XI746_I78_XG_p1 I746_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I78_XG_MP1 (I746_G12_11 I746_gn11 XI746_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
