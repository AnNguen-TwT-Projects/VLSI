    I_MXI1_I1390_I127_XG_MP1 (XI1_I1390_I127_XG_p1 I1_I1390_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I125_XG_MP2 (XI1_I1390_I125_XG_p1 I1_I1390_G29_28 I1_I1390_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I125_XG_MP0 (VDD I1_I1390_P29_28 XI1_I1390_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I125_XG_MP1 (XI1_I1390_I125_XG_p1 I1_I1390_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I117_XG_MP2 (XI1_I1390_I117_XG_p1 I1_I1390_G21_20 I1_I1390_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I117_XG_MP0 (VDD I1_I1390_P21_20 XI1_I1390_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I117_XG_MP1 (XI1_I1390_I117_XG_p1 I1_I1390_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I115_XG_MP2 (XI1_I1390_I115_XG_p1 I1_I1390_G19_18 I1_I1390_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I115_XG_MP0 (VDD I1_I1390_P19_18 XI1_I1390_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I115_XG_MP1 (XI1_I1390_I115_XG_p1 I1_I1390_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I113_XG_MP2 (XI1_I1390_I113_XG_p1 I1_I1390_G17_16 I1_I1390_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I113_XG_MP0 (VDD I1_I1390_P17_16 XI1_I1390_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I113_XG_MP1 (XI1_I1390_I113_XG_p1 I1_I1390_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I99_XG_MP2 (XI1_I1344_I99_XG_p1 I1_I1344_G3_2 I1_I1344_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I99_XG_MP0 (VDD I1_I1344_P3_2 XI1_I1344_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I99_XG_MP1 (XI1_I1344_I99_XG_p1 I1_I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I100_XG_MP2 (XI1_I1344_I100_XG_p1 I1_I1344_G4_3 I1_I1344_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I100_XG_MP0 (VDD I1_I1344_P4_3 XI1_I1344_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I100_XG_MP1 (XI1_I1344_I100_XG_p1 I1_I1344_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I98_XG_MP2 (XI1_I1298_I98_XG_p1 I1_I1298_G2_1 I1_I1298_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I98_XG_MP0 (VDD I1_I1298_P2_1 XI1_I1298_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I98_XG_MP1 (XI1_I1298_I98_XG_p1 I1_I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I100_XG_MP2 (XI1_I1298_I100_XG_p1 I1_I1298_G4_3 I1_I1298_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I100_XG_MP0 (VDD I1_I1298_P4_3 XI1_I1298_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I100_XG_MP1 (XI1_I1298_I100_XG_p1 I1_I1298_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I174_XG_MP2 (XI1_I1160_I174_XG_p1 I1_I1160_G23_16 I1_I1160_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I174_XG_MP0 (VDD I1_I1160_P23_16 XI1_I1160_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I174_XG_MP1 (XI1_I1160_I174_XG_p1 I1_I1160_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I166_XG_MP2 (XI1_I1160_I166_XG_p1 I1_I1160_G15_8 I1_I1160_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I166_XG_MP0 (VDD I1_I1160_P15_8 XI1_I1160_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I166_XG_MP1 (XI1_I1160_I166_XG_p1 I1_I1160_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I179_XG_MP2 (XI1_I884_I179_XG_p1 I1_I884_G28_21 I1_I884_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I179_XG_MP0 (VDD I1_I884_P28_21 XI1_I884_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I179_XG_MP1 (XI1_I884_I179_XG_p1 I1_I884_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I171_XG_MP2 (XI1_I884_I171_XG_p1 I1_I884_G20_13 I1_I884_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I171_XG_MP0 (VDD I1_I884_P20_13 XI1_I884_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I171_XG_MP1 (XI1_I884_I171_XG_p1 I1_I884_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I163_XG_MP2 (XI1_I884_I163_XG_p1 I1_I884_G12_5 I1_I884_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I163_XG_MP0 (VDD I1_I884_P12_5 XI1_I884_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I163_XG_MP1 (XI1_I884_I163_XG_p1 I1_I884_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I169_XG_MP2 (XI1_I884_I169_XG_p1 I1_I884_G18_11 I1_I884_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I169_XG_MP0 (VDD I1_I884_P18_11 XI1_I884_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I169_XG_MP1 (XI1_I884_I169_XG_p1 I1_I884_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I160_XG_MP2 (XI1_I884_I160_XG_p1 I1_I884_G10_3 I1_I884_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I160_XG_MP0 (VDD I1_I884_P10_3 XI1_I884_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I160_XG_MP1 (XI1_I884_I160_XG_p1 I1_I884_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I167_XG_MP2 (XI1_I884_I167_XG_p1 I1_I884_G16_9 I1_I884_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I167_XG_MP0 (VDD I1_I884_P16_9 XI1_I884_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I167_XG_MP1 (XI1_I884_I167_XG_p1 I1_I884_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I157_XG_MP2 (XI1_I884_I157_XG_p1 I1_I884_G8_1 I1_I884_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I157_XG_MP0 (VDD I1_I884_P8_1 XI1_I884_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I157_XG_MP1 (XI1_I884_I157_XG_p1 I1_I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I100_XG_MP2 (XI1_I884_I100_XG_p1 I1_I884_G4_3 I1_I884_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I100_XG_MP0 (VDD I1_I884_P4_3 XI1_I884_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I100_XG_MP1 (XI1_I884_I100_XG_p1 I1_I884_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I158_XG_MP2 (XI1_I700_I158_XG_p1 I1_I700_G9_2 I1_I700_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I158_XG_MP0 (VDD I1_I700_P9_2 XI1_I700_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I158_XG_MP1 (XI1_I700_I158_XG_p1 I1_I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I107_XG_MP2 (XI1_I700_I107_XG_p1 I1_I700_G11_10 I1_I700_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I107_XG_MP0 (VDD I1_I700_P11_10 XI1_I700_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I107_XG_MP1 (XI1_I700_I107_XG_p1 I1_I700_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I109_XG_MP2 (XI1_I700_I109_XG_p1 I1_I700_G13_12 I1_I700_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I109_XG_MP0 (VDD I1_I700_P13_12 XI1_I700_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I109_XG_MP1 (XI1_I700_I109_XG_p1 I1_I700_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I168_XG_MP2 (XI1_I700_I168_XG_p1 I1_I700_G17_10 I1_I700_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I168_XG_MP0 (VDD I1_I700_P17_10 XI1_I700_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I168_XG_MP1 (XI1_I700_I168_XG_p1 I1_I700_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I111_XG_MP2 (XI1_I700_I111_XG_p1 I1_I700_G15_14 I1_I700_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I111_XG_MP0 (VDD I1_I700_P15_14 XI1_I700_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I111_XG_MP1 (XI1_I700_I111_XG_p1 I1_I700_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I113_XG_MP2 (XI1_I700_I113_XG_p1 I1_I700_G17_16 I1_I700_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I113_XG_MP0 (VDD I1_I700_P17_16 XI1_I700_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I113_XG_MP1 (XI1_I700_I113_XG_p1 I1_I700_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I115_XG_MP2 (XI1_I700_I115_XG_p1 I1_I700_G19_18 I1_I700_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I115_XG_MP0 (VDD I1_I700_P19_18 XI1_I700_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I115_XG_MP1 (XI1_I700_I115_XG_p1 I1_I700_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I176_XG_MP2 (XI1_I700_I176_XG_p1 I1_I700_G25_18 I1_I700_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I176_XG_MP0 (VDD I1_I700_P25_18 XI1_I700_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I176_XG_MP1 (XI1_I700_I176_XG_p1 I1_I700_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I180_XG_MP2 (XI1_I700_I180_XG_p1 I1_I700_G29_22 I1_I700_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I180_XG_MP0 (VDD I1_I700_P29_22 XI1_I700_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I180_XG_MP1 (XI1_I700_I180_XG_p1 I1_I700_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I125_XG_MP2 (XI1_I700_I125_XG_p1 I1_I700_G29_28 I1_I700_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I125_XG_MP0 (VDD I1_I700_P29_28 XI1_I700_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I125_XG_MP1 (XI1_I700_I125_XG_p1 I1_I700_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I127_XG_MP2 (XI1_I700_I127_XG_p1 I1_I700_G31_30 I1_I700_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I127_XG_MP0 (VDD I1_I700_P31_30 XI1_I700_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I127_XG_MP1 (XI1_I700_I127_XG_p1 I1_I700_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I182_XG_MP2 (XI1_I1390_I182_XG_p1 I1_I1390_G31_24 I1_I1390_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I182_XG_MP0 (VDD I1_I1390_P31_24 XI1_I1390_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I182_XG_MP1 (XI1_I1390_I182_XG_p1 I1_I1390_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I180_XG_MP2 (XI1_I1390_I180_XG_p1 I1_I1390_G29_22 I1_I1390_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I180_XG_MP0 (VDD I1_I1390_P29_22 XI1_I1390_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I180_XG_MP1 (XI1_I1390_I180_XG_p1 I1_I1390_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I174_XG_MP2 (XI1_I1390_I174_XG_p1 I1_I1390_G23_16 I1_I1390_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I174_XG_MP0 (VDD I1_I1390_P23_16 XI1_I1390_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I174_XG_MP1 (XI1_I1390_I174_XG_p1 I1_I1390_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I178_XG_MP2 (XI1_I1390_I178_XG_p1 I1_I1390_G27_20 I1_I1390_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I178_XG_MP0 (VDD I1_I1390_P27_20 XI1_I1390_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I178_XG_MP1 (XI1_I1390_I178_XG_p1 I1_I1390_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I111_XG_MP2 (XI1_I1390_I111_XG_p1 I1_I1390_G15_14 I1_I1390_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I111_XG_MP0 (VDD I1_I1390_P15_14 XI1_I1390_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I111_XG_MP1 (XI1_I1390_I111_XG_p1 I1_I1390_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I109_XG_MP2 (XI1_I1390_I109_XG_p1 I1_I1390_G13_12 I1_I1390_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I109_XG_MP0 (VDD I1_I1390_P13_12 XI1_I1390_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I109_XG_MP1 (XI1_I1390_I109_XG_p1 I1_I1390_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I98_XG_MP2 (XI1_I1344_I98_XG_p1 I1_I1344_G2_1 I1_I1344_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I98_XG_MP0 (VDD I1_I1344_P2_1 XI1_I1344_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I98_XG_MP1 (XI1_I1344_I98_XG_p1 I1_I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I182_XG_MP2 (XI1_I1160_I182_XG_p1 I1_I1160_G31_24 I1_I1160_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I182_XG_MP0 (VDD I1_I1160_P31_24 XI1_I1160_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I182_XG_MP1 (XI1_I1160_I182_XG_p1 I1_I1160_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I180_XG_MP2 (XI1_I1160_I180_XG_p1 I1_I1160_G29_22 I1_I1160_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I180_XG_MP0 (VDD I1_I1160_P29_22 XI1_I1160_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I180_XG_MP1 (XI1_I1160_I180_XG_p1 I1_I1160_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I172_XG_MP2 (XI1_I1160_I172_XG_p1 I1_I1160_G21_14 I1_I1160_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I172_XG_MP0 (VDD I1_I1160_P21_14 XI1_I1160_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I172_XG_MP1 (XI1_I1160_I172_XG_p1 I1_I1160_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I164_XG_MP2 (XI1_I1160_I164_XG_p1 I1_I1160_G13_6 I1_I1160_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I164_XG_MP0 (VDD I1_I1160_P13_6 XI1_I1160_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I164_XG_MP1 (XI1_I1160_I164_XG_p1 I1_I1160_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I176_XG_MP2 (XI1_I1160_I176_XG_p1 I1_I1160_G25_18 I1_I1160_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I176_XG_MP0 (VDD I1_I1160_P25_18 XI1_I1160_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I176_XG_MP1 (XI1_I1160_I176_XG_p1 I1_I1160_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I168_XG_MP2 (XI1_I1160_I168_XG_p1 I1_I1160_G17_10 I1_I1160_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I168_XG_MP0 (VDD I1_I1160_P17_10 XI1_I1160_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I168_XG_MP1 (XI1_I1160_I168_XG_p1 I1_I1160_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I158_XG_MP2 (XI1_I1160_I158_XG_p1 I1_I1160_G9_2 I1_I1160_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I158_XG_MP0 (VDD I1_I1160_P9_2 XI1_I1160_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I158_XG_MP1 (XI1_I1160_I158_XG_p1 I1_I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I98_XG_MP2 (XI1_I884_I98_XG_p1 I1_I884_G2_1 I1_I884_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I98_XG_MP0 (VDD I1_I884_P2_1 XI1_I884_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I98_XG_MP1 (XI1_I884_I98_XG_p1 I1_I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I99_XG_MP2 (XI1_I700_I99_XG_p1 I1_I700_G3_2 I1_I700_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I99_XG_MP0 (VDD I1_I700_P3_2 XI1_I700_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I99_XG_MP1 (XI1_I700_I99_XG_p1 I1_I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I101_XG_MP2 (XI1_I700_I101_XG_p1 I1_I700_G5_4 I1_I700_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I101_XG_MP0 (VDD I1_I700_P5_4 XI1_I700_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I101_XG_MP1 (XI1_I700_I101_XG_p1 I1_I700_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I103_XG_MP2 (XI1_I700_I103_XG_p1 I1_I700_G7_6 I1_I700_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I103_XG_MP0 (VDD I1_I700_P7_6 XI1_I700_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I103_XG_MP1 (XI1_I700_I103_XG_p1 I1_I700_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I105_XG_MP2 (XI1_I700_I105_XG_p1 I1_I700_G9_8 I1_I700_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I105_XG_MP0 (VDD I1_I700_P9_8 XI1_I700_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I105_XG_MP1 (XI1_I700_I105_XG_p1 I1_I700_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I117_XG_MP2 (XI1_I700_I117_XG_p1 I1_I700_G21_20 I1_I700_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I117_XG_MP0 (VDD I1_I700_P21_20 XI1_I700_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I117_XG_MP1 (XI1_I700_I117_XG_p1 I1_I700_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I119_XG_MP2 (XI1_I700_I119_XG_p1 I1_I700_G23_22 I1_I700_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I119_XG_MP0 (VDD I1_I700_P23_22 XI1_I700_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I119_XG_MP1 (XI1_I700_I119_XG_p1 I1_I700_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I121_XG_MP2 (XI1_I700_I121_XG_p1 I1_I700_G25_24 I1_I700_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I121_XG_MP0 (VDD I1_I700_P25_24 XI1_I700_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I121_XG_MP1 (XI1_I700_I121_XG_p1 I1_I700_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I123_XG_MP2 (XI1_I700_I123_XG_p1 I1_I700_G27_26 I1_I700_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I123_XG_MP0 (VDD I1_I700_P27_26 XI1_I700_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I123_XG_MP1 (XI1_I700_I123_XG_p1 I1_I700_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I126_XG_MP2 (XI1_I1390_I126_XG_p1 I1_I1390_G30_29 I1_I1390_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I126_XG_MP0 (VDD I1_I1390_P30_29 XI1_I1390_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I126_XG_MP1 (XI1_I1390_I126_XG_p1 I1_I1390_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I124_XG_MP2 (XI1_I1390_I124_XG_p1 I1_I1390_G28_27 I1_I1390_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I124_XG_MP0 (VDD I1_I1390_P28_27 XI1_I1390_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I124_XG_MP1 (XI1_I1390_I124_XG_p1 I1_I1390_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I166_XG_MP2 (XI1_I1390_I166_XG_p1 I1_I1390_G15_8 I1_I1390_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I166_XG_MP0 (VDD I1_I1390_P15_8 XI1_I1390_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I166_XG_MP1 (XI1_I1390_I166_XG_p1 I1_I1390_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I170_XG_MP2 (XI1_I1390_I170_XG_p1 I1_I1390_G19_12 I1_I1390_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I170_XG_MP0 (VDD I1_I1390_P19_12 XI1_I1390_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I170_XG_MP1 (XI1_I1390_I170_XG_p1 I1_I1390_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I164_XG_MP2 (XI1_I1390_I164_XG_p1 I1_I1390_G13_6 I1_I1390_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I164_XG_MP0 (VDD I1_I1390_P13_6 XI1_I1390_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I164_XG_MP1 (XI1_I1390_I164_XG_p1 I1_I1390_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I162_XG_MP2 (XI1_I1390_I162_XG_p1 I1_I1390_G11_4 I1_I1390_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I162_XG_MP0 (VDD I1_I1390_P11_4 XI1_I1390_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I162_XG_MP1 (XI1_I1390_I162_XG_p1 I1_I1390_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I107_XG_MP2 (XI1_I1390_I107_XG_p1 I1_I1390_G11_10 I1_I1390_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I107_XG_MP0 (VDD I1_I1390_P11_10 XI1_I1390_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I107_XG_MP1 (XI1_I1390_I107_XG_p1 I1_I1390_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I105_XG_MP2 (XI1_I1390_I105_XG_p1 I1_I1390_G9_8 I1_I1390_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I105_XG_MP0 (VDD I1_I1390_P9_8 XI1_I1390_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I105_XG_MP1 (XI1_I1390_I105_XG_p1 I1_I1390_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I127_XG_MP2 (XI1_I1160_I127_XG_p1 I1_I1160_G31_30 I1_I1160_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I127_XG_MP0 (VDD I1_I1160_P31_30 XI1_I1160_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I127_XG_MP1 (XI1_I1160_I127_XG_p1 I1_I1160_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I125_XG_MP2 (XI1_I1160_I125_XG_p1 I1_I1160_G29_28 I1_I1160_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I125_XG_MP0 (VDD I1_I1160_P29_28 XI1_I1160_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I125_XG_MP1 (XI1_I1160_I125_XG_p1 I1_I1160_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I123_XG_MP2 (XI1_I1160_I123_XG_p1 I1_I1160_G27_26 I1_I1160_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I123_XG_MP0 (VDD I1_I1160_P27_26 XI1_I1160_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I123_XG_MP1 (XI1_I1160_I123_XG_p1 I1_I1160_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I117_XG_MP2 (XI1_I1160_I117_XG_p1 I1_I1160_G21_20 I1_I1160_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I117_XG_MP0 (VDD I1_I1160_P21_20 XI1_I1160_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I117_XG_MP1 (XI1_I1160_I117_XG_p1 I1_I1160_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I115_XG_MP2 (XI1_I1160_I115_XG_p1 I1_I1160_G19_18 I1_I1160_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I115_XG_MP0 (VDD I1_I1160_P19_18 XI1_I1160_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I115_XG_MP1 (XI1_I1160_I115_XG_p1 I1_I1160_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I113_XG_MP2 (XI1_I1160_I113_XG_p1 I1_I1160_G17_16 I1_I1160_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I113_XG_MP0 (VDD I1_I1160_P17_16 XI1_I1160_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I113_XG_MP1 (XI1_I1160_I113_XG_p1 I1_I1160_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I111_XG_MP2 (XI1_I1160_I111_XG_p1 I1_I1160_G15_14 I1_I1160_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I111_XG_MP0 (VDD I1_I1160_P15_14 XI1_I1160_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I111_XG_MP1 (XI1_I1160_I111_XG_p1 I1_I1160_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I109_XG_MP2 (XI1_I1160_I109_XG_p1 I1_I1160_G13_12 I1_I1160_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I109_XG_MP0 (VDD I1_I1160_P13_12 XI1_I1160_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I109_XG_MP1 (XI1_I1160_I109_XG_p1 I1_I1160_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I107_XG_MP2 (XI1_I1160_I107_XG_p1 I1_I1160_G11_10 I1_I1160_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I107_XG_MP0 (VDD I1_I1160_P11_10 XI1_I1160_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I107_XG_MP1 (XI1_I1160_I107_XG_p1 I1_I1160_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I105_XG_MP2 (XI1_I1160_I105_XG_p1 I1_I1160_G9_8 I1_I1160_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I105_XG_MP0 (VDD I1_I1160_P9_8 XI1_I1160_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I105_XG_MP1 (XI1_I1160_I105_XG_p1 I1_I1160_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I103_XG_MP2 (XI1_I1160_I103_XG_p1 I1_I1160_G7_6 I1_I1160_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I103_XG_MP0 (VDD I1_I1160_P7_6 XI1_I1160_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I103_XG_MP1 (XI1_I1160_I103_XG_p1 I1_I1160_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I101_XG_MP2 (XI1_I1160_I101_XG_p1 I1_I1160_G5_4 I1_I1160_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I101_XG_MP0 (VDD I1_I1160_P5_4 XI1_I1160_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I101_XG_MP1 (XI1_I1160_I101_XG_p1 I1_I1160_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I99_XG_MP2 (XI1_I1160_I99_XG_p1 I1_I1160_G3_2 I1_I1160_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I99_XG_MP0 (VDD I1_I1160_P3_2 XI1_I1160_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I99_XG_MP1 (XI1_I1160_I99_XG_p1 I1_I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I98_XG_MP2 (XI1_I700_I98_XG_p1 I1_I700_G2_1 I1_I700_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I98_XG_MP0 (VDD I1_I700_P2_1 XI1_I700_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I98_XG_MP1 (XI1_I700_I98_XG_p1 I1_I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I100_XG_MP2 (XI1_I700_I100_XG_p1 I1_I700_G4_3 I1_I700_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I100_XG_MP0 (VDD I1_I700_P4_3 XI1_I700_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I100_XG_MP1 (XI1_I700_I100_XG_p1 I1_I700_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I157_XG_MP2 (XI1_I700_I157_XG_p1 I1_I700_G8_1 I1_I700_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I157_XG_MP0 (VDD I1_I700_P8_1 XI1_I700_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I157_XG_MP1 (XI1_I700_I157_XG_p1 I1_I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I160_XG_MP2 (XI1_I700_I160_XG_p1 I1_I700_G10_3 I1_I700_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I160_XG_MP0 (VDD I1_I700_P10_3 XI1_I700_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I160_XG_MP1 (XI1_I700_I160_XG_p1 I1_I700_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I169_XG_MP2 (XI1_I700_I169_XG_p1 I1_I700_G18_11 I1_I700_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I169_XG_MP0 (VDD I1_I700_P18_11 XI1_I700_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I169_XG_MP1 (XI1_I700_I169_XG_p1 I1_I700_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I163_XG_MP2 (XI1_I700_I163_XG_p1 I1_I700_G12_5 I1_I700_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I163_XG_MP0 (VDD I1_I700_P12_5 XI1_I700_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I163_XG_MP1 (XI1_I700_I163_XG_p1 I1_I700_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I171_XG_MP2 (XI1_I700_I171_XG_p1 I1_I700_G20_13 I1_I700_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I171_XG_MP0 (VDD I1_I700_P20_13 XI1_I700_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I171_XG_MP1 (XI1_I700_I171_XG_p1 I1_I700_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I165_XG_MP2 (XI1_I700_I165_XG_p1 I1_I700_G14_7 I1_I700_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I165_XG_MP0 (VDD I1_I700_P14_7 XI1_I700_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I165_XG_MP1 (XI1_I700_I165_XG_p1 I1_I700_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I177_XG_MP2 (XI1_I700_I177_XG_p1 I1_I700_G26_19 I1_I700_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I177_XG_MP0 (VDD I1_I700_P26_19 XI1_I700_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I177_XG_MP1 (XI1_I700_I177_XG_p1 I1_I700_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I173_XG_MP2 (XI1_I700_I173_XG_p1 I1_I700_G22_15 I1_I700_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I173_XG_MP0 (VDD I1_I700_P22_15 XI1_I700_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I173_XG_MP1 (XI1_I700_I173_XG_p1 I1_I700_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I179_XG_MP2 (XI1_I700_I179_XG_p1 I1_I700_G28_21 I1_I700_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I179_XG_MP0 (VDD I1_I700_P28_21 XI1_I700_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I179_XG_MP1 (XI1_I700_I179_XG_p1 I1_I700_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I181_XG_MP2 (XI1_I700_I181_XG_p1 I1_I700_G30_23 I1_I700_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I181_XG_MP0 (VDD I1_I700_P30_23 XI1_I700_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I181_XG_MP1 (XI1_I700_I181_XG_p1 I1_I700_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I126_XG_MP2 (XI1_I700_I126_XG_p1 I1_I700_G30_29 I1_I700_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I126_XG_MP0 (VDD I1_I700_P30_29 XI1_I700_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I126_XG_MP1 (XI1_I700_I126_XG_p1 I1_I700_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I122_XG_MP2 (XI1_I1390_I122_XG_p1 I1_I1390_G26_25 I1_I1390_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I122_XG_MP0 (VDD I1_I1390_P26_25 XI1_I1390_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I122_XG_MP1 (XI1_I1390_I122_XG_p1 I1_I1390_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I120_XG_MP2 (XI1_I1390_I120_XG_p1 I1_I1390_G24_23 I1_I1390_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I120_XG_MP0 (VDD I1_I1390_P24_23 XI1_I1390_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I120_XG_MP1 (XI1_I1390_I120_XG_p1 I1_I1390_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I118_XG_MP2 (XI1_I1390_I118_XG_p1 I1_I1390_G22_21 I1_I1390_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I118_XG_MP0 (VDD I1_I1390_P22_21 XI1_I1390_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I118_XG_MP1 (XI1_I1390_I118_XG_p1 I1_I1390_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I116_XG_MP2 (XI1_I1390_I116_XG_p1 I1_I1390_G20_19 I1_I1390_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I116_XG_MP0 (VDD I1_I1390_P20_19 XI1_I1390_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I116_XG_MP1 (XI1_I1390_I116_XG_p1 I1_I1390_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I112_XG_MP2 (XI1_I1390_I112_XG_p1 I1_I1390_G16_15 I1_I1390_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I112_XG_MP0 (VDD I1_I1390_P16_15 XI1_I1390_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I112_XG_MP1 (XI1_I1390_I112_XG_p1 I1_I1390_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I168_XG_MP2 (XI1_I1390_I168_XG_p1 I1_I1390_G17_10 I1_I1390_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I168_XG_MP0 (VDD I1_I1390_P17_10 XI1_I1390_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I168_XG_MP1 (XI1_I1390_I168_XG_p1 I1_I1390_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I158_XG_MP2 (XI1_I1390_I158_XG_p1 I1_I1390_G9_2 I1_I1390_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I158_XG_MP0 (VDD I1_I1390_P9_2 XI1_I1390_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I158_XG_MP1 (XI1_I1390_I158_XG_p1 I1_I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I103_XG_MP2 (XI1_I1390_I103_XG_p1 I1_I1390_G7_6 I1_I1390_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I103_XG_MP0 (VDD I1_I1390_P7_6 XI1_I1390_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I103_XG_MP1 (XI1_I1390_I103_XG_p1 I1_I1390_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I126_XG_MP2 (XI1_I1160_I126_XG_p1 I1_I1160_G30_29 I1_I1160_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I126_XG_MP0 (VDD I1_I1160_P30_29 XI1_I1160_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I126_XG_MP1 (XI1_I1160_I126_XG_p1 I1_I1160_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I181_XG_MP2 (XI1_I1160_I181_XG_p1 I1_I1160_G30_23 I1_I1160_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I181_XG_MP0 (VDD I1_I1160_P30_23 XI1_I1160_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I181_XG_MP1 (XI1_I1160_I181_XG_p1 I1_I1160_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I163_XG_MP2 (XI1_I1160_I163_XG_p1 I1_I1160_G12_5 I1_I1160_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I163_XG_MP0 (VDD I1_I1160_P12_5 XI1_I1160_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I163_XG_MP1 (XI1_I1160_I163_XG_p1 I1_I1160_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I157_XG_MP2 (XI1_I1160_I157_XG_p1 I1_I1160_G8_1 I1_I1160_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I157_XG_MP0 (VDD I1_I1160_P8_1 XI1_I1160_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I157_XG_MP1 (XI1_I1160_I157_XG_p1 I1_I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I125_XG_MP2 (XI1_I930_I125_XG_p1 I1_I930_G29_28 I1_I930_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I125_XG_MP0 (VDD I1_I930_P29_28 XI1_I930_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I125_XG_MP1 (XI1_I930_I125_XG_p1 I1_I930_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I123_XG_MP2 (XI1_I930_I123_XG_p1 I1_I930_G27_26 I1_I930_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I123_XG_MP0 (VDD I1_I930_P27_26 XI1_I930_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I123_XG_MP1 (XI1_I930_I123_XG_p1 I1_I930_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I121_XG_MP2 (XI1_I930_I121_XG_p1 I1_I930_G25_24 I1_I930_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I121_XG_MP0 (VDD I1_I930_P25_24 XI1_I930_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I121_XG_MP1 (XI1_I930_I121_XG_p1 I1_I930_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I119_XG_MP2 (XI1_I930_I119_XG_p1 I1_I930_G23_22 I1_I930_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I119_XG_MP0 (VDD I1_I930_P23_22 XI1_I930_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I119_XG_MP1 (XI1_I930_I119_XG_p1 I1_I930_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I117_XG_MP2 (XI1_I930_I117_XG_p1 I1_I930_G21_20 I1_I930_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I117_XG_MP0 (VDD I1_I930_P21_20 XI1_I930_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I117_XG_MP1 (XI1_I930_I117_XG_p1 I1_I930_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I115_XG_MP2 (XI1_I930_I115_XG_p1 I1_I930_G19_18 I1_I930_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I115_XG_MP0 (VDD I1_I930_P19_18 XI1_I930_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I115_XG_MP1 (XI1_I930_I115_XG_p1 I1_I930_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I113_XG_MP2 (XI1_I930_I113_XG_p1 I1_I930_G17_16 I1_I930_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I113_XG_MP0 (VDD I1_I930_P17_16 XI1_I930_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I113_XG_MP1 (XI1_I930_I113_XG_p1 I1_I930_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I111_XG_MP2 (XI1_I930_I111_XG_p1 I1_I930_G15_14 I1_I930_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I111_XG_MP0 (VDD I1_I930_P15_14 XI1_I930_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I111_XG_MP1 (XI1_I930_I111_XG_p1 I1_I930_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I109_XG_MP2 (XI1_I930_I109_XG_p1 I1_I930_G13_12 I1_I930_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I109_XG_MP0 (VDD I1_I930_P13_12 XI1_I930_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I109_XG_MP1 (XI1_I930_I109_XG_p1 I1_I930_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I107_XG_MP2 (XI1_I930_I107_XG_p1 I1_I930_G11_10 I1_I930_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I107_XG_MP0 (VDD I1_I930_P11_10 XI1_I930_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I107_XG_MP1 (XI1_I930_I107_XG_p1 I1_I930_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I102_XG_MP2 (XI1_I700_I102_XG_p1 I1_I700_G6_5 I1_I700_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I102_XG_MP0 (VDD I1_I700_P6_5 XI1_I700_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I102_XG_MP1 (XI1_I700_I102_XG_p1 I1_I700_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I104_XG_MP2 (XI1_I700_I104_XG_p1 I1_I700_G8_7 I1_I700_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I104_XG_MP0 (VDD I1_I700_P8_7 XI1_I700_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I104_XG_MP1 (XI1_I700_I104_XG_p1 I1_I700_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I167_XG_MP2 (XI1_I700_I167_XG_p1 I1_I700_G16_9 I1_I700_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I167_XG_MP0 (VDD I1_I700_P16_9 XI1_I700_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I167_XG_MP1 (XI1_I700_I167_XG_p1 I1_I700_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I106_XG_MP2 (XI1_I700_I106_XG_p1 I1_I700_G10_9 I1_I700_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I106_XG_MP0 (VDD I1_I700_P10_9 XI1_I700_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I106_XG_MP1 (XI1_I700_I106_XG_p1 I1_I700_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I108_XG_MP2 (XI1_I700_I108_XG_p1 I1_I700_G12_11 I1_I700_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I108_XG_MP0 (VDD I1_I700_P12_11 XI1_I700_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I108_XG_MP1 (XI1_I700_I108_XG_p1 I1_I700_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I175_XG_MP2 (XI1_I700_I175_XG_p1 I1_I700_G24_17 I1_I700_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I175_XG_MP0 (VDD I1_I700_P24_17 XI1_I700_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I175_XG_MP1 (XI1_I700_I175_XG_p1 I1_I700_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I112_XG_MP2 (XI1_I700_I112_XG_p1 I1_I700_G16_15 I1_I700_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I112_XG_MP0 (VDD I1_I700_P16_15 XI1_I700_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I112_XG_MP1 (XI1_I700_I112_XG_p1 I1_I700_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I114_XG_MP2 (XI1_I700_I114_XG_p1 I1_I700_G18_17 I1_I700_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I114_XG_MP0 (VDD I1_I700_P18_17 XI1_I700_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I114_XG_MP1 (XI1_I700_I114_XG_p1 I1_I700_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I116_XG_MP2 (XI1_I700_I116_XG_p1 I1_I700_G20_19 I1_I700_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I116_XG_MP0 (VDD I1_I700_P20_19 XI1_I700_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I116_XG_MP1 (XI1_I700_I116_XG_p1 I1_I700_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I118_XG_MP2 (XI1_I700_I118_XG_p1 I1_I700_G22_21 I1_I700_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I118_XG_MP0 (VDD I1_I700_P22_21 XI1_I700_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I118_XG_MP1 (XI1_I700_I118_XG_p1 I1_I700_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I120_XG_MP2 (XI1_I700_I120_XG_p1 I1_I700_G24_23 I1_I700_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I120_XG_MP0 (VDD I1_I700_P24_23 XI1_I700_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I120_XG_MP1 (XI1_I700_I120_XG_p1 I1_I700_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I122_XG_MP2 (XI1_I700_I122_XG_p1 I1_I700_G26_25 I1_I700_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I122_XG_MP0 (VDD I1_I700_P26_25 XI1_I700_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I122_XG_MP1 (XI1_I700_I122_XG_p1 I1_I700_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I124_XG_MP2 (XI1_I700_I124_XG_p1 I1_I700_G28_27 I1_I700_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I124_XG_MP0 (VDD I1_I700_P28_27 XI1_I700_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I124_XG_MP1 (XI1_I700_I124_XG_p1 I1_I700_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I181_XG_MP2 (XI1_I1390_I181_XG_p1 I1_I1390_G30_23 I1_I1390_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I181_XG_MP0 (VDD I1_I1390_P30_23 XI1_I1390_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I181_XG_MP1 (XI1_I1390_I181_XG_p1 I1_I1390_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I179_XG_MP2 (XI1_I1390_I179_XG_p1 I1_I1390_G28_21 I1_I1390_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I179_XG_MP0 (VDD I1_I1390_P28_21 XI1_I1390_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I179_XG_MP1 (XI1_I1390_I179_XG_p1 I1_I1390_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I173_XG_MP2 (XI1_I1390_I173_XG_p1 I1_I1390_G22_15 I1_I1390_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I173_XG_MP0 (VDD I1_I1390_P22_15 XI1_I1390_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I173_XG_MP1 (XI1_I1390_I173_XG_p1 I1_I1390_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I177_XG_MP2 (XI1_I1390_I177_XG_p1 I1_I1390_G26_19 I1_I1390_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I177_XG_MP0 (VDD I1_I1390_P26_19 XI1_I1390_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I177_XG_MP1 (XI1_I1390_I177_XG_p1 I1_I1390_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I114_XG_MP2 (XI1_I1390_I114_XG_p1 I1_I1390_G18_17 I1_I1390_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I114_XG_MP0 (VDD I1_I1390_P18_17 XI1_I1390_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I114_XG_MP1 (XI1_I1390_I114_XG_p1 I1_I1390_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I110_XG_MP2 (XI1_I1390_I110_XG_p1 I1_I1390_G14_13 I1_I1390_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I110_XG_MP0 (VDD I1_I1390_P14_13 XI1_I1390_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I110_XG_MP1 (XI1_I1390_I110_XG_p1 I1_I1390_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I108_XG_MP2 (XI1_I1390_I108_XG_p1 I1_I1390_G12_11 I1_I1390_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I108_XG_MP0 (VDD I1_I1390_P12_11 XI1_I1390_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I108_XG_MP1 (XI1_I1390_I108_XG_p1 I1_I1390_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I106_XG_MP2 (XI1_I1390_I106_XG_p1 I1_I1390_G10_9 I1_I1390_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I106_XG_MP0 (VDD I1_I1390_P10_9 XI1_I1390_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I106_XG_MP1 (XI1_I1390_I106_XG_p1 I1_I1390_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I104_XG_MP2 (XI1_I1390_I104_XG_p1 I1_I1390_G8_7 I1_I1390_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I104_XG_MP0 (VDD I1_I1390_P8_7 XI1_I1390_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I104_XG_MP1 (XI1_I1390_I104_XG_p1 I1_I1390_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I101_XG_MP2 (XI1_I1390_I101_XG_p1 I1_I1390_G5_4 I1_I1390_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I101_XG_MP0 (VDD I1_I1390_P5_4 XI1_I1390_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I101_XG_MP1 (XI1_I1390_I101_XG_p1 I1_I1390_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I124_XG_MP2 (XI1_I1160_I124_XG_p1 I1_I1160_G28_27 I1_I1160_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I124_XG_MP0 (VDD I1_I1160_P28_27 XI1_I1160_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I124_XG_MP1 (XI1_I1160_I124_XG_p1 I1_I1160_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I122_XG_MP2 (XI1_I1160_I122_XG_p1 I1_I1160_G26_25 I1_I1160_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I122_XG_MP0 (VDD I1_I1160_P26_25 XI1_I1160_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I122_XG_MP1 (XI1_I1160_I122_XG_p1 I1_I1160_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I173_XG_MP2 (XI1_I1160_I173_XG_p1 I1_I1160_G22_15 I1_I1160_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I173_XG_MP0 (VDD I1_I1160_P22_15 XI1_I1160_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I173_XG_MP1 (XI1_I1160_I173_XG_p1 I1_I1160_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I165_XG_MP2 (XI1_I1160_I165_XG_p1 I1_I1160_G14_7 I1_I1160_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I165_XG_MP0 (VDD I1_I1160_P14_7 XI1_I1160_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I165_XG_MP1 (XI1_I1160_I165_XG_p1 I1_I1160_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I179_XG_MP2 (XI1_I1160_I179_XG_p1 I1_I1160_G28_21 I1_I1160_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I179_XG_MP0 (VDD I1_I1160_P28_21 XI1_I1160_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I179_XG_MP1 (XI1_I1160_I179_XG_p1 I1_I1160_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I177_XG_MP2 (XI1_I1160_I177_XG_p1 I1_I1160_G26_19 I1_I1160_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I177_XG_MP0 (VDD I1_I1160_P26_19 XI1_I1160_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I177_XG_MP1 (XI1_I1160_I177_XG_p1 I1_I1160_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I171_XG_MP2 (XI1_I1160_I171_XG_p1 I1_I1160_G20_13 I1_I1160_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I171_XG_MP0 (VDD I1_I1160_P20_13 XI1_I1160_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I171_XG_MP1 (XI1_I1160_I171_XG_p1 I1_I1160_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I160_XG_MP2 (XI1_I1160_I160_XG_p1 I1_I1160_G10_3 I1_I1160_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I160_XG_MP0 (VDD I1_I1160_P10_3 XI1_I1160_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I160_XG_MP1 (XI1_I1160_I160_XG_p1 I1_I1160_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I175_XG_MP2 (XI1_I1160_I175_XG_p1 I1_I1160_G24_17 I1_I1160_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I175_XG_MP0 (VDD I1_I1160_P24_17 XI1_I1160_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I175_XG_MP1 (XI1_I1160_I175_XG_p1 I1_I1160_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I167_XG_MP2 (XI1_I1160_I167_XG_p1 I1_I1160_G16_9 I1_I1160_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I167_XG_MP0 (VDD I1_I1160_P16_9 XI1_I1160_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I167_XG_MP1 (XI1_I1160_I167_XG_p1 I1_I1160_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I100_XG_MP2 (XI1_I1160_I100_XG_p1 I1_I1160_G4_3 I1_I1160_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I100_XG_MP0 (VDD I1_I1160_P4_3 XI1_I1160_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I100_XG_MP1 (XI1_I1160_I100_XG_p1 I1_I1160_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I98_XG_MP2 (XI1_I1160_I98_XG_p1 I1_I1160_G2_1 I1_I1160_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I98_XG_MP0 (VDD I1_I1160_P2_1 XI1_I1160_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I98_XG_MP1 (XI1_I1160_I98_XG_p1 I1_I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I127_XG_MP2 (XI1_I930_I127_XG_p1 I1_I930_G31_30 I1_I930_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I127_XG_MP0 (VDD I1_I930_P31_30 XI1_I930_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I127_XG_MP1 (XI1_I930_I127_XG_p1 I1_I930_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I182_XG_MP2 (XI1_I930_I182_XG_p1 I1_I930_G31_24 I1_I930_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I182_XG_MP0 (VDD I1_I930_P31_24 XI1_I930_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I182_XG_MP1 (XI1_I930_I182_XG_p1 I1_I930_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I180_XG_MP2 (XI1_I930_I180_XG_p1 I1_I930_G29_22 I1_I930_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I180_XG_MP0 (VDD I1_I930_P29_22 XI1_I930_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I180_XG_MP1 (XI1_I930_I180_XG_p1 I1_I930_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I178_XG_MP2 (XI1_I930_I178_XG_p1 I1_I930_G27_20 I1_I930_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I178_XG_MP0 (VDD I1_I930_P27_20 XI1_I930_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I178_XG_MP1 (XI1_I930_I178_XG_p1 I1_I930_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I174_XG_MP2 (XI1_I930_I174_XG_p1 I1_I930_G23_16 I1_I930_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I174_XG_MP0 (VDD I1_I930_P23_16 XI1_I930_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I174_XG_MP1 (XI1_I930_I174_XG_p1 I1_I930_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I166_XG_MP2 (XI1_I930_I166_XG_p1 I1_I930_G15_8 I1_I930_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I166_XG_MP0 (VDD I1_I930_P15_8 XI1_I930_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I166_XG_MP1 (XI1_I930_I166_XG_p1 I1_I930_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I172_XG_MP2 (XI1_I930_I172_XG_p1 I1_I930_G21_14 I1_I930_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I172_XG_MP0 (VDD I1_I930_P21_14 XI1_I930_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I172_XG_MP1 (XI1_I930_I172_XG_p1 I1_I930_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I176_XG_MP2 (XI1_I930_I176_XG_p1 I1_I930_G25_18 I1_I930_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I176_XG_MP0 (VDD I1_I930_P25_18 XI1_I930_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I176_XG_MP1 (XI1_I930_I176_XG_p1 I1_I930_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I170_XG_MP2 (XI1_I930_I170_XG_p1 I1_I930_G19_12 I1_I930_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I170_XG_MP0 (VDD I1_I930_P19_12 XI1_I930_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I170_XG_MP1 (XI1_I930_I170_XG_p1 I1_I930_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I168_XG_MP2 (XI1_I930_I168_XG_p1 I1_I930_G17_10 I1_I930_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I168_XG_MP0 (VDD I1_I930_P17_10 XI1_I930_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I168_XG_MP1 (XI1_I930_I168_XG_p1 I1_I930_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I105_XG_MP2 (XI1_I930_I105_XG_p1 I1_I930_G9_8 I1_I930_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I105_XG_MP0 (VDD I1_I930_P9_8 XI1_I930_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I105_XG_MP1 (XI1_I930_I105_XG_p1 I1_I930_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I103_XG_MP2 (XI1_I930_I103_XG_p1 I1_I930_G7_6 I1_I930_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I103_XG_MP0 (VDD I1_I930_P7_6 XI1_I930_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I103_XG_MP1 (XI1_I930_I103_XG_p1 I1_I930_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I110_XG_MP2 (XI1_I700_I110_XG_p1 I1_I700_G14_13 I1_I700_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I110_XG_MP0 (VDD I1_I700_P14_13 XI1_I700_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I110_XG_MP1 (XI1_I700_I110_XG_p1 I1_I700_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I165_XG_MP2 (XI1_I1390_I165_XG_p1 I1_I1390_G14_7 I1_I1390_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I165_XG_MP0 (VDD I1_I1390_P14_7 XI1_I1390_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I165_XG_MP1 (XI1_I1390_I165_XG_p1 I1_I1390_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I175_XG_MP2 (XI1_I1390_I175_XG_p1 I1_I1390_G24_17 I1_I1390_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I175_XG_MP0 (VDD I1_I1390_P24_17 XI1_I1390_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I175_XG_MP1 (XI1_I1390_I175_XG_p1 I1_I1390_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I171_XG_MP2 (XI1_I1390_I171_XG_p1 I1_I1390_G20_13 I1_I1390_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I171_XG_MP0 (VDD I1_I1390_P20_13 XI1_I1390_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I171_XG_MP1 (XI1_I1390_I171_XG_p1 I1_I1390_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I163_XG_MP2 (XI1_I1390_I163_XG_p1 I1_I1390_G12_5 I1_I1390_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I163_XG_MP0 (VDD I1_I1390_P12_5 XI1_I1390_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I163_XG_MP1 (XI1_I1390_I163_XG_p1 I1_I1390_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I169_XG_MP2 (XI1_I1390_I169_XG_p1 I1_I1390_G18_11 I1_I1390_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I169_XG_MP0 (VDD I1_I1390_P18_11 XI1_I1390_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I169_XG_MP1 (XI1_I1390_I169_XG_p1 I1_I1390_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I160_XG_MP2 (XI1_I1390_I160_XG_p1 I1_I1390_G10_3 I1_I1390_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I160_XG_MP0 (VDD I1_I1390_P10_3 XI1_I1390_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I160_XG_MP1 (XI1_I1390_I160_XG_p1 I1_I1390_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I167_XG_MP2 (XI1_I1390_I167_XG_p1 I1_I1390_G16_9 I1_I1390_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I167_XG_MP0 (VDD I1_I1390_P16_9 XI1_I1390_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I167_XG_MP1 (XI1_I1390_I167_XG_p1 I1_I1390_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I102_XG_MP2 (XI1_I1390_I102_XG_p1 I1_I1390_G6_5 I1_I1390_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I102_XG_MP0 (VDD I1_I1390_P6_5 XI1_I1390_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I102_XG_MP1 (XI1_I1390_I102_XG_p1 I1_I1390_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I99_XG_MP2 (XI1_I1390_I99_XG_p1 I1_I1390_G3_2 I1_I1390_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I99_XG_MP0 (VDD I1_I1390_P3_2 XI1_I1390_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I99_XG_MP1 (XI1_I1390_I99_XG_p1 I1_I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I120_XG_MP2 (XI1_I1160_I120_XG_p1 I1_I1160_G24_23 I1_I1160_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I120_XG_MP0 (VDD I1_I1160_P24_23 XI1_I1160_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I120_XG_MP1 (XI1_I1160_I120_XG_p1 I1_I1160_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I118_XG_MP2 (XI1_I1160_I118_XG_p1 I1_I1160_G22_21 I1_I1160_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I118_XG_MP0 (VDD I1_I1160_P22_21 XI1_I1160_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I118_XG_MP1 (XI1_I1160_I118_XG_p1 I1_I1160_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I116_XG_MP2 (XI1_I1160_I116_XG_p1 I1_I1160_G20_19 I1_I1160_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I116_XG_MP0 (VDD I1_I1160_P20_19 XI1_I1160_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I116_XG_MP1 (XI1_I1160_I116_XG_p1 I1_I1160_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I169_XG_MP2 (XI1_I1160_I169_XG_p1 I1_I1160_G18_11 I1_I1160_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I169_XG_MP0 (VDD I1_I1160_P18_11 XI1_I1160_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I169_XG_MP1 (XI1_I1160_I169_XG_p1 I1_I1160_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I106_XG_MP2 (XI1_I1160_I106_XG_p1 I1_I1160_G10_9 I1_I1160_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I106_XG_MP0 (VDD I1_I1160_P10_9 XI1_I1160_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I106_XG_MP1 (XI1_I1160_I106_XG_p1 I1_I1160_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I104_XG_MP2 (XI1_I1160_I104_XG_p1 I1_I1160_G8_7 I1_I1160_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I104_XG_MP0 (VDD I1_I1160_P8_7 XI1_I1160_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I104_XG_MP1 (XI1_I1160_I104_XG_p1 I1_I1160_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I102_XG_MP2 (XI1_I1160_I102_XG_p1 I1_I1160_G6_5 I1_I1160_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I102_XG_MP0 (VDD I1_I1160_P6_5 XI1_I1160_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I102_XG_MP1 (XI1_I1160_I102_XG_p1 I1_I1160_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I126_XG_MP2 (XI1_I930_I126_XG_p1 I1_I930_G30_29 I1_I930_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I126_XG_MP0 (VDD I1_I930_P30_29 XI1_I930_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I126_XG_MP1 (XI1_I930_I126_XG_p1 I1_I930_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I124_XG_MP2 (XI1_I930_I124_XG_p1 I1_I930_G28_27 I1_I930_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I124_XG_MP0 (VDD I1_I930_P28_27 XI1_I930_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I124_XG_MP1 (XI1_I930_I124_XG_p1 I1_I930_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I122_XG_MP2 (XI1_I930_I122_XG_p1 I1_I930_G26_25 I1_I930_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I122_XG_MP0 (VDD I1_I930_P26_25 XI1_I930_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I122_XG_MP1 (XI1_I930_I122_XG_p1 I1_I930_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I120_XG_MP2 (XI1_I930_I120_XG_p1 I1_I930_G24_23 I1_I930_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I120_XG_MP0 (VDD I1_I930_P24_23 XI1_I930_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I120_XG_MP1 (XI1_I930_I120_XG_p1 I1_I930_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I118_XG_MP2 (XI1_I930_I118_XG_p1 I1_I930_G22_21 I1_I930_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I118_XG_MP0 (VDD I1_I930_P22_21 XI1_I930_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I118_XG_MP1 (XI1_I930_I118_XG_p1 I1_I930_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I114_XG_MP2 (XI1_I930_I114_XG_p1 I1_I930_G18_17 I1_I930_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I114_XG_MP0 (VDD I1_I930_P18_17 XI1_I930_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I114_XG_MP1 (XI1_I930_I114_XG_p1 I1_I930_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I112_XG_MP2 (XI1_I930_I112_XG_p1 I1_I930_G16_15 I1_I930_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I112_XG_MP0 (VDD I1_I930_P16_15 XI1_I930_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I112_XG_MP1 (XI1_I930_I112_XG_p1 I1_I930_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I164_XG_MP2 (XI1_I930_I164_XG_p1 I1_I930_G13_6 I1_I930_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I164_XG_MP0 (VDD I1_I930_P13_6 XI1_I930_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I164_XG_MP1 (XI1_I930_I164_XG_p1 I1_I930_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I110_XG_MP2 (XI1_I930_I110_XG_p1 I1_I930_G14_13 I1_I930_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I110_XG_MP0 (VDD I1_I930_P14_13 XI1_I930_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I110_XG_MP1 (XI1_I930_I110_XG_p1 I1_I930_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I162_XG_MP2 (XI1_I930_I162_XG_p1 I1_I930_G11_4 I1_I930_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I162_XG_MP0 (VDD I1_I930_P11_4 XI1_I930_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I162_XG_MP1 (XI1_I930_I162_XG_p1 I1_I930_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I158_XG_MP2 (XI1_I930_I158_XG_p1 I1_I930_G9_2 I1_I930_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I158_XG_MP0 (VDD I1_I930_P9_2 XI1_I930_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I158_XG_MP1 (XI1_I930_I158_XG_p1 I1_I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I101_XG_MP2 (XI1_I930_I101_XG_p1 I1_I930_G5_4 I1_I930_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I101_XG_MP0 (VDD I1_I930_P5_4 XI1_I930_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I101_XG_MP1 (XI1_I930_I101_XG_p1 I1_I930_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I157_XG_MP2 (XI1_I1390_I157_XG_p1 I1_I1390_G8_1 I1_I1390_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I157_XG_MP0 (VDD I1_I1390_P8_1 XI1_I1390_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I157_XG_MP1 (XI1_I1390_I157_XG_p1 I1_I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I100_XG_MP2 (XI1_I1390_I100_XG_p1 I1_I1390_G4_3 I1_I1390_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I100_XG_MP0 (VDD I1_I1390_P4_3 XI1_I1390_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I100_XG_MP1 (XI1_I1390_I100_XG_p1 I1_I1390_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I98_XG_MP2 (XI1_I1390_I98_XG_p1 I1_I1390_G2_1 I1_I1390_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I98_XG_MP0 (VDD I1_I1390_P2_1 XI1_I1390_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I98_XG_MP1 (XI1_I1390_I98_XG_p1 I1_I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I114_XG_MP2 (XI1_I1160_I114_XG_p1 I1_I1160_G18_17 I1_I1160_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I114_XG_MP0 (VDD I1_I1160_P18_17 XI1_I1160_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I114_XG_MP1 (XI1_I1160_I114_XG_p1 I1_I1160_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I112_XG_MP2 (XI1_I1160_I112_XG_p1 I1_I1160_G16_15 I1_I1160_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I112_XG_MP0 (VDD I1_I1160_P16_15 XI1_I1160_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I112_XG_MP1 (XI1_I1160_I112_XG_p1 I1_I1160_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I110_XG_MP2 (XI1_I1160_I110_XG_p1 I1_I1160_G14_13 I1_I1160_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I110_XG_MP0 (VDD I1_I1160_P14_13 XI1_I1160_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I110_XG_MP1 (XI1_I1160_I110_XG_p1 I1_I1160_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I108_XG_MP2 (XI1_I1160_I108_XG_p1 I1_I1160_G12_11 I1_I1160_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I108_XG_MP0 (VDD I1_I1160_P12_11 XI1_I1160_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I108_XG_MP1 (XI1_I1160_I108_XG_p1 I1_I1160_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I181_XG_MP2 (XI1_I930_I181_XG_p1 I1_I930_G30_23 I1_I930_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I181_XG_MP0 (VDD I1_I930_P30_23 XI1_I930_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I181_XG_MP1 (XI1_I930_I181_XG_p1 I1_I930_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I179_XG_MP2 (XI1_I930_I179_XG_p1 I1_I930_G28_21 I1_I930_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I179_XG_MP0 (VDD I1_I930_P28_21 XI1_I930_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I179_XG_MP1 (XI1_I930_I179_XG_p1 I1_I930_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I177_XG_MP2 (XI1_I930_I177_XG_p1 I1_I930_G26_19 I1_I930_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I177_XG_MP0 (VDD I1_I930_P26_19 XI1_I930_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I177_XG_MP1 (XI1_I930_I177_XG_p1 I1_I930_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I116_XG_MP2 (XI1_I930_I116_XG_p1 I1_I930_G20_19 I1_I930_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I116_XG_MP0 (VDD I1_I930_P20_19 XI1_I930_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I116_XG_MP1 (XI1_I930_I116_XG_p1 I1_I930_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I175_XG_MP2 (XI1_I930_I175_XG_p1 I1_I930_G24_17 I1_I930_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I175_XG_MP0 (VDD I1_I930_P24_17 XI1_I930_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I175_XG_MP1 (XI1_I930_I175_XG_p1 I1_I930_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I108_XG_MP2 (XI1_I930_I108_XG_p1 I1_I930_G12_11 I1_I930_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I108_XG_MP0 (VDD I1_I930_P12_11 XI1_I930_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I108_XG_MP1 (XI1_I930_I108_XG_p1 I1_I930_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I169_XG_MP2 (XI1_I930_I169_XG_p1 I1_I930_G18_11 I1_I930_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I169_XG_MP0 (VDD I1_I930_P18_11 XI1_I930_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I169_XG_MP1 (XI1_I930_I169_XG_p1 I1_I930_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I106_XG_MP2 (XI1_I930_I106_XG_p1 I1_I930_G10_9 I1_I930_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I106_XG_MP0 (VDD I1_I930_P10_9 XI1_I930_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I106_XG_MP1 (XI1_I930_I106_XG_p1 I1_I930_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I104_XG_MP2 (XI1_I930_I104_XG_p1 I1_I930_G8_7 I1_I930_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I104_XG_MP0 (VDD I1_I930_P8_7 XI1_I930_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I104_XG_MP1 (XI1_I930_I104_XG_p1 I1_I930_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I102_XG_MP2 (XI1_I930_I102_XG_p1 I1_I930_G6_5 I1_I930_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I102_XG_MP0 (VDD I1_I930_P6_5 XI1_I930_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I102_XG_MP1 (XI1_I930_I102_XG_p1 I1_I930_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I99_XG_MP2 (XI1_I930_I99_XG_p1 I1_I930_G3_2 I1_I930_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I99_XG_MP0 (VDD I1_I930_P3_2 XI1_I930_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I99_XG_MP1 (XI1_I930_I99_XG_p1 I1_I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I162_XG_MP2 (XI1_I654_I162_XG_p1 I1_I654_G11_4 I1_I654_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I162_XG_MP0 (VDD I1_I654_P11_4 XI1_I654_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I162_XG_MP1 (XI1_I654_I162_XG_p1 I1_I654_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I170_XG_MP2 (XI1_I654_I170_XG_p1 I1_I654_G19_12 I1_I654_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I170_XG_MP0 (VDD I1_I654_P19_12 XI1_I654_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I170_XG_MP1 (XI1_I654_I170_XG_p1 I1_I654_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I164_XG_MP2 (XI1_I654_I164_XG_p1 I1_I654_G13_6 I1_I654_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I164_XG_MP0 (VDD I1_I654_P13_6 XI1_I654_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I164_XG_MP1 (XI1_I654_I164_XG_p1 I1_I654_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I166_XG_MP2 (XI1_I654_I166_XG_p1 I1_I654_G15_8 I1_I654_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I166_XG_MP0 (VDD I1_I654_P15_8 XI1_I654_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I166_XG_MP1 (XI1_I654_I166_XG_p1 I1_I654_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I173_XG_MP2 (XI1_I930_I173_XG_p1 I1_I930_G22_15 I1_I930_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I173_XG_MP0 (VDD I1_I930_P22_15 XI1_I930_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I173_XG_MP1 (XI1_I930_I173_XG_p1 I1_I930_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I165_XG_MP2 (XI1_I930_I165_XG_p1 I1_I930_G14_7 I1_I930_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I165_XG_MP0 (VDD I1_I930_P14_7 XI1_I930_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I165_XG_MP1 (XI1_I930_I165_XG_p1 I1_I930_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I171_XG_MP2 (XI1_I930_I171_XG_p1 I1_I930_G20_13 I1_I930_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I171_XG_MP0 (VDD I1_I930_P20_13 XI1_I930_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I171_XG_MP1 (XI1_I930_I171_XG_p1 I1_I930_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I163_XG_MP2 (XI1_I930_I163_XG_p1 I1_I930_G12_5 I1_I930_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I163_XG_MP0 (VDD I1_I930_P12_5 XI1_I930_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I163_XG_MP1 (XI1_I930_I163_XG_p1 I1_I930_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I167_XG_MP2 (XI1_I930_I167_XG_p1 I1_I930_G16_9 I1_I930_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I167_XG_MP0 (VDD I1_I930_P16_9 XI1_I930_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I167_XG_MP1 (XI1_I930_I167_XG_p1 I1_I930_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I160_XG_MP2 (XI1_I930_I160_XG_p1 I1_I930_G10_3 I1_I930_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I160_XG_MP0 (VDD I1_I930_P10_3 XI1_I930_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I160_XG_MP1 (XI1_I930_I160_XG_p1 I1_I930_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I100_XG_MP2 (XI1_I930_I100_XG_p1 I1_I930_G4_3 I1_I930_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I100_XG_MP0 (VDD I1_I930_P4_3 XI1_I930_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I100_XG_MP1 (XI1_I930_I100_XG_p1 I1_I930_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I99_XG_MP2 (XI1_I654_I99_XG_p1 I1_I654_G3_2 I1_I654_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I99_XG_MP0 (VDD I1_I654_P3_2 XI1_I654_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I99_XG_MP1 (XI1_I654_I99_XG_p1 I1_I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I101_XG_MP2 (XI1_I654_I101_XG_p1 I1_I654_G5_4 I1_I654_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I101_XG_MP0 (VDD I1_I654_P5_4 XI1_I654_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I101_XG_MP1 (XI1_I654_I101_XG_p1 I1_I654_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I158_XG_MP2 (XI1_I654_I158_XG_p1 I1_I654_G9_2 I1_I654_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I158_XG_MP0 (VDD I1_I654_P9_2 XI1_I654_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I158_XG_MP1 (XI1_I654_I158_XG_p1 I1_I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I168_XG_MP2 (XI1_I654_I168_XG_p1 I1_I654_G17_10 I1_I654_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I168_XG_MP0 (VDD I1_I654_P17_10 XI1_I654_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I168_XG_MP1 (XI1_I654_I168_XG_p1 I1_I654_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I176_XG_MP2 (XI1_I654_I176_XG_p1 I1_I654_G25_18 I1_I654_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I176_XG_MP0 (VDD I1_I654_P25_18 XI1_I654_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I176_XG_MP1 (XI1_I654_I176_XG_p1 I1_I654_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I172_XG_MP2 (XI1_I654_I172_XG_p1 I1_I654_G21_14 I1_I654_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I172_XG_MP0 (VDD I1_I654_P21_14 XI1_I654_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I172_XG_MP1 (XI1_I654_I172_XG_p1 I1_I654_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I178_XG_MP2 (XI1_I654_I178_XG_p1 I1_I654_G27_20 I1_I654_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I178_XG_MP0 (VDD I1_I654_P27_20 XI1_I654_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I178_XG_MP1 (XI1_I654_I178_XG_p1 I1_I654_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I174_XG_MP2 (XI1_I654_I174_XG_p1 I1_I654_G23_16 I1_I654_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I174_XG_MP0 (VDD I1_I654_P23_16 XI1_I654_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I174_XG_MP1 (XI1_I654_I174_XG_p1 I1_I654_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I180_XG_MP2 (XI1_I654_I180_XG_p1 I1_I654_G29_22 I1_I654_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I180_XG_MP0 (VDD I1_I654_P29_22 XI1_I654_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I180_XG_MP1 (XI1_I654_I180_XG_p1 I1_I654_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I182_XG_MP2 (XI1_I654_I182_XG_p1 I1_I654_G31_24 I1_I654_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I182_XG_MP0 (VDD I1_I654_P31_24 XI1_I654_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I182_XG_MP1 (XI1_I654_I182_XG_p1 I1_I654_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I114_XG_MP2 (XI1_I1436_I114_XG_p1 I1_I1436_G18_17 I1_I1436_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I114_XG_MP0 (VDD I1_I1436_P18_17 XI1_I1436_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I114_XG_MP1 (XI1_I1436_I114_XG_p1 I1_I1436_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I110_XG_MP2 (XI1_I1436_I110_XG_p1 I1_I1436_G14_13 I1_I1436_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I110_XG_MP0 (VDD I1_I1436_P14_13 XI1_I1436_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I110_XG_MP1 (XI1_I1436_I110_XG_p1 I1_I1436_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I127_XG_MP2 (XI1_I1114_I127_XG_p1 I1_I1114_G31_30 I1_I1114_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I127_XG_MP0 (VDD I1_I1114_P31_30 XI1_I1114_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I127_XG_MP1 (XI1_I1114_I127_XG_p1 I1_I1114_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I125_XG_MP2 (XI1_I1114_I125_XG_p1 I1_I1114_G29_28 I1_I1114_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I125_XG_MP0 (VDD I1_I1114_P29_28 XI1_I1114_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I125_XG_MP1 (XI1_I1114_I125_XG_p1 I1_I1114_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I126_XG_MP2 (XI1_I1114_I126_XG_p1 I1_I1114_G30_29 I1_I1114_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I126_XG_MP0 (VDD I1_I1114_P30_29 XI1_I1114_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I126_XG_MP1 (XI1_I1114_I126_XG_p1 I1_I1114_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I181_XG_MP2 (XI1_I1114_I181_XG_p1 I1_I1114_G30_23 I1_I1114_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I181_XG_MP0 (VDD I1_I1114_P30_23 XI1_I1114_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I181_XG_MP1 (XI1_I1114_I181_XG_p1 I1_I1114_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I157_XG_MP2 (XI1_I930_I157_XG_p1 I1_I930_G8_1 I1_I930_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I157_XG_MP0 (VDD I1_I930_P8_1 XI1_I930_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I157_XG_MP1 (XI1_I930_I157_XG_p1 I1_I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I98_XG_MP2 (XI1_I930_I98_XG_p1 I1_I930_G2_1 I1_I930_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I930_I98_XG_MP0 (VDD I1_I930_P2_1 XI1_I930_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I930_I98_XG_MP1 (XI1_I930_I98_XG_p1 I1_I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I98_XG_MP2 (XI1_I654_I98_XG_p1 I1_I654_G2_1 I1_I654_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I98_XG_MP0 (VDD I1_I654_P2_1 XI1_I654_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I98_XG_MP1 (XI1_I654_I98_XG_p1 I1_I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I103_XG_MP2 (XI1_I654_I103_XG_p1 I1_I654_G7_6 I1_I654_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I103_XG_MP0 (VDD I1_I654_P7_6 XI1_I654_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I103_XG_MP1 (XI1_I654_I103_XG_p1 I1_I654_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I105_XG_MP2 (XI1_I654_I105_XG_p1 I1_I654_G9_8 I1_I654_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I105_XG_MP0 (VDD I1_I654_P9_8 XI1_I654_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I105_XG_MP1 (XI1_I654_I105_XG_p1 I1_I654_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I107_XG_MP2 (XI1_I654_I107_XG_p1 I1_I654_G11_10 I1_I654_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I107_XG_MP0 (VDD I1_I654_P11_10 XI1_I654_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I107_XG_MP1 (XI1_I654_I107_XG_p1 I1_I654_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I109_XG_MP2 (XI1_I654_I109_XG_p1 I1_I654_G13_12 I1_I654_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I109_XG_MP0 (VDD I1_I654_P13_12 XI1_I654_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I109_XG_MP1 (XI1_I654_I109_XG_p1 I1_I654_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I111_XG_MP2 (XI1_I654_I111_XG_p1 I1_I654_G15_14 I1_I654_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I111_XG_MP0 (VDD I1_I654_P15_14 XI1_I654_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I111_XG_MP1 (XI1_I654_I111_XG_p1 I1_I654_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I113_XG_MP2 (XI1_I654_I113_XG_p1 I1_I654_G17_16 I1_I654_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I113_XG_MP0 (VDD I1_I654_P17_16 XI1_I654_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I113_XG_MP1 (XI1_I654_I113_XG_p1 I1_I654_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I115_XG_MP2 (XI1_I654_I115_XG_p1 I1_I654_G19_18 I1_I654_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I115_XG_MP0 (VDD I1_I654_P19_18 XI1_I654_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I115_XG_MP1 (XI1_I654_I115_XG_p1 I1_I654_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I117_XG_MP2 (XI1_I654_I117_XG_p1 I1_I654_G21_20 I1_I654_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I117_XG_MP0 (VDD I1_I654_P21_20 XI1_I654_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I117_XG_MP1 (XI1_I654_I117_XG_p1 I1_I654_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I119_XG_MP2 (XI1_I654_I119_XG_p1 I1_I654_G23_22 I1_I654_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I119_XG_MP0 (VDD I1_I654_P23_22 XI1_I654_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I119_XG_MP1 (XI1_I654_I119_XG_p1 I1_I654_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I121_XG_MP2 (XI1_I654_I121_XG_p1 I1_I654_G25_24 I1_I654_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I121_XG_MP0 (VDD I1_I654_P25_24 XI1_I654_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I121_XG_MP1 (XI1_I654_I121_XG_p1 I1_I654_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I123_XG_MP2 (XI1_I654_I123_XG_p1 I1_I654_G27_26 I1_I654_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I123_XG_MP0 (VDD I1_I654_P27_26 XI1_I654_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I123_XG_MP1 (XI1_I654_I123_XG_p1 I1_I654_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I125_XG_MP2 (XI1_I654_I125_XG_p1 I1_I654_G29_28 I1_I654_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I125_XG_MP0 (VDD I1_I654_P29_28 XI1_I654_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I125_XG_MP1 (XI1_I654_I125_XG_p1 I1_I654_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I124_XG_MP2 (XI1_I1436_I124_XG_p1 I1_I1436_G28_27 I1_I1436_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I124_XG_MP0 (VDD I1_I1436_P28_27 XI1_I1436_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I124_XG_MP1 (XI1_I1436_I124_XG_p1 I1_I1436_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I122_XG_MP2 (XI1_I1436_I122_XG_p1 I1_I1436_G26_25 I1_I1436_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I122_XG_MP0 (VDD I1_I1436_P26_25 XI1_I1436_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I122_XG_MP1 (XI1_I1436_I122_XG_p1 I1_I1436_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I120_XG_MP2 (XI1_I1436_I120_XG_p1 I1_I1436_G24_23 I1_I1436_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I120_XG_MP0 (VDD I1_I1436_P24_23 XI1_I1436_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I120_XG_MP1 (XI1_I1436_I120_XG_p1 I1_I1436_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I118_XG_MP2 (XI1_I1436_I118_XG_p1 I1_I1436_G22_21 I1_I1436_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I118_XG_MP0 (VDD I1_I1436_P22_21 XI1_I1436_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I118_XG_MP1 (XI1_I1436_I118_XG_p1 I1_I1436_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I116_XG_MP2 (XI1_I1436_I116_XG_p1 I1_I1436_G20_19 I1_I1436_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I116_XG_MP0 (VDD I1_I1436_P20_19 XI1_I1436_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I116_XG_MP1 (XI1_I1436_I116_XG_p1 I1_I1436_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I112_XG_MP2 (XI1_I1436_I112_XG_p1 I1_I1436_G16_15 I1_I1436_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I112_XG_MP0 (VDD I1_I1436_P16_15 XI1_I1436_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I112_XG_MP1 (XI1_I1436_I112_XG_p1 I1_I1436_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I108_XG_MP2 (XI1_I1436_I108_XG_p1 I1_I1436_G12_11 I1_I1436_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I108_XG_MP0 (VDD I1_I1436_P12_11 XI1_I1436_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I108_XG_MP1 (XI1_I1436_I108_XG_p1 I1_I1436_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I106_XG_MP2 (XI1_I1436_I106_XG_p1 I1_I1436_G10_9 I1_I1436_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I106_XG_MP0 (VDD I1_I1436_P10_9 XI1_I1436_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I106_XG_MP1 (XI1_I1436_I106_XG_p1 I1_I1436_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I104_XG_MP2 (XI1_I1436_I104_XG_p1 I1_I1436_G8_7 I1_I1436_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I104_XG_MP0 (VDD I1_I1436_P8_7 XI1_I1436_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I104_XG_MP1 (XI1_I1436_I104_XG_p1 I1_I1436_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I102_XG_MP2 (XI1_I1436_I102_XG_p1 I1_I1436_G6_5 I1_I1436_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I102_XG_MP0 (VDD I1_I1436_P6_5 XI1_I1436_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I102_XG_MP1 (XI1_I1436_I102_XG_p1 I1_I1436_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I123_XG_MP2 (XI1_I1114_I123_XG_p1 I1_I1114_G27_26 I1_I1114_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I123_XG_MP0 (VDD I1_I1114_P27_26 XI1_I1114_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I123_XG_MP1 (XI1_I1114_I123_XG_p1 I1_I1114_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I124_XG_MP2 (XI1_I1114_I124_XG_p1 I1_I1114_G28_27 I1_I1114_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I124_XG_MP0 (VDD I1_I1114_P28_27 XI1_I1114_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I124_XG_MP1 (XI1_I1114_I124_XG_p1 I1_I1114_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I122_XG_MP2 (XI1_I1114_I122_XG_p1 I1_I1114_G26_25 I1_I1114_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I122_XG_MP0 (VDD I1_I1114_P26_25 XI1_I1114_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I122_XG_MP1 (XI1_I1114_I122_XG_p1 I1_I1114_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I173_XG_MP2 (XI1_I1114_I173_XG_p1 I1_I1114_G22_15 I1_I1114_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I173_XG_MP0 (VDD I1_I1114_P22_15 XI1_I1114_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I173_XG_MP1 (XI1_I1114_I173_XG_p1 I1_I1114_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I126_XG_MP2 (XI1_I1068_I126_XG_p1 I1_I1068_G30_29 I1_I1068_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I126_XG_MP0 (VDD I1_I1068_P30_29 XI1_I1068_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I126_XG_MP1 (XI1_I1068_I126_XG_p1 I1_I1068_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I127_XG_MP2 (XI1_I1068_I127_XG_p1 I1_I1068_G31_30 I1_I1068_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I127_XG_MP0 (VDD I1_I1068_P31_30 XI1_I1068_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I127_XG_MP1 (XI1_I1068_I127_XG_p1 I1_I1068_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I100_XG_MP2 (XI1_I654_I100_XG_p1 I1_I654_G4_3 I1_I654_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I100_XG_MP0 (VDD I1_I654_P4_3 XI1_I654_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I100_XG_MP1 (XI1_I654_I100_XG_p1 I1_I654_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I157_XG_MP2 (XI1_I654_I157_XG_p1 I1_I654_G8_1 I1_I654_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I157_XG_MP0 (VDD I1_I654_P8_1 XI1_I654_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I157_XG_MP1 (XI1_I654_I157_XG_p1 I1_I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I167_XG_MP2 (XI1_I654_I167_XG_p1 I1_I654_G16_9 I1_I654_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I167_XG_MP0 (VDD I1_I654_P16_9 XI1_I654_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I167_XG_MP1 (XI1_I654_I167_XG_p1 I1_I654_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I160_XG_MP2 (XI1_I654_I160_XG_p1 I1_I654_G10_3 I1_I654_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I160_XG_MP0 (VDD I1_I654_P10_3 XI1_I654_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I160_XG_MP1 (XI1_I654_I160_XG_p1 I1_I654_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I169_XG_MP2 (XI1_I654_I169_XG_p1 I1_I654_G18_11 I1_I654_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I169_XG_MP0 (VDD I1_I654_P18_11 XI1_I654_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I169_XG_MP1 (XI1_I654_I169_XG_p1 I1_I654_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I163_XG_MP2 (XI1_I654_I163_XG_p1 I1_I654_G12_5 I1_I654_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I163_XG_MP0 (VDD I1_I654_P12_5 XI1_I654_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I163_XG_MP1 (XI1_I654_I163_XG_p1 I1_I654_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I171_XG_MP2 (XI1_I654_I171_XG_p1 I1_I654_G20_13 I1_I654_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I171_XG_MP0 (VDD I1_I654_P20_13 XI1_I654_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I171_XG_MP1 (XI1_I654_I171_XG_p1 I1_I654_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I165_XG_MP2 (XI1_I654_I165_XG_p1 I1_I654_G14_7 I1_I654_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I165_XG_MP0 (VDD I1_I654_P14_7 XI1_I654_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I165_XG_MP1 (XI1_I654_I165_XG_p1 I1_I654_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I173_XG_MP2 (XI1_I654_I173_XG_p1 I1_I654_G22_15 I1_I654_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I173_XG_MP0 (VDD I1_I654_P22_15 XI1_I654_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I173_XG_MP1 (XI1_I654_I173_XG_p1 I1_I654_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I181_XG_MP2 (XI1_I654_I181_XG_p1 I1_I654_G30_23 I1_I654_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I181_XG_MP0 (VDD I1_I654_P30_23 XI1_I654_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I181_XG_MP1 (XI1_I654_I181_XG_p1 I1_I654_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I126_XG_MP2 (XI1_I654_I126_XG_p1 I1_I654_G30_29 I1_I654_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I126_XG_MP0 (VDD I1_I654_P30_29 XI1_I654_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I126_XG_MP1 (XI1_I654_I126_XG_p1 I1_I654_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I127_XG_MP2 (XI1_I654_I127_XG_p1 I1_I654_G31_30 I1_I654_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I127_XG_MP0 (VDD I1_I654_P31_30 XI1_I654_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I127_XG_MP1 (XI1_I654_I127_XG_p1 I1_I654_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I126_XG_MP2 (XI1_I1436_I126_XG_p1 I1_I1436_G30_29 I1_I1436_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I126_XG_MP0 (VDD I1_I1436_P30_29 XI1_I1436_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I126_XG_MP1 (XI1_I1436_I126_XG_p1 I1_I1436_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I181_XG_MP2 (XI1_I1436_I181_XG_p1 I1_I1436_G30_23 I1_I1436_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I181_XG_MP0 (VDD I1_I1436_P30_23 XI1_I1436_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I181_XG_MP1 (XI1_I1436_I181_XG_p1 I1_I1436_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I179_XG_MP2 (XI1_I1436_I179_XG_p1 I1_I1436_G28_21 I1_I1436_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I179_XG_MP0 (VDD I1_I1436_P28_21 XI1_I1436_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I179_XG_MP1 (XI1_I1436_I179_XG_p1 I1_I1436_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I173_XG_MP2 (XI1_I1436_I173_XG_p1 I1_I1436_G22_15 I1_I1436_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I173_XG_MP0 (VDD I1_I1436_P22_15 XI1_I1436_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I173_XG_MP1 (XI1_I1436_I173_XG_p1 I1_I1436_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I177_XG_MP2 (XI1_I1436_I177_XG_p1 I1_I1436_G26_19 I1_I1436_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I177_XG_MP0 (VDD I1_I1436_P26_19 XI1_I1436_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I177_XG_MP1 (XI1_I1436_I177_XG_p1 I1_I1436_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I165_XG_MP2 (XI1_I1436_I165_XG_p1 I1_I1436_G14_7 I1_I1436_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I165_XG_MP0 (VDD I1_I1436_P14_7 XI1_I1436_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I165_XG_MP1 (XI1_I1436_I165_XG_p1 I1_I1436_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I171_XG_MP2 (XI1_I1436_I171_XG_p1 I1_I1436_G20_13 I1_I1436_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I171_XG_MP0 (VDD I1_I1436_P20_13 XI1_I1436_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I171_XG_MP1 (XI1_I1436_I171_XG_p1 I1_I1436_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I163_XG_MP2 (XI1_I1436_I163_XG_p1 I1_I1436_G12_5 I1_I1436_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I163_XG_MP0 (VDD I1_I1436_P12_5 XI1_I1436_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I163_XG_MP1 (XI1_I1436_I163_XG_p1 I1_I1436_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I175_XG_MP2 (XI1_I1436_I175_XG_p1 I1_I1436_G24_17 I1_I1436_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I175_XG_MP0 (VDD I1_I1436_P24_17 XI1_I1436_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I175_XG_MP1 (XI1_I1436_I175_XG_p1 I1_I1436_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I169_XG_MP2 (XI1_I1436_I169_XG_p1 I1_I1436_G18_11 I1_I1436_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I169_XG_MP0 (VDD I1_I1436_P18_11 XI1_I1436_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I169_XG_MP1 (XI1_I1436_I169_XG_p1 I1_I1436_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I160_XG_MP2 (XI1_I1436_I160_XG_p1 I1_I1436_G10_3 I1_I1436_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I160_XG_MP0 (VDD I1_I1436_P10_3 XI1_I1436_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I160_XG_MP1 (XI1_I1436_I160_XG_p1 I1_I1436_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I167_XG_MP2 (XI1_I1436_I167_XG_p1 I1_I1436_G16_9 I1_I1436_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I167_XG_MP0 (VDD I1_I1436_P16_9 XI1_I1436_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I167_XG_MP1 (XI1_I1436_I167_XG_p1 I1_I1436_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I100_XG_MP2 (XI1_I1436_I100_XG_p1 I1_I1436_G4_3 I1_I1436_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I100_XG_MP0 (VDD I1_I1436_P4_3 XI1_I1436_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I100_XG_MP1 (XI1_I1436_I100_XG_p1 I1_I1436_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I182_XG_MP2 (XI1_I1114_I182_XG_p1 I1_I1114_G31_24 I1_I1114_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I182_XG_MP0 (VDD I1_I1114_P31_24 XI1_I1114_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I182_XG_MP1 (XI1_I1114_I182_XG_p1 I1_I1114_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I121_XG_MP2 (XI1_I1114_I121_XG_p1 I1_I1114_G25_24 I1_I1114_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I121_XG_MP0 (VDD I1_I1114_P25_24 XI1_I1114_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I121_XG_MP1 (XI1_I1114_I121_XG_p1 I1_I1114_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I119_XG_MP2 (XI1_I1114_I119_XG_p1 I1_I1114_G23_22 I1_I1114_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I119_XG_MP0 (VDD I1_I1114_P23_22 XI1_I1114_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I119_XG_MP1 (XI1_I1114_I119_XG_p1 I1_I1114_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I120_XG_MP2 (XI1_I1114_I120_XG_p1 I1_I1114_G24_23 I1_I1114_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I120_XG_MP0 (VDD I1_I1114_P24_23 XI1_I1114_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I120_XG_MP1 (XI1_I1114_I120_XG_p1 I1_I1114_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I165_XG_MP2 (XI1_I1114_I165_XG_p1 I1_I1114_G14_7 I1_I1114_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I165_XG_MP0 (VDD I1_I1114_P14_7 XI1_I1114_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I165_XG_MP1 (XI1_I1114_I165_XG_p1 I1_I1114_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I181_XG_MP2 (XI1_I1068_I181_XG_p1 I1_I1068_G30_23 I1_I1068_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I181_XG_MP0 (VDD I1_I1068_P30_23 XI1_I1068_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I181_XG_MP1 (XI1_I1068_I181_XG_p1 I1_I1068_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I122_XG_MP2 (XI1_I1068_I122_XG_p1 I1_I1068_G26_25 I1_I1068_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I122_XG_MP0 (VDD I1_I1068_P26_25 XI1_I1068_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I122_XG_MP1 (XI1_I1068_I122_XG_p1 I1_I1068_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I124_XG_MP2 (XI1_I1068_I124_XG_p1 I1_I1068_G28_27 I1_I1068_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I124_XG_MP0 (VDD I1_I1068_P28_27 XI1_I1068_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I124_XG_MP1 (XI1_I1068_I124_XG_p1 I1_I1068_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I182_XG_MP2 (XI1_I1068_I182_XG_p1 I1_I1068_G31_24 I1_I1068_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I182_XG_MP0 (VDD I1_I1068_P31_24 XI1_I1068_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I182_XG_MP1 (XI1_I1068_I182_XG_p1 I1_I1068_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I125_XG_MP2 (XI1_I1068_I125_XG_p1 I1_I1068_G29_28 I1_I1068_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I125_XG_MP0 (VDD I1_I1068_P29_28 XI1_I1068_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I125_XG_MP1 (XI1_I1068_I125_XG_p1 I1_I1068_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I123_XG_MP2 (XI1_I1068_I123_XG_p1 I1_I1068_G27_26 I1_I1068_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I123_XG_MP0 (VDD I1_I1068_P27_26 XI1_I1068_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I123_XG_MP1 (XI1_I1068_I123_XG_p1 I1_I1068_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I127_XG_MP2 (XI1_I976_I127_XG_p1 I1_I976_G31_30 I1_I976_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I127_XG_MP0 (VDD I1_I976_P31_30 XI1_I976_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I127_XG_MP1 (XI1_I976_I127_XG_p1 I1_I976_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I125_XG_MP2 (XI1_I976_I125_XG_p1 I1_I976_G29_28 I1_I976_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I125_XG_MP0 (VDD I1_I976_P29_28 XI1_I976_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I125_XG_MP1 (XI1_I976_I125_XG_p1 I1_I976_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I123_XG_MP2 (XI1_I976_I123_XG_p1 I1_I976_G27_26 I1_I976_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I123_XG_MP0 (VDD I1_I976_P27_26 XI1_I976_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I123_XG_MP1 (XI1_I976_I123_XG_p1 I1_I976_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I121_XG_MP2 (XI1_I976_I121_XG_p1 I1_I976_G25_24 I1_I976_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I121_XG_MP0 (VDD I1_I976_P25_24 XI1_I976_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I121_XG_MP1 (XI1_I976_I121_XG_p1 I1_I976_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I119_XG_MP2 (XI1_I976_I119_XG_p1 I1_I976_G23_22 I1_I976_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I119_XG_MP0 (VDD I1_I976_P23_22 XI1_I976_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I119_XG_MP1 (XI1_I976_I119_XG_p1 I1_I976_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I180_XG_MP2 (XI1_I976_I180_XG_p1 I1_I976_G29_22 I1_I976_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I180_XG_MP0 (VDD I1_I976_P29_22 XI1_I976_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I180_XG_MP1 (XI1_I976_I180_XG_p1 I1_I976_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I117_XG_MP2 (XI1_I976_I117_XG_p1 I1_I976_G21_20 I1_I976_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I117_XG_MP0 (VDD I1_I976_P21_20 XI1_I976_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I117_XG_MP1 (XI1_I976_I117_XG_p1 I1_I976_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I115_XG_MP2 (XI1_I976_I115_XG_p1 I1_I976_G19_18 I1_I976_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I115_XG_MP0 (VDD I1_I976_P19_18 XI1_I976_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I115_XG_MP1 (XI1_I976_I115_XG_p1 I1_I976_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I113_XG_MP2 (XI1_I976_I113_XG_p1 I1_I976_G17_16 I1_I976_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I113_XG_MP0 (VDD I1_I976_P17_16 XI1_I976_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I113_XG_MP1 (XI1_I976_I113_XG_p1 I1_I976_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I176_XG_MP2 (XI1_I976_I176_XG_p1 I1_I976_G25_18 I1_I976_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I176_XG_MP0 (VDD I1_I976_P25_18 XI1_I976_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I176_XG_MP1 (XI1_I976_I176_XG_p1 I1_I976_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I109_XG_MP2 (XI1_I976_I109_XG_p1 I1_I976_G13_12 I1_I976_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I109_XG_MP0 (VDD I1_I976_P13_12 XI1_I976_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I109_XG_MP1 (XI1_I976_I109_XG_p1 I1_I976_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I102_XG_MP2 (XI1_I654_I102_XG_p1 I1_I654_G6_5 I1_I654_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I102_XG_MP0 (VDD I1_I654_P6_5 XI1_I654_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I102_XG_MP1 (XI1_I654_I102_XG_p1 I1_I654_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I104_XG_MP2 (XI1_I654_I104_XG_p1 I1_I654_G8_7 I1_I654_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I104_XG_MP0 (VDD I1_I654_P8_7 XI1_I654_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I104_XG_MP1 (XI1_I654_I104_XG_p1 I1_I654_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I106_XG_MP2 (XI1_I654_I106_XG_p1 I1_I654_G10_9 I1_I654_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I106_XG_MP0 (VDD I1_I654_P10_9 XI1_I654_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I106_XG_MP1 (XI1_I654_I106_XG_p1 I1_I654_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I175_XG_MP2 (XI1_I654_I175_XG_p1 I1_I654_G24_17 I1_I654_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I175_XG_MP0 (VDD I1_I654_P24_17 XI1_I654_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I175_XG_MP1 (XI1_I654_I175_XG_p1 I1_I654_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I110_XG_MP2 (XI1_I654_I110_XG_p1 I1_I654_G14_13 I1_I654_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I110_XG_MP0 (VDD I1_I654_P14_13 XI1_I654_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I110_XG_MP1 (XI1_I654_I110_XG_p1 I1_I654_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I177_XG_MP2 (XI1_I654_I177_XG_p1 I1_I654_G26_19 I1_I654_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I177_XG_MP0 (VDD I1_I654_P26_19 XI1_I654_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I177_XG_MP1 (XI1_I654_I177_XG_p1 I1_I654_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I179_XG_MP2 (XI1_I654_I179_XG_p1 I1_I654_G28_21 I1_I654_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I179_XG_MP0 (VDD I1_I654_P28_21 XI1_I654_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I179_XG_MP1 (XI1_I654_I179_XG_p1 I1_I654_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I118_XG_MP2 (XI1_I654_I118_XG_p1 I1_I654_G22_21 I1_I654_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I118_XG_MP0 (VDD I1_I654_P22_21 XI1_I654_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I118_XG_MP1 (XI1_I654_I118_XG_p1 I1_I654_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I120_XG_MP2 (XI1_I654_I120_XG_p1 I1_I654_G24_23 I1_I654_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I120_XG_MP0 (VDD I1_I654_P24_23 XI1_I654_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I120_XG_MP1 (XI1_I654_I120_XG_p1 I1_I654_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I122_XG_MP2 (XI1_I654_I122_XG_p1 I1_I654_G26_25 I1_I654_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I122_XG_MP0 (VDD I1_I654_P26_25 XI1_I654_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I122_XG_MP1 (XI1_I654_I122_XG_p1 I1_I654_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I124_XG_MP2 (XI1_I654_I124_XG_p1 I1_I654_G28_27 I1_I654_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I124_XG_MP0 (VDD I1_I654_P28_27 XI1_I654_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I124_XG_MP1 (XI1_I654_I124_XG_p1 I1_I654_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I125_XG_MP2 (XI1_I1436_I125_XG_p1 I1_I1436_G29_28 I1_I1436_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I125_XG_MP0 (VDD I1_I1436_P29_28 XI1_I1436_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I125_XG_MP1 (XI1_I1436_I125_XG_p1 I1_I1436_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I123_XG_MP2 (XI1_I1436_I123_XG_p1 I1_I1436_G27_26 I1_I1436_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I123_XG_MP0 (VDD I1_I1436_P27_26 XI1_I1436_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I123_XG_MP1 (XI1_I1436_I123_XG_p1 I1_I1436_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I121_XG_MP2 (XI1_I1436_I121_XG_p1 I1_I1436_G25_24 I1_I1436_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I121_XG_MP0 (VDD I1_I1436_P25_24 XI1_I1436_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I121_XG_MP1 (XI1_I1436_I121_XG_p1 I1_I1436_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I119_XG_MP2 (XI1_I1436_I119_XG_p1 I1_I1436_G23_22 I1_I1436_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I119_XG_MP0 (VDD I1_I1436_P23_22 XI1_I1436_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I119_XG_MP1 (XI1_I1436_I119_XG_p1 I1_I1436_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I117_XG_MP2 (XI1_I1436_I117_XG_p1 I1_I1436_G21_20 I1_I1436_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I117_XG_MP0 (VDD I1_I1436_P21_20 XI1_I1436_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I117_XG_MP1 (XI1_I1436_I117_XG_p1 I1_I1436_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I115_XG_MP2 (XI1_I1436_I115_XG_p1 I1_I1436_G19_18 I1_I1436_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I115_XG_MP0 (VDD I1_I1436_P19_18 XI1_I1436_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I115_XG_MP1 (XI1_I1436_I115_XG_p1 I1_I1436_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I113_XG_MP2 (XI1_I1436_I113_XG_p1 I1_I1436_G17_16 I1_I1436_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I113_XG_MP0 (VDD I1_I1436_P17_16 XI1_I1436_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I113_XG_MP1 (XI1_I1436_I113_XG_p1 I1_I1436_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I111_XG_MP2 (XI1_I1436_I111_XG_p1 I1_I1436_G15_14 I1_I1436_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I111_XG_MP0 (VDD I1_I1436_P15_14 XI1_I1436_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I111_XG_MP1 (XI1_I1436_I111_XG_p1 I1_I1436_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I109_XG_MP2 (XI1_I1436_I109_XG_p1 I1_I1436_G13_12 I1_I1436_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I109_XG_MP0 (VDD I1_I1436_P13_12 XI1_I1436_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I109_XG_MP1 (XI1_I1436_I109_XG_p1 I1_I1436_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I157_XG_MP2 (XI1_I1436_I157_XG_p1 I1_I1436_G8_1 I1_I1436_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I157_XG_MP0 (VDD I1_I1436_P8_1 XI1_I1436_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I157_XG_MP1 (XI1_I1436_I157_XG_p1 I1_I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I98_XG_MP2 (XI1_I1436_I98_XG_p1 I1_I1436_G2_1 I1_I1436_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I98_XG_MP0 (VDD I1_I1436_P2_1 XI1_I1436_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I98_XG_MP1 (XI1_I1436_I98_XG_p1 I1_I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I174_XG_MP2 (XI1_I1114_I174_XG_p1 I1_I1114_G23_16 I1_I1114_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I174_XG_MP0 (VDD I1_I1114_P23_16 XI1_I1114_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I174_XG_MP1 (XI1_I1114_I174_XG_p1 I1_I1114_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I180_XG_MP2 (XI1_I1114_I180_XG_p1 I1_I1114_G29_22 I1_I1114_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I180_XG_MP0 (VDD I1_I1114_P29_22 XI1_I1114_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I180_XG_MP1 (XI1_I1114_I180_XG_p1 I1_I1114_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I117_XG_MP2 (XI1_I1114_I117_XG_p1 I1_I1114_G21_20 I1_I1114_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I117_XG_MP0 (VDD I1_I1114_P21_20 XI1_I1114_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I117_XG_MP1 (XI1_I1114_I117_XG_p1 I1_I1114_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I177_XG_MP2 (XI1_I1114_I177_XG_p1 I1_I1114_G26_19 I1_I1114_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I177_XG_MP0 (VDD I1_I1114_P26_19 XI1_I1114_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I177_XG_MP1 (XI1_I1114_I177_XG_p1 I1_I1114_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I118_XG_MP2 (XI1_I1114_I118_XG_p1 I1_I1114_G22_21 I1_I1114_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I118_XG_MP0 (VDD I1_I1114_P22_21 XI1_I1114_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I118_XG_MP1 (XI1_I1114_I118_XG_p1 I1_I1114_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I179_XG_MP2 (XI1_I1068_I179_XG_p1 I1_I1068_G28_21 I1_I1068_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I179_XG_MP0 (VDD I1_I1068_P28_21 XI1_I1068_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I179_XG_MP1 (XI1_I1068_I179_XG_p1 I1_I1068_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I120_XG_MP2 (XI1_I1068_I120_XG_p1 I1_I1068_G24_23 I1_I1068_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I120_XG_MP0 (VDD I1_I1068_P24_23 XI1_I1068_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I120_XG_MP1 (XI1_I1068_I120_XG_p1 I1_I1068_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I180_XG_MP2 (XI1_I1068_I180_XG_p1 I1_I1068_G29_22 I1_I1068_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I180_XG_MP0 (VDD I1_I1068_P29_22 XI1_I1068_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I180_XG_MP1 (XI1_I1068_I180_XG_p1 I1_I1068_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I121_XG_MP2 (XI1_I1068_I121_XG_p1 I1_I1068_G25_24 I1_I1068_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I121_XG_MP0 (VDD I1_I1068_P25_24 XI1_I1068_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I121_XG_MP1 (XI1_I1068_I121_XG_p1 I1_I1068_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I126_XG_MP2 (XI1_I976_I126_XG_p1 I1_I976_G30_29 I1_I976_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I126_XG_MP0 (VDD I1_I976_P30_29 XI1_I976_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I126_XG_MP1 (XI1_I976_I126_XG_p1 I1_I976_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I124_XG_MP2 (XI1_I976_I124_XG_p1 I1_I976_G28_27 I1_I976_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I124_XG_MP0 (VDD I1_I976_P28_27 XI1_I976_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I124_XG_MP1 (XI1_I976_I124_XG_p1 I1_I976_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I122_XG_MP2 (XI1_I976_I122_XG_p1 I1_I976_G26_25 I1_I976_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I122_XG_MP0 (VDD I1_I976_P26_25 XI1_I976_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I122_XG_MP1 (XI1_I976_I122_XG_p1 I1_I976_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I182_XG_MP2 (XI1_I976_I182_XG_p1 I1_I976_G31_24 I1_I976_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I182_XG_MP0 (VDD I1_I976_P31_24 XI1_I976_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I182_XG_MP1 (XI1_I976_I182_XG_p1 I1_I976_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I174_XG_MP2 (XI1_I976_I174_XG_p1 I1_I976_G23_16 I1_I976_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I174_XG_MP0 (VDD I1_I976_P23_16 XI1_I976_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I174_XG_MP1 (XI1_I976_I174_XG_p1 I1_I976_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I166_XG_MP2 (XI1_I976_I166_XG_p1 I1_I976_G15_8 I1_I976_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I166_XG_MP0 (VDD I1_I976_P15_8 XI1_I976_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I166_XG_MP1 (XI1_I976_I166_XG_p1 I1_I976_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I178_XG_MP2 (XI1_I976_I178_XG_p1 I1_I976_G27_20 I1_I976_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I178_XG_MP0 (VDD I1_I976_P27_20 XI1_I976_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I178_XG_MP1 (XI1_I976_I178_XG_p1 I1_I976_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I111_XG_MP2 (XI1_I976_I111_XG_p1 I1_I976_G15_14 I1_I976_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I111_XG_MP0 (VDD I1_I976_P15_14 XI1_I976_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I111_XG_MP1 (XI1_I976_I111_XG_p1 I1_I976_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I172_XG_MP2 (XI1_I976_I172_XG_p1 I1_I976_G21_14 I1_I976_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I172_XG_MP0 (VDD I1_I976_P21_14 XI1_I976_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I172_XG_MP1 (XI1_I976_I172_XG_p1 I1_I976_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I164_XG_MP2 (XI1_I976_I164_XG_p1 I1_I976_G13_6 I1_I976_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I164_XG_MP0 (VDD I1_I976_P13_6 XI1_I976_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I164_XG_MP1 (XI1_I976_I164_XG_p1 I1_I976_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I107_XG_MP2 (XI1_I976_I107_XG_p1 I1_I976_G11_10 I1_I976_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I107_XG_MP0 (VDD I1_I976_P11_10 XI1_I976_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I107_XG_MP1 (XI1_I976_I107_XG_p1 I1_I976_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I108_XG_MP2 (XI1_I654_I108_XG_p1 I1_I654_G12_11 I1_I654_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I108_XG_MP0 (VDD I1_I654_P12_11 XI1_I654_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I108_XG_MP1 (XI1_I654_I108_XG_p1 I1_I654_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I112_XG_MP2 (XI1_I654_I112_XG_p1 I1_I654_G16_15 I1_I654_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I112_XG_MP0 (VDD I1_I654_P16_15 XI1_I654_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I112_XG_MP1 (XI1_I654_I112_XG_p1 I1_I654_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I114_XG_MP2 (XI1_I654_I114_XG_p1 I1_I654_G18_17 I1_I654_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I114_XG_MP0 (VDD I1_I654_P18_17 XI1_I654_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I114_XG_MP1 (XI1_I654_I114_XG_p1 I1_I654_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I116_XG_MP2 (XI1_I654_I116_XG_p1 I1_I654_G20_19 I1_I654_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I654_I116_XG_MP0 (VDD I1_I654_P20_19 XI1_I654_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I654_I116_XG_MP1 (XI1_I654_I116_XG_p1 I1_I654_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I127_XG_MP2 (XI1_I1436_I127_XG_p1 I1_I1436_G31_30 I1_I1436_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I127_XG_MP0 (VDD I1_I1436_P31_30 XI1_I1436_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I127_XG_MP1 (XI1_I1436_I127_XG_p1 I1_I1436_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I180_XG_MP2 (XI1_I1436_I180_XG_p1 I1_I1436_G29_22 I1_I1436_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I180_XG_MP0 (VDD I1_I1436_P29_22 XI1_I1436_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I180_XG_MP1 (XI1_I1436_I180_XG_p1 I1_I1436_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I164_XG_MP2 (XI1_I1436_I164_XG_p1 I1_I1436_G13_6 I1_I1436_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I164_XG_MP0 (VDD I1_I1436_P13_6 XI1_I1436_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I164_XG_MP1 (XI1_I1436_I164_XG_p1 I1_I1436_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I107_XG_MP2 (XI1_I1436_I107_XG_p1 I1_I1436_G11_10 I1_I1436_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I107_XG_MP0 (VDD I1_I1436_P11_10 XI1_I1436_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I107_XG_MP1 (XI1_I1436_I107_XG_p1 I1_I1436_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I168_XG_MP2 (XI1_I1436_I168_XG_p1 I1_I1436_G17_10 I1_I1436_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I168_XG_MP0 (VDD I1_I1436_P17_10 XI1_I1436_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I168_XG_MP1 (XI1_I1436_I168_XG_p1 I1_I1436_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I105_XG_MP2 (XI1_I1436_I105_XG_p1 I1_I1436_G9_8 I1_I1436_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I105_XG_MP0 (VDD I1_I1436_P9_8 XI1_I1436_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I105_XG_MP1 (XI1_I1436_I105_XG_p1 I1_I1436_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I103_XG_MP2 (XI1_I1436_I103_XG_p1 I1_I1436_G7_6 I1_I1436_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I103_XG_MP0 (VDD I1_I1436_P7_6 XI1_I1436_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I103_XG_MP1 (XI1_I1436_I103_XG_p1 I1_I1436_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I101_XG_MP2 (XI1_I1436_I101_XG_p1 I1_I1436_G5_4 I1_I1436_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I101_XG_MP0 (VDD I1_I1436_P5_4 XI1_I1436_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I101_XG_MP1 (XI1_I1436_I101_XG_p1 I1_I1436_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I99_XG_MP2 (XI1_I1436_I99_XG_p1 I1_I1436_G3_2 I1_I1436_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I99_XG_MP0 (VDD I1_I1436_P3_2 XI1_I1436_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I99_XG_MP1 (XI1_I1436_I99_XG_p1 I1_I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I178_XG_MP2 (XI1_I1114_I178_XG_p1 I1_I1114_G27_20 I1_I1114_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I178_XG_MP0 (VDD I1_I1114_P27_20 XI1_I1114_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I178_XG_MP1 (XI1_I1114_I178_XG_p1 I1_I1114_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I166_XG_MP2 (XI1_I1114_I166_XG_p1 I1_I1114_G15_8 I1_I1114_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I166_XG_MP0 (VDD I1_I1114_P15_8 XI1_I1114_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I166_XG_MP1 (XI1_I1114_I166_XG_p1 I1_I1114_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I172_XG_MP2 (XI1_I1114_I172_XG_p1 I1_I1114_G21_14 I1_I1114_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I172_XG_MP0 (VDD I1_I1114_P21_14 XI1_I1114_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I172_XG_MP1 (XI1_I1114_I172_XG_p1 I1_I1114_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I115_XG_MP2 (XI1_I1114_I115_XG_p1 I1_I1114_G19_18 I1_I1114_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I115_XG_MP0 (VDD I1_I1114_P19_18 XI1_I1114_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I115_XG_MP1 (XI1_I1114_I115_XG_p1 I1_I1114_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I179_XG_MP2 (XI1_I1114_I179_XG_p1 I1_I1114_G28_21 I1_I1114_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I179_XG_MP0 (VDD I1_I1114_P28_21 XI1_I1114_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I179_XG_MP1 (XI1_I1114_I179_XG_p1 I1_I1114_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I116_XG_MP2 (XI1_I1114_I116_XG_p1 I1_I1114_G20_19 I1_I1114_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I116_XG_MP0 (VDD I1_I1114_P20_19 XI1_I1114_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I116_XG_MP1 (XI1_I1114_I116_XG_p1 I1_I1114_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I114_XG_MP2 (XI1_I1114_I114_XG_p1 I1_I1114_G18_17 I1_I1114_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I114_XG_MP0 (VDD I1_I1114_P18_17 XI1_I1114_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I114_XG_MP1 (XI1_I1114_I114_XG_p1 I1_I1114_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I173_XG_MP2 (XI1_I1068_I173_XG_p1 I1_I1068_G22_15 I1_I1068_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I173_XG_MP0 (VDD I1_I1068_P22_15 XI1_I1068_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I173_XG_MP1 (XI1_I1068_I173_XG_p1 I1_I1068_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I118_XG_MP2 (XI1_I1068_I118_XG_p1 I1_I1068_G22_21 I1_I1068_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I118_XG_MP0 (VDD I1_I1068_P22_21 XI1_I1068_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I118_XG_MP1 (XI1_I1068_I118_XG_p1 I1_I1068_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I166_XG_MP2 (XI1_I1068_I166_XG_p1 I1_I1068_G15_8 I1_I1068_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I166_XG_MP0 (VDD I1_I1068_P15_8 XI1_I1068_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I166_XG_MP1 (XI1_I1068_I166_XG_p1 I1_I1068_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I174_XG_MP2 (XI1_I1068_I174_XG_p1 I1_I1068_G23_16 I1_I1068_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I174_XG_MP0 (VDD I1_I1068_P23_16 XI1_I1068_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I174_XG_MP1 (XI1_I1068_I174_XG_p1 I1_I1068_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I119_XG_MP2 (XI1_I1068_I119_XG_p1 I1_I1068_G23_22 I1_I1068_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I119_XG_MP0 (VDD I1_I1068_P23_22 XI1_I1068_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I119_XG_MP1 (XI1_I1068_I119_XG_p1 I1_I1068_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I126_XG_MP2 (XI1_I1022_I126_XG_p1 I1_I1022_G30_29 I1_I1022_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I126_XG_MP0 (VDD I1_I1022_P30_29 XI1_I1022_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I126_XG_MP1 (XI1_I1022_I126_XG_p1 I1_I1022_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I127_XG_MP2 (XI1_I1022_I127_XG_p1 I1_I1022_G31_30 I1_I1022_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I127_XG_MP0 (VDD I1_I1022_P31_30 XI1_I1022_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I127_XG_MP1 (XI1_I1022_I127_XG_p1 I1_I1022_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I120_XG_MP2 (XI1_I976_I120_XG_p1 I1_I976_G24_23 I1_I976_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I120_XG_MP0 (VDD I1_I976_P24_23 XI1_I976_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I120_XG_MP1 (XI1_I976_I120_XG_p1 I1_I976_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I118_XG_MP2 (XI1_I976_I118_XG_p1 I1_I976_G22_21 I1_I976_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I118_XG_MP0 (VDD I1_I976_P22_21 XI1_I976_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I118_XG_MP1 (XI1_I976_I118_XG_p1 I1_I976_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I170_XG_MP2 (XI1_I976_I170_XG_p1 I1_I976_G19_12 I1_I976_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I170_XG_MP0 (VDD I1_I976_P19_12 XI1_I976_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I170_XG_MP1 (XI1_I976_I170_XG_p1 I1_I976_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I168_XG_MP2 (XI1_I976_I168_XG_p1 I1_I976_G17_10 I1_I976_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I168_XG_MP0 (VDD I1_I976_P17_10 XI1_I976_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I168_XG_MP1 (XI1_I976_I168_XG_p1 I1_I976_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I105_XG_MP2 (XI1_I976_I105_XG_p1 I1_I976_G9_8 I1_I976_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I105_XG_MP0 (VDD I1_I976_P9_8 XI1_I976_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I105_XG_MP1 (XI1_I976_I105_XG_p1 I1_I976_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I103_XG_MP2 (XI1_I976_I103_XG_p1 I1_I976_G7_6 I1_I976_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I103_XG_MP0 (VDD I1_I976_P7_6 XI1_I976_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I103_XG_MP1 (XI1_I976_I103_XG_p1 I1_I976_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I182_XG_MP2 (XI1_I1436_I182_XG_p1 I1_I1436_G31_24 I1_I1436_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I182_XG_MP0 (VDD I1_I1436_P31_24 XI1_I1436_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I182_XG_MP1 (XI1_I1436_I182_XG_p1 I1_I1436_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I178_XG_MP2 (XI1_I1436_I178_XG_p1 I1_I1436_G27_20 I1_I1436_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I178_XG_MP0 (VDD I1_I1436_P27_20 XI1_I1436_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I178_XG_MP1 (XI1_I1436_I178_XG_p1 I1_I1436_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I174_XG_MP2 (XI1_I1436_I174_XG_p1 I1_I1436_G23_16 I1_I1436_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I174_XG_MP0 (VDD I1_I1436_P23_16 XI1_I1436_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I174_XG_MP1 (XI1_I1436_I174_XG_p1 I1_I1436_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I166_XG_MP2 (XI1_I1436_I166_XG_p1 I1_I1436_G15_8 I1_I1436_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I166_XG_MP0 (VDD I1_I1436_P15_8 XI1_I1436_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I166_XG_MP1 (XI1_I1436_I166_XG_p1 I1_I1436_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I170_XG_MP2 (XI1_I1436_I170_XG_p1 I1_I1436_G19_12 I1_I1436_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I170_XG_MP0 (VDD I1_I1436_P19_12 XI1_I1436_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I170_XG_MP1 (XI1_I1436_I170_XG_p1 I1_I1436_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I162_XG_MP2 (XI1_I1436_I162_XG_p1 I1_I1436_G11_4 I1_I1436_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I162_XG_MP0 (VDD I1_I1436_P11_4 XI1_I1436_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I162_XG_MP1 (XI1_I1436_I162_XG_p1 I1_I1436_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I158_XG_MP2 (XI1_I1436_I158_XG_p1 I1_I1436_G9_2 I1_I1436_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1436_I158_XG_MP0 (VDD I1_I1436_P9_2 XI1_I1436_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1436_I158_XG_MP1 (XI1_I1436_I158_XG_p1 I1_I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I176_XG_MP2 (XI1_I1114_I176_XG_p1 I1_I1114_G25_18 I1_I1114_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I176_XG_MP0 (VDD I1_I1114_P25_18 XI1_I1114_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I176_XG_MP1 (XI1_I1114_I176_XG_p1 I1_I1114_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I164_XG_MP2 (XI1_I1114_I164_XG_p1 I1_I1114_G13_6 I1_I1114_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I164_XG_MP0 (VDD I1_I1114_P13_6 XI1_I1114_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I164_XG_MP1 (XI1_I1114_I164_XG_p1 I1_I1114_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I113_XG_MP2 (XI1_I1114_I113_XG_p1 I1_I1114_G17_16 I1_I1114_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I113_XG_MP0 (VDD I1_I1114_P17_16 XI1_I1114_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I113_XG_MP1 (XI1_I1114_I113_XG_p1 I1_I1114_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I175_XG_MP2 (XI1_I1114_I175_XG_p1 I1_I1114_G24_17 I1_I1114_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I175_XG_MP0 (VDD I1_I1114_P24_17 XI1_I1114_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I175_XG_MP1 (XI1_I1114_I175_XG_p1 I1_I1114_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I171_XG_MP2 (XI1_I1114_I171_XG_p1 I1_I1114_G20_13 I1_I1114_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I171_XG_MP0 (VDD I1_I1114_P20_13 XI1_I1114_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I171_XG_MP1 (XI1_I1114_I171_XG_p1 I1_I1114_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I169_XG_MP2 (XI1_I1114_I169_XG_p1 I1_I1114_G18_11 I1_I1114_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I169_XG_MP0 (VDD I1_I1114_P18_11 XI1_I1114_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I169_XG_MP1 (XI1_I1114_I169_XG_p1 I1_I1114_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I160_XG_MP2 (XI1_I1114_I160_XG_p1 I1_I1114_G10_3 I1_I1114_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I160_XG_MP0 (VDD I1_I1114_P10_3 XI1_I1114_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I160_XG_MP1 (XI1_I1114_I160_XG_p1 I1_I1114_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I112_XG_MP2 (XI1_I1114_I112_XG_p1 I1_I1114_G16_15 I1_I1114_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I112_XG_MP0 (VDD I1_I1114_P16_15 XI1_I1114_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I112_XG_MP1 (XI1_I1114_I112_XG_p1 I1_I1114_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I165_XG_MP2 (XI1_I1068_I165_XG_p1 I1_I1068_G14_7 I1_I1068_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I165_XG_MP0 (VDD I1_I1068_P14_7 XI1_I1068_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I165_XG_MP1 (XI1_I1068_I165_XG_p1 I1_I1068_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I177_XG_MP2 (XI1_I1068_I177_XG_p1 I1_I1068_G26_19 I1_I1068_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I177_XG_MP0 (VDD I1_I1068_P26_19 XI1_I1068_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I177_XG_MP1 (XI1_I1068_I177_XG_p1 I1_I1068_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I116_XG_MP2 (XI1_I1068_I116_XG_p1 I1_I1068_G20_19 I1_I1068_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I116_XG_MP0 (VDD I1_I1068_P20_19 XI1_I1068_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I116_XG_MP1 (XI1_I1068_I116_XG_p1 I1_I1068_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I172_XG_MP2 (XI1_I1068_I172_XG_p1 I1_I1068_G21_14 I1_I1068_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I172_XG_MP0 (VDD I1_I1068_P21_14 XI1_I1068_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I172_XG_MP1 (XI1_I1068_I172_XG_p1 I1_I1068_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I178_XG_MP2 (XI1_I1068_I178_XG_p1 I1_I1068_G27_20 I1_I1068_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I178_XG_MP0 (VDD I1_I1068_P27_20 XI1_I1068_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I178_XG_MP1 (XI1_I1068_I178_XG_p1 I1_I1068_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I117_XG_MP2 (XI1_I1068_I117_XG_p1 I1_I1068_G21_20 I1_I1068_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I117_XG_MP0 (VDD I1_I1068_P21_20 XI1_I1068_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I117_XG_MP1 (XI1_I1068_I117_XG_p1 I1_I1068_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I124_XG_MP2 (XI1_I1022_I124_XG_p1 I1_I1022_G28_27 I1_I1022_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I124_XG_MP0 (VDD I1_I1022_P28_27 XI1_I1022_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I124_XG_MP1 (XI1_I1022_I124_XG_p1 I1_I1022_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I122_XG_MP2 (XI1_I1022_I122_XG_p1 I1_I1022_G26_25 I1_I1022_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I122_XG_MP0 (VDD I1_I1022_P26_25 XI1_I1022_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I122_XG_MP1 (XI1_I1022_I122_XG_p1 I1_I1022_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I125_XG_MP2 (XI1_I1022_I125_XG_p1 I1_I1022_G29_28 I1_I1022_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I125_XG_MP0 (VDD I1_I1022_P29_28 XI1_I1022_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I125_XG_MP1 (XI1_I1022_I125_XG_p1 I1_I1022_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I181_XG_MP2 (XI1_I976_I181_XG_p1 I1_I976_G30_23 I1_I976_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I181_XG_MP0 (VDD I1_I976_P30_23 XI1_I976_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I181_XG_MP1 (XI1_I976_I181_XG_p1 I1_I976_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I116_XG_MP2 (XI1_I976_I116_XG_p1 I1_I976_G20_19 I1_I976_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I116_XG_MP0 (VDD I1_I976_P20_19 XI1_I976_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I116_XG_MP1 (XI1_I976_I116_XG_p1 I1_I976_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I114_XG_MP2 (XI1_I976_I114_XG_p1 I1_I976_G18_17 I1_I976_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I114_XG_MP0 (VDD I1_I976_P18_17 XI1_I976_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I114_XG_MP1 (XI1_I976_I114_XG_p1 I1_I976_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I112_XG_MP2 (XI1_I976_I112_XG_p1 I1_I976_G16_15 I1_I976_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I112_XG_MP0 (VDD I1_I976_P16_15 XI1_I976_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I112_XG_MP1 (XI1_I976_I112_XG_p1 I1_I976_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I110_XG_MP2 (XI1_I976_I110_XG_p1 I1_I976_G14_13 I1_I976_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I110_XG_MP0 (VDD I1_I976_P14_13 XI1_I976_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I110_XG_MP1 (XI1_I976_I110_XG_p1 I1_I976_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I162_XG_MP2 (XI1_I976_I162_XG_p1 I1_I976_G11_4 I1_I976_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I162_XG_MP0 (VDD I1_I976_P11_4 XI1_I976_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I162_XG_MP1 (XI1_I976_I162_XG_p1 I1_I976_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I158_XG_MP2 (XI1_I976_I158_XG_p1 I1_I976_G9_2 I1_I976_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I158_XG_MP0 (VDD I1_I976_P9_2 XI1_I976_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I158_XG_MP1 (XI1_I976_I158_XG_p1 I1_I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I157_XG_MP2 (XI1_I608_I157_XG_p1 I1_I608_G8_1 I1_I608_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I157_XG_MP0 (VDD I1_I608_P8_1 XI1_I608_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I157_XG_MP1 (XI1_I608_I157_XG_p1 I1_I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I170_XG_MP2 (XI1_I1114_I170_XG_p1 I1_I1114_G19_12 I1_I1114_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I170_XG_MP0 (VDD I1_I1114_P19_12 XI1_I1114_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I170_XG_MP1 (XI1_I1114_I170_XG_p1 I1_I1114_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I168_XG_MP2 (XI1_I1114_I168_XG_p1 I1_I1114_G17_10 I1_I1114_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I168_XG_MP0 (VDD I1_I1114_P17_10 XI1_I1114_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I168_XG_MP1 (XI1_I1114_I168_XG_p1 I1_I1114_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I111_XG_MP2 (XI1_I1114_I111_XG_p1 I1_I1114_G15_14 I1_I1114_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I111_XG_MP0 (VDD I1_I1114_P15_14 XI1_I1114_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I111_XG_MP1 (XI1_I1114_I111_XG_p1 I1_I1114_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I109_XG_MP2 (XI1_I1114_I109_XG_p1 I1_I1114_G13_12 I1_I1114_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I109_XG_MP0 (VDD I1_I1114_P13_12 XI1_I1114_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I109_XG_MP1 (XI1_I1114_I109_XG_p1 I1_I1114_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I163_XG_MP2 (XI1_I1114_I163_XG_p1 I1_I1114_G12_5 I1_I1114_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I163_XG_MP0 (VDD I1_I1114_P12_5 XI1_I1114_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I163_XG_MP1 (XI1_I1114_I163_XG_p1 I1_I1114_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I110_XG_MP2 (XI1_I1114_I110_XG_p1 I1_I1114_G14_13 I1_I1114_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I110_XG_MP0 (VDD I1_I1114_P14_13 XI1_I1114_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I110_XG_MP1 (XI1_I1114_I110_XG_p1 I1_I1114_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I171_XG_MP2 (XI1_I1068_I171_XG_p1 I1_I1068_G20_13 I1_I1068_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I171_XG_MP0 (VDD I1_I1068_P20_13 XI1_I1068_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I171_XG_MP1 (XI1_I1068_I171_XG_p1 I1_I1068_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I164_XG_MP2 (XI1_I1068_I164_XG_p1 I1_I1068_G13_6 I1_I1068_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I164_XG_MP0 (VDD I1_I1068_P13_6 XI1_I1068_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I164_XG_MP1 (XI1_I1068_I164_XG_p1 I1_I1068_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I170_XG_MP2 (XI1_I1068_I170_XG_p1 I1_I1068_G19_12 I1_I1068_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I170_XG_MP0 (VDD I1_I1068_P19_12 XI1_I1068_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I170_XG_MP1 (XI1_I1068_I170_XG_p1 I1_I1068_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I115_XG_MP2 (XI1_I1068_I115_XG_p1 I1_I1068_G19_18 I1_I1068_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I115_XG_MP0 (VDD I1_I1068_P19_18 XI1_I1068_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I115_XG_MP1 (XI1_I1068_I115_XG_p1 I1_I1068_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I120_XG_MP2 (XI1_I1022_I120_XG_p1 I1_I1022_G24_23 I1_I1022_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I120_XG_MP0 (VDD I1_I1022_P24_23 XI1_I1022_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I120_XG_MP1 (XI1_I1022_I120_XG_p1 I1_I1022_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I123_XG_MP2 (XI1_I1022_I123_XG_p1 I1_I1022_G27_26 I1_I1022_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I123_XG_MP0 (VDD I1_I1022_P27_26 XI1_I1022_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I123_XG_MP1 (XI1_I1022_I123_XG_p1 I1_I1022_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I121_XG_MP2 (XI1_I1022_I121_XG_p1 I1_I1022_G25_24 I1_I1022_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I121_XG_MP0 (VDD I1_I1022_P25_24 XI1_I1022_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I121_XG_MP1 (XI1_I1022_I121_XG_p1 I1_I1022_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I179_XG_MP2 (XI1_I976_I179_XG_p1 I1_I976_G28_21 I1_I976_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I179_XG_MP0 (VDD I1_I976_P28_21 XI1_I976_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I179_XG_MP1 (XI1_I976_I179_XG_p1 I1_I976_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I173_XG_MP2 (XI1_I976_I173_XG_p1 I1_I976_G22_15 I1_I976_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I173_XG_MP0 (VDD I1_I976_P22_15 XI1_I976_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I173_XG_MP1 (XI1_I976_I173_XG_p1 I1_I976_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I177_XG_MP2 (XI1_I976_I177_XG_p1 I1_I976_G26_19 I1_I976_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I177_XG_MP0 (VDD I1_I976_P26_19 XI1_I976_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I177_XG_MP1 (XI1_I976_I177_XG_p1 I1_I976_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I175_XG_MP2 (XI1_I976_I175_XG_p1 I1_I976_G24_17 I1_I976_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I175_XG_MP0 (VDD I1_I976_P24_17 XI1_I976_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I175_XG_MP1 (XI1_I976_I175_XG_p1 I1_I976_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I108_XG_MP2 (XI1_I976_I108_XG_p1 I1_I976_G12_11 I1_I976_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I108_XG_MP0 (VDD I1_I976_P12_11 XI1_I976_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I108_XG_MP1 (XI1_I976_I108_XG_p1 I1_I976_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I106_XG_MP2 (XI1_I976_I106_XG_p1 I1_I976_G10_9 I1_I976_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I106_XG_MP0 (VDD I1_I976_P10_9 XI1_I976_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I106_XG_MP1 (XI1_I976_I106_XG_p1 I1_I976_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I101_XG_MP2 (XI1_I976_I101_XG_p1 I1_I976_G5_4 I1_I976_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I101_XG_MP0 (VDD I1_I976_P5_4 XI1_I976_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I101_XG_MP1 (XI1_I976_I101_XG_p1 I1_I976_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I98_XG_MP2 (XI1_I608_I98_XG_p1 I1_I608_G2_1 I1_I608_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I98_XG_MP0 (VDD I1_I608_P2_1 XI1_I608_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I98_XG_MP1 (XI1_I608_I98_XG_p1 I1_I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I100_XG_MP2 (XI1_I608_I100_XG_p1 I1_I608_G4_3 I1_I608_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I100_XG_MP0 (VDD I1_I608_P4_3 XI1_I608_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I100_XG_MP1 (XI1_I608_I100_XG_p1 I1_I608_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I167_XG_MP2 (XI1_I608_I167_XG_p1 I1_I608_G16_9 I1_I608_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I167_XG_MP0 (VDD I1_I608_P16_9 XI1_I608_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I167_XG_MP1 (XI1_I608_I167_XG_p1 I1_I608_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I160_XG_MP2 (XI1_I608_I160_XG_p1 I1_I608_G10_3 I1_I608_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I160_XG_MP0 (VDD I1_I608_P10_3 XI1_I608_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I160_XG_MP1 (XI1_I608_I160_XG_p1 I1_I608_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I169_XG_MP2 (XI1_I608_I169_XG_p1 I1_I608_G18_11 I1_I608_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I169_XG_MP0 (VDD I1_I608_P18_11 XI1_I608_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I169_XG_MP1 (XI1_I608_I169_XG_p1 I1_I608_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I175_XG_MP2 (XI1_I608_I175_XG_p1 I1_I608_G24_17 I1_I608_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I175_XG_MP0 (VDD I1_I608_P24_17 XI1_I608_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I175_XG_MP1 (XI1_I608_I175_XG_p1 I1_I608_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I163_XG_MP2 (XI1_I608_I163_XG_p1 I1_I608_G12_5 I1_I608_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I163_XG_MP0 (VDD I1_I608_P12_5 XI1_I608_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I163_XG_MP1 (XI1_I608_I163_XG_p1 I1_I608_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I171_XG_MP2 (XI1_I608_I171_XG_p1 I1_I608_G20_13 I1_I608_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I171_XG_MP0 (VDD I1_I608_P20_13 XI1_I608_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I171_XG_MP1 (XI1_I608_I171_XG_p1 I1_I608_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I165_XG_MP2 (XI1_I608_I165_XG_p1 I1_I608_G14_7 I1_I608_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I165_XG_MP0 (VDD I1_I608_P14_7 XI1_I608_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I165_XG_MP1 (XI1_I608_I165_XG_p1 I1_I608_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I177_XG_MP2 (XI1_I608_I177_XG_p1 I1_I608_G26_19 I1_I608_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I177_XG_MP0 (VDD I1_I608_P26_19 XI1_I608_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I177_XG_MP1 (XI1_I608_I177_XG_p1 I1_I608_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I173_XG_MP2 (XI1_I608_I173_XG_p1 I1_I608_G22_15 I1_I608_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I173_XG_MP0 (VDD I1_I608_P22_15 XI1_I608_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I173_XG_MP1 (XI1_I608_I173_XG_p1 I1_I608_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I179_XG_MP2 (XI1_I608_I179_XG_p1 I1_I608_G28_21 I1_I608_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I179_XG_MP0 (VDD I1_I608_P28_21 XI1_I608_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I179_XG_MP1 (XI1_I608_I179_XG_p1 I1_I608_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I181_XG_MP2 (XI1_I608_I181_XG_p1 I1_I608_G30_23 I1_I608_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I181_XG_MP0 (VDD I1_I608_P30_23 XI1_I608_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I181_XG_MP1 (XI1_I608_I181_XG_p1 I1_I608_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I126_XG_MP2 (XI1_I608_I126_XG_p1 I1_I608_G30_29 I1_I608_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I126_XG_MP0 (VDD I1_I608_P30_29 XI1_I608_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I126_XG_MP1 (XI1_I608_I126_XG_p1 I1_I608_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I162_XG_MP2 (XI1_I1114_I162_XG_p1 I1_I1114_G11_4 I1_I1114_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I162_XG_MP0 (VDD I1_I1114_P11_4 XI1_I1114_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I162_XG_MP1 (XI1_I1114_I162_XG_p1 I1_I1114_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I158_XG_MP2 (XI1_I1114_I158_XG_p1 I1_I1114_G9_2 I1_I1114_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I158_XG_MP0 (VDD I1_I1114_P9_2 XI1_I1114_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I158_XG_MP1 (XI1_I1114_I158_XG_p1 I1_I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I163_XG_MP2 (XI1_I1068_I163_XG_p1 I1_I1068_G12_5 I1_I1068_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I163_XG_MP0 (VDD I1_I1068_P12_5 XI1_I1068_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I163_XG_MP1 (XI1_I1068_I163_XG_p1 I1_I1068_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I169_XG_MP2 (XI1_I1068_I169_XG_p1 I1_I1068_G18_11 I1_I1068_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I169_XG_MP0 (VDD I1_I1068_P18_11 XI1_I1068_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I169_XG_MP1 (XI1_I1068_I169_XG_p1 I1_I1068_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I114_XG_MP2 (XI1_I1068_I114_XG_p1 I1_I1068_G18_17 I1_I1068_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I114_XG_MP0 (VDD I1_I1068_P18_17 XI1_I1068_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I114_XG_MP1 (XI1_I1068_I114_XG_p1 I1_I1068_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I162_XG_MP2 (XI1_I1068_I162_XG_p1 I1_I1068_G11_4 I1_I1068_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I162_XG_MP0 (VDD I1_I1068_P11_4 XI1_I1068_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I162_XG_MP1 (XI1_I1068_I162_XG_p1 I1_I1068_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I176_XG_MP2 (XI1_I1068_I176_XG_p1 I1_I1068_G25_18 I1_I1068_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I176_XG_MP0 (VDD I1_I1068_P25_18 XI1_I1068_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I176_XG_MP1 (XI1_I1068_I176_XG_p1 I1_I1068_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I113_XG_MP2 (XI1_I1068_I113_XG_p1 I1_I1068_G17_16 I1_I1068_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I113_XG_MP0 (VDD I1_I1068_P17_16 XI1_I1068_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I113_XG_MP1 (XI1_I1068_I113_XG_p1 I1_I1068_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I181_XG_MP2 (XI1_I1022_I181_XG_p1 I1_I1022_G30_23 I1_I1022_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I181_XG_MP0 (VDD I1_I1022_P30_23 XI1_I1022_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I181_XG_MP1 (XI1_I1022_I181_XG_p1 I1_I1022_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I118_XG_MP2 (XI1_I1022_I118_XG_p1 I1_I1022_G22_21 I1_I1022_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I118_XG_MP0 (VDD I1_I1022_P22_21 XI1_I1022_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I118_XG_MP1 (XI1_I1022_I118_XG_p1 I1_I1022_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I182_XG_MP2 (XI1_I1022_I182_XG_p1 I1_I1022_G31_24 I1_I1022_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I182_XG_MP0 (VDD I1_I1022_P31_24 XI1_I1022_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I182_XG_MP1 (XI1_I1022_I182_XG_p1 I1_I1022_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I119_XG_MP2 (XI1_I1022_I119_XG_p1 I1_I1022_G23_22 I1_I1022_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I119_XG_MP0 (VDD I1_I1022_P23_22 XI1_I1022_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I119_XG_MP1 (XI1_I1022_I119_XG_p1 I1_I1022_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I165_XG_MP2 (XI1_I976_I165_XG_p1 I1_I976_G14_7 I1_I976_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I165_XG_MP0 (VDD I1_I976_P14_7 XI1_I976_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I165_XG_MP1 (XI1_I976_I165_XG_p1 I1_I976_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I171_XG_MP2 (XI1_I976_I171_XG_p1 I1_I976_G20_13 I1_I976_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I171_XG_MP0 (VDD I1_I976_P20_13 XI1_I976_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I171_XG_MP1 (XI1_I976_I171_XG_p1 I1_I976_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I163_XG_MP2 (XI1_I976_I163_XG_p1 I1_I976_G12_5 I1_I976_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I163_XG_MP0 (VDD I1_I976_P12_5 XI1_I976_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I163_XG_MP1 (XI1_I976_I163_XG_p1 I1_I976_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I169_XG_MP2 (XI1_I976_I169_XG_p1 I1_I976_G18_11 I1_I976_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I169_XG_MP0 (VDD I1_I976_P18_11 XI1_I976_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I169_XG_MP1 (XI1_I976_I169_XG_p1 I1_I976_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I160_XG_MP2 (XI1_I976_I160_XG_p1 I1_I976_G10_3 I1_I976_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I160_XG_MP0 (VDD I1_I976_P10_3 XI1_I976_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I160_XG_MP1 (XI1_I976_I160_XG_p1 I1_I976_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I104_XG_MP2 (XI1_I976_I104_XG_p1 I1_I976_G8_7 I1_I976_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I104_XG_MP0 (VDD I1_I976_P8_7 XI1_I976_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I104_XG_MP1 (XI1_I976_I104_XG_p1 I1_I976_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I102_XG_MP2 (XI1_I976_I102_XG_p1 I1_I976_G6_5 I1_I976_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I102_XG_MP0 (VDD I1_I976_P6_5 XI1_I976_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I102_XG_MP1 (XI1_I976_I102_XG_p1 I1_I976_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I99_XG_MP2 (XI1_I976_I99_XG_p1 I1_I976_G3_2 I1_I976_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I99_XG_MP0 (VDD I1_I976_P3_2 XI1_I976_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I99_XG_MP1 (XI1_I976_I99_XG_p1 I1_I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I102_XG_MP2 (XI1_I608_I102_XG_p1 I1_I608_G6_5 I1_I608_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I102_XG_MP0 (VDD I1_I608_P6_5 XI1_I608_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I102_XG_MP1 (XI1_I608_I102_XG_p1 I1_I608_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I104_XG_MP2 (XI1_I608_I104_XG_p1 I1_I608_G8_7 I1_I608_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I104_XG_MP0 (VDD I1_I608_P8_7 XI1_I608_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I104_XG_MP1 (XI1_I608_I104_XG_p1 I1_I608_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I106_XG_MP2 (XI1_I608_I106_XG_p1 I1_I608_G10_9 I1_I608_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I106_XG_MP0 (VDD I1_I608_P10_9 XI1_I608_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I106_XG_MP1 (XI1_I608_I106_XG_p1 I1_I608_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I108_XG_MP2 (XI1_I608_I108_XG_p1 I1_I608_G12_11 I1_I608_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I108_XG_MP0 (VDD I1_I608_P12_11 XI1_I608_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I108_XG_MP1 (XI1_I608_I108_XG_p1 I1_I608_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I110_XG_MP2 (XI1_I608_I110_XG_p1 I1_I608_G14_13 I1_I608_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I110_XG_MP0 (VDD I1_I608_P14_13 XI1_I608_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I110_XG_MP1 (XI1_I608_I110_XG_p1 I1_I608_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I112_XG_MP2 (XI1_I608_I112_XG_p1 I1_I608_G16_15 I1_I608_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I112_XG_MP0 (VDD I1_I608_P16_15 XI1_I608_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I112_XG_MP1 (XI1_I608_I112_XG_p1 I1_I608_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I114_XG_MP2 (XI1_I608_I114_XG_p1 I1_I608_G18_17 I1_I608_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I114_XG_MP0 (VDD I1_I608_P18_17 XI1_I608_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I114_XG_MP1 (XI1_I608_I114_XG_p1 I1_I608_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I116_XG_MP2 (XI1_I608_I116_XG_p1 I1_I608_G20_19 I1_I608_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I116_XG_MP0 (VDD I1_I608_P20_19 XI1_I608_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I116_XG_MP1 (XI1_I608_I116_XG_p1 I1_I608_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I118_XG_MP2 (XI1_I608_I118_XG_p1 I1_I608_G22_21 I1_I608_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I118_XG_MP0 (VDD I1_I608_P22_21 XI1_I608_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I118_XG_MP1 (XI1_I608_I118_XG_p1 I1_I608_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I120_XG_MP2 (XI1_I608_I120_XG_p1 I1_I608_G24_23 I1_I608_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I120_XG_MP0 (VDD I1_I608_P24_23 XI1_I608_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I120_XG_MP1 (XI1_I608_I120_XG_p1 I1_I608_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I122_XG_MP2 (XI1_I608_I122_XG_p1 I1_I608_G26_25 I1_I608_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I122_XG_MP0 (VDD I1_I608_P26_25 XI1_I608_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I122_XG_MP1 (XI1_I608_I122_XG_p1 I1_I608_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I124_XG_MP2 (XI1_I608_I124_XG_p1 I1_I608_G28_27 I1_I608_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I124_XG_MP0 (VDD I1_I608_P28_27 XI1_I608_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I124_XG_MP1 (XI1_I608_I124_XG_p1 I1_I608_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I121_XG_MP2 (XI1_I1482_I121_XG_p1 I1_I1482_G25_24 I1_I1482_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I121_XG_MP0 (VDD I1_I1482_P25_24 XI1_I1482_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I121_XG_MP1 (XI1_I1482_I121_XG_p1 I1_I1482_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I119_XG_MP2 (XI1_I1482_I119_XG_p1 I1_I1482_G23_22 I1_I1482_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I119_XG_MP0 (VDD I1_I1482_P23_22 XI1_I1482_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I119_XG_MP1 (XI1_I1482_I119_XG_p1 I1_I1482_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I117_XG_MP2 (XI1_I1482_I117_XG_p1 I1_I1482_G21_20 I1_I1482_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I117_XG_MP0 (VDD I1_I1482_P21_20 XI1_I1482_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I117_XG_MP1 (XI1_I1482_I117_XG_p1 I1_I1482_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I115_XG_MP2 (XI1_I1482_I115_XG_p1 I1_I1482_G19_18 I1_I1482_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I115_XG_MP0 (VDD I1_I1482_P19_18 XI1_I1482_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I115_XG_MP1 (XI1_I1482_I115_XG_p1 I1_I1482_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I113_XG_MP2 (XI1_I1482_I113_XG_p1 I1_I1482_G17_16 I1_I1482_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I113_XG_MP0 (VDD I1_I1482_P17_16 XI1_I1482_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I113_XG_MP1 (XI1_I1482_I113_XG_p1 I1_I1482_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I111_XG_MP2 (XI1_I1482_I111_XG_p1 I1_I1482_G15_14 I1_I1482_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I111_XG_MP0 (VDD I1_I1482_P15_14 XI1_I1482_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I111_XG_MP1 (XI1_I1482_I111_XG_p1 I1_I1482_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I109_XG_MP2 (XI1_I1482_I109_XG_p1 I1_I1482_G13_12 I1_I1482_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I109_XG_MP0 (VDD I1_I1482_P13_12 XI1_I1482_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I109_XG_MP1 (XI1_I1482_I109_XG_p1 I1_I1482_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I107_XG_MP2 (XI1_I1482_I107_XG_p1 I1_I1482_G11_10 I1_I1482_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I107_XG_MP0 (VDD I1_I1482_P11_10 XI1_I1482_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I107_XG_MP1 (XI1_I1482_I107_XG_p1 I1_I1482_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I105_XG_MP2 (XI1_I1482_I105_XG_p1 I1_I1482_G9_8 I1_I1482_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I105_XG_MP0 (VDD I1_I1482_P9_8 XI1_I1482_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I105_XG_MP1 (XI1_I1482_I105_XG_p1 I1_I1482_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I103_XG_MP2 (XI1_I1482_I103_XG_p1 I1_I1482_G7_6 I1_I1482_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I103_XG_MP0 (VDD I1_I1482_P7_6 XI1_I1482_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I103_XG_MP1 (XI1_I1482_I103_XG_p1 I1_I1482_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I101_XG_MP2 (XI1_I1482_I101_XG_p1 I1_I1482_G5_4 I1_I1482_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I101_XG_MP0 (VDD I1_I1482_P5_4 XI1_I1482_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I101_XG_MP1 (XI1_I1482_I101_XG_p1 I1_I1482_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I99_XG_MP2 (XI1_I1482_I99_XG_p1 I1_I1482_G3_2 I1_I1482_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I99_XG_MP0 (VDD I1_I1482_P3_2 XI1_I1482_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I99_XG_MP1 (XI1_I1482_I99_XG_p1 I1_I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I105_XG_MP2 (XI1_I1114_I105_XG_p1 I1_I1114_G9_8 I1_I1114_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I105_XG_MP0 (VDD I1_I1114_P9_8 XI1_I1114_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I105_XG_MP1 (XI1_I1114_I105_XG_p1 I1_I1114_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I107_XG_MP2 (XI1_I1114_I107_XG_p1 I1_I1114_G11_10 I1_I1114_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I107_XG_MP0 (VDD I1_I1114_P11_10 XI1_I1114_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I107_XG_MP1 (XI1_I1114_I107_XG_p1 I1_I1114_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I108_XG_MP2 (XI1_I1114_I108_XG_p1 I1_I1114_G12_11 I1_I1114_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I108_XG_MP0 (VDD I1_I1114_P12_11 XI1_I1114_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I108_XG_MP1 (XI1_I1114_I108_XG_p1 I1_I1114_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I167_XG_MP2 (XI1_I1114_I167_XG_p1 I1_I1114_G16_9 I1_I1114_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I167_XG_MP0 (VDD I1_I1114_P16_9 XI1_I1114_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I167_XG_MP1 (XI1_I1114_I167_XG_p1 I1_I1114_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I160_XG_MP2 (XI1_I1068_I160_XG_p1 I1_I1068_G10_3 I1_I1068_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I160_XG_MP0 (VDD I1_I1068_P10_3 XI1_I1068_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I160_XG_MP1 (XI1_I1068_I160_XG_p1 I1_I1068_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I112_XG_MP2 (XI1_I1068_I112_XG_p1 I1_I1068_G16_15 I1_I1068_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I112_XG_MP0 (VDD I1_I1068_P16_15 XI1_I1068_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I112_XG_MP1 (XI1_I1068_I112_XG_p1 I1_I1068_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I110_XG_MP2 (XI1_I1068_I110_XG_p1 I1_I1068_G14_13 I1_I1068_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I110_XG_MP0 (VDD I1_I1068_P14_13 XI1_I1068_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I110_XG_MP1 (XI1_I1068_I110_XG_p1 I1_I1068_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I111_XG_MP2 (XI1_I1068_I111_XG_p1 I1_I1068_G15_14 I1_I1068_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I111_XG_MP0 (VDD I1_I1068_P15_14 XI1_I1068_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I111_XG_MP1 (XI1_I1068_I111_XG_p1 I1_I1068_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I173_XG_MP2 (XI1_I1022_I173_XG_p1 I1_I1022_G22_15 I1_I1022_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I173_XG_MP0 (VDD I1_I1022_P22_15 XI1_I1022_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I173_XG_MP1 (XI1_I1022_I173_XG_p1 I1_I1022_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I174_XG_MP2 (XI1_I1022_I174_XG_p1 I1_I1022_G23_16 I1_I1022_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I174_XG_MP0 (VDD I1_I1022_P23_16 XI1_I1022_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I174_XG_MP1 (XI1_I1022_I174_XG_p1 I1_I1022_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I117_XG_MP2 (XI1_I1022_I117_XG_p1 I1_I1022_G21_20 I1_I1022_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I117_XG_MP0 (VDD I1_I1022_P21_20 XI1_I1022_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I117_XG_MP1 (XI1_I1022_I117_XG_p1 I1_I1022_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I115_XG_MP2 (XI1_I1022_I115_XG_p1 I1_I1022_G19_18 I1_I1022_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I115_XG_MP0 (VDD I1_I1022_P19_18 XI1_I1022_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I115_XG_MP1 (XI1_I1022_I115_XG_p1 I1_I1022_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I167_XG_MP2 (XI1_I976_I167_XG_p1 I1_I976_G16_9 I1_I976_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I167_XG_MP0 (VDD I1_I976_P16_9 XI1_I976_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I167_XG_MP1 (XI1_I976_I167_XG_p1 I1_I976_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I100_XG_MP2 (XI1_I976_I100_XG_p1 I1_I976_G4_3 I1_I976_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I100_XG_MP0 (VDD I1_I976_P4_3 XI1_I976_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I100_XG_MP1 (XI1_I976_I100_XG_p1 I1_I976_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I99_XG_MP2 (XI1_I608_I99_XG_p1 I1_I608_G3_2 I1_I608_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I99_XG_MP0 (VDD I1_I608_P3_2 XI1_I608_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I99_XG_MP1 (XI1_I608_I99_XG_p1 I1_I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I101_XG_MP2 (XI1_I608_I101_XG_p1 I1_I608_G5_4 I1_I608_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I101_XG_MP0 (VDD I1_I608_P5_4 XI1_I608_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I101_XG_MP1 (XI1_I608_I101_XG_p1 I1_I608_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I158_XG_MP2 (XI1_I608_I158_XG_p1 I1_I608_G9_2 I1_I608_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I158_XG_MP0 (VDD I1_I608_P9_2 XI1_I608_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I158_XG_MP1 (XI1_I608_I158_XG_p1 I1_I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I168_XG_MP2 (XI1_I608_I168_XG_p1 I1_I608_G17_10 I1_I608_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I168_XG_MP0 (VDD I1_I608_P17_10 XI1_I608_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I168_XG_MP1 (XI1_I608_I168_XG_p1 I1_I608_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I162_XG_MP2 (XI1_I608_I162_XG_p1 I1_I608_G11_4 I1_I608_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I162_XG_MP0 (VDD I1_I608_P11_4 XI1_I608_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I162_XG_MP1 (XI1_I608_I162_XG_p1 I1_I608_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I170_XG_MP2 (XI1_I608_I170_XG_p1 I1_I608_G19_12 I1_I608_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I170_XG_MP0 (VDD I1_I608_P19_12 XI1_I608_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I170_XG_MP1 (XI1_I608_I170_XG_p1 I1_I608_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I164_XG_MP2 (XI1_I608_I164_XG_p1 I1_I608_G13_6 I1_I608_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I164_XG_MP0 (VDD I1_I608_P13_6 XI1_I608_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I164_XG_MP1 (XI1_I608_I164_XG_p1 I1_I608_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I172_XG_MP2 (XI1_I608_I172_XG_p1 I1_I608_G21_14 I1_I608_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I172_XG_MP0 (VDD I1_I608_P21_14 XI1_I608_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I172_XG_MP1 (XI1_I608_I172_XG_p1 I1_I608_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I166_XG_MP2 (XI1_I608_I166_XG_p1 I1_I608_G15_8 I1_I608_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I166_XG_MP0 (VDD I1_I608_P15_8 XI1_I608_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I166_XG_MP1 (XI1_I608_I166_XG_p1 I1_I608_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I174_XG_MP2 (XI1_I608_I174_XG_p1 I1_I608_G23_16 I1_I608_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I174_XG_MP0 (VDD I1_I608_P23_16 XI1_I608_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I174_XG_MP1 (XI1_I608_I174_XG_p1 I1_I608_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I180_XG_MP2 (XI1_I608_I180_XG_p1 I1_I608_G29_22 I1_I608_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I180_XG_MP0 (VDD I1_I608_P29_22 XI1_I608_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I180_XG_MP1 (XI1_I608_I180_XG_p1 I1_I608_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I182_XG_MP2 (XI1_I608_I182_XG_p1 I1_I608_G31_24 I1_I608_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I182_XG_MP0 (VDD I1_I608_P31_24 XI1_I608_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I182_XG_MP1 (XI1_I608_I182_XG_p1 I1_I608_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I127_XG_MP2 (XI1_I608_I127_XG_p1 I1_I608_G31_30 I1_I608_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I127_XG_MP0 (VDD I1_I608_P31_30 XI1_I608_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I127_XG_MP1 (XI1_I608_I127_XG_p1 I1_I608_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I182_XG_MP2 (XI1_I1482_I182_XG_p1 I1_I1482_G31_24 I1_I1482_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I182_XG_MP0 (VDD I1_I1482_P31_24 XI1_I1482_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I182_XG_MP1 (XI1_I1482_I182_XG_p1 I1_I1482_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I174_XG_MP2 (XI1_I1482_I174_XG_p1 I1_I1482_G23_16 I1_I1482_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I174_XG_MP0 (VDD I1_I1482_P23_16 XI1_I1482_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I174_XG_MP1 (XI1_I1482_I174_XG_p1 I1_I1482_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I166_XG_MP2 (XI1_I1482_I166_XG_p1 I1_I1482_G15_8 I1_I1482_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I166_XG_MP0 (VDD I1_I1482_P15_8 XI1_I1482_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I166_XG_MP1 (XI1_I1482_I166_XG_p1 I1_I1482_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I176_XG_MP2 (XI1_I1482_I176_XG_p1 I1_I1482_G25_18 I1_I1482_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I176_XG_MP0 (VDD I1_I1482_P25_18 XI1_I1482_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I176_XG_MP1 (XI1_I1482_I176_XG_p1 I1_I1482_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I172_XG_MP2 (XI1_I1482_I172_XG_p1 I1_I1482_G21_14 I1_I1482_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I172_XG_MP0 (VDD I1_I1482_P21_14 XI1_I1482_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I172_XG_MP1 (XI1_I1482_I172_XG_p1 I1_I1482_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I164_XG_MP2 (XI1_I1482_I164_XG_p1 I1_I1482_G13_6 I1_I1482_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I164_XG_MP0 (VDD I1_I1482_P13_6 XI1_I1482_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I164_XG_MP1 (XI1_I1482_I164_XG_p1 I1_I1482_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I170_XG_MP2 (XI1_I1482_I170_XG_p1 I1_I1482_G19_12 I1_I1482_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I170_XG_MP0 (VDD I1_I1482_P19_12 XI1_I1482_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I170_XG_MP1 (XI1_I1482_I170_XG_p1 I1_I1482_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I162_XG_MP2 (XI1_I1482_I162_XG_p1 I1_I1482_G11_4 I1_I1482_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I162_XG_MP0 (VDD I1_I1482_P11_4 XI1_I1482_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I162_XG_MP1 (XI1_I1482_I162_XG_p1 I1_I1482_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I168_XG_MP2 (XI1_I1482_I168_XG_p1 I1_I1482_G17_10 I1_I1482_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I168_XG_MP0 (VDD I1_I1482_P17_10 XI1_I1482_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I168_XG_MP1 (XI1_I1482_I168_XG_p1 I1_I1482_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I158_XG_MP2 (XI1_I1482_I158_XG_p1 I1_I1482_G9_2 I1_I1482_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I158_XG_MP0 (VDD I1_I1482_P9_2 XI1_I1482_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I158_XG_MP1 (XI1_I1482_I158_XG_p1 I1_I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I102_XG_MP2 (XI1_I1482_I102_XG_p1 I1_I1482_G6_5 I1_I1482_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I102_XG_MP0 (VDD I1_I1482_P6_5 XI1_I1482_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I102_XG_MP1 (XI1_I1482_I102_XG_p1 I1_I1482_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I98_XG_MP2 (XI1_I1482_I98_XG_p1 I1_I1482_G2_1 I1_I1482_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I98_XG_MP0 (VDD I1_I1482_P2_1 XI1_I1482_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I98_XG_MP1 (XI1_I1482_I98_XG_p1 I1_I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I103_XG_MP2 (XI1_I1114_I103_XG_p1 I1_I1114_G7_6 I1_I1114_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I103_XG_MP0 (VDD I1_I1114_P7_6 XI1_I1114_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I103_XG_MP1 (XI1_I1114_I103_XG_p1 I1_I1114_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I99_XG_MP2 (XI1_I1114_I99_XG_p1 I1_I1114_G3_2 I1_I1114_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I99_XG_MP0 (VDD I1_I1114_P3_2 XI1_I1114_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I99_XG_MP1 (XI1_I1114_I99_XG_p1 I1_I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I106_XG_MP2 (XI1_I1114_I106_XG_p1 I1_I1114_G10_9 I1_I1114_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I106_XG_MP0 (VDD I1_I1114_P10_9 XI1_I1114_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I106_XG_MP1 (XI1_I1114_I106_XG_p1 I1_I1114_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I157_XG_MP2 (XI1_I1114_I157_XG_p1 I1_I1114_G8_1 I1_I1114_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I157_XG_MP0 (VDD I1_I1114_P8_1 XI1_I1114_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I157_XG_MP1 (XI1_I1114_I157_XG_p1 I1_I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I175_XG_MP2 (XI1_I1068_I175_XG_p1 I1_I1068_G24_17 I1_I1068_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I175_XG_MP0 (VDD I1_I1068_P24_17 XI1_I1068_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I175_XG_MP1 (XI1_I1068_I175_XG_p1 I1_I1068_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I108_XG_MP2 (XI1_I1068_I108_XG_p1 I1_I1068_G12_11 I1_I1068_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I108_XG_MP0 (VDD I1_I1068_P12_11 XI1_I1068_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I108_XG_MP1 (XI1_I1068_I108_XG_p1 I1_I1068_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I168_XG_MP2 (XI1_I1068_I168_XG_p1 I1_I1068_G17_10 I1_I1068_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I168_XG_MP0 (VDD I1_I1068_P17_10 XI1_I1068_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I168_XG_MP1 (XI1_I1068_I168_XG_p1 I1_I1068_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I107_XG_MP2 (XI1_I1068_I107_XG_p1 I1_I1068_G11_10 I1_I1068_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I107_XG_MP0 (VDD I1_I1068_P11_10 XI1_I1068_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I107_XG_MP1 (XI1_I1068_I107_XG_p1 I1_I1068_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I109_XG_MP2 (XI1_I1068_I109_XG_p1 I1_I1068_G13_12 I1_I1068_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I109_XG_MP0 (VDD I1_I1068_P13_12 XI1_I1068_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I109_XG_MP1 (XI1_I1068_I109_XG_p1 I1_I1068_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I165_XG_MP2 (XI1_I1022_I165_XG_p1 I1_I1022_G14_7 I1_I1022_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I165_XG_MP0 (VDD I1_I1022_P14_7 XI1_I1022_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I165_XG_MP1 (XI1_I1022_I165_XG_p1 I1_I1022_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I114_XG_MP2 (XI1_I1022_I114_XG_p1 I1_I1022_G18_17 I1_I1022_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I114_XG_MP0 (VDD I1_I1022_P18_17 XI1_I1022_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I114_XG_MP1 (XI1_I1022_I114_XG_p1 I1_I1022_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I180_XG_MP2 (XI1_I1022_I180_XG_p1 I1_I1022_G29_22 I1_I1022_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I180_XG_MP0 (VDD I1_I1022_P29_22 XI1_I1022_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I180_XG_MP1 (XI1_I1022_I180_XG_p1 I1_I1022_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I166_XG_MP2 (XI1_I1022_I166_XG_p1 I1_I1022_G15_8 I1_I1022_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I166_XG_MP0 (VDD I1_I1022_P15_8 XI1_I1022_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I166_XG_MP1 (XI1_I1022_I166_XG_p1 I1_I1022_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I178_XG_MP2 (XI1_I1022_I178_XG_p1 I1_I1022_G27_20 I1_I1022_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I178_XG_MP0 (VDD I1_I1022_P27_20 XI1_I1022_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I178_XG_MP1 (XI1_I1022_I178_XG_p1 I1_I1022_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I170_XG_MP2 (XI1_I1022_I170_XG_p1 I1_I1022_G19_12 I1_I1022_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I170_XG_MP0 (VDD I1_I1022_P19_12 XI1_I1022_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I170_XG_MP1 (XI1_I1022_I170_XG_p1 I1_I1022_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I113_XG_MP2 (XI1_I1022_I113_XG_p1 I1_I1022_G17_16 I1_I1022_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I113_XG_MP0 (VDD I1_I1022_P17_16 XI1_I1022_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I113_XG_MP1 (XI1_I1022_I113_XG_p1 I1_I1022_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I157_XG_MP2 (XI1_I976_I157_XG_p1 I1_I976_G8_1 I1_I976_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I157_XG_MP0 (VDD I1_I976_P8_1 XI1_I976_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I157_XG_MP1 (XI1_I976_I157_XG_p1 I1_I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I98_XG_MP2 (XI1_I976_I98_XG_p1 I1_I976_G2_1 I1_I976_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I976_I98_XG_MP0 (VDD I1_I976_P2_1 XI1_I976_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I976_I98_XG_MP1 (XI1_I976_I98_XG_p1 I1_I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I103_XG_MP2 (XI1_I608_I103_XG_p1 I1_I608_G7_6 I1_I608_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I103_XG_MP0 (VDD I1_I608_P7_6 XI1_I608_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I103_XG_MP1 (XI1_I608_I103_XG_p1 I1_I608_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I105_XG_MP2 (XI1_I608_I105_XG_p1 I1_I608_G9_8 I1_I608_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I105_XG_MP0 (VDD I1_I608_P9_8 XI1_I608_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I105_XG_MP1 (XI1_I608_I105_XG_p1 I1_I608_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I107_XG_MP2 (XI1_I608_I107_XG_p1 I1_I608_G11_10 I1_I608_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I107_XG_MP0 (VDD I1_I608_P11_10 XI1_I608_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I107_XG_MP1 (XI1_I608_I107_XG_p1 I1_I608_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I109_XG_MP2 (XI1_I608_I109_XG_p1 I1_I608_G13_12 I1_I608_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I109_XG_MP0 (VDD I1_I608_P13_12 XI1_I608_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I109_XG_MP1 (XI1_I608_I109_XG_p1 I1_I608_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I176_XG_MP2 (XI1_I608_I176_XG_p1 I1_I608_G25_18 I1_I608_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I176_XG_MP0 (VDD I1_I608_P25_18 XI1_I608_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I176_XG_MP1 (XI1_I608_I176_XG_p1 I1_I608_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I178_XG_MP2 (XI1_I608_I178_XG_p1 I1_I608_G27_20 I1_I608_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I178_XG_MP0 (VDD I1_I608_P27_20 XI1_I608_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I178_XG_MP1 (XI1_I608_I178_XG_p1 I1_I608_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I121_XG_MP2 (XI1_I608_I121_XG_p1 I1_I608_G25_24 I1_I608_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I121_XG_MP0 (VDD I1_I608_P25_24 XI1_I608_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I121_XG_MP1 (XI1_I608_I121_XG_p1 I1_I608_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I123_XG_MP2 (XI1_I608_I123_XG_p1 I1_I608_G27_26 I1_I608_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I123_XG_MP0 (VDD I1_I608_P27_26 XI1_I608_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I123_XG_MP1 (XI1_I608_I123_XG_p1 I1_I608_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I125_XG_MP2 (XI1_I608_I125_XG_p1 I1_I608_G29_28 I1_I608_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I125_XG_MP0 (VDD I1_I608_P29_28 XI1_I608_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I125_XG_MP1 (XI1_I608_I125_XG_p1 I1_I608_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I123_XG_MP2 (XI1_I1482_I123_XG_p1 I1_I1482_G27_26 I1_I1482_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I123_XG_MP0 (VDD I1_I1482_P27_26 XI1_I1482_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I123_XG_MP1 (XI1_I1482_I123_XG_p1 I1_I1482_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I180_XG_MP2 (XI1_I1482_I180_XG_p1 I1_I1482_G29_22 I1_I1482_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I180_XG_MP0 (VDD I1_I1482_P29_22 XI1_I1482_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I180_XG_MP1 (XI1_I1482_I180_XG_p1 I1_I1482_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I178_XG_MP2 (XI1_I1482_I178_XG_p1 I1_I1482_G27_20 I1_I1482_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I178_XG_MP0 (VDD I1_I1482_P27_20 XI1_I1482_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I178_XG_MP1 (XI1_I1482_I178_XG_p1 I1_I1482_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I112_XG_MP2 (XI1_I1482_I112_XG_p1 I1_I1482_G16_15 I1_I1482_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I112_XG_MP0 (VDD I1_I1482_P16_15 XI1_I1482_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I112_XG_MP1 (XI1_I1482_I112_XG_p1 I1_I1482_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I110_XG_MP2 (XI1_I1482_I110_XG_p1 I1_I1482_G14_13 I1_I1482_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I110_XG_MP0 (VDD I1_I1482_P14_13 XI1_I1482_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I110_XG_MP1 (XI1_I1482_I110_XG_p1 I1_I1482_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I108_XG_MP2 (XI1_I1482_I108_XG_p1 I1_I1482_G12_11 I1_I1482_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I108_XG_MP0 (VDD I1_I1482_P12_11 XI1_I1482_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I108_XG_MP1 (XI1_I1482_I108_XG_p1 I1_I1482_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I106_XG_MP2 (XI1_I1482_I106_XG_p1 I1_I1482_G10_9 I1_I1482_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I106_XG_MP0 (VDD I1_I1482_P10_9 XI1_I1482_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I106_XG_MP1 (XI1_I1482_I106_XG_p1 I1_I1482_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I104_XG_MP2 (XI1_I1482_I104_XG_p1 I1_I1482_G8_7 I1_I1482_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I104_XG_MP0 (VDD I1_I1482_P8_7 XI1_I1482_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I104_XG_MP1 (XI1_I1482_I104_XG_p1 I1_I1482_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I100_XG_MP2 (XI1_I1482_I100_XG_p1 I1_I1482_G4_3 I1_I1482_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I100_XG_MP0 (VDD I1_I1482_P4_3 XI1_I1482_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I100_XG_MP1 (XI1_I1482_I100_XG_p1 I1_I1482_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I101_XG_MP2 (XI1_I1114_I101_XG_p1 I1_I1114_G5_4 I1_I1114_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I101_XG_MP0 (VDD I1_I1114_P5_4 XI1_I1114_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I101_XG_MP1 (XI1_I1114_I101_XG_p1 I1_I1114_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I104_XG_MP2 (XI1_I1114_I104_XG_p1 I1_I1114_G8_7 I1_I1114_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I104_XG_MP0 (VDD I1_I1114_P8_7 XI1_I1114_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I104_XG_MP1 (XI1_I1114_I104_XG_p1 I1_I1114_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I102_XG_MP2 (XI1_I1114_I102_XG_p1 I1_I1114_G6_5 I1_I1114_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I102_XG_MP0 (VDD I1_I1114_P6_5 XI1_I1114_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I102_XG_MP1 (XI1_I1114_I102_XG_p1 I1_I1114_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I100_XG_MP2 (XI1_I1114_I100_XG_p1 I1_I1114_G4_3 I1_I1114_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I100_XG_MP0 (VDD I1_I1114_P4_3 XI1_I1114_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I100_XG_MP1 (XI1_I1114_I100_XG_p1 I1_I1114_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I98_XG_MP2 (XI1_I1114_I98_XG_p1 I1_I1114_G2_1 I1_I1114_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1114_I98_XG_MP0 (VDD I1_I1114_P2_1 XI1_I1114_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1114_I98_XG_MP1 (XI1_I1114_I98_XG_p1 I1_I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I167_XG_MP2 (XI1_I1068_I167_XG_p1 I1_I1068_G16_9 I1_I1068_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I167_XG_MP0 (VDD I1_I1068_P16_9 XI1_I1068_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I167_XG_MP1 (XI1_I1068_I167_XG_p1 I1_I1068_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I106_XG_MP2 (XI1_I1068_I106_XG_p1 I1_I1068_G10_9 I1_I1068_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I106_XG_MP0 (VDD I1_I1068_P10_9 XI1_I1068_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I106_XG_MP1 (XI1_I1068_I106_XG_p1 I1_I1068_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I158_XG_MP2 (XI1_I1068_I158_XG_p1 I1_I1068_G9_2 I1_I1068_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I158_XG_MP0 (VDD I1_I1068_P9_2 XI1_I1068_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I158_XG_MP1 (XI1_I1068_I158_XG_p1 I1_I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I105_XG_MP2 (XI1_I1068_I105_XG_p1 I1_I1068_G9_8 I1_I1068_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I105_XG_MP0 (VDD I1_I1068_P9_8 XI1_I1068_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I105_XG_MP1 (XI1_I1068_I105_XG_p1 I1_I1068_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I169_XG_MP2 (XI1_I1022_I169_XG_p1 I1_I1022_G18_11 I1_I1022_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I169_XG_MP0 (VDD I1_I1022_P18_11 XI1_I1022_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I169_XG_MP1 (XI1_I1022_I169_XG_p1 I1_I1022_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I177_XG_MP2 (XI1_I1022_I177_XG_p1 I1_I1022_G26_19 I1_I1022_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I177_XG_MP0 (VDD I1_I1022_P26_19 XI1_I1022_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I177_XG_MP1 (XI1_I1022_I177_XG_p1 I1_I1022_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I112_XG_MP2 (XI1_I1022_I112_XG_p1 I1_I1022_G16_15 I1_I1022_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I112_XG_MP0 (VDD I1_I1022_P16_15 XI1_I1022_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I112_XG_MP1 (XI1_I1022_I112_XG_p1 I1_I1022_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I110_XG_MP2 (XI1_I1022_I110_XG_p1 I1_I1022_G14_13 I1_I1022_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I110_XG_MP0 (VDD I1_I1022_P14_13 XI1_I1022_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I110_XG_MP1 (XI1_I1022_I110_XG_p1 I1_I1022_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I162_XG_MP2 (XI1_I1022_I162_XG_p1 I1_I1022_G11_4 I1_I1022_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I162_XG_MP0 (VDD I1_I1022_P11_4 XI1_I1022_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I162_XG_MP1 (XI1_I1022_I162_XG_p1 I1_I1022_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I111_XG_MP2 (XI1_I1022_I111_XG_p1 I1_I1022_G15_14 I1_I1022_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I111_XG_MP0 (VDD I1_I1022_P15_14 XI1_I1022_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I111_XG_MP1 (XI1_I1022_I111_XG_p1 I1_I1022_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I111_XG_MP2 (XI1_I608_I111_XG_p1 I1_I608_G15_14 I1_I608_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I111_XG_MP0 (VDD I1_I608_P15_14 XI1_I608_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I111_XG_MP1 (XI1_I608_I111_XG_p1 I1_I608_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I113_XG_MP2 (XI1_I608_I113_XG_p1 I1_I608_G17_16 I1_I608_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I113_XG_MP0 (VDD I1_I608_P17_16 XI1_I608_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I113_XG_MP1 (XI1_I608_I113_XG_p1 I1_I608_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I115_XG_MP2 (XI1_I608_I115_XG_p1 I1_I608_G19_18 I1_I608_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I115_XG_MP0 (VDD I1_I608_P19_18 XI1_I608_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I115_XG_MP1 (XI1_I608_I115_XG_p1 I1_I608_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I117_XG_MP2 (XI1_I608_I117_XG_p1 I1_I608_G21_20 I1_I608_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I117_XG_MP0 (VDD I1_I608_P21_20 XI1_I608_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I117_XG_MP1 (XI1_I608_I117_XG_p1 I1_I608_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I119_XG_MP2 (XI1_I608_I119_XG_p1 I1_I608_G23_22 I1_I608_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I608_I119_XG_MP0 (VDD I1_I608_P23_22 XI1_I608_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I608_I119_XG_MP1 (XI1_I608_I119_XG_p1 I1_I608_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I125_XG_MP2 (XI1_I1482_I125_XG_p1 I1_I1482_G29_28 I1_I1482_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I125_XG_MP0 (VDD I1_I1482_P29_28 XI1_I1482_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I125_XG_MP1 (XI1_I1482_I125_XG_p1 I1_I1482_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I120_XG_MP2 (XI1_I1482_I120_XG_p1 I1_I1482_G24_23 I1_I1482_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I120_XG_MP0 (VDD I1_I1482_P24_23 XI1_I1482_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I120_XG_MP1 (XI1_I1482_I120_XG_p1 I1_I1482_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I118_XG_MP2 (XI1_I1482_I118_XG_p1 I1_I1482_G22_21 I1_I1482_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I118_XG_MP0 (VDD I1_I1482_P22_21 XI1_I1482_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I118_XG_MP1 (XI1_I1482_I118_XG_p1 I1_I1482_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I116_XG_MP2 (XI1_I1482_I116_XG_p1 I1_I1482_G20_19 I1_I1482_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I116_XG_MP0 (VDD I1_I1482_P20_19 XI1_I1482_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I116_XG_MP1 (XI1_I1482_I116_XG_p1 I1_I1482_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I114_XG_MP2 (XI1_I1482_I114_XG_p1 I1_I1482_G18_17 I1_I1482_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I114_XG_MP0 (VDD I1_I1482_P18_17 XI1_I1482_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I114_XG_MP1 (XI1_I1482_I114_XG_p1 I1_I1482_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I175_XG_MP2 (XI1_I1482_I175_XG_p1 I1_I1482_G24_17 I1_I1482_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I175_XG_MP0 (VDD I1_I1482_P24_17 XI1_I1482_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I175_XG_MP1 (XI1_I1482_I175_XG_p1 I1_I1482_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I167_XG_MP2 (XI1_I1482_I167_XG_p1 I1_I1482_G16_9 I1_I1482_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I167_XG_MP0 (VDD I1_I1482_P16_9 XI1_I1482_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I167_XG_MP1 (XI1_I1482_I167_XG_p1 I1_I1482_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I157_XG_MP2 (XI1_I1482_I157_XG_p1 I1_I1482_G8_1 I1_I1482_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I157_XG_MP0 (VDD I1_I1482_P8_1 XI1_I1482_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I157_XG_MP1 (XI1_I1482_I157_XG_p1 I1_I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I157_XG_MP2 (XI1_I1068_I157_XG_p1 I1_I1068_G8_1 I1_I1068_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I157_XG_MP0 (VDD I1_I1068_P8_1 XI1_I1068_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I157_XG_MP1 (XI1_I1068_I157_XG_p1 I1_I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I104_XG_MP2 (XI1_I1068_I104_XG_p1 I1_I1068_G8_7 I1_I1068_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I104_XG_MP0 (VDD I1_I1068_P8_7 XI1_I1068_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I104_XG_MP1 (XI1_I1068_I104_XG_p1 I1_I1068_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I160_XG_MP2 (XI1_I1022_I160_XG_p1 I1_I1022_G10_3 I1_I1022_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I160_XG_MP0 (VDD I1_I1022_P10_3 XI1_I1022_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I160_XG_MP1 (XI1_I1022_I160_XG_p1 I1_I1022_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I175_XG_MP2 (XI1_I1022_I175_XG_p1 I1_I1022_G24_17 I1_I1022_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I175_XG_MP0 (VDD I1_I1022_P24_17 XI1_I1022_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I175_XG_MP1 (XI1_I1022_I175_XG_p1 I1_I1022_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I108_XG_MP2 (XI1_I1022_I108_XG_p1 I1_I1022_G12_11 I1_I1022_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I108_XG_MP0 (VDD I1_I1022_P12_11 XI1_I1022_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I108_XG_MP1 (XI1_I1022_I108_XG_p1 I1_I1022_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I106_XG_MP2 (XI1_I1022_I106_XG_p1 I1_I1022_G10_9 I1_I1022_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I106_XG_MP0 (VDD I1_I1022_P10_9 XI1_I1022_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I106_XG_MP1 (XI1_I1022_I106_XG_p1 I1_I1022_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I172_XG_MP2 (XI1_I1022_I172_XG_p1 I1_I1022_G21_14 I1_I1022_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I172_XG_MP0 (VDD I1_I1022_P21_14 XI1_I1022_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I172_XG_MP1 (XI1_I1022_I172_XG_p1 I1_I1022_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I176_XG_MP2 (XI1_I1022_I176_XG_p1 I1_I1022_G25_18 I1_I1022_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I176_XG_MP0 (VDD I1_I1022_P25_18 XI1_I1022_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I176_XG_MP1 (XI1_I1022_I176_XG_p1 I1_I1022_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I168_XG_MP2 (XI1_I1022_I168_XG_p1 I1_I1022_G17_10 I1_I1022_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I168_XG_MP0 (VDD I1_I1022_P17_10 XI1_I1022_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I168_XG_MP1 (XI1_I1022_I168_XG_p1 I1_I1022_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I109_XG_MP2 (XI1_I1022_I109_XG_p1 I1_I1022_G13_12 I1_I1022_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I109_XG_MP0 (VDD I1_I1022_P13_12 XI1_I1022_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I109_XG_MP1 (XI1_I1022_I109_XG_p1 I1_I1022_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I107_XG_MP2 (XI1_I1022_I107_XG_p1 I1_I1022_G11_10 I1_I1022_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I107_XG_MP0 (VDD I1_I1022_P11_10 XI1_I1022_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I107_XG_MP1 (XI1_I1022_I107_XG_p1 I1_I1022_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I124_XG_MP2 (XI1_I1482_I124_XG_p1 I1_I1482_G28_27 I1_I1482_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I124_XG_MP0 (VDD I1_I1482_P28_27 XI1_I1482_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I124_XG_MP1 (XI1_I1482_I124_XG_p1 I1_I1482_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I122_XG_MP2 (XI1_I1482_I122_XG_p1 I1_I1482_G26_25 I1_I1482_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I122_XG_MP0 (VDD I1_I1482_P26_25 XI1_I1482_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I122_XG_MP1 (XI1_I1482_I122_XG_p1 I1_I1482_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I179_XG_MP2 (XI1_I1482_I179_XG_p1 I1_I1482_G28_21 I1_I1482_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I179_XG_MP0 (VDD I1_I1482_P28_21 XI1_I1482_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I179_XG_MP1 (XI1_I1482_I179_XG_p1 I1_I1482_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I171_XG_MP2 (XI1_I1482_I171_XG_p1 I1_I1482_G20_13 I1_I1482_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I171_XG_MP0 (VDD I1_I1482_P20_13 XI1_I1482_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I171_XG_MP1 (XI1_I1482_I171_XG_p1 I1_I1482_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I169_XG_MP2 (XI1_I1482_I169_XG_p1 I1_I1482_G18_11 I1_I1482_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I169_XG_MP0 (VDD I1_I1482_P18_11 XI1_I1482_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I169_XG_MP1 (XI1_I1482_I169_XG_p1 I1_I1482_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I163_XG_MP2 (XI1_I1482_I163_XG_p1 I1_I1482_G12_5 I1_I1482_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I163_XG_MP0 (VDD I1_I1482_P12_5 XI1_I1482_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I163_XG_MP1 (XI1_I1482_I163_XG_p1 I1_I1482_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I160_XG_MP2 (XI1_I1482_I160_XG_p1 I1_I1482_G10_3 I1_I1482_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I160_XG_MP0 (VDD I1_I1482_P10_3 XI1_I1482_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I160_XG_MP1 (XI1_I1482_I160_XG_p1 I1_I1482_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I100_XG_MP2 (XI1_I1068_I100_XG_p1 I1_I1068_G4_3 I1_I1068_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I100_XG_MP0 (VDD I1_I1068_P4_3 XI1_I1068_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I100_XG_MP1 (XI1_I1068_I100_XG_p1 I1_I1068_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I102_XG_MP2 (XI1_I1068_I102_XG_p1 I1_I1068_G6_5 I1_I1068_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I102_XG_MP0 (VDD I1_I1068_P6_5 XI1_I1068_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I102_XG_MP1 (XI1_I1068_I102_XG_p1 I1_I1068_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I99_XG_MP2 (XI1_I1068_I99_XG_p1 I1_I1068_G3_2 I1_I1068_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I99_XG_MP0 (VDD I1_I1068_P3_2 XI1_I1068_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I99_XG_MP1 (XI1_I1068_I99_XG_p1 I1_I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I101_XG_MP2 (XI1_I1068_I101_XG_p1 I1_I1068_G5_4 I1_I1068_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I101_XG_MP0 (VDD I1_I1068_P5_4 XI1_I1068_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I101_XG_MP1 (XI1_I1068_I101_XG_p1 I1_I1068_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I103_XG_MP2 (XI1_I1068_I103_XG_p1 I1_I1068_G7_6 I1_I1068_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I103_XG_MP0 (VDD I1_I1068_P7_6 XI1_I1068_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I103_XG_MP1 (XI1_I1068_I103_XG_p1 I1_I1068_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I163_XG_MP2 (XI1_I1022_I163_XG_p1 I1_I1022_G12_5 I1_I1022_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I163_XG_MP0 (VDD I1_I1022_P12_5 XI1_I1022_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I163_XG_MP1 (XI1_I1022_I163_XG_p1 I1_I1022_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I171_XG_MP2 (XI1_I1022_I171_XG_p1 I1_I1022_G20_13 I1_I1022_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I171_XG_MP0 (VDD I1_I1022_P20_13 XI1_I1022_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I171_XG_MP1 (XI1_I1022_I171_XG_p1 I1_I1022_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I104_XG_MP2 (XI1_I1022_I104_XG_p1 I1_I1022_G8_7 I1_I1022_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I104_XG_MP0 (VDD I1_I1022_P8_7 XI1_I1022_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I104_XG_MP1 (XI1_I1022_I104_XG_p1 I1_I1022_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I102_XG_MP2 (XI1_I1022_I102_XG_p1 I1_I1022_G6_5 I1_I1022_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I102_XG_MP0 (VDD I1_I1022_P6_5 XI1_I1022_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I102_XG_MP1 (XI1_I1022_I102_XG_p1 I1_I1022_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I164_XG_MP2 (XI1_I1022_I164_XG_p1 I1_I1022_G13_6 I1_I1022_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I164_XG_MP0 (VDD I1_I1022_P13_6 XI1_I1022_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I164_XG_MP1 (XI1_I1022_I164_XG_p1 I1_I1022_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I158_XG_MP2 (XI1_I1022_I158_XG_p1 I1_I1022_G9_2 I1_I1022_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I158_XG_MP0 (VDD I1_I1022_P9_2 XI1_I1022_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I158_XG_MP1 (XI1_I1022_I158_XG_p1 I1_I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I103_XG_MP2 (XI1_I1022_I103_XG_p1 I1_I1022_G7_6 I1_I1022_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I103_XG_MP0 (VDD I1_I1022_P7_6 XI1_I1022_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I103_XG_MP1 (XI1_I1022_I103_XG_p1 I1_I1022_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I105_XG_MP2 (XI1_I1022_I105_XG_p1 I1_I1022_G9_8 I1_I1022_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I105_XG_MP0 (VDD I1_I1022_P9_8 XI1_I1022_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I105_XG_MP1 (XI1_I1022_I105_XG_p1 I1_I1022_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I127_XG_MP2 (XI1_I1482_I127_XG_p1 I1_I1482_G31_30 I1_I1482_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I127_XG_MP0 (VDD I1_I1482_P31_30 XI1_I1482_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I127_XG_MP1 (XI1_I1482_I127_XG_p1 I1_I1482_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I126_XG_MP2 (XI1_I1482_I126_XG_p1 I1_I1482_G30_29 I1_I1482_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I126_XG_MP0 (VDD I1_I1482_P30_29 XI1_I1482_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I126_XG_MP1 (XI1_I1482_I126_XG_p1 I1_I1482_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I181_XG_MP2 (XI1_I1482_I181_XG_p1 I1_I1482_G30_23 I1_I1482_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I181_XG_MP0 (VDD I1_I1482_P30_23 XI1_I1482_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I181_XG_MP1 (XI1_I1482_I181_XG_p1 I1_I1482_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I173_XG_MP2 (XI1_I1482_I173_XG_p1 I1_I1482_G22_15 I1_I1482_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I173_XG_MP0 (VDD I1_I1482_P22_15 XI1_I1482_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I173_XG_MP1 (XI1_I1482_I173_XG_p1 I1_I1482_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I177_XG_MP2 (XI1_I1482_I177_XG_p1 I1_I1482_G26_19 I1_I1482_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I177_XG_MP0 (VDD I1_I1482_P26_19 XI1_I1482_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I177_XG_MP1 (XI1_I1482_I177_XG_p1 I1_I1482_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I165_XG_MP2 (XI1_I1482_I165_XG_p1 I1_I1482_G14_7 I1_I1482_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1482_I165_XG_MP0 (VDD I1_I1482_P14_7 XI1_I1482_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1482_I165_XG_MP1 (XI1_I1482_I165_XG_p1 I1_I1482_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I114_XG_MP2 (XI1_I1528_I114_XG_p1 I1_I1528_G18_17 I1_I1528_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I114_XG_MP0 (VDD I1_I1528_P18_17 XI1_I1528_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I114_XG_MP1 (XI1_I1528_I114_XG_p1 I1_I1528_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I112_XG_MP2 (XI1_I1528_I112_XG_p1 I1_I1528_G16_15 I1_I1528_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I112_XG_MP0 (VDD I1_I1528_P16_15 XI1_I1528_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I112_XG_MP1 (XI1_I1528_I112_XG_p1 I1_I1528_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I110_XG_MP2 (XI1_I1528_I110_XG_p1 I1_I1528_G14_13 I1_I1528_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I110_XG_MP0 (VDD I1_I1528_P14_13 XI1_I1528_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I110_XG_MP1 (XI1_I1528_I110_XG_p1 I1_I1528_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I108_XG_MP2 (XI1_I1528_I108_XG_p1 I1_I1528_G12_11 I1_I1528_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I108_XG_MP0 (VDD I1_I1528_P12_11 XI1_I1528_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I108_XG_MP1 (XI1_I1528_I108_XG_p1 I1_I1528_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I106_XG_MP2 (XI1_I1528_I106_XG_p1 I1_I1528_G10_9 I1_I1528_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I106_XG_MP0 (VDD I1_I1528_P10_9 XI1_I1528_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I106_XG_MP1 (XI1_I1528_I106_XG_p1 I1_I1528_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I104_XG_MP2 (XI1_I1528_I104_XG_p1 I1_I1528_G8_7 I1_I1528_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I104_XG_MP0 (VDD I1_I1528_P8_7 XI1_I1528_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I104_XG_MP1 (XI1_I1528_I104_XG_p1 I1_I1528_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I102_XG_MP2 (XI1_I1528_I102_XG_p1 I1_I1528_G6_5 I1_I1528_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I102_XG_MP0 (VDD I1_I1528_P6_5 XI1_I1528_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I102_XG_MP1 (XI1_I1528_I102_XG_p1 I1_I1528_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1068_I98_XG_MP2 (XI1_I1068_I98_XG_p1 I1_I1068_G2_1 I1_I1068_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1068_I98_XG_MP0 (VDD I1_I1068_P2_1 XI1_I1068_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1068_I98_XG_MP1 (XI1_I1068_I98_XG_p1 I1_I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I167_XG_MP2 (XI1_I1022_I167_XG_p1 I1_I1022_G16_9 I1_I1022_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I167_XG_MP0 (VDD I1_I1022_P16_9 XI1_I1022_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I167_XG_MP1 (XI1_I1022_I167_XG_p1 I1_I1022_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I157_XG_MP2 (XI1_I1022_I157_XG_p1 I1_I1022_G8_1 I1_I1022_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I157_XG_MP0 (VDD I1_I1022_P8_1 XI1_I1022_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I157_XG_MP1 (XI1_I1022_I157_XG_p1 I1_I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I100_XG_MP2 (XI1_I1022_I100_XG_p1 I1_I1022_G4_3 I1_I1022_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I100_XG_MP0 (VDD I1_I1022_P4_3 XI1_I1022_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I100_XG_MP1 (XI1_I1022_I100_XG_p1 I1_I1022_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I98_XG_MP2 (XI1_I1022_I98_XG_p1 I1_I1022_G2_1 I1_I1022_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I98_XG_MP0 (VDD I1_I1022_P2_1 XI1_I1022_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I98_XG_MP1 (XI1_I1022_I98_XG_p1 I1_I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I99_XG_MP2 (XI1_I1022_I99_XG_p1 I1_I1022_G3_2 I1_I1022_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I99_XG_MP0 (VDD I1_I1022_P3_2 XI1_I1022_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I99_XG_MP1 (XI1_I1022_I99_XG_p1 I1_I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I101_XG_MP2 (XI1_I1022_I101_XG_p1 I1_I1022_G5_4 I1_I1022_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1022_I101_XG_MP0 (VDD I1_I1022_P5_4 XI1_I1022_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1022_I101_XG_MP1 (XI1_I1022_I101_XG_p1 I1_I1022_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2159_MP2 (XI1_I2159_p1 I1_nqk27 I1_nqkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2159_MP0 (VDD I1_sq_b3_5 XI1_I2159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2159_MP1 (XI1_I2159_p1 I1_qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2162_MP2 (XI1_I2162_p1 I1_nqk28 I1_nqkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2162_MP0 (VDD I1_sq_b3_5 XI1_I2162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2162_MP1 (XI1_I2162_p1 I1_qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2165_MP2 (XI1_I2165_p1 I1_nqk29 I1_nqkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2165_MP0 (VDD I1_sq_b3_5 XI1_I2165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2165_MP1 (XI1_I2165_p1 I1_qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2168_MP2 (XI1_I2168_p1 I1_nqk30 I1_nqkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2168_MP0 (VDD I1_sq_b3_5 XI1_I2168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2168_MP1 (XI1_I2168_p1 I1_qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I98_XG_MP2 (XI1_I562_I98_XG_p1 I1_I562_G2_1 I1_I562_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I98_XG_MP0 (VDD I1_I562_P2_1 XI1_I562_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I98_XG_MP1 (XI1_I562_I98_XG_p1 I1_I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I116_XG_MP2 (XI1_I1528_I116_XG_p1 I1_I1528_G20_19 I1_I1528_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I116_XG_MP0 (VDD I1_I1528_P20_19 XI1_I1528_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I116_XG_MP1 (XI1_I1528_I116_XG_p1 I1_I1528_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I175_XG_MP2 (XI1_I1528_I175_XG_p1 I1_I1528_G24_17 I1_I1528_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I175_XG_MP0 (VDD I1_I1528_P24_17 XI1_I1528_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I175_XG_MP1 (XI1_I1528_I175_XG_p1 I1_I1528_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I160_XG_MP2 (XI1_I1528_I160_XG_p1 I1_I1528_G10_3 I1_I1528_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I160_XG_MP0 (VDD I1_I1528_P10_3 XI1_I1528_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I160_XG_MP1 (XI1_I1528_I160_XG_p1 I1_I1528_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I167_XG_MP2 (XI1_I1528_I167_XG_p1 I1_I1528_G16_9 I1_I1528_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I167_XG_MP0 (VDD I1_I1528_P16_9 XI1_I1528_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I167_XG_MP1 (XI1_I1528_I167_XG_p1 I1_I1528_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I157_XG_MP2 (XI1_I1528_I157_XG_p1 I1_I1528_G8_1 I1_I1528_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I157_XG_MP0 (VDD I1_I1528_P8_1 XI1_I1528_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I157_XG_MP1 (XI1_I1528_I157_XG_p1 I1_I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I100_XG_MP2 (XI1_I1528_I100_XG_p1 I1_I1528_G4_3 I1_I1528_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I100_XG_MP0 (VDD I1_I1528_P4_3 XI1_I1528_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I100_XG_MP1 (XI1_I1528_I100_XG_p1 I1_I1528_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I98_XG_MP2 (XI1_I1528_I98_XG_p1 I1_I1528_G2_1 I1_I1528_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I98_XG_MP0 (VDD I1_I1528_P2_1 XI1_I1528_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I98_XG_MP1 (XI1_I1528_I98_XG_p1 I1_I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2120_MP2 (XI1_I2120_p1 I1_nqk14 I1_nqkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2120_MP0 (VDD I1_sq_b3_2 XI1_I2120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2120_MP1 (XI1_I2120_p1 I1_qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2123_MP2 (XI1_I2123_p1 I1_nqk15 I1_nqkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2123_MP0 (VDD I1_sq_b3_2 XI1_I2123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2123_MP1 (XI1_I2123_p1 I1_qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2126_MP2 (XI1_I2126_p1 I1_nqk16 I1_nqkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2126_MP0 (VDD I1_sq_b3_3 XI1_I2126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2126_MP1 (XI1_I2126_p1 I1_qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2129_MP2 (XI1_I2129_p1 I1_nqk17 I1_nqkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2129_MP0 (VDD I1_sq_b3_3 XI1_I2129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2129_MP1 (XI1_I2129_p1 I1_qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2132_MP2 (XI1_I2132_p1 I1_nqk18 I1_nqkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2132_MP0 (VDD I1_sq_b3_3 XI1_I2132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2132_MP1 (XI1_I2132_p1 I1_qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2135_MP2 (XI1_I2135_p1 I1_nqk19 I1_nqkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2135_MP0 (VDD I1_sq_b3_3 XI1_I2135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2135_MP1 (XI1_I2135_p1 I1_qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2138_MP2 (XI1_I2138_p1 I1_nqk20 I1_nqkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2138_MP0 (VDD I1_sq_b3_3 XI1_I2138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2138_MP1 (XI1_I2138_p1 I1_qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2141_MP2 (XI1_I2141_p1 I1_nqk21 I1_nqkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2141_MP0 (VDD I1_sq_b3_3 XI1_I2141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2141_MP1 (XI1_I2141_p1 I1_qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2144_MP2 (XI1_I2144_p1 I1_nqk22 I1_nqkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2144_MP0 (VDD I1_sq_b3_4 XI1_I2144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2144_MP1 (XI1_I2144_p1 I1_qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2147_MP2 (XI1_I2147_p1 I1_nqk23 I1_nqkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2147_MP0 (VDD I1_sq_b3_4 XI1_I2147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2147_MP1 (XI1_I2147_p1 I1_qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2150_MP2 (XI1_I2150_p1 I1_nqk24 I1_nqkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2150_MP0 (VDD I1_sq_b3_4 XI1_I2150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2150_MP1 (XI1_I2150_p1 I1_qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2153_MP2 (XI1_I2153_p1 I1_nqk25 I1_nqkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2153_MP0 (VDD I1_sq_b3_4 XI1_I2153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2153_MP1 (XI1_I2153_p1 I1_qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2156_MP2 (XI1_I2156_p1 I1_nqk26 I1_nqkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2156_MP0 (VDD I1_sq_b3_4 XI1_I2156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2156_MP1 (XI1_I2156_p1 I1_qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I126_MP2 (XI1_I126_p1 I1_nak30 I1_nakn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I126_MP0 (VDD I1_A_31_b3_5 XI1_I126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I126_MP1 (XI1_I126_p1 A_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I123_MP2 (XI1_I123_p1 I1_nak29 I1_nakn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I123_MP0 (VDD I1_A_31_b3_4 XI1_I123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I123_MP1 (XI1_I123_p1 A_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I100_XG_MP2 (XI1_I562_I100_XG_p1 I1_I562_G4_3 I1_I562_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I100_XG_MP0 (VDD I1_I562_P4_3 XI1_I562_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I100_XG_MP1 (XI1_I562_I100_XG_p1 I1_I562_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I102_XG_MP2 (XI1_I562_I102_XG_p1 I1_I562_G6_5 I1_I562_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I102_XG_MP0 (VDD I1_I562_P6_5 XI1_I562_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I102_XG_MP1 (XI1_I562_I102_XG_p1 I1_I562_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I157_XG_MP2 (XI1_I562_I157_XG_p1 I1_I562_G8_1 I1_I562_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I157_XG_MP0 (VDD I1_I562_P8_1 XI1_I562_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I157_XG_MP1 (XI1_I562_I157_XG_p1 I1_I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I167_XG_MP2 (XI1_I562_I167_XG_p1 I1_I562_G16_9 I1_I562_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I167_XG_MP0 (VDD I1_I562_P16_9 XI1_I562_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I167_XG_MP1 (XI1_I562_I167_XG_p1 I1_I562_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I160_XG_MP2 (XI1_I562_I160_XG_p1 I1_I562_G10_3 I1_I562_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I160_XG_MP0 (VDD I1_I562_P10_3 XI1_I562_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I160_XG_MP1 (XI1_I562_I160_XG_p1 I1_I562_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I169_XG_MP2 (XI1_I562_I169_XG_p1 I1_I562_G18_11 I1_I562_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I169_XG_MP0 (VDD I1_I562_P18_11 XI1_I562_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I169_XG_MP1 (XI1_I562_I169_XG_p1 I1_I562_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I163_XG_MP2 (XI1_I562_I163_XG_p1 I1_I562_G12_5 I1_I562_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I163_XG_MP0 (VDD I1_I562_P12_5 XI1_I562_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I163_XG_MP1 (XI1_I562_I163_XG_p1 I1_I562_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I171_XG_MP2 (XI1_I562_I171_XG_p1 I1_I562_G20_13 I1_I562_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I171_XG_MP0 (VDD I1_I562_P20_13 XI1_I562_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I171_XG_MP1 (XI1_I562_I171_XG_p1 I1_I562_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I165_XG_MP2 (XI1_I562_I165_XG_p1 I1_I562_G14_7 I1_I562_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I165_XG_MP0 (VDD I1_I562_P14_7 XI1_I562_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I165_XG_MP1 (XI1_I562_I165_XG_p1 I1_I562_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I173_XG_MP2 (XI1_I562_I173_XG_p1 I1_I562_G22_15 I1_I562_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I173_XG_MP0 (VDD I1_I562_P22_15 XI1_I562_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I173_XG_MP1 (XI1_I562_I173_XG_p1 I1_I562_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I120_XG_MP2 (XI1_I1528_I120_XG_p1 I1_I1528_G24_23 I1_I1528_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I120_XG_MP0 (VDD I1_I1528_P24_23 XI1_I1528_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I120_XG_MP1 (XI1_I1528_I120_XG_p1 I1_I1528_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I118_XG_MP2 (XI1_I1528_I118_XG_p1 I1_I1528_G22_21 I1_I1528_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I118_XG_MP0 (VDD I1_I1528_P22_21 XI1_I1528_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I118_XG_MP1 (XI1_I1528_I118_XG_p1 I1_I1528_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I173_XG_MP2 (XI1_I1528_I173_XG_p1 I1_I1528_G22_15 I1_I1528_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I173_XG_MP0 (VDD I1_I1528_P22_15 XI1_I1528_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I173_XG_MP1 (XI1_I1528_I173_XG_p1 I1_I1528_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I165_XG_MP2 (XI1_I1528_I165_XG_p1 I1_I1528_G14_7 I1_I1528_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I165_XG_MP0 (VDD I1_I1528_P14_7 XI1_I1528_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I165_XG_MP1 (XI1_I1528_I165_XG_p1 I1_I1528_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I177_XG_MP2 (XI1_I1528_I177_XG_p1 I1_I1528_G26_19 I1_I1528_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I177_XG_MP0 (VDD I1_I1528_P26_19 XI1_I1528_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I177_XG_MP1 (XI1_I1528_I177_XG_p1 I1_I1528_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I171_XG_MP2 (XI1_I1528_I171_XG_p1 I1_I1528_G20_13 I1_I1528_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I171_XG_MP0 (VDD I1_I1528_P20_13 XI1_I1528_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I171_XG_MP1 (XI1_I1528_I171_XG_p1 I1_I1528_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I163_XG_MP2 (XI1_I1528_I163_XG_p1 I1_I1528_G12_5 I1_I1528_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I163_XG_MP0 (VDD I1_I1528_P12_5 XI1_I1528_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I163_XG_MP1 (XI1_I1528_I163_XG_p1 I1_I1528_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I169_XG_MP2 (XI1_I1528_I169_XG_p1 I1_I1528_G18_11 I1_I1528_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I169_XG_MP0 (VDD I1_I1528_P18_11 XI1_I1528_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I169_XG_MP1 (XI1_I1528_I169_XG_p1 I1_I1528_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I90_MP2 (XI1_I90_p1 I1_nak18 I1_nakn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I90_MP0 (VDD I1_A_31_b3_3 XI1_I90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I90_MP1 (XI1_I90_p1 A_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I93_MP2 (XI1_I93_p1 I1_nak19 I1_nakn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I93_MP0 (VDD I1_A_31_b3_3 XI1_I93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I93_MP1 (XI1_I93_p1 A_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I96_MP2 (XI1_I96_p1 I1_nak20 I1_nakn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I96_MP0 (VDD I1_A_31_b3_3 XI1_I96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I96_MP1 (XI1_I96_p1 A_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I505_MP2 (XI1_I505_p1 I1_nbk29 I1_nbkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I505_MP0 (VDD I1_B_31_b3_5 XI1_I505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I505_MP1 (XI1_I505_p1 B_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I492_MP2 (XI1_I492_p1 I1_nbk28 I1_nbkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I492_MP0 (VDD I1_B_31_b3_4 XI1_I492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I492_MP1 (XI1_I492_p1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I99_MP2 (XI1_I99_p1 I1_nak21 I1_nakn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I99_MP0 (VDD I1_A_31_b3_3 XI1_I99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I99_MP1 (XI1_I99_p1 A_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I102_MP2 (XI1_I102_p1 I1_nak22 I1_nakn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I102_MP0 (VDD I1_A_31_b3_3 XI1_I102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I102_MP1 (XI1_I102_p1 A_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I105_MP2 (XI1_I105_p1 I1_nak23 I1_nakn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I105_MP0 (VDD I1_A_31_b3_3 XI1_I105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I105_MP1 (XI1_I105_p1 A_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I108_MP2 (XI1_I108_p1 I1_nak24 I1_nakn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I108_MP0 (VDD I1_A_31_b3_4 XI1_I108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I108_MP1 (XI1_I108_p1 A_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I111_MP2 (XI1_I111_p1 I1_nak25 I1_nakn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I111_MP0 (VDD I1_A_31_b3_4 XI1_I111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I111_MP1 (XI1_I111_p1 A_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I120_MP2 (XI1_I120_p1 I1_nak28 I1_nakn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I120_MP0 (VDD I1_A_31_b3_4 XI1_I120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I120_MP1 (XI1_I120_p1 A_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I104_XG_MP2 (XI1_I562_I104_XG_p1 I1_I562_G8_7 I1_I562_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I104_XG_MP0 (VDD I1_I562_P8_7 XI1_I562_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I104_XG_MP1 (XI1_I562_I104_XG_p1 I1_I562_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I106_XG_MP2 (XI1_I562_I106_XG_p1 I1_I562_G10_9 I1_I562_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I106_XG_MP0 (VDD I1_I562_P10_9 XI1_I562_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I106_XG_MP1 (XI1_I562_I106_XG_p1 I1_I562_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I108_XG_MP2 (XI1_I562_I108_XG_p1 I1_I562_G12_11 I1_I562_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I108_XG_MP0 (VDD I1_I562_P12_11 XI1_I562_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I108_XG_MP1 (XI1_I562_I108_XG_p1 I1_I562_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I110_XG_MP2 (XI1_I562_I110_XG_p1 I1_I562_G14_13 I1_I562_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I110_XG_MP0 (VDD I1_I562_P14_13 XI1_I562_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I110_XG_MP1 (XI1_I562_I110_XG_p1 I1_I562_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I175_XG_MP2 (XI1_I562_I175_XG_p1 I1_I562_G24_17 I1_I562_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I175_XG_MP0 (VDD I1_I562_P24_17 XI1_I562_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I175_XG_MP1 (XI1_I562_I175_XG_p1 I1_I562_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I177_XG_MP2 (XI1_I562_I177_XG_p1 I1_I562_G26_19 I1_I562_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I177_XG_MP0 (VDD I1_I562_P26_19 XI1_I562_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I177_XG_MP1 (XI1_I562_I177_XG_p1 I1_I562_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I179_XG_MP2 (XI1_I562_I179_XG_p1 I1_I562_G28_21 I1_I562_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I179_XG_MP0 (VDD I1_I562_P28_21 XI1_I562_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I179_XG_MP1 (XI1_I562_I179_XG_p1 I1_I562_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I181_XG_MP2 (XI1_I562_I181_XG_p1 I1_I562_G30_23 I1_I562_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I181_XG_MP0 (VDD I1_I562_P30_23 XI1_I562_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I181_XG_MP1 (XI1_I562_I181_XG_p1 I1_I562_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I126_XG_MP2 (XI1_I562_I126_XG_p1 I1_I562_G30_29 I1_I562_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I126_XG_MP0 (VDD I1_I562_P30_29 XI1_I562_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I126_XG_MP1 (XI1_I562_I126_XG_p1 I1_I562_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I126_XG_MP2 (XI1_I1528_I126_XG_p1 I1_I1528_G30_29 I1_I1528_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I126_XG_MP0 (VDD I1_I1528_P30_29 XI1_I1528_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I126_XG_MP1 (XI1_I1528_I126_XG_p1 I1_I1528_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I124_XG_MP2 (XI1_I1528_I124_XG_p1 I1_I1528_G28_27 I1_I1528_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I124_XG_MP0 (VDD I1_I1528_P28_27 XI1_I1528_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I124_XG_MP1 (XI1_I1528_I124_XG_p1 I1_I1528_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I122_XG_MP2 (XI1_I1528_I122_XG_p1 I1_I1528_G26_25 I1_I1528_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I122_XG_MP0 (VDD I1_I1528_P26_25 XI1_I1528_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I122_XG_MP1 (XI1_I1528_I122_XG_p1 I1_I1528_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I115_XG_MP2 (XI1_I1528_I115_XG_p1 I1_I1528_G19_18 I1_I1528_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I115_XG_MP0 (VDD I1_I1528_P19_18 XI1_I1528_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I115_XG_MP1 (XI1_I1528_I115_XG_p1 I1_I1528_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I181_XG_MP2 (XI1_I1528_I181_XG_p1 I1_I1528_G30_23 I1_I1528_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I181_XG_MP0 (VDD I1_I1528_P30_23 XI1_I1528_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I181_XG_MP1 (XI1_I1528_I181_XG_p1 I1_I1528_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I179_XG_MP2 (XI1_I1528_I179_XG_p1 I1_I1528_G28_21 I1_I1528_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I179_XG_MP0 (VDD I1_I1528_P28_21 XI1_I1528_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I179_XG_MP1 (XI1_I1528_I179_XG_p1 I1_I1528_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I105_XG_MP2 (XI1_I1528_I105_XG_p1 I1_I1528_G9_8 I1_I1528_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I105_XG_MP0 (VDD I1_I1528_P9_8 XI1_I1528_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I105_XG_MP1 (XI1_I1528_I105_XG_p1 I1_I1528_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I103_XG_MP2 (XI1_I1528_I103_XG_p1 I1_I1528_G7_6 I1_I1528_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I103_XG_MP0 (VDD I1_I1528_P7_6 XI1_I1528_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I103_XG_MP1 (XI1_I1528_I103_XG_p1 I1_I1528_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I101_XG_MP2 (XI1_I1528_I101_XG_p1 I1_I1528_G5_4 I1_I1528_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I101_XG_MP0 (VDD I1_I1528_P5_4 XI1_I1528_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I101_XG_MP1 (XI1_I1528_I101_XG_p1 I1_I1528_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I99_XG_MP2 (XI1_I1528_I99_XG_p1 I1_I1528_G3_2 I1_I1528_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I99_XG_MP0 (VDD I1_I1528_P3_2 XI1_I1528_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I99_XG_MP1 (XI1_I1528_I99_XG_p1 I1_I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I109_XG_MP2 (XI1_I1574_I109_XG_p1 I1_I1574_G13_12 I1_I1574_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I109_XG_MP0 (VDD I1_I1574_P13_12 XI1_I1574_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I109_XG_MP1 (XI1_I1574_I109_XG_p1 I1_I1574_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I75_MP2 (XI1_I75_p1 I1_nak13 I1_nakn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I75_MP0 (VDD I1_A_31_b3_2 XI1_I75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I75_MP1 (XI1_I75_p1 A_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I78_MP2 (XI1_I78_p1 I1_nak14 I1_nakn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I78_MP0 (VDD I1_A_31_b3_2 XI1_I78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I78_MP1 (XI1_I78_p1 A_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2117_MP2 (XI1_I2117_p1 I1_nqk13 I1_nqkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2117_MP0 (VDD I1_sq_b3_2 XI1_I2117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2117_MP1 (XI1_I2117_p1 I1_qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I81_MP2 (XI1_I81_p1 I1_nak15 I1_nakn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I81_MP0 (VDD I1_A_31_b3_2 XI1_I81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I81_MP1 (XI1_I81_p1 A_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I84_MP2 (XI1_I84_p1 I1_nak16 I1_nakn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I84_MP0 (VDD I1_A_31_b3_2 XI1_I84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I84_MP1 (XI1_I84_p1 A_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I310_MP2 (XI1_I310_p1 I1_nbk14 I1_nbkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I310_MP0 (VDD I1_B_31_b3_2 XI1_I310_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I310_MP1 (XI1_I310_p1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I87_MP2 (XI1_I87_p1 I1_nak17 I1_nakn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I87_MP0 (VDD I1_A_31_b3_2 XI1_I87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I87_MP1 (XI1_I87_p1 A_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I375_MP2 (XI1_I375_p1 I1_nbk19 I1_nbkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I375_MP0 (VDD I1_B_31_b3_3 XI1_I375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I375_MP1 (XI1_I375_p1 B_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I388_MP2 (XI1_I388_p1 I1_nbk20 I1_nbkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I388_MP0 (VDD I1_B_31_b3_3 XI1_I388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I388_MP1 (XI1_I388_p1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I401_MP2 (XI1_I401_p1 I1_nbk21 I1_nbkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I401_MP0 (VDD I1_B_31_b3_3 XI1_I401_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I401_MP1 (XI1_I401_p1 B_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I414_MP2 (XI1_I414_p1 I1_nbk22 I1_nbkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I414_MP0 (VDD I1_B_31_b3_3 XI1_I414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I414_MP1 (XI1_I414_p1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I427_MP2 (XI1_I427_p1 I1_nbk23 I1_nbkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I427_MP0 (VDD I1_B_31_b3_4 XI1_I427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I427_MP1 (XI1_I427_p1 B_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I518_MP2 (XI1_I518_p1 I1_nbk30 I1_nbkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I518_MP0 (VDD I1_B_31_b3_5 XI1_I518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I518_MP1 (XI1_I518_p1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I479_MP2 (XI1_I479_p1 I1_nbk27 I1_nbkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I479_MP0 (VDD I1_B_31_b3_4 XI1_I479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I479_MP1 (XI1_I479_p1 B_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I114_MP2 (XI1_I114_p1 I1_nak26 I1_nakn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I114_MP0 (VDD I1_A_31_b3_4 XI1_I114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I114_MP1 (XI1_I114_p1 A_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I117_MP2 (XI1_I117_p1 I1_nak27 I1_nakn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I117_MP0 (VDD I1_A_31_b3_4 XI1_I117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I117_MP1 (XI1_I117_p1 A_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I112_XG_MP2 (XI1_I562_I112_XG_p1 I1_I562_G16_15 I1_I562_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I112_XG_MP0 (VDD I1_I562_P16_15 XI1_I562_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I112_XG_MP1 (XI1_I562_I112_XG_p1 I1_I562_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I114_XG_MP2 (XI1_I562_I114_XG_p1 I1_I562_G18_17 I1_I562_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I114_XG_MP0 (VDD I1_I562_P18_17 XI1_I562_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I114_XG_MP1 (XI1_I562_I114_XG_p1 I1_I562_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I116_XG_MP2 (XI1_I562_I116_XG_p1 I1_I562_G20_19 I1_I562_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I116_XG_MP0 (VDD I1_I562_P20_19 XI1_I562_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I116_XG_MP1 (XI1_I562_I116_XG_p1 I1_I562_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I118_XG_MP2 (XI1_I562_I118_XG_p1 I1_I562_G22_21 I1_I562_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I118_XG_MP0 (VDD I1_I562_P22_21 XI1_I562_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I118_XG_MP1 (XI1_I562_I118_XG_p1 I1_I562_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I120_XG_MP2 (XI1_I562_I120_XG_p1 I1_I562_G24_23 I1_I562_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I120_XG_MP0 (VDD I1_I562_P24_23 XI1_I562_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I120_XG_MP1 (XI1_I562_I120_XG_p1 I1_I562_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I122_XG_MP2 (XI1_I562_I122_XG_p1 I1_I562_G26_25 I1_I562_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I122_XG_MP0 (VDD I1_I562_P26_25 XI1_I562_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I122_XG_MP1 (XI1_I562_I122_XG_p1 I1_I562_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I124_XG_MP2 (XI1_I562_I124_XG_p1 I1_I562_G28_27 I1_I562_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I124_XG_MP0 (VDD I1_I562_P28_27 XI1_I562_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I124_XG_MP1 (XI1_I562_I124_XG_p1 I1_I562_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I178_XG_MP2 (XI1_I1712_I178_XG_p1 I1_I1712_G27_20 I1_I1712_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I178_XG_MP0 (VDD I1_I1712_P27_20 XI1_I1712_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I178_XG_MP1 (XI1_I1712_I178_XG_p1 I1_I1712_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I174_XG_MP2 (XI1_I1712_I174_XG_p1 I1_I1712_G23_16 I1_I1712_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I174_XG_MP0 (VDD I1_I1712_P23_16 XI1_I1712_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I174_XG_MP1 (XI1_I1712_I174_XG_p1 I1_I1712_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I127_XG_MP2 (XI1_I1528_I127_XG_p1 I1_I1528_G31_30 I1_I1528_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I127_XG_MP0 (VDD I1_I1528_P31_30 XI1_I1528_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I127_XG_MP1 (XI1_I1528_I127_XG_p1 I1_I1528_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I125_XG_MP2 (XI1_I1528_I125_XG_p1 I1_I1528_G29_28 I1_I1528_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I125_XG_MP0 (VDD I1_I1528_P29_28 XI1_I1528_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I125_XG_MP1 (XI1_I1528_I125_XG_p1 I1_I1528_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I123_XG_MP2 (XI1_I1528_I123_XG_p1 I1_I1528_G27_26 I1_I1528_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I123_XG_MP0 (VDD I1_I1528_P27_26 XI1_I1528_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I123_XG_MP1 (XI1_I1528_I123_XG_p1 I1_I1528_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I121_XG_MP2 (XI1_I1528_I121_XG_p1 I1_I1528_G25_24 I1_I1528_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I121_XG_MP0 (VDD I1_I1528_P25_24 XI1_I1528_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I121_XG_MP1 (XI1_I1528_I121_XG_p1 I1_I1528_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I119_XG_MP2 (XI1_I1528_I119_XG_p1 I1_I1528_G23_22 I1_I1528_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I119_XG_MP0 (VDD I1_I1528_P23_22 XI1_I1528_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I119_XG_MP1 (XI1_I1528_I119_XG_p1 I1_I1528_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I117_XG_MP2 (XI1_I1528_I117_XG_p1 I1_I1528_G21_20 I1_I1528_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I117_XG_MP0 (VDD I1_I1528_P21_20 XI1_I1528_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I117_XG_MP1 (XI1_I1528_I117_XG_p1 I1_I1528_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I113_XG_MP2 (XI1_I1528_I113_XG_p1 I1_I1528_G17_16 I1_I1528_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I113_XG_MP0 (VDD I1_I1528_P17_16 XI1_I1528_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I113_XG_MP1 (XI1_I1528_I113_XG_p1 I1_I1528_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I111_XG_MP2 (XI1_I1528_I111_XG_p1 I1_I1528_G15_14 I1_I1528_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I111_XG_MP0 (VDD I1_I1528_P15_14 XI1_I1528_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I111_XG_MP1 (XI1_I1528_I111_XG_p1 I1_I1528_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I109_XG_MP2 (XI1_I1528_I109_XG_p1 I1_I1528_G13_12 I1_I1528_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I109_XG_MP0 (VDD I1_I1528_P13_12 XI1_I1528_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I109_XG_MP1 (XI1_I1528_I109_XG_p1 I1_I1528_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I107_XG_MP2 (XI1_I1528_I107_XG_p1 I1_I1528_G11_10 I1_I1528_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I107_XG_MP0 (VDD I1_I1528_P11_10 XI1_I1528_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I107_XG_MP1 (XI1_I1528_I107_XG_p1 I1_I1528_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I158_XG_MP2 (XI1_I1528_I158_XG_p1 I1_I1528_G9_2 I1_I1528_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I158_XG_MP0 (VDD I1_I1528_P9_2 XI1_I1528_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I158_XG_MP1 (XI1_I1528_I158_XG_p1 I1_I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I170_XG_MP2 (XI1_I1574_I170_XG_p1 I1_I1574_G19_12 I1_I1574_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I170_XG_MP0 (VDD I1_I1574_P19_12 XI1_I1574_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I170_XG_MP1 (XI1_I1574_I170_XG_p1 I1_I1574_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I111_XG_MP2 (XI1_I1574_I111_XG_p1 I1_I1574_G15_14 I1_I1574_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I111_XG_MP0 (VDD I1_I1574_P15_14 XI1_I1574_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I111_XG_MP1 (XI1_I1574_I111_XG_p1 I1_I1574_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I162_XG_MP2 (XI1_I1574_I162_XG_p1 I1_I1574_G11_4 I1_I1574_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I162_XG_MP0 (VDD I1_I1574_P11_4 XI1_I1574_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I162_XG_MP1 (XI1_I1574_I162_XG_p1 I1_I1574_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I107_XG_MP2 (XI1_I1574_I107_XG_p1 I1_I1574_G11_10 I1_I1574_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I107_XG_MP0 (VDD I1_I1574_P11_10 XI1_I1574_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I107_XG_MP1 (XI1_I1574_I107_XG_p1 I1_I1574_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I105_XG_MP2 (XI1_I1574_I105_XG_p1 I1_I1574_G9_8 I1_I1574_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I105_XG_MP0 (VDD I1_I1574_P9_8 XI1_I1574_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I105_XG_MP1 (XI1_I1574_I105_XG_p1 I1_I1574_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I72_MP2 (XI1_I72_p1 I1_nak12 I1_nakn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I72_MP0 (VDD I1_A_31_b3_2 XI1_I72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I72_MP1 (XI1_I72_p1 A_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2114_MP2 (XI1_I2114_p1 I1_nqk12 I1_nqkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2114_MP0 (VDD I1_sq_b3_2 XI1_I2114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2114_MP1 (XI1_I2114_p1 I1_qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2111_MP2 (XI1_I2111_p1 I1_nqk11 I1_nqkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2111_MP0 (VDD I1_sq_b3_2 XI1_I2111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2111_MP1 (XI1_I2111_p1 I1_qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I245_MP2 (XI1_I245_p1 I1_nbk9 I1_nbkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I245_MP0 (VDD I1_B_31_b3_1 XI1_I245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I245_MP1 (XI1_I245_p1 B_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I258_MP2 (XI1_I258_p1 I1_nbk10 I1_nbkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I258_MP0 (VDD I1_B_31_b3_1 XI1_I258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I258_MP1 (XI1_I258_p1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I271_MP2 (XI1_I271_p1 I1_nbk11 I1_nbkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I271_MP0 (VDD I1_B_31_b3_1 XI1_I271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I271_MP1 (XI1_I271_p1 B_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I180_MP2 (XI1_I180_p1 I1_nbk4 I1_nbkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I180_MP0 (VDD I1_B_31_b3_0 XI1_I180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I180_MP1 (XI1_I180_p1 B_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I284_MP2 (XI1_I284_p1 I1_nbk12 I1_nbkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I284_MP0 (VDD I1_B_31_b3_2 XI1_I284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I284_MP1 (XI1_I284_p1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I297_MP2 (XI1_I297_p1 I1_nbk13 I1_nbkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I297_MP0 (VDD I1_B_31_b3_2 XI1_I297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I297_MP1 (XI1_I297_p1 B_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I323_MP2 (XI1_I323_p1 I1_nbk15 I1_nbkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I323_MP0 (VDD I1_B_31_b3_2 XI1_I323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I323_MP1 (XI1_I323_p1 B_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I336_MP2 (XI1_I336_p1 I1_nbk16 I1_nbkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I336_MP0 (VDD I1_B_31_b3_2 XI1_I336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I336_MP1 (XI1_I336_p1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I349_MP2 (XI1_I349_p1 I1_nbk17 I1_nbkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I349_MP0 (VDD I1_B_31_b3_3 XI1_I349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I349_MP1 (XI1_I349_p1 B_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I362_MP2 (XI1_I362_p1 I1_nbk18 I1_nbkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I362_MP0 (VDD I1_B_31_b3_3 XI1_I362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I362_MP1 (XI1_I362_p1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I308_MP2 (XI2_I3_I308_p1 I2_I3_o18_2 I2_I3_q18_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I308_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I308_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I308_MP1 (XI2_I3_I308_p1 I2_S_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I320_MP2 (XI2_I3_I320_p1 I2_I3_o19_2 I2_I3_q19_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I320_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I320_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I320_MP1 (XI2_I3_I320_p1 I2_S_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I332_MP2 (XI2_I3_I332_p1 I2_I3_o20_2 I2_I3_q20_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I332_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I332_MP1 (XI2_I3_I332_p1 I2_S_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I344_MP2 (XI2_I3_I344_p1 I2_I3_o21_2 I2_I3_q21_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I344_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I344_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I344_MP1 (XI2_I3_I344_p1 I2_S_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I440_MP2 (XI1_I440_p1 I1_nbk24 I1_nbkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I440_MP0 (VDD I1_B_31_b3_4 XI1_I440_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I440_MP1 (XI1_I440_p1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I453_MP2 (XI1_I453_p1 I1_nbk25 I1_nbkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I453_MP0 (VDD I1_B_31_b3_4 XI1_I453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I453_MP1 (XI1_I453_p1 B_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I466_MP2 (XI1_I466_p1 I1_nbk26 I1_nbkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I466_MP0 (VDD I1_B_31_b3_4 XI1_I466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I466_MP1 (XI1_I466_p1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I99_XG_MP2 (XI1_I562_I99_XG_p1 I1_I562_G3_2 I1_I562_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I99_XG_MP0 (VDD I1_I562_P3_2 XI1_I562_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I99_XG_MP1 (XI1_I562_I99_XG_p1 I1_I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I101_XG_MP2 (XI1_I562_I101_XG_p1 I1_I562_G5_4 I1_I562_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I101_XG_MP0 (VDD I1_I562_P5_4 XI1_I562_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I101_XG_MP1 (XI1_I562_I101_XG_p1 I1_I562_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I103_XG_MP2 (XI1_I562_I103_XG_p1 I1_I562_G7_6 I1_I562_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I103_XG_MP0 (VDD I1_I562_P7_6 XI1_I562_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I103_XG_MP1 (XI1_I562_I103_XG_p1 I1_I562_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I105_XG_MP2 (XI1_I562_I105_XG_p1 I1_I562_G9_8 I1_I562_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I105_XG_MP0 (VDD I1_I562_P9_8 XI1_I562_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I105_XG_MP1 (XI1_I562_I105_XG_p1 I1_I562_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I107_XG_MP2 (XI1_I562_I107_XG_p1 I1_I562_G11_10 I1_I562_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I107_XG_MP0 (VDD I1_I562_P11_10 XI1_I562_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I107_XG_MP1 (XI1_I562_I107_XG_p1 I1_I562_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I182_XG_MP2 (XI1_I1712_I182_XG_p1 I1_I1712_G31_24 I1_I1712_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I182_XG_MP0 (VDD I1_I1712_P31_24 XI1_I1712_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I182_XG_MP1 (XI1_I1712_I182_XG_p1 I1_I1712_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I166_XG_MP2 (XI1_I1712_I166_XG_p1 I1_I1712_G15_8 I1_I1712_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I166_XG_MP0 (VDD I1_I1712_P15_8 XI1_I1712_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I166_XG_MP1 (XI1_I1712_I166_XG_p1 I1_I1712_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I170_XG_MP2 (XI1_I1712_I170_XG_p1 I1_I1712_G19_12 I1_I1712_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I170_XG_MP0 (VDD I1_I1712_P19_12 XI1_I1712_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I170_XG_MP1 (XI1_I1712_I170_XG_p1 I1_I1712_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I162_XG_MP2 (XI1_I1712_I162_XG_p1 I1_I1712_G11_4 I1_I1712_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I162_XG_MP0 (VDD I1_I1712_P11_4 XI1_I1712_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I162_XG_MP1 (XI1_I1712_I162_XG_p1 I1_I1712_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I182_XG_MP2 (XI1_I1528_I182_XG_p1 I1_I1528_G31_24 I1_I1528_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I182_XG_MP0 (VDD I1_I1528_P31_24 XI1_I1528_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I182_XG_MP1 (XI1_I1528_I182_XG_p1 I1_I1528_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I166_XG_MP2 (XI1_I1528_I166_XG_p1 I1_I1528_G15_8 I1_I1528_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I166_XG_MP0 (VDD I1_I1528_P15_8 XI1_I1528_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I166_XG_MP1 (XI1_I1528_I166_XG_p1 I1_I1528_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I178_XG_MP2 (XI1_I1528_I178_XG_p1 I1_I1528_G27_20 I1_I1528_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I178_XG_MP0 (VDD I1_I1528_P27_20 XI1_I1528_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I178_XG_MP1 (XI1_I1528_I178_XG_p1 I1_I1528_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I180_XG_MP2 (XI1_I1528_I180_XG_p1 I1_I1528_G29_22 I1_I1528_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I180_XG_MP0 (VDD I1_I1528_P29_22 XI1_I1528_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I180_XG_MP1 (XI1_I1528_I180_XG_p1 I1_I1528_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I176_XG_MP2 (XI1_I1528_I176_XG_p1 I1_I1528_G25_18 I1_I1528_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I176_XG_MP0 (VDD I1_I1528_P25_18 XI1_I1528_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I176_XG_MP1 (XI1_I1528_I176_XG_p1 I1_I1528_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I164_XG_MP2 (XI1_I1528_I164_XG_p1 I1_I1528_G13_6 I1_I1528_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I164_XG_MP0 (VDD I1_I1528_P13_6 XI1_I1528_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I164_XG_MP1 (XI1_I1528_I164_XG_p1 I1_I1528_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I170_XG_MP2 (XI1_I1528_I170_XG_p1 I1_I1528_G19_12 I1_I1528_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I170_XG_MP0 (VDD I1_I1528_P19_12 XI1_I1528_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I170_XG_MP1 (XI1_I1528_I170_XG_p1 I1_I1528_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I162_XG_MP2 (XI1_I1528_I162_XG_p1 I1_I1528_G11_4 I1_I1528_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I162_XG_MP0 (VDD I1_I1528_P11_4 XI1_I1528_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I162_XG_MP1 (XI1_I1528_I162_XG_p1 I1_I1528_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I168_XG_MP2 (XI1_I1528_I168_XG_p1 I1_I1528_G17_10 I1_I1528_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I168_XG_MP0 (VDD I1_I1528_P17_10 XI1_I1528_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I168_XG_MP1 (XI1_I1528_I168_XG_p1 I1_I1528_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I178_XG_MP2 (XI1_I1574_I178_XG_p1 I1_I1574_G27_20 I1_I1574_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I178_XG_MP0 (VDD I1_I1574_P27_20 XI1_I1574_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I178_XG_MP1 (XI1_I1574_I178_XG_p1 I1_I1574_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I174_XG_MP2 (XI1_I1574_I174_XG_p1 I1_I1574_G23_16 I1_I1574_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I174_XG_MP0 (VDD I1_I1574_P23_16 XI1_I1574_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I174_XG_MP1 (XI1_I1574_I174_XG_p1 I1_I1574_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I166_XG_MP2 (XI1_I1574_I166_XG_p1 I1_I1574_G15_8 I1_I1574_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I166_XG_MP0 (VDD I1_I1574_P15_8 XI1_I1574_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I166_XG_MP1 (XI1_I1574_I166_XG_p1 I1_I1574_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I103_XG_MP2 (XI1_I1574_I103_XG_p1 I1_I1574_G7_6 I1_I1574_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I103_XG_MP0 (VDD I1_I1574_P7_6 XI1_I1574_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I103_XG_MP1 (XI1_I1574_I103_XG_p1 I1_I1574_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I232_MP2 (XI1_I232_p1 I1_nbk8 I1_nbkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I232_MP0 (VDD I1_B_31_b3_1 XI1_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I232_MP1 (XI1_I232_p1 B_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I219_MP2 (XI1_I219_p1 I1_nbk7 I1_nbkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I219_MP0 (VDD I1_B_31_b3_1 XI1_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I219_MP1 (XI1_I219_p1 B_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I206_MP2 (XI1_I206_p1 I1_nbk6 I1_nbkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I206_MP0 (VDD I1_B_31_b3_1 XI1_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I206_MP1 (XI1_I206_p1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I193_MP2 (XI1_I193_p1 I1_nbk5 I1_nbkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I193_MP0 (VDD I1_B_31_b3_0 XI1_I193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I193_MP1 (XI1_I193_p1 B_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I167_MP2 (XI1_I167_p1 I1_nbk3 I1_nbkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I167_MP0 (VDD I1_B_31_b3_0 XI1_I167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I167_MP1 (XI1_I167_p1 B_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I154_MP2 (XI1_I154_p1 I1_nbk2 I1_nbkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I154_MP0 (VDD I1_B_31_b3_0 XI1_I154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I154_MP1 (XI1_I154_p1 B_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I141_MP2 (XI1_I141_p1 I1_nbk1 I1_nbkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I141_MP0 (VDD I1_B_31_b3_0 XI1_I141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I141_MP1 (XI1_I141_p1 B_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I296_MP2 (XI2_I3_I296_p1 I2_I3_o17_2 I2_I3_q17_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I296_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I296_MP1 (XI2_I3_I296_p1 I2_S_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I368_MP2 (XI2_I3_I368_p1 I2_I3_o23_2 I2_I3_q23_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I368_MP0 (VDD I2_I3_SEL_AS_b3_4 XI2_I3_I368_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I368_MP1 (XI2_I3_I368_p1 I2_S_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I356_MP2 (XI2_I3_I356_p1 I2_I3_o22_2 I2_I3_q22_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I356_MP0 (VDD I2_I3_SEL_AS_b3_4 XI2_I3_I356_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I356_MP1 (XI2_I3_I356_p1 I2_S_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I158_XG_MP2 (XI1_I562_I158_XG_p1 I1_I562_G9_2 I1_I562_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I158_XG_MP0 (VDD I1_I562_P9_2 XI1_I562_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I158_XG_MP1 (XI1_I562_I158_XG_p1 I1_I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I168_XG_MP2 (XI1_I562_I168_XG_p1 I1_I562_G17_10 I1_I562_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I168_XG_MP0 (VDD I1_I562_P17_10 XI1_I562_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I168_XG_MP1 (XI1_I562_I168_XG_p1 I1_I562_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I109_XG_MP2 (XI1_I562_I109_XG_p1 I1_I562_G13_12 I1_I562_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I109_XG_MP0 (VDD I1_I562_P13_12 XI1_I562_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I109_XG_MP1 (XI1_I562_I109_XG_p1 I1_I562_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I164_XG_MP2 (XI1_I562_I164_XG_p1 I1_I562_G13_6 I1_I562_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I164_XG_MP0 (VDD I1_I562_P13_6 XI1_I562_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I164_XG_MP1 (XI1_I562_I164_XG_p1 I1_I562_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I111_XG_MP2 (XI1_I562_I111_XG_p1 I1_I562_G15_14 I1_I562_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I111_XG_MP0 (VDD I1_I562_P15_14 XI1_I562_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I111_XG_MP1 (XI1_I562_I111_XG_p1 I1_I562_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I113_XG_MP2 (XI1_I562_I113_XG_p1 I1_I562_G17_16 I1_I562_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I113_XG_MP0 (VDD I1_I562_P17_16 XI1_I562_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I113_XG_MP1 (XI1_I562_I113_XG_p1 I1_I562_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I115_XG_MP2 (XI1_I562_I115_XG_p1 I1_I562_G19_18 I1_I562_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I115_XG_MP0 (VDD I1_I562_P19_18 XI1_I562_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I115_XG_MP1 (XI1_I562_I115_XG_p1 I1_I562_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I117_XG_MP2 (XI1_I562_I117_XG_p1 I1_I562_G21_20 I1_I562_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I117_XG_MP0 (VDD I1_I562_P21_20 XI1_I562_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I117_XG_MP1 (XI1_I562_I117_XG_p1 I1_I562_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I119_XG_MP2 (XI1_I562_I119_XG_p1 I1_I562_G23_22 I1_I562_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I119_XG_MP0 (VDD I1_I562_P23_22 XI1_I562_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I119_XG_MP1 (XI1_I562_I119_XG_p1 I1_I562_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I121_XG_MP2 (XI1_I562_I121_XG_p1 I1_I562_G25_24 I1_I562_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I121_XG_MP0 (VDD I1_I562_P25_24 XI1_I562_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I121_XG_MP1 (XI1_I562_I121_XG_p1 I1_I562_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I127_XG_MP2 (XI1_I1712_I127_XG_p1 I1_I1712_G31_30 I1_I1712_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I127_XG_MP0 (VDD I1_I1712_P31_30 XI1_I1712_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I127_XG_MP1 (XI1_I1712_I127_XG_p1 I1_I1712_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I176_XG_MP2 (XI1_I1712_I176_XG_p1 I1_I1712_G25_18 I1_I1712_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I176_XG_MP0 (VDD I1_I1712_P25_18 XI1_I1712_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I176_XG_MP1 (XI1_I1712_I176_XG_p1 I1_I1712_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I174_XG_MP2 (XI1_I1528_I174_XG_p1 I1_I1528_G23_16 I1_I1528_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I174_XG_MP0 (VDD I1_I1528_P23_16 XI1_I1528_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I174_XG_MP1 (XI1_I1528_I174_XG_p1 I1_I1528_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I172_XG_MP2 (XI1_I1528_I172_XG_p1 I1_I1528_G21_14 I1_I1528_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I172_XG_MP0 (VDD I1_I1528_P21_14 XI1_I1528_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I172_XG_MP1 (XI1_I1528_I172_XG_p1 I1_I1528_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I127_XG_MP2 (XI1_I1574_I127_XG_p1 I1_I1574_G31_30 I1_I1574_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I127_XG_MP0 (VDD I1_I1574_P31_30 XI1_I1574_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I127_XG_MP1 (XI1_I1574_I127_XG_p1 I1_I1574_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I182_XG_MP2 (XI1_I1574_I182_XG_p1 I1_I1574_G31_24 I1_I1574_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I182_XG_MP0 (VDD I1_I1574_P31_24 XI1_I1574_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I182_XG_MP1 (XI1_I1574_I182_XG_p1 I1_I1574_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I115_XG_MP2 (XI1_I1574_I115_XG_p1 I1_I1574_G19_18 I1_I1574_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I115_XG_MP0 (VDD I1_I1574_P19_18 XI1_I1574_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I115_XG_MP1 (XI1_I1574_I115_XG_p1 I1_I1574_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I113_XG_MP2 (XI1_I1574_I113_XG_p1 I1_I1574_G17_16 I1_I1574_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I113_XG_MP0 (VDD I1_I1574_P17_16 XI1_I1574_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I113_XG_MP1 (XI1_I1574_I113_XG_p1 I1_I1574_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I172_XG_MP2 (XI1_I1574_I172_XG_p1 I1_I1574_G21_14 I1_I1574_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I172_XG_MP0 (VDD I1_I1574_P21_14 XI1_I1574_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I172_XG_MP1 (XI1_I1574_I172_XG_p1 I1_I1574_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I164_XG_MP2 (XI1_I1574_I164_XG_p1 I1_I1574_G13_6 I1_I1574_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I164_XG_MP0 (VDD I1_I1574_P13_6 XI1_I1574_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I164_XG_MP1 (XI1_I1574_I164_XG_p1 I1_I1574_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I168_XG_MP2 (XI1_I1574_I168_XG_p1 I1_I1574_G17_10 I1_I1574_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I168_XG_MP0 (VDD I1_I1574_P17_10 XI1_I1574_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I168_XG_MP1 (XI1_I1574_I168_XG_p1 I1_I1574_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I101_XG_MP2 (XI1_I1574_I101_XG_p1 I1_I1574_G5_4 I1_I1574_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I101_XG_MP0 (VDD I1_I1574_P5_4 XI1_I1574_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I101_XG_MP1 (XI1_I1574_I101_XG_p1 I1_I1574_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I69_MP2 (XI1_I69_p1 I1_nak11 I1_nakn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I69_MP0 (VDD I1_A_31_b3_1 XI1_I69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I69_MP1 (XI1_I69_p1 A_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I66_MP2 (XI1_I66_p1 I1_nak10 I1_nakn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I66_MP0 (VDD I1_A_31_b3_1 XI1_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I66_MP1 (XI1_I66_p1 A_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I112_XG_MP2 (XI2_I1_I42_I112_XG_p1 I2_I1_I42_G16_15 I2_I1_I42_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I112_XG_MP0 (VDD I2_I1_I42_P16_15 XI2_I1_I42_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I112_XG_MP1 (XI2_I1_I42_I112_XG_p1 I2_I1_I42_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I114_XG_MP2 (XI2_I1_I42_I114_XG_p1 I2_I1_I42_G18_17 I2_I1_I42_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I114_XG_MP0 (VDD I2_I1_I42_P18_17 XI2_I1_I42_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I114_XG_MP1 (XI2_I1_I42_I114_XG_p1 I2_I1_I42_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I116_XG_MP2 (XI2_I1_I42_I116_XG_p1 I2_I1_I42_G20_19 I2_I1_I42_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I116_XG_MP0 (VDD I2_I1_I42_P20_19 XI2_I1_I42_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I116_XG_MP1 (XI2_I1_I42_I116_XG_p1 I2_I1_I42_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I118_XG_MP2 (XI2_I1_I42_I118_XG_p1 I2_I1_I42_G22_21 I2_I1_I42_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I118_XG_MP0 (VDD I2_I1_I42_P22_21 XI2_I1_I42_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I118_XG_MP1 (XI2_I1_I42_I118_XG_p1 I2_I1_I42_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I284_MP2 (XI2_I3_I284_p1 I2_I3_o16_2 I2_I3_q16_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I284_MP0 (VDD I2_I3_SEL_AS_b3_3 XI2_I3_I284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I284_MP1 (XI2_I3_I284_p1 I2_S_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I176_XG_MP2 (XI1_I562_I176_XG_p1 I1_I562_G25_18 I1_I562_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I176_XG_MP0 (VDD I1_I562_P25_18 XI1_I562_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I176_XG_MP1 (XI1_I562_I176_XG_p1 I1_I562_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I172_XG_MP2 (XI1_I562_I172_XG_p1 I1_I562_G21_14 I1_I562_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I172_XG_MP0 (VDD I1_I562_P21_14 XI1_I562_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I172_XG_MP1 (XI1_I562_I172_XG_p1 I1_I562_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I180_XG_MP2 (XI1_I562_I180_XG_p1 I1_I562_G29_22 I1_I562_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I180_XG_MP0 (VDD I1_I562_P29_22 XI1_I562_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I180_XG_MP1 (XI1_I562_I180_XG_p1 I1_I562_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I123_XG_MP2 (XI1_I562_I123_XG_p1 I1_I562_G27_26 I1_I562_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I123_XG_MP0 (VDD I1_I562_P27_26 XI1_I562_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I123_XG_MP1 (XI1_I562_I123_XG_p1 I1_I562_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I125_XG_MP2 (XI1_I562_I125_XG_p1 I1_I562_G29_28 I1_I562_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I125_XG_MP0 (VDD I1_I562_P29_28 XI1_I562_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I125_XG_MP1 (XI1_I562_I125_XG_p1 I1_I562_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I127_XG_MP2 (XI1_I562_I127_XG_p1 I1_I562_G31_30 I1_I562_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I127_XG_MP0 (VDD I1_I562_P31_30 XI1_I562_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I127_XG_MP1 (XI1_I562_I127_XG_p1 I1_I562_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I121_XG_MP2 (XI1_I1712_I121_XG_p1 I1_I1712_G25_24 I1_I1712_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I121_XG_MP0 (VDD I1_I1712_P25_24 XI1_I1712_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I121_XG_MP1 (XI1_I1712_I121_XG_p1 I1_I1712_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I180_XG_MP2 (XI1_I1712_I180_XG_p1 I1_I1712_G29_22 I1_I1712_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I180_XG_MP0 (VDD I1_I1712_P29_22 XI1_I1712_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I180_XG_MP1 (XI1_I1712_I180_XG_p1 I1_I1712_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I119_XG_MP2 (XI1_I1712_I119_XG_p1 I1_I1712_G23_22 I1_I1712_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I119_XG_MP0 (VDD I1_I1712_P23_22 XI1_I1712_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I119_XG_MP1 (XI1_I1712_I119_XG_p1 I1_I1712_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I172_XG_MP2 (XI1_I1712_I172_XG_p1 I1_I1712_G21_14 I1_I1712_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I172_XG_MP0 (VDD I1_I1712_P21_14 XI1_I1712_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I172_XG_MP1 (XI1_I1712_I172_XG_p1 I1_I1712_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I164_XG_MP2 (XI1_I1712_I164_XG_p1 I1_I1712_G13_6 I1_I1712_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I164_XG_MP0 (VDD I1_I1712_P13_6 XI1_I1712_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I164_XG_MP1 (XI1_I1712_I164_XG_p1 I1_I1712_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I109_XG_MP2 (XI1_I1712_I109_XG_p1 I1_I1712_G13_12 I1_I1712_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I109_XG_MP0 (VDD I1_I1712_P13_12 XI1_I1712_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I109_XG_MP1 (XI1_I1712_I109_XG_p1 I1_I1712_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I168_XG_MP2 (XI1_I1712_I168_XG_p1 I1_I1712_G17_10 I1_I1712_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I168_XG_MP0 (VDD I1_I1712_P17_10 XI1_I1712_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I168_XG_MP1 (XI1_I1712_I168_XG_p1 I1_I1712_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I158_XG_MP2 (XI1_I1712_I158_XG_p1 I1_I1712_G9_2 I1_I1712_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I158_XG_MP0 (VDD I1_I1712_P9_2 XI1_I1712_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I158_XG_MP1 (XI1_I1712_I158_XG_p1 I1_I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I107_XG_MP2 (XI1_I1712_I107_XG_p1 I1_I1712_G11_10 I1_I1712_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I107_XG_MP0 (VDD I1_I1712_P11_10 XI1_I1712_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I107_XG_MP1 (XI1_I1712_I107_XG_p1 I1_I1712_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I105_XG_MP2 (XI1_I1712_I105_XG_p1 I1_I1712_G9_8 I1_I1712_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I105_XG_MP0 (VDD I1_I1712_P9_8 XI1_I1712_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I105_XG_MP1 (XI1_I1712_I105_XG_p1 I1_I1712_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I103_XG_MP2 (XI1_I1712_I103_XG_p1 I1_I1712_G7_6 I1_I1712_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I103_XG_MP0 (VDD I1_I1712_P7_6 XI1_I1712_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I103_XG_MP1 (XI1_I1712_I103_XG_p1 I1_I1712_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I101_XG_MP2 (XI1_I1712_I101_XG_p1 I1_I1712_G5_4 I1_I1712_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I101_XG_MP0 (VDD I1_I1712_P5_4 XI1_I1712_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I101_XG_MP1 (XI1_I1712_I101_XG_p1 I1_I1712_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I99_XG_MP2 (XI1_I1712_I99_XG_p1 I1_I1712_G3_2 I1_I1712_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I99_XG_MP0 (VDD I1_I1712_P3_2 XI1_I1712_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I99_XG_MP1 (XI1_I1712_I99_XG_p1 I1_I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I125_XG_MP2 (XI1_I1574_I125_XG_p1 I1_I1574_G29_28 I1_I1574_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I125_XG_MP0 (VDD I1_I1574_P29_28 XI1_I1574_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I125_XG_MP1 (XI1_I1574_I125_XG_p1 I1_I1574_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I121_XG_MP2 (XI1_I1574_I121_XG_p1 I1_I1574_G25_24 I1_I1574_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I121_XG_MP0 (VDD I1_I1574_P25_24 XI1_I1574_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I121_XG_MP1 (XI1_I1574_I121_XG_p1 I1_I1574_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I180_XG_MP2 (XI1_I1574_I180_XG_p1 I1_I1574_G29_22 I1_I1574_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I180_XG_MP0 (VDD I1_I1574_P29_22 XI1_I1574_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I180_XG_MP1 (XI1_I1574_I180_XG_p1 I1_I1574_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I117_XG_MP2 (XI1_I1574_I117_XG_p1 I1_I1574_G21_20 I1_I1574_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I117_XG_MP0 (VDD I1_I1574_P21_20 XI1_I1574_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I117_XG_MP1 (XI1_I1574_I117_XG_p1 I1_I1574_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I176_XG_MP2 (XI1_I1574_I176_XG_p1 I1_I1574_G25_18 I1_I1574_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I176_XG_MP0 (VDD I1_I1574_P25_18 XI1_I1574_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I176_XG_MP1 (XI1_I1574_I176_XG_p1 I1_I1574_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I158_XG_MP2 (XI1_I1574_I158_XG_p1 I1_I1574_G9_2 I1_I1574_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I158_XG_MP0 (VDD I1_I1574_P9_2 XI1_I1574_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I158_XG_MP1 (XI1_I1574_I158_XG_p1 I1_I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I99_XG_MP2 (XI1_I1574_I99_XG_p1 I1_I1574_G3_2 I1_I1574_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I99_XG_MP0 (VDD I1_I1574_P3_2 XI1_I1574_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I99_XG_MP1 (XI1_I1574_I99_XG_p1 I1_I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I248_MP2 (XI2_I3_I248_p1 I2_I3_o13_2 I2_I3_q13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I248_MP0 (VDD I2_I3_SEL_AS_b3_2 XI2_I3_I248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I248_MP1 (XI2_I3_I248_p1 I2_S_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I163_XG_MP2 (XI2_I1_I42_I163_XG_p1 I2_I1_I42_G12_5 I2_I1_I42_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I163_XG_MP0 (VDD I2_I1_I42_P12_5 XI2_I1_I42_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I163_XG_MP1 (XI2_I1_I42_I163_XG_p1 I2_I1_I42_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I110_XG_MP2 (XI2_I1_I42_I110_XG_p1 I2_I1_I42_G14_13 I2_I1_I42_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I110_XG_MP0 (VDD I2_I1_I42_P14_13 XI2_I1_I42_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I110_XG_MP1 (XI2_I1_I42_I110_XG_p1 I2_I1_I42_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I171_XG_MP2 (XI2_I1_I42_I171_XG_p1 I2_I1_I42_G20_13 I2_I1_I42_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I171_XG_MP0 (VDD I2_I1_I42_P20_13 XI2_I1_I42_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I171_XG_MP1 (XI2_I1_I42_I171_XG_p1 I2_I1_I42_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I179_XG_MP2 (XI2_I1_I42_I179_XG_p1 I2_I1_I42_G28_21 I2_I1_I42_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I179_XG_MP0 (VDD I2_I1_I42_P28_21 XI2_I1_I42_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I179_XG_MP1 (XI2_I1_I42_I179_XG_p1 I2_I1_I42_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I120_XG_MP2 (XI2_I1_I42_I120_XG_p1 I2_I1_I42_G24_23 I2_I1_I42_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I120_XG_MP0 (VDD I2_I1_I42_P24_23 XI2_I1_I42_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I120_XG_MP1 (XI2_I1_I42_I120_XG_p1 I2_I1_I42_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I122_XG_MP2 (XI2_I1_I42_I122_XG_p1 I2_I1_I42_G26_25 I2_I1_I42_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I122_XG_MP0 (VDD I2_I1_I42_P26_25 XI2_I1_I42_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I122_XG_MP1 (XI2_I1_I42_I122_XG_p1 I2_I1_I42_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I124_XG_MP2 (XI2_I1_I42_I124_XG_p1 I2_I1_I42_G28_27 I2_I1_I42_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I124_XG_MP0 (VDD I2_I1_I42_P28_27 XI2_I1_I42_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I124_XG_MP1 (XI2_I1_I42_I124_XG_p1 I2_I1_I42_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I392_MP2 (XI2_I3_I392_p1 I2_I3_o25_2 I2_I3_q25_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I392_MP0 (VDD I2_I3_SEL_AS_b3_4 XI2_I3_I392_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I392_MP1 (XI2_I3_I392_p1 I2_S_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I440_MP2 (XI2_I3_I440_p1 I2_I3_o29_2 I2_I3_q29_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I440_MP0 (VDD I2_I3_SEL_AS_b3_5 XI2_I3_I440_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I440_MP1 (XI2_I3_I440_p1 I2_S_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I162_XG_MP2 (XI1_I562_I162_XG_p1 I1_I562_G11_4 I1_I562_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I162_XG_MP0 (VDD I1_I562_P11_4 XI1_I562_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I162_XG_MP1 (XI1_I562_I162_XG_p1 I1_I562_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I170_XG_MP2 (XI1_I562_I170_XG_p1 I1_I562_G19_12 I1_I562_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I170_XG_MP0 (VDD I1_I562_P19_12 XI1_I562_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I170_XG_MP1 (XI1_I562_I170_XG_p1 I1_I562_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I166_XG_MP2 (XI1_I562_I166_XG_p1 I1_I562_G15_8 I1_I562_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I166_XG_MP0 (VDD I1_I562_P15_8 XI1_I562_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I166_XG_MP1 (XI1_I562_I166_XG_p1 I1_I562_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I178_XG_MP2 (XI1_I562_I178_XG_p1 I1_I562_G27_20 I1_I562_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I178_XG_MP0 (VDD I1_I562_P27_20 XI1_I562_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I178_XG_MP1 (XI1_I562_I178_XG_p1 I1_I562_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I174_XG_MP2 (XI1_I562_I174_XG_p1 I1_I562_G23_16 I1_I562_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I174_XG_MP0 (VDD I1_I562_P23_16 XI1_I562_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I174_XG_MP1 (XI1_I562_I174_XG_p1 I1_I562_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I182_XG_MP2 (XI1_I562_I182_XG_p1 I1_I562_G31_24 I1_I562_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I182_XG_MP0 (VDD I1_I562_P31_24 XI1_I562_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I182_XG_MP1 (XI1_I562_I182_XG_p1 I1_I562_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I117_XG_MP2 (XI1_I1712_I117_XG_p1 I1_I1712_G21_20 I1_I1712_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I117_XG_MP0 (VDD I1_I1712_P21_20 XI1_I1712_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I117_XG_MP1 (XI1_I1712_I117_XG_p1 I1_I1712_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I179_XG_MP2 (XI1_I1712_I179_XG_p1 I1_I1712_G28_21 I1_I1712_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I179_XG_MP0 (VDD I1_I1712_P28_21 XI1_I1712_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I179_XG_MP1 (XI1_I1712_I179_XG_p1 I1_I1712_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I115_XG_MP2 (XI1_I1712_I115_XG_p1 I1_I1712_G19_18 I1_I1712_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I115_XG_MP0 (VDD I1_I1712_P19_18 XI1_I1712_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I115_XG_MP1 (XI1_I1712_I115_XG_p1 I1_I1712_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I171_XG_MP2 (XI1_I1712_I171_XG_p1 I1_I1712_G20_13 I1_I1712_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I171_XG_MP0 (VDD I1_I1712_P20_13 XI1_I1712_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I171_XG_MP1 (XI1_I1712_I171_XG_p1 I1_I1712_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I113_XG_MP2 (XI1_I1712_I113_XG_p1 I1_I1712_G17_16 I1_I1712_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I113_XG_MP0 (VDD I1_I1712_P17_16 XI1_I1712_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I113_XG_MP1 (XI1_I1712_I113_XG_p1 I1_I1712_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I111_XG_MP2 (XI1_I1712_I111_XG_p1 I1_I1712_G15_14 I1_I1712_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I111_XG_MP0 (VDD I1_I1712_P15_14 XI1_I1712_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I111_XG_MP1 (XI1_I1712_I111_XG_p1 I1_I1712_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I163_XG_MP2 (XI1_I1712_I163_XG_p1 I1_I1712_G12_5 I1_I1712_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I163_XG_MP0 (VDD I1_I1712_P12_5 XI1_I1712_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I163_XG_MP1 (XI1_I1712_I163_XG_p1 I1_I1712_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I123_XG_MP2 (XI1_I1574_I123_XG_p1 I1_I1574_G27_26 I1_I1574_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I123_XG_MP0 (VDD I1_I1574_P27_26 XI1_I1574_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I123_XG_MP1 (XI1_I1574_I123_XG_p1 I1_I1574_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I119_XG_MP2 (XI1_I1574_I119_XG_p1 I1_I1574_G23_22 I1_I1574_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I119_XG_MP0 (VDD I1_I1574_P23_22 XI1_I1574_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I119_XG_MP1 (XI1_I1574_I119_XG_p1 I1_I1574_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I112_XG_MP2 (XI1_I1574_I112_XG_p1 I1_I1574_G16_15 I1_I1574_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I112_XG_MP0 (VDD I1_I1574_P16_15 XI1_I1574_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I112_XG_MP1 (XI1_I1574_I112_XG_p1 I1_I1574_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I110_XG_MP2 (XI1_I1574_I110_XG_p1 I1_I1574_G14_13 I1_I1574_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I110_XG_MP0 (VDD I1_I1574_P14_13 XI1_I1574_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I110_XG_MP1 (XI1_I1574_I110_XG_p1 I1_I1574_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I108_XG_MP2 (XI1_I1574_I108_XG_p1 I1_I1574_G12_11 I1_I1574_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I108_XG_MP0 (VDD I1_I1574_P12_11 XI1_I1574_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I108_XG_MP1 (XI1_I1574_I108_XG_p1 I1_I1574_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I106_XG_MP2 (XI1_I1574_I106_XG_p1 I1_I1574_G10_9 I1_I1574_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I106_XG_MP0 (VDD I1_I1574_P10_9 XI1_I1574_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I106_XG_MP1 (XI1_I1574_I106_XG_p1 I1_I1574_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I104_XG_MP2 (XI1_I1574_I104_XG_p1 I1_I1574_G8_7 I1_I1574_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I104_XG_MP0 (VDD I1_I1574_P8_7 XI1_I1574_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I104_XG_MP1 (XI1_I1574_I104_XG_p1 I1_I1574_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I102_XG_MP2 (XI1_I1574_I102_XG_p1 I1_I1574_G6_5 I1_I1574_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I102_XG_MP0 (VDD I1_I1574_P6_5 XI1_I1574_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I102_XG_MP1 (XI1_I1574_I102_XG_p1 I1_I1574_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I260_MP2 (XI2_I3_I260_p1 I2_I3_o14_2 I2_I3_q14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I260_MP0 (VDD I2_I3_SEL_AS_b3_2 XI2_I3_I260_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I260_MP1 (XI2_I3_I260_p1 I2_S_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I272_MP2 (XI2_I3_I272_p1 I2_I3_o15_2 I2_I3_q15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I272_MP0 (VDD I2_I3_SEL_AS_b3_2 XI2_I3_I272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I3_I272_MP1 (XI2_I3_I272_p1 I2_S_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I165_XG_MP2 (XI2_I1_I42_I165_XG_p1 I2_I1_I42_G14_7 I2_I1_I42_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I165_XG_MP0 (VDD I2_I1_I42_P14_7 XI2_I1_I42_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I165_XG_MP1 (XI2_I1_I42_I165_XG_p1 I2_I1_I42_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I113_XG_MP2 (XI2_I1_I42_I113_XG_p1 I2_I1_I42_G17_16 I2_I1_I42_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I113_XG_MP0 (VDD I2_I1_I42_P17_16 XI2_I1_I42_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I113_XG_MP1 (XI2_I1_I42_I113_XG_p1 I2_I1_I42_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I173_XG_MP2 (XI2_I1_I42_I173_XG_p1 I2_I1_I42_G22_15 I2_I1_I42_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I173_XG_MP0 (VDD I2_I1_I42_P22_15 XI2_I1_I42_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I173_XG_MP1 (XI2_I1_I42_I173_XG_p1 I2_I1_I42_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I177_XG_MP2 (XI2_I1_I42_I177_XG_p1 I2_I1_I42_G26_19 I2_I1_I42_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I177_XG_MP0 (VDD I2_I1_I42_P26_19 XI2_I1_I42_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I177_XG_MP1 (XI2_I1_I42_I177_XG_p1 I2_I1_I42_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I115_XG_MP2 (XI2_I1_I42_I115_XG_p1 I2_I1_I42_G19_18 I2_I1_I42_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I115_XG_MP0 (VDD I2_I1_I42_P19_18 XI2_I1_I42_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I115_XG_MP1 (XI2_I1_I42_I115_XG_p1 I2_I1_I42_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I117_XG_MP2 (XI2_I1_I42_I117_XG_p1 I2_I1_I42_G21_20 I2_I1_I42_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I117_XG_MP0 (VDD I2_I1_I42_P21_20 XI2_I1_I42_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I117_XG_MP1 (XI2_I1_I42_I117_XG_p1 I2_I1_I42_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I181_XG_MP2 (XI2_I1_I42_I181_XG_p1 I2_I1_I42_G30_23 I2_I1_I42_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I181_XG_MP0 (VDD I2_I1_I42_P30_23 XI2_I1_I42_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I181_XG_MP1 (XI2_I1_I42_I181_XG_p1 I2_I1_I42_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I119_XG_MP2 (XI2_I1_I42_I119_XG_p1 I2_I1_I42_G23_22 I2_I1_I42_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I119_XG_MP0 (VDD I2_I1_I42_P23_22 XI2_I1_I42_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I119_XG_MP1 (XI2_I1_I42_I119_XG_p1 I2_I1_I42_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I126_XG_MP2 (XI2_I1_I42_I126_XG_p1 I2_I1_I42_G30_29 I2_I1_I42_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I126_XG_MP0 (VDD I2_I1_I42_P30_29 XI2_I1_I42_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I126_XG_MP1 (XI2_I1_I42_I126_XG_p1 I2_I1_I42_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I380_MP2 (XI2_I3_I380_p1 I2_I3_o24_2 I2_I3_q24_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I380_MP0 (VDD I2_I3_SEL_AS_b3_4 XI2_I3_I380_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
