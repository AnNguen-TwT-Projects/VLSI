    I_MXI1_I884_I188_XG_MN2 (XI1_I884_I188_XG_n1 I1_I884_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I188_XG_MN0 (I1_I884_G20_0 I1_I884_P20_5n XI1_I884_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I188_XG_MN1 (XI1_I884_I188_XG_n1 I1_I884_G4_0n I1_I884_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I185_XG_MN2 (XI1_I884_I185_XG_n1 I1_I884_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I185_XG_MN0 (I1_I884_G18_0 I1_I884_P18_3n XI1_I884_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I185_XG_MN1 (XI1_I884_I185_XG_n1 I1_I884_G2_0n I1_I884_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I135_XG_MN2 (XI1_I884_I135_XG_n1 I1_I884_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I135_XG_MN0 (I1_I884_G10_3 I1_I884_P10_7n XI1_I884_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I135_XG_MN1 (XI1_I884_I135_XG_n1 I1_I884_G6_3n I1_I884_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I183_XG_MN2 (XI1_I884_I183_XG_n1 I1_I884_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I183_XG_MN0 (I1_I884_G16_0 I1_I884_P16_1n XI1_I884_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I183_XG_MN1 (XI1_I884_I183_XG_n1 I1_I884_G0_0n I1_I884_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I131_XG_MN2 (XI1_I884_I131_XG_n1 I1_I884_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I131_XG_MN0 (I1_I884_G6_0 I1_I884_P6_3n XI1_I884_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I131_XG_MN1 (XI1_I884_I131_XG_n1 I1_I884_G2_0n I1_I884_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I133_XG_MN2 (XI1_I884_I133_XG_n1 I1_I884_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I133_XG_MN0 (I1_I884_G8_1 I1_I884_P8_5n XI1_I884_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I133_XG_MN1 (XI1_I884_I133_XG_n1 I1_I884_G4_1n I1_I884_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I128_XG_MN2 (XI1_I884_I128_XG_n1 I1_I884_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I128_XG_MN0 (I1_I884_G4_0 I1_I884_P4_1n XI1_I884_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I128_XG_MN1 (XI1_I884_I128_XG_n1 I1_I884_G0_0n I1_I884_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I69_XG_MN2 (XI1_I884_I69_XG_n1 I1_I884_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I69_XG_MN0 (I1_I884_G3_2 I1_I884_pn3 XI1_I884_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I69_XG_MN1 (XI1_I884_I69_XG_n1 I1_I884_gn2 I1_I884_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I130_XG_MN2 (XI1_I700_I130_XG_n1 I1_I700_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I130_XG_MN0 (I1_I700_G5_0 I1_I700_P5_2n XI1_I700_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I130_XG_MN1 (XI1_I700_I130_XG_n1 I1_I700_G1_0n I1_I700_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I134_XG_MN2 (XI1_I700_I134_XG_n1 I1_I700_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I134_XG_MN0 (I1_I700_G9_2 I1_I700_P9_6n XI1_I700_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I134_XG_MN1 (XI1_I700_I134_XG_n1 I1_I700_G5_2n I1_I700_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I184_XG_MN2 (XI1_I700_I184_XG_n1 I1_I700_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I184_XG_MN0 (I1_I700_G17_0 I1_I700_P17_2n XI1_I700_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I184_XG_MN1 (XI1_I700_I184_XG_n1 I1_I700_G1_0n I1_I700_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I138_XG_MN2 (XI1_I700_I138_XG_n1 I1_I700_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I138_XG_MN0 (I1_I700_G13_6 I1_I700_P13_10n XI1_I700_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I138_XG_MN1 (XI1_I700_I138_XG_n1 I1_I700_G9_6n I1_I700_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I142_XG_MN2 (XI1_I700_I142_XG_n1 I1_I700_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I142_XG_MN0 (I1_I700_G17_10 I1_I700_P17_14n XI1_I700_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I142_XG_MN1 (XI1_I700_I142_XG_n1 I1_I700_G13_10n I1_I700_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I144_XG_MN2 (XI1_I700_I144_XG_n1 I1_I700_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I144_XG_MN0 (I1_I700_G19_12 I1_I700_P19_16n XI1_I700_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I144_XG_MN1 (XI1_I700_I144_XG_n1 I1_I700_G15_12n I1_I700_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I146_XG_MN2 (XI1_I700_I146_XG_n1 I1_I700_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I146_XG_MN0 (I1_I700_G21_14 I1_I700_P21_18n XI1_I700_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I146_XG_MN1 (XI1_I700_I146_XG_n1 I1_I700_G17_14n I1_I700_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I150_XG_MN2 (XI1_I700_I150_XG_n1 I1_I700_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I150_XG_MN0 (I1_I700_G25_18 I1_I700_P25_22n XI1_I700_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I150_XG_MN1 (XI1_I700_I150_XG_n1 I1_I700_G21_18n I1_I700_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I154_XG_MN2 (XI1_I700_I154_XG_n1 I1_I700_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I154_XG_MN0 (I1_I700_G29_22 I1_I700_P29_26n XI1_I700_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I154_XG_MN1 (XI1_I700_I154_XG_n1 I1_I700_G25_22n I1_I700_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I202_XG_MN2 (XI1_I1390_I202_XG_n1 I1_I1390_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I202_XG_MN0 (I1_c18_o I1_I1390_P31_16n XI1_I1390_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I202_XG_MN1 (XI1_I1390_I202_XG_n1 I1_I1390_G15_0n I1_c18_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I200_XG_MN2 (XI1_I1390_I200_XG_n1 I1_I1390_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I200_XG_MN0 (I1_I1390_G29_0 I1_I1390_P29_14n XI1_I1390_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I200_XG_MN1 (XI1_I1390_I200_XG_n1 I1_I1390_G13_0n I1_I1390_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I80_XG_MN2 (XI1_I1390_I80_XG_n1 I1_I1390_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I80_XG_MN0 (I1_I1390_G14_13 I1_I1390_pn14 XI1_I1390_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I80_XG_MN1 (XI1_I1390_I80_XG_n1 I1_I1390_gn13 I1_I1390_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I79_XG_MN2 (XI1_I1390_I79_XG_n1 I1_I1390_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I79_XG_MN0 (I1_I1390_G13_12 I1_I1390_pn13 XI1_I1390_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I79_XG_MN1 (XI1_I1390_I79_XG_n1 I1_I1390_gn12 I1_I1390_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I78_XG_MN2 (XI1_I1390_I78_XG_n1 I1_I1390_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I78_XG_MN0 (I1_I1390_G12_11 I1_I1390_pn12 XI1_I1390_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I78_XG_MN1 (XI1_I1390_I78_XG_n1 I1_I1390_gn11 I1_I1390_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I77_XG_MN2 (XI1_I1390_I77_XG_n1 I1_I1390_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I77_XG_MN0 (I1_I1390_G11_10 I1_I1390_pn11 XI1_I1390_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I77_XG_MN1 (XI1_I1390_I77_XG_n1 I1_I1390_gn10 I1_I1390_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I76_XG_MN2 (XI1_I1390_I76_XG_n1 I1_I1390_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I76_XG_MN0 (I1_I1390_G10_9 I1_I1390_pn10 XI1_I1390_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I76_XG_MN1 (XI1_I1390_I76_XG_n1 I1_I1390_gn9 I1_I1390_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I69_XG_MN2 (XI1_I1344_I69_XG_n1 I1_I1344_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I69_XG_MN0 (I1_I1344_G3_2 I1_I1344_pn3 XI1_I1344_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I69_XG_MN1 (XI1_I1344_I69_XG_n1 I1_I1344_gn2 I1_I1344_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I68_XG_MN2 (XI1_I1344_I68_XG_n1 I1_I1344_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I68_XG_MN0 (I1_I1344_G2_1 I1_I1344_pn2 XI1_I1344_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I68_XG_MN1 (XI1_I1344_I68_XG_n1 I1_I1344_gn1 I1_I1344_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I67_XG_MN2 (XI1_I1298_I67_XG_n1 I1_I1298_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I67_XG_MN0 (I1_I1298_G1_0 I1_I1298_pn1 XI1_I1298_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I67_XG_MN1 (XI1_I1298_I67_XG_n1 I1_I1298_G0_0n I1_I1298_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I68_XG_MN2 (XI1_I1298_I68_XG_n1 I1_I1298_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I68_XG_MN0 (I1_I1298_G2_1 I1_I1298_pn2 XI1_I1298_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I68_XG_MN1 (XI1_I1298_I68_XG_n1 I1_I1298_gn1 I1_I1298_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I69_XG_MN2 (XI1_I1298_I69_XG_n1 I1_I1298_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I69_XG_MN0 (I1_I1298_G3_2 I1_I1298_pn3 XI1_I1298_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I69_XG_MN1 (XI1_I1298_I69_XG_n1 I1_I1298_gn2 I1_I1298_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I67_XG_MN2 (XI1_I1252_I67_XG_n1 I1_I1252_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I67_XG_MN0 (I1_I1252_G1_0 I1_I1252_pn1 XI1_I1252_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I67_XG_MN1 (XI1_I1252_I67_XG_n1 I1_I1252_G0_0n I1_I1252_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I68_XG_MN2 (XI1_I1252_I68_XG_n1 I1_I1252_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I68_XG_MN0 (I1_I1252_G2_1 I1_I1252_pn2 XI1_I1252_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I68_XG_MN1 (XI1_I1252_I68_XG_n1 I1_I1252_gn1 I1_I1252_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I152_XG_MN2 (XI1_I1160_I152_XG_n1 I1_I1160_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I152_XG_MN0 (I1_I1160_G27_20 I1_I1160_P27_24n XI1_I1160_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I152_XG_MN1 (XI1_I1160_I152_XG_n1 I1_I1160_G23_20n I1_I1160_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I184_XG_MN2 (XI1_I1160_I184_XG_n1 I1_I1160_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I184_XG_MN0 (I1_I1160_G17_0 I1_I1160_P17_2n XI1_I1160_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I184_XG_MN1 (XI1_I1160_I184_XG_n1 I1_I1160_G1_0n I1_I1160_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I130_XG_MN2 (XI1_I1160_I130_XG_n1 I1_I1160_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I130_XG_MN0 (I1_I1160_G5_0 I1_I1160_P5_2n XI1_I1160_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I130_XG_MN1 (XI1_I1160_I130_XG_n1 I1_I1160_G1_0n I1_I1160_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I67_XG_MN2 (XI1_I884_I67_XG_n1 I1_I884_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I67_XG_MN0 (I1_I884_G1_0 I1_I884_pn1 XI1_I884_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I67_XG_MN1 (XI1_I884_I67_XG_n1 I1_I884_G0_0n I1_I884_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I68_XG_MN2 (XI1_I884_I68_XG_n1 I1_I884_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I68_XG_MN0 (I1_I884_G2_1 I1_I884_pn2 XI1_I884_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I68_XG_MN1 (XI1_I884_I68_XG_n1 I1_I884_gn1 I1_I884_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I65_XG_MN2 (XI1_I792_I65_XG_n1 I1_I792_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I65_XG_MN0 (I1_I792_G0_0 I1_I792_pn0 XI1_I792_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I792_I65_XG_MN1 (XI1_I792_I65_XG_n1 I1_I792_cinn I1_I792_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I185_XG_MN2 (XI1_I700_I185_XG_n1 I1_I700_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I185_XG_MN0 (I1_I700_G18_0 I1_I700_P18_3n XI1_I700_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I185_XG_MN1 (XI1_I700_I185_XG_n1 I1_I700_G2_0n I1_I700_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I188_XG_MN2 (XI1_I700_I188_XG_n1 I1_I700_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I188_XG_MN0 (I1_I700_G20_0 I1_I700_P20_5n XI1_I700_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I188_XG_MN1 (XI1_I700_I188_XG_n1 I1_I700_G4_0n I1_I700_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I192_XG_MN2 (XI1_I700_I192_XG_n1 I1_I700_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I192_XG_MN0 (I1_I700_G22_0 I1_I700_P22_7n XI1_I700_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I192_XG_MN1 (XI1_I700_I192_XG_n1 I1_I700_G6_0n I1_I700_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I194_XG_MN2 (XI1_I1390_I194_XG_n1 I1_I1390_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I194_XG_MN0 (I1_I1390_G23_0 I1_I1390_P23_8n XI1_I1390_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I194_XG_MN1 (XI1_I1390_I194_XG_n1 I1_I1390_G7_0n I1_I1390_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I198_XG_MN2 (XI1_I1390_I198_XG_n1 I1_I1390_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I198_XG_MN0 (I1_I1390_G27_0 I1_I1390_P27_12n XI1_I1390_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I198_XG_MN1 (XI1_I1390_I198_XG_n1 I1_I1390_G11_0n I1_I1390_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I196_XG_MN2 (XI1_I1390_I196_XG_n1 I1_I1390_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I196_XG_MN0 (I1_I1390_G25_0 I1_I1390_P25_10n XI1_I1390_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I196_XG_MN1 (XI1_I1390_I196_XG_n1 I1_I1390_G9_0n I1_I1390_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I190_XG_MN2 (XI1_I1390_I190_XG_n1 I1_I1390_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I190_XG_MN0 (I1_I1390_G21_0 I1_I1390_P21_6n XI1_I1390_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I190_XG_MN1 (XI1_I1390_I190_XG_n1 I1_I1390_G5_0n I1_I1390_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I138_XG_MN2 (XI1_I1390_I138_XG_n1 I1_I1390_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I138_XG_MN0 (I1_I1390_G13_6 I1_I1390_P13_10n XI1_I1390_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I138_XG_MN1 (XI1_I1390_I138_XG_n1 I1_I1390_G9_6n I1_I1390_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I136_XG_MN2 (XI1_I1390_I136_XG_n1 I1_I1390_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I136_XG_MN0 (I1_I1390_G11_4 I1_I1390_P11_8n XI1_I1390_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I136_XG_MN1 (XI1_I1390_I136_XG_n1 I1_I1390_G7_4n I1_I1390_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I134_XG_MN2 (XI1_I1390_I134_XG_n1 I1_I1390_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I134_XG_MN0 (I1_I1390_G9_2 I1_I1390_P9_6n XI1_I1390_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I134_XG_MN1 (XI1_I1390_I134_XG_n1 I1_I1390_G5_2n I1_I1390_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I75_XG_MN2 (XI1_I1390_I75_XG_n1 I1_I1390_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I75_XG_MN0 (I1_I1390_G9_8 I1_I1390_pn9 XI1_I1390_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I75_XG_MN1 (XI1_I1390_I75_XG_n1 I1_I1390_gn8 I1_I1390_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I74_XG_MN2 (XI1_I1390_I74_XG_n1 I1_I1390_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I74_XG_MN0 (I1_I1390_G8_7 I1_I1390_pn8 XI1_I1390_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I74_XG_MN1 (XI1_I1390_I74_XG_n1 I1_I1390_gn7 I1_I1390_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I67_XG_MN2 (XI1_I1344_I67_XG_n1 I1_I1344_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I67_XG_MN0 (I1_I1344_G1_0 I1_I1344_pn1 XI1_I1344_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I67_XG_MN1 (XI1_I1344_I67_XG_n1 I1_I1344_G0_0n I1_I1344_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I65_XG_MN2 (XI1_I1252_I65_XG_n1 I1_I1252_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I65_XG_MN0 (I1_I1252_G0_0 I1_I1252_pn0 XI1_I1252_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1252_I65_XG_MN1 (XI1_I1252_I65_XG_n1 I1_I1252_cinn I1_I1252_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I146_XG_MN2 (XI1_I1160_I146_XG_n1 I1_I1160_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I146_XG_MN0 (I1_I1160_G21_14 I1_I1160_P21_18n XI1_I1160_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I146_XG_MN1 (XI1_I1160_I146_XG_n1 I1_I1160_G17_14n I1_I1160_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I134_XG_MN2 (XI1_I1160_I134_XG_n1 I1_I1160_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I134_XG_MN0 (I1_I1160_G9_2 I1_I1160_P9_6n XI1_I1160_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I134_XG_MN1 (XI1_I1160_I134_XG_n1 I1_I1160_G5_2n I1_I1160_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I65_XG_MN2 (XI1_I1206_I65_XG_n1 I1_I1206_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I65_XG_MN0 (I1_I1206_G0_0 I1_I1206_pn0 XI1_I1206_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1206_I65_XG_MN1 (XI1_I1206_I65_XG_n1 I1_I1206_cinn I1_I1206_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I89_XG_MN2 (XI1_I930_I89_XG_n1 I1_I930_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I89_XG_MN0 (I1_I930_G23_22 I1_I930_pn23 XI1_I930_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I89_XG_MN1 (XI1_I930_I89_XG_n1 I1_I930_gn22 I1_I930_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I88_XG_MN2 (XI1_I930_I88_XG_n1 I1_I930_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I88_XG_MN0 (I1_I930_G22_21 I1_I930_pn22 XI1_I930_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I88_XG_MN1 (XI1_I930_I88_XG_n1 I1_I930_gn21 I1_I930_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I84_XG_MN2 (XI1_I930_I84_XG_n1 I1_I930_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I84_XG_MN0 (I1_I930_G18_17 I1_I930_pn18 XI1_I930_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I84_XG_MN1 (XI1_I930_I84_XG_n1 I1_I930_gn17 I1_I930_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I81_XG_MN2 (XI1_I930_I81_XG_n1 I1_I930_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I81_XG_MN0 (I1_I930_G15_14 I1_I930_pn15 XI1_I930_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I81_XG_MN1 (XI1_I930_I81_XG_n1 I1_I930_gn14 I1_I930_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I67_XG_MN2 (XI1_I700_I67_XG_n1 I1_I700_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I67_XG_MN0 (I1_I700_G1_0 I1_I700_pn1 XI1_I700_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I67_XG_MN1 (XI1_I700_I67_XG_n1 I1_I700_G0_0n I1_I700_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I128_XG_MN2 (XI1_I700_I128_XG_n1 I1_I700_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I128_XG_MN0 (I1_I700_G4_0 I1_I700_P4_1n XI1_I700_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I128_XG_MN1 (XI1_I700_I128_XG_n1 I1_I700_G0_0n I1_I700_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I133_XG_MN2 (XI1_I700_I133_XG_n1 I1_I700_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I133_XG_MN0 (I1_I700_G8_1 I1_I700_P8_5n XI1_I700_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I133_XG_MN1 (XI1_I700_I133_XG_n1 I1_I700_G4_1n I1_I700_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I183_XG_MN2 (XI1_I700_I183_XG_n1 I1_I700_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I183_XG_MN0 (I1_I700_G16_0 I1_I700_P16_1n XI1_I700_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I183_XG_MN1 (XI1_I700_I183_XG_n1 I1_I700_G0_0n I1_I700_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I131_XG_MN2 (XI1_I700_I131_XG_n1 I1_I700_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I131_XG_MN0 (I1_I700_G6_0 I1_I700_P6_3n XI1_I700_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I131_XG_MN1 (XI1_I700_I131_XG_n1 I1_I700_G2_0n I1_I700_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I135_XG_MN2 (XI1_I700_I135_XG_n1 I1_I700_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I135_XG_MN0 (I1_I700_G10_3 I1_I700_P10_7n XI1_I700_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I135_XG_MN1 (XI1_I700_I135_XG_n1 I1_I700_G6_3n I1_I700_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I195_XG_MN2 (XI1_I700_I195_XG_n1 I1_I700_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I195_XG_MN0 (I1_I700_G24_0 I1_I700_P24_9n XI1_I700_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I195_XG_MN1 (XI1_I700_I195_XG_n1 I1_I700_G8_0n I1_I700_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I197_XG_MN2 (XI1_I700_I197_XG_n1 I1_I700_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I197_XG_MN0 (I1_I700_G26_0 I1_I700_P26_11n XI1_I700_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I197_XG_MN1 (XI1_I700_I197_XG_n1 I1_I700_G10_0n I1_I700_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I151_XG_MN2 (XI1_I700_I151_XG_n1 I1_I700_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I151_XG_MN0 (I1_I700_G26_19 I1_I700_P26_23n XI1_I700_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I151_XG_MN1 (XI1_I700_I151_XG_n1 I1_I700_G22_19n I1_I700_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I155_XG_MN2 (XI1_I700_I155_XG_n1 I1_I700_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I155_XG_MN0 (I1_I700_G30_23 I1_I700_P30_27n XI1_I700_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I155_XG_MN1 (XI1_I700_I155_XG_n1 I1_I700_G26_23n I1_I700_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I151_XG_MN2 (XI1_I1390_I151_XG_n1 I1_I1390_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I151_XG_MN0 (I1_I1390_G26_19 I1_I1390_P26_23n XI1_I1390_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I151_XG_MN1 (XI1_I1390_I151_XG_n1 I1_I1390_G22_19n I1_I1390_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I186_XG_MN2 (XI1_I1390_I186_XG_n1 I1_I1390_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I186_XG_MN0 (I1_I1390_G19_0 I1_I1390_P19_4n XI1_I1390_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I186_XG_MN1 (XI1_I1390_I186_XG_n1 I1_I1390_G3_0n I1_I1390_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I184_XG_MN2 (XI1_I1390_I184_XG_n1 I1_I1390_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I184_XG_MN0 (I1_I1390_G17_0 I1_I1390_P17_2n XI1_I1390_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I184_XG_MN1 (XI1_I1390_I184_XG_n1 I1_I1390_G1_0n I1_I1390_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I130_XG_MN2 (XI1_I1390_I130_XG_n1 I1_I1390_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I130_XG_MN0 (I1_I1390_G5_0 I1_I1390_P5_2n XI1_I1390_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I130_XG_MN1 (XI1_I1390_I130_XG_n1 I1_I1390_G1_0n I1_I1390_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I132_XG_MN2 (XI1_I1390_I132_XG_n1 I1_I1390_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I132_XG_MN0 (I1_I1390_G7_0 I1_I1390_P7_4n XI1_I1390_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I132_XG_MN1 (XI1_I1390_I132_XG_n1 I1_I1390_G3_0n I1_I1390_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I73_XG_MN2 (XI1_I1390_I73_XG_n1 I1_I1390_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I73_XG_MN0 (I1_I1390_G7_6 I1_I1390_pn7 XI1_I1390_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I73_XG_MN1 (XI1_I1390_I73_XG_n1 I1_I1390_gn6 I1_I1390_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I65_XG_MN2 (XI1_I1298_I65_XG_n1 I1_I1298_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I65_XG_MN0 (I1_I1298_G0_0 I1_I1298_pn0 XI1_I1298_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1298_I65_XG_MN1 (XI1_I1298_I65_XG_n1 I1_I1298_cinn I1_I1298_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I95_XG_MN2 (XI1_I1160_I95_XG_n1 I1_I1160_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I95_XG_MN0 (I1_I1160_G29_28 I1_I1160_pn29 XI1_I1160_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I95_XG_MN1 (XI1_I1160_I95_XG_n1 I1_I1160_gn28 I1_I1160_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I97_XG_MN2 (XI1_I1160_I97_XG_n1 I1_I1160_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I97_XG_MN0 (I1_I1160_G31_30 I1_I1160_pn31 XI1_I1160_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I97_XG_MN1 (XI1_I1160_I97_XG_n1 I1_I1160_gn30 I1_I1160_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I96_XG_MN2 (XI1_I1160_I96_XG_n1 I1_I1160_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I96_XG_MN0 (I1_I1160_G30_29 I1_I1160_pn30 XI1_I1160_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I96_XG_MN1 (XI1_I1160_I96_XG_n1 I1_I1160_gn29 I1_I1160_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I201_XG_MN2 (XI1_I1160_I201_XG_n1 I1_I1160_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I201_XG_MN0 (I1_c13_m I1_I1160_P30_15n XI1_I1160_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I201_XG_MN1 (XI1_I1160_I201_XG_n1 I1_I1160_G14_0n I1_c13_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I192_XG_MN2 (XI1_I1160_I192_XG_n1 I1_I1160_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I192_XG_MN0 (I1_I1160_G22_0 I1_I1160_P22_7n XI1_I1160_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I192_XG_MN1 (XI1_I1160_I192_XG_n1 I1_I1160_G6_0n I1_I1160_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I199_XG_MN2 (XI1_I1160_I199_XG_n1 I1_I1160_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I199_XG_MN0 (I1_I1160_G28_0 I1_I1160_P28_13n XI1_I1160_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I199_XG_MN1 (XI1_I1160_I199_XG_n1 I1_I1160_G12_0n I1_I1160_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I188_XG_MN2 (XI1_I1160_I188_XG_n1 I1_I1160_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I188_XG_MN0 (I1_I1160_G20_0 I1_I1160_P20_5n XI1_I1160_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I188_XG_MN1 (XI1_I1160_I188_XG_n1 I1_I1160_G4_0n I1_I1160_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I195_XG_MN2 (XI1_I1160_I195_XG_n1 I1_I1160_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I195_XG_MN0 (I1_I1160_G24_0 I1_I1160_P24_9n XI1_I1160_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I195_XG_MN1 (XI1_I1160_I195_XG_n1 I1_I1160_G8_0n I1_I1160_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I183_XG_MN2 (XI1_I1160_I183_XG_n1 I1_I1160_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I183_XG_MN0 (I1_I1160_G16_0 I1_I1160_P16_1n XI1_I1160_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I183_XG_MN1 (XI1_I1160_I183_XG_n1 I1_I1160_G0_0n I1_I1160_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I128_XG_MN2 (XI1_I1160_I128_XG_n1 I1_I1160_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I128_XG_MN0 (I1_I1160_G4_0 I1_I1160_P4_1n XI1_I1160_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I128_XG_MN1 (XI1_I1160_I128_XG_n1 I1_I1160_G0_0n I1_I1160_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I67_XG_MN2 (XI1_I1160_I67_XG_n1 I1_I1160_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I67_XG_MN0 (I1_I1160_G1_0 I1_I1160_pn1 XI1_I1160_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I67_XG_MN1 (XI1_I1160_I67_XG_n1 I1_I1160_G0_0n I1_I1160_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I95_XG_MN2 (XI1_I930_I95_XG_n1 I1_I930_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I95_XG_MN0 (I1_I930_G29_28 I1_I930_pn29 XI1_I930_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I95_XG_MN1 (XI1_I930_I95_XG_n1 I1_I930_gn28 I1_I930_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I90_XG_MN2 (XI1_I930_I90_XG_n1 I1_I930_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I90_XG_MN0 (I1_I930_G24_23 I1_I930_pn24 XI1_I930_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I90_XG_MN1 (XI1_I930_I90_XG_n1 I1_I930_gn23 I1_I930_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I154_XG_MN2 (XI1_I930_I154_XG_n1 I1_I930_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I154_XG_MN0 (I1_I930_G29_22 I1_I930_P29_26n XI1_I930_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I154_XG_MN1 (XI1_I930_I154_XG_n1 I1_I930_G25_22n I1_I930_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I152_XG_MN2 (XI1_I930_I152_XG_n1 I1_I930_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I152_XG_MN0 (I1_I930_G27_20 I1_I930_P27_24n XI1_I930_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I152_XG_MN1 (XI1_I930_I152_XG_n1 I1_I930_G23_20n I1_I930_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I148_XG_MN2 (XI1_I930_I148_XG_n1 I1_I930_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I148_XG_MN0 (I1_I930_G23_16 I1_I930_P23_20n XI1_I930_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I148_XG_MN1 (XI1_I930_I148_XG_n1 I1_I930_G19_16n I1_I930_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I150_XG_MN2 (XI1_I930_I150_XG_n1 I1_I930_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I150_XG_MN0 (I1_I930_G25_18 I1_I930_P25_22n XI1_I930_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I150_XG_MN1 (XI1_I930_I150_XG_n1 I1_I930_G21_18n I1_I930_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I146_XG_MN2 (XI1_I930_I146_XG_n1 I1_I930_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I146_XG_MN0 (I1_I930_G21_14 I1_I930_P21_18n XI1_I930_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I146_XG_MN1 (XI1_I930_I146_XG_n1 I1_I930_G17_14n I1_I930_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I80_XG_MN2 (XI1_I930_I80_XG_n1 I1_I930_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I80_XG_MN0 (I1_I930_G14_13 I1_I930_pn14 XI1_I930_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I80_XG_MN1 (XI1_I930_I80_XG_n1 I1_I930_gn13 I1_I930_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I142_XG_MN2 (XI1_I930_I142_XG_n1 I1_I930_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I142_XG_MN0 (I1_I930_G17_10 I1_I930_P17_14n XI1_I930_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I142_XG_MN1 (XI1_I930_I142_XG_n1 I1_I930_G13_10n I1_I930_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I79_XG_MN2 (XI1_I930_I79_XG_n1 I1_I930_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I79_XG_MN0 (I1_I930_G13_12 I1_I930_pn13 XI1_I930_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I79_XG_MN1 (XI1_I930_I79_XG_n1 I1_I930_gn12 I1_I930_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I78_XG_MN2 (XI1_I930_I78_XG_n1 I1_I930_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I78_XG_MN0 (I1_I930_G12_11 I1_I930_pn12 XI1_I930_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I78_XG_MN1 (XI1_I930_I78_XG_n1 I1_I930_gn11 I1_I930_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I77_XG_MN2 (XI1_I930_I77_XG_n1 I1_I930_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I77_XG_MN0 (I1_I930_G11_10 I1_I930_pn11 XI1_I930_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I77_XG_MN1 (XI1_I930_I77_XG_n1 I1_I930_gn10 I1_I930_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I76_XG_MN2 (XI1_I930_I76_XG_n1 I1_I930_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I76_XG_MN0 (I1_I930_G10_9 I1_I930_pn10 XI1_I930_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I76_XG_MN1 (XI1_I930_I76_XG_n1 I1_I930_gn9 I1_I930_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I65_XG_MN2 (XI1_I838_I65_XG_n1 I1_I838_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I65_XG_MN0 (I1_I838_G0_0 I1_I838_pn0 XI1_I838_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I838_I65_XG_MN1 (XI1_I838_I65_XG_n1 I1_I838_cinn I1_I838_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I68_XG_MN2 (XI1_I700_I68_XG_n1 I1_I700_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I68_XG_MN0 (I1_I700_G2_1 I1_I700_pn2 XI1_I700_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I68_XG_MN1 (XI1_I700_I68_XG_n1 I1_I700_gn1 I1_I700_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I69_XG_MN2 (XI1_I700_I69_XG_n1 I1_I700_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I69_XG_MN0 (I1_I700_G3_2 I1_I700_pn3 XI1_I700_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I69_XG_MN1 (XI1_I700_I69_XG_n1 I1_I700_gn2 I1_I700_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I71_XG_MN2 (XI1_I700_I71_XG_n1 I1_I700_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I71_XG_MN0 (I1_I700_G5_4 I1_I700_pn5 XI1_I700_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I71_XG_MN1 (XI1_I700_I71_XG_n1 I1_I700_gn4 I1_I700_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I72_XG_MN2 (XI1_I700_I72_XG_n1 I1_I700_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I72_XG_MN0 (I1_I700_G6_5 I1_I700_pn6 XI1_I700_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I72_XG_MN1 (XI1_I700_I72_XG_n1 I1_I700_gn5 I1_I700_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I73_XG_MN2 (XI1_I700_I73_XG_n1 I1_I700_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I73_XG_MN0 (I1_I700_G7_6 I1_I700_pn7 XI1_I700_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I73_XG_MN1 (XI1_I700_I73_XG_n1 I1_I700_gn6 I1_I700_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I74_XG_MN2 (XI1_I700_I74_XG_n1 I1_I700_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I74_XG_MN0 (I1_I700_G8_7 I1_I700_pn8 XI1_I700_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I74_XG_MN1 (XI1_I700_I74_XG_n1 I1_I700_gn7 I1_I700_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I137_XG_MN2 (XI1_I700_I137_XG_n1 I1_I700_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I137_XG_MN0 (I1_I700_G12_5 I1_I700_P12_9n XI1_I700_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I137_XG_MN1 (XI1_I700_I137_XG_n1 I1_I700_G8_5n I1_I700_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I141_XG_MN2 (XI1_I700_I141_XG_n1 I1_I700_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I141_XG_MN0 (I1_I700_G16_9 I1_I700_P16_13n XI1_I700_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I141_XG_MN1 (XI1_I700_I141_XG_n1 I1_I700_G12_9n I1_I700_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I139_XG_MN2 (XI1_I700_I139_XG_n1 I1_I700_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I139_XG_MN0 (I1_I700_G14_7 I1_I700_P14_11n XI1_I700_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I139_XG_MN1 (XI1_I700_I139_XG_n1 I1_I700_G10_7n I1_I700_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I143_XG_MN2 (XI1_I700_I143_XG_n1 I1_I700_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I143_XG_MN0 (I1_I700_G18_11 I1_I700_P18_15n XI1_I700_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I143_XG_MN1 (XI1_I700_I143_XG_n1 I1_I700_G14_11n I1_I700_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I145_XG_MN2 (XI1_I700_I145_XG_n1 I1_I700_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I145_XG_MN0 (I1_I700_G20_13 I1_I700_P20_17n XI1_I700_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I145_XG_MN1 (XI1_I700_I145_XG_n1 I1_I700_G16_13n I1_I700_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I149_XG_MN2 (XI1_I700_I149_XG_n1 I1_I700_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I149_XG_MN0 (I1_I700_G24_17 I1_I700_P24_21n XI1_I700_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I149_XG_MN1 (XI1_I700_I149_XG_n1 I1_I700_G20_17n I1_I700_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I147_XG_MN2 (XI1_I700_I147_XG_n1 I1_I700_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I147_XG_MN0 (I1_I700_G22_15 I1_I700_P22_19n XI1_I700_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I147_XG_MN1 (XI1_I700_I147_XG_n1 I1_I700_G18_15n I1_I700_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I153_XG_MN2 (XI1_I700_I153_XG_n1 I1_I700_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I153_XG_MN0 (I1_I700_G28_21 I1_I700_P28_25n XI1_I700_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I153_XG_MN1 (XI1_I700_I153_XG_n1 I1_I700_G24_21n I1_I700_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I92_XG_MN2 (XI1_I700_I92_XG_n1 I1_I700_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I92_XG_MN0 (I1_I700_G26_25 I1_I700_pn26 XI1_I700_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I92_XG_MN1 (XI1_I700_I92_XG_n1 I1_I700_gn25 I1_I700_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I93_XG_MN2 (XI1_I700_I93_XG_n1 I1_I700_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I93_XG_MN0 (I1_I700_G27_26 I1_I700_pn27 XI1_I700_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I93_XG_MN1 (XI1_I700_I93_XG_n1 I1_I700_gn26 I1_I700_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I94_XG_MN2 (XI1_I700_I94_XG_n1 I1_I700_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I94_XG_MN0 (I1_I700_G28_27 I1_I700_pn28 XI1_I700_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I94_XG_MN1 (XI1_I700_I94_XG_n1 I1_I700_gn27 I1_I700_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I95_XG_MN2 (XI1_I700_I95_XG_n1 I1_I700_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I95_XG_MN0 (I1_I700_G29_28 I1_I700_pn29 XI1_I700_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I95_XG_MN1 (XI1_I700_I95_XG_n1 I1_I700_gn28 I1_I700_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I155_XG_MN2 (XI1_I1390_I155_XG_n1 I1_I1390_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I155_XG_MN0 (I1_I1390_G30_23 I1_I1390_P30_27n XI1_I1390_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I155_XG_MN1 (XI1_I1390_I155_XG_n1 I1_I1390_G26_23n I1_I1390_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I153_XG_MN2 (XI1_I1390_I153_XG_n1 I1_I1390_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I153_XG_MN0 (I1_I1390_G28_21 I1_I1390_P28_25n XI1_I1390_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I153_XG_MN1 (XI1_I1390_I153_XG_n1 I1_I1390_G24_21n I1_I1390_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I147_XG_MN2 (XI1_I1390_I147_XG_n1 I1_I1390_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I147_XG_MN0 (I1_I1390_G22_15 I1_I1390_P22_19n XI1_I1390_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I147_XG_MN1 (XI1_I1390_I147_XG_n1 I1_I1390_G18_15n I1_I1390_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I143_XG_MN2 (XI1_I1390_I143_XG_n1 I1_I1390_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I143_XG_MN0 (I1_I1390_G18_11 I1_I1390_P18_15n XI1_I1390_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I143_XG_MN1 (XI1_I1390_I143_XG_n1 I1_I1390_G14_11n I1_I1390_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I139_XG_MN2 (XI1_I1390_I139_XG_n1 I1_I1390_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I139_XG_MN0 (I1_I1390_G14_7 I1_I1390_P14_11n XI1_I1390_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I139_XG_MN1 (XI1_I1390_I139_XG_n1 I1_I1390_G10_7n I1_I1390_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I141_XG_MN2 (XI1_I1390_I141_XG_n1 I1_I1390_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I141_XG_MN0 (I1_I1390_G16_9 I1_I1390_P16_13n XI1_I1390_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I141_XG_MN1 (XI1_I1390_I141_XG_n1 I1_I1390_G12_9n I1_I1390_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I137_XG_MN2 (XI1_I1390_I137_XG_n1 I1_I1390_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I137_XG_MN0 (I1_I1390_G12_5 I1_I1390_P12_9n XI1_I1390_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I137_XG_MN1 (XI1_I1390_I137_XG_n1 I1_I1390_G8_5n I1_I1390_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I70_XG_MN2 (XI1_I1390_I70_XG_n1 I1_I1390_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I70_XG_MN0 (I1_I1390_G4_3 I1_I1390_pn4 XI1_I1390_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I70_XG_MN1 (XI1_I1390_I70_XG_n1 I1_I1390_gn3 I1_I1390_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I94_XG_MN2 (XI1_I1160_I94_XG_n1 I1_I1160_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I94_XG_MN0 (I1_I1160_G28_27 I1_I1160_pn28 XI1_I1160_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I94_XG_MN1 (XI1_I1160_I94_XG_n1 I1_I1160_gn27 I1_I1160_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I93_XG_MN2 (XI1_I1160_I93_XG_n1 I1_I1160_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I93_XG_MN0 (I1_I1160_G27_26 I1_I1160_pn27 XI1_I1160_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I93_XG_MN1 (XI1_I1160_I93_XG_n1 I1_I1160_gn26 I1_I1160_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I92_XG_MN2 (XI1_I1160_I92_XG_n1 I1_I1160_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I92_XG_MN0 (I1_I1160_G26_25 I1_I1160_pn26 XI1_I1160_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I92_XG_MN1 (XI1_I1160_I92_XG_n1 I1_I1160_gn25 I1_I1160_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I91_XG_MN2 (XI1_I1160_I91_XG_n1 I1_I1160_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I91_XG_MN0 (I1_I1160_G25_24 I1_I1160_pn25 XI1_I1160_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I91_XG_MN1 (XI1_I1160_I91_XG_n1 I1_I1160_gn24 I1_I1160_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I155_XG_MN2 (XI1_I1160_I155_XG_n1 I1_I1160_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I155_XG_MN0 (I1_I1160_G30_23 I1_I1160_P30_27n XI1_I1160_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I155_XG_MN1 (XI1_I1160_I155_XG_n1 I1_I1160_G26_23n I1_I1160_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I153_XG_MN2 (XI1_I1160_I153_XG_n1 I1_I1160_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I153_XG_MN0 (I1_I1160_G28_21 I1_I1160_P28_25n XI1_I1160_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I153_XG_MN1 (XI1_I1160_I153_XG_n1 I1_I1160_G24_21n I1_I1160_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I149_XG_MN2 (XI1_I1160_I149_XG_n1 I1_I1160_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I149_XG_MN0 (I1_I1160_G24_17 I1_I1160_P24_21n XI1_I1160_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I149_XG_MN1 (XI1_I1160_I149_XG_n1 I1_I1160_G20_17n I1_I1160_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I197_XG_MN2 (XI1_I1160_I197_XG_n1 I1_I1160_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I197_XG_MN0 (I1_I1160_G26_0 I1_I1160_P26_11n XI1_I1160_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I197_XG_MN1 (XI1_I1160_I197_XG_n1 I1_I1160_G10_0n I1_I1160_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I185_XG_MN2 (XI1_I1160_I185_XG_n1 I1_I1160_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I185_XG_MN0 (I1_I1160_G18_0 I1_I1160_P18_3n XI1_I1160_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I185_XG_MN1 (XI1_I1160_I185_XG_n1 I1_I1160_G2_0n I1_I1160_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I131_XG_MN2 (XI1_I1160_I131_XG_n1 I1_I1160_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I131_XG_MN0 (I1_I1160_G6_0 I1_I1160_P6_3n XI1_I1160_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I131_XG_MN1 (XI1_I1160_I131_XG_n1 I1_I1160_G2_0n I1_I1160_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I133_XG_MN2 (XI1_I1160_I133_XG_n1 I1_I1160_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I133_XG_MN0 (I1_I1160_G8_1 I1_I1160_P8_5n XI1_I1160_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I133_XG_MN1 (XI1_I1160_I133_XG_n1 I1_I1160_G4_1n I1_I1160_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I65_XG_MN2 (XI1_I1160_I65_XG_n1 I1_I1160_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I65_XG_MN0 (I1_I1160_G0_0 I1_I1160_pn0 XI1_I1160_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I65_XG_MN1 (XI1_I1160_I65_XG_n1 I1_I1160_cinn I1_I1160_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I97_XG_MN2 (XI1_I930_I97_XG_n1 I1_I930_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I97_XG_MN0 (I1_I930_G31_30 I1_I930_pn31 XI1_I930_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I97_XG_MN1 (XI1_I930_I97_XG_n1 I1_I930_gn30 I1_I930_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I96_XG_MN2 (XI1_I930_I96_XG_n1 I1_I930_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I96_XG_MN0 (I1_I930_G30_29 I1_I930_pn30 XI1_I930_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I96_XG_MN1 (XI1_I930_I96_XG_n1 I1_I930_gn29 I1_I930_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I156_XG_MN2 (XI1_I930_I156_XG_n1 I1_I930_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I156_XG_MN0 (I1_I930_G31_24 I1_I930_P31_28n XI1_I930_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I156_XG_MN1 (XI1_I930_I156_XG_n1 I1_I930_G27_24n I1_I930_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I202_XG_MN2 (XI1_I930_I202_XG_n1 I1_I930_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I202_XG_MN0 (I1_c8_o I1_I930_P31_16n XI1_I930_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I202_XG_MN1 (XI1_I930_I202_XG_n1 I1_I930_G15_0n I1_c8_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I144_XG_MN2 (XI1_I930_I144_XG_n1 I1_I930_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I144_XG_MN0 (I1_I930_G19_12 I1_I930_P19_16n XI1_I930_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I144_XG_MN1 (XI1_I930_I144_XG_n1 I1_I930_G15_12n I1_I930_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I140_XG_MN2 (XI1_I930_I140_XG_n1 I1_I930_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I140_XG_MN0 (I1_I930_G15_8 I1_I930_P15_12n XI1_I930_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I140_XG_MN1 (XI1_I930_I140_XG_n1 I1_I930_G11_8n I1_I930_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I138_XG_MN2 (XI1_I930_I138_XG_n1 I1_I930_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I138_XG_MN0 (I1_I930_G13_6 I1_I930_P13_10n XI1_I930_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I138_XG_MN1 (XI1_I930_I138_XG_n1 I1_I930_G9_6n I1_I930_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I136_XG_MN2 (XI1_I930_I136_XG_n1 I1_I930_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I136_XG_MN0 (I1_I930_G11_4 I1_I930_P11_8n XI1_I930_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I136_XG_MN1 (XI1_I930_I136_XG_n1 I1_I930_G7_4n I1_I930_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I134_XG_MN2 (XI1_I930_I134_XG_n1 I1_I930_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I134_XG_MN0 (I1_I930_G9_2 I1_I930_P9_6n XI1_I930_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I134_XG_MN1 (XI1_I930_I134_XG_n1 I1_I930_G5_2n I1_I930_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I73_XG_MN2 (XI1_I930_I73_XG_n1 I1_I930_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I73_XG_MN0 (I1_I930_G7_6 I1_I930_pn7 XI1_I930_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I73_XG_MN1 (XI1_I930_I73_XG_n1 I1_I930_gn6 I1_I930_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I72_XG_MN2 (XI1_I930_I72_XG_n1 I1_I930_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I72_XG_MN0 (I1_I930_G6_5 I1_I930_pn6 XI1_I930_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I72_XG_MN1 (XI1_I930_I72_XG_n1 I1_I930_gn5 I1_I930_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I65_XG_MN2 (XI1_I746_I65_XG_n1 I1_I746_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I65_XG_MN0 (I1_I746_G0_0 I1_I746_pn0 XI1_I746_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I746_I65_XG_MN1 (XI1_I746_I65_XG_n1 I1_I746_cinn I1_I746_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I70_XG_MN2 (XI1_I700_I70_XG_n1 I1_I700_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I70_XG_MN0 (I1_I700_G4_3 I1_I700_pn4 XI1_I700_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I70_XG_MN1 (XI1_I700_I70_XG_n1 I1_I700_gn3 I1_I700_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I78_XG_MN2 (XI1_I700_I78_XG_n1 I1_I700_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I78_XG_MN0 (I1_I700_G12_11 I1_I700_pn12 XI1_I700_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I78_XG_MN1 (XI1_I700_I78_XG_n1 I1_I700_gn11 I1_I700_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I79_XG_MN2 (XI1_I700_I79_XG_n1 I1_I700_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I79_XG_MN0 (I1_I700_G13_12 I1_I700_pn13 XI1_I700_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I79_XG_MN1 (XI1_I700_I79_XG_n1 I1_I700_gn12 I1_I700_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I80_XG_MN2 (XI1_I700_I80_XG_n1 I1_I700_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I80_XG_MN0 (I1_I700_G14_13 I1_I700_pn14 XI1_I700_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I80_XG_MN1 (XI1_I700_I80_XG_n1 I1_I700_gn13 I1_I700_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I81_XG_MN2 (XI1_I700_I81_XG_n1 I1_I700_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I81_XG_MN0 (I1_I700_G15_14 I1_I700_pn15 XI1_I700_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I81_XG_MN1 (XI1_I700_I81_XG_n1 I1_I700_gn14 I1_I700_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I82_XG_MN2 (XI1_I700_I82_XG_n1 I1_I700_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I82_XG_MN0 (I1_I700_G16_15 I1_I700_pn16 XI1_I700_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I82_XG_MN1 (XI1_I700_I82_XG_n1 I1_I700_gn15 I1_I700_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I83_XG_MN2 (XI1_I700_I83_XG_n1 I1_I700_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I83_XG_MN0 (I1_I700_G17_16 I1_I700_pn17 XI1_I700_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I83_XG_MN1 (XI1_I700_I83_XG_n1 I1_I700_gn16 I1_I700_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I84_XG_MN2 (XI1_I700_I84_XG_n1 I1_I700_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I84_XG_MN0 (I1_I700_G18_17 I1_I700_pn18 XI1_I700_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I84_XG_MN1 (XI1_I700_I84_XG_n1 I1_I700_gn17 I1_I700_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I85_XG_MN2 (XI1_I700_I85_XG_n1 I1_I700_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I85_XG_MN0 (I1_I700_G19_18 I1_I700_pn19 XI1_I700_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I85_XG_MN1 (XI1_I700_I85_XG_n1 I1_I700_gn18 I1_I700_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I86_XG_MN2 (XI1_I700_I86_XG_n1 I1_I700_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I86_XG_MN0 (I1_I700_G20_19 I1_I700_pn20 XI1_I700_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I86_XG_MN1 (XI1_I700_I86_XG_n1 I1_I700_gn19 I1_I700_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I90_XG_MN2 (XI1_I700_I90_XG_n1 I1_I700_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I90_XG_MN0 (I1_I700_G24_23 I1_I700_pn24 XI1_I700_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I90_XG_MN1 (XI1_I700_I90_XG_n1 I1_I700_gn23 I1_I700_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I91_XG_MN2 (XI1_I700_I91_XG_n1 I1_I700_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I91_XG_MN0 (I1_I700_G25_24 I1_I700_pn25 XI1_I700_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I91_XG_MN1 (XI1_I700_I91_XG_n1 I1_I700_gn24 I1_I700_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I96_XG_MN2 (XI1_I700_I96_XG_n1 I1_I700_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I96_XG_MN0 (I1_I700_G30_29 I1_I700_pn30 XI1_I700_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I96_XG_MN1 (XI1_I700_I96_XG_n1 I1_I700_gn29 I1_I700_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I201_XG_MN2 (XI1_I1390_I201_XG_n1 I1_I1390_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I201_XG_MN0 (I1_c18_m I1_I1390_P30_15n XI1_I1390_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I201_XG_MN1 (XI1_I1390_I201_XG_n1 I1_I1390_G14_0n I1_c18_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I199_XG_MN2 (XI1_I1390_I199_XG_n1 I1_I1390_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I199_XG_MN0 (I1_I1390_G28_0 I1_I1390_P28_13n XI1_I1390_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I199_XG_MN1 (XI1_I1390_I199_XG_n1 I1_I1390_G12_0n I1_I1390_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I192_XG_MN2 (XI1_I1390_I192_XG_n1 I1_I1390_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I192_XG_MN0 (I1_I1390_G22_0 I1_I1390_P22_7n XI1_I1390_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I192_XG_MN1 (XI1_I1390_I192_XG_n1 I1_I1390_G6_0n I1_I1390_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I197_XG_MN2 (XI1_I1390_I197_XG_n1 I1_I1390_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I197_XG_MN0 (I1_I1390_G26_0 I1_I1390_P26_11n XI1_I1390_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I197_XG_MN1 (XI1_I1390_I197_XG_n1 I1_I1390_G10_0n I1_I1390_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I195_XG_MN2 (XI1_I1390_I195_XG_n1 I1_I1390_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I195_XG_MN0 (I1_I1390_G24_0 I1_I1390_P24_9n XI1_I1390_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I195_XG_MN1 (XI1_I1390_I195_XG_n1 I1_I1390_G8_0n I1_I1390_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I185_XG_MN2 (XI1_I1390_I185_XG_n1 I1_I1390_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I185_XG_MN0 (I1_I1390_G18_0 I1_I1390_P18_3n XI1_I1390_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I185_XG_MN1 (XI1_I1390_I185_XG_n1 I1_I1390_G2_0n I1_I1390_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I135_XG_MN2 (XI1_I1390_I135_XG_n1 I1_I1390_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I135_XG_MN0 (I1_I1390_G10_3 I1_I1390_P10_7n XI1_I1390_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I135_XG_MN1 (XI1_I1390_I135_XG_n1 I1_I1390_G6_3n I1_I1390_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I133_XG_MN2 (XI1_I1390_I133_XG_n1 I1_I1390_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I133_XG_MN0 (I1_I1390_G8_1 I1_I1390_P8_5n XI1_I1390_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I133_XG_MN1 (XI1_I1390_I133_XG_n1 I1_I1390_G4_1n I1_I1390_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I131_XG_MN2 (XI1_I1390_I131_XG_n1 I1_I1390_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I131_XG_MN0 (I1_I1390_G6_0 I1_I1390_P6_3n XI1_I1390_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I131_XG_MN1 (XI1_I1390_I131_XG_n1 I1_I1390_G2_0n I1_I1390_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I69_XG_MN2 (XI1_I1390_I69_XG_n1 I1_I1390_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I69_XG_MN0 (I1_I1390_G3_2 I1_I1390_pn3 XI1_I1390_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I69_XG_MN1 (XI1_I1390_I69_XG_n1 I1_I1390_gn2 I1_I1390_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I68_XG_MN2 (XI1_I1390_I68_XG_n1 I1_I1390_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I68_XG_MN0 (I1_I1390_G2_1 I1_I1390_pn2 XI1_I1390_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I68_XG_MN1 (XI1_I1390_I68_XG_n1 I1_I1390_gn1 I1_I1390_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I65_XG_MN2 (XI1_I1344_I65_XG_n1 I1_I1344_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I65_XG_MN0 (I1_I1344_G0_0 I1_I1344_pn0 XI1_I1344_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1344_I65_XG_MN1 (XI1_I1344_I65_XG_n1 I1_I1344_cinn I1_I1344_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I90_XG_MN2 (XI1_I1160_I90_XG_n1 I1_I1160_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I90_XG_MN0 (I1_I1160_G24_23 I1_I1160_pn24 XI1_I1160_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I90_XG_MN1 (XI1_I1160_I90_XG_n1 I1_I1160_gn23 I1_I1160_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I89_XG_MN2 (XI1_I1160_I89_XG_n1 I1_I1160_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I89_XG_MN0 (I1_I1160_G23_22 I1_I1160_pn23 XI1_I1160_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I89_XG_MN1 (XI1_I1160_I89_XG_n1 I1_I1160_gn22 I1_I1160_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I88_XG_MN2 (XI1_I1160_I88_XG_n1 I1_I1160_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I88_XG_MN0 (I1_I1160_G22_21 I1_I1160_pn22 XI1_I1160_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I88_XG_MN1 (XI1_I1160_I88_XG_n1 I1_I1160_gn21 I1_I1160_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I87_XG_MN2 (XI1_I1160_I87_XG_n1 I1_I1160_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I87_XG_MN0 (I1_I1160_G21_20 I1_I1160_pn21 XI1_I1160_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I87_XG_MN1 (XI1_I1160_I87_XG_n1 I1_I1160_gn20 I1_I1160_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I86_XG_MN2 (XI1_I1160_I86_XG_n1 I1_I1160_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I86_XG_MN0 (I1_I1160_G20_19 I1_I1160_pn20 XI1_I1160_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I86_XG_MN1 (XI1_I1160_I86_XG_n1 I1_I1160_gn19 I1_I1160_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I145_XG_MN2 (XI1_I1160_I145_XG_n1 I1_I1160_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I145_XG_MN0 (I1_I1160_G20_13 I1_I1160_P20_17n XI1_I1160_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I145_XG_MN1 (XI1_I1160_I145_XG_n1 I1_I1160_G16_13n I1_I1160_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I143_XG_MN2 (XI1_I1160_I143_XG_n1 I1_I1160_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I143_XG_MN0 (I1_I1160_G18_11 I1_I1160_P18_15n XI1_I1160_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I143_XG_MN1 (XI1_I1160_I143_XG_n1 I1_I1160_G14_11n I1_I1160_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I139_XG_MN2 (XI1_I1160_I139_XG_n1 I1_I1160_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I139_XG_MN0 (I1_I1160_G14_7 I1_I1160_P14_11n XI1_I1160_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I139_XG_MN1 (XI1_I1160_I139_XG_n1 I1_I1160_G10_7n I1_I1160_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I71_XG_MN2 (XI1_I1160_I71_XG_n1 I1_I1160_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I71_XG_MN0 (I1_I1160_G5_4 I1_I1160_pn5 XI1_I1160_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I71_XG_MN1 (XI1_I1160_I71_XG_n1 I1_I1160_gn4 I1_I1160_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I70_XG_MN2 (XI1_I1160_I70_XG_n1 I1_I1160_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I70_XG_MN0 (I1_I1160_G4_3 I1_I1160_pn4 XI1_I1160_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I70_XG_MN1 (XI1_I1160_I70_XG_n1 I1_I1160_gn3 I1_I1160_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I200_XG_MN2 (XI1_I930_I200_XG_n1 I1_I930_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I200_XG_MN0 (I1_I930_G29_0 I1_I930_P29_14n XI1_I930_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I200_XG_MN1 (XI1_I930_I200_XG_n1 I1_I930_G13_0n I1_I930_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I198_XG_MN2 (XI1_I930_I198_XG_n1 I1_I930_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I198_XG_MN0 (I1_I930_G27_0 I1_I930_P27_12n XI1_I930_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I198_XG_MN1 (XI1_I930_I198_XG_n1 I1_I930_G11_0n I1_I930_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I194_XG_MN2 (XI1_I930_I194_XG_n1 I1_I930_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I194_XG_MN0 (I1_I930_G23_0 I1_I930_P23_8n XI1_I930_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I194_XG_MN1 (XI1_I930_I194_XG_n1 I1_I930_G7_0n I1_I930_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I190_XG_MN2 (XI1_I930_I190_XG_n1 I1_I930_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I190_XG_MN0 (I1_I930_G21_0 I1_I930_P21_6n XI1_I930_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I190_XG_MN1 (XI1_I930_I190_XG_n1 I1_I930_G5_0n I1_I930_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I196_XG_MN2 (XI1_I930_I196_XG_n1 I1_I930_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I196_XG_MN0 (I1_I930_G25_0 I1_I930_P25_10n XI1_I930_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I196_XG_MN1 (XI1_I930_I196_XG_n1 I1_I930_G9_0n I1_I930_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I186_XG_MN2 (XI1_I930_I186_XG_n1 I1_I930_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I186_XG_MN0 (I1_I930_G19_0 I1_I930_P19_4n XI1_I930_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I186_XG_MN1 (XI1_I930_I186_XG_n1 I1_I930_G3_0n I1_I930_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I184_XG_MN2 (XI1_I930_I184_XG_n1 I1_I930_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I184_XG_MN0 (I1_I930_G17_0 I1_I930_P17_2n XI1_I930_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I184_XG_MN1 (XI1_I930_I184_XG_n1 I1_I930_G1_0n I1_I930_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I130_XG_MN2 (XI1_I930_I130_XG_n1 I1_I930_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I130_XG_MN0 (I1_I930_G5_0 I1_I930_P5_2n XI1_I930_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I130_XG_MN1 (XI1_I930_I130_XG_n1 I1_I930_G1_0n I1_I930_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I132_XG_MN2 (XI1_I930_I132_XG_n1 I1_I930_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I132_XG_MN0 (I1_I930_G7_0 I1_I930_P7_4n XI1_I930_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I132_XG_MN1 (XI1_I930_I132_XG_n1 I1_I930_G3_0n I1_I930_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I71_XG_MN2 (XI1_I930_I71_XG_n1 I1_I930_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I71_XG_MN0 (I1_I930_G5_4 I1_I930_pn5 XI1_I930_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I71_XG_MN1 (XI1_I930_I71_XG_n1 I1_I930_gn4 I1_I930_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I97_XG_MN2 (XI1_I700_I97_XG_n1 I1_I700_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I97_XG_MN0 (I1_I700_G31_30 I1_I700_pn31 XI1_I700_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I97_XG_MN1 (XI1_I700_I97_XG_n1 I1_I700_gn30 I1_I700_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I188_XG_MN2 (XI1_I1390_I188_XG_n1 I1_I1390_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I188_XG_MN0 (I1_I1390_G20_0 I1_I1390_P20_5n XI1_I1390_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I188_XG_MN1 (XI1_I1390_I188_XG_n1 I1_I1390_G4_0n I1_I1390_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I183_XG_MN2 (XI1_I1390_I183_XG_n1 I1_I1390_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I183_XG_MN0 (I1_I1390_G16_0 I1_I1390_P16_1n XI1_I1390_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I183_XG_MN1 (XI1_I1390_I183_XG_n1 I1_I1390_G0_0n I1_I1390_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I128_XG_MN2 (XI1_I1390_I128_XG_n1 I1_I1390_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I128_XG_MN0 (I1_I1390_G4_0 I1_I1390_P4_1n XI1_I1390_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I128_XG_MN1 (XI1_I1390_I128_XG_n1 I1_I1390_G0_0n I1_I1390_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I67_XG_MN2 (XI1_I1390_I67_XG_n1 I1_I1390_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I67_XG_MN0 (I1_I1390_G1_0 I1_I1390_pn1 XI1_I1390_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I67_XG_MN1 (XI1_I1390_I67_XG_n1 I1_I1390_G0_0n I1_I1390_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I83_XG_MN2 (XI1_I1160_I83_XG_n1 I1_I1160_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I83_XG_MN0 (I1_I1160_G17_16 I1_I1160_pn17 XI1_I1160_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I83_XG_MN1 (XI1_I1160_I83_XG_n1 I1_I1160_gn16 I1_I1160_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I82_XG_MN2 (XI1_I1160_I82_XG_n1 I1_I1160_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I82_XG_MN0 (I1_I1160_G16_15 I1_I1160_pn16 XI1_I1160_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I82_XG_MN1 (XI1_I1160_I82_XG_n1 I1_I1160_gn15 I1_I1160_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I81_XG_MN2 (XI1_I1160_I81_XG_n1 I1_I1160_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I81_XG_MN0 (I1_I1160_G15_14 I1_I1160_pn15 XI1_I1160_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I81_XG_MN1 (XI1_I1160_I81_XG_n1 I1_I1160_gn14 I1_I1160_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I80_XG_MN2 (XI1_I1160_I80_XG_n1 I1_I1160_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I80_XG_MN0 (I1_I1160_G14_13 I1_I1160_pn14 XI1_I1160_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I80_XG_MN1 (XI1_I1160_I80_XG_n1 I1_I1160_gn13 I1_I1160_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I76_XG_MN2 (XI1_I1160_I76_XG_n1 I1_I1160_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I76_XG_MN0 (I1_I1160_G10_9 I1_I1160_pn10 XI1_I1160_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I76_XG_MN1 (XI1_I1160_I76_XG_n1 I1_I1160_gn9 I1_I1160_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I73_XG_MN2 (XI1_I1160_I73_XG_n1 I1_I1160_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I73_XG_MN0 (I1_I1160_G7_6 I1_I1160_pn7 XI1_I1160_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I73_XG_MN1 (XI1_I1160_I73_XG_n1 I1_I1160_gn6 I1_I1160_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I72_XG_MN2 (XI1_I1160_I72_XG_n1 I1_I1160_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I72_XG_MN0 (I1_I1160_G6_5 I1_I1160_pn6 XI1_I1160_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I72_XG_MN1 (XI1_I1160_I72_XG_n1 I1_I1160_gn5 I1_I1160_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I155_XG_MN2 (XI1_I930_I155_XG_n1 I1_I930_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I155_XG_MN0 (I1_I930_G30_23 I1_I930_P30_27n XI1_I930_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I155_XG_MN1 (XI1_I930_I155_XG_n1 I1_I930_G26_23n I1_I930_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I153_XG_MN2 (XI1_I930_I153_XG_n1 I1_I930_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I153_XG_MN0 (I1_I930_G28_21 I1_I930_P28_25n XI1_I930_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I153_XG_MN1 (XI1_I930_I153_XG_n1 I1_I930_G24_21n I1_I930_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I143_XG_MN2 (XI1_I930_I143_XG_n1 I1_I930_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I143_XG_MN0 (I1_I930_G18_11 I1_I930_P18_15n XI1_I930_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I143_XG_MN1 (XI1_I930_I143_XG_n1 I1_I930_G14_11n I1_I930_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I139_XG_MN2 (XI1_I930_I139_XG_n1 I1_I930_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I139_XG_MN0 (I1_I930_G14_7 I1_I930_P14_11n XI1_I930_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I139_XG_MN1 (XI1_I930_I139_XG_n1 I1_I930_G10_7n I1_I930_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I141_XG_MN2 (XI1_I930_I141_XG_n1 I1_I930_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I141_XG_MN0 (I1_I930_G16_9 I1_I930_P16_13n XI1_I930_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I141_XG_MN1 (XI1_I930_I141_XG_n1 I1_I930_G12_9n I1_I930_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I135_XG_MN2 (XI1_I930_I135_XG_n1 I1_I930_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I135_XG_MN0 (I1_I930_G10_3 I1_I930_P10_7n XI1_I930_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I135_XG_MN1 (XI1_I930_I135_XG_n1 I1_I930_G6_3n I1_I930_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I70_XG_MN2 (XI1_I930_I70_XG_n1 I1_I930_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I70_XG_MN0 (I1_I930_G4_3 I1_I930_pn4 XI1_I930_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I70_XG_MN1 (XI1_I930_I70_XG_n1 I1_I930_gn3 I1_I930_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I69_XG_MN2 (XI1_I930_I69_XG_n1 I1_I930_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I69_XG_MN0 (I1_I930_G3_2 I1_I930_pn3 XI1_I930_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I69_XG_MN1 (XI1_I930_I69_XG_n1 I1_I930_gn2 I1_I930_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I65_XG_MN2 (XI1_I700_I65_XG_n1 I1_I700_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I65_XG_MN0 (I1_I700_G0_0 I1_I700_pn0 XI1_I700_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I700_I65_XG_MN1 (XI1_I700_I65_XG_n1 I1_I700_cinn I1_I700_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I130_XG_MN2 (XI1_I654_I130_XG_n1 I1_I654_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I130_XG_MN0 (I1_I654_G5_0 I1_I654_P5_2n XI1_I654_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I130_XG_MN1 (XI1_I654_I130_XG_n1 I1_I654_G1_0n I1_I654_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I184_XG_MN2 (XI1_I654_I184_XG_n1 I1_I654_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I184_XG_MN0 (I1_I654_G17_0 I1_I654_P17_2n XI1_I654_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I184_XG_MN1 (XI1_I654_I184_XG_n1 I1_I654_G1_0n I1_I654_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I132_XG_MN2 (XI1_I654_I132_XG_n1 I1_I654_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I132_XG_MN0 (I1_I654_G7_0 I1_I654_P7_4n XI1_I654_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I132_XG_MN1 (XI1_I654_I132_XG_n1 I1_I654_G3_0n I1_I654_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I186_XG_MN2 (XI1_I654_I186_XG_n1 I1_I654_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I186_XG_MN0 (I1_I654_G19_0 I1_I654_P19_4n XI1_I654_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I186_XG_MN1 (XI1_I654_I186_XG_n1 I1_I654_G3_0n I1_I654_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I190_XG_MN2 (XI1_I654_I190_XG_n1 I1_I654_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I190_XG_MN0 (I1_I654_G21_0 I1_I654_P21_6n XI1_I654_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I190_XG_MN1 (XI1_I654_I190_XG_n1 I1_I654_G5_0n I1_I654_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I198_XG_MN2 (XI1_I654_I198_XG_n1 I1_I654_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I198_XG_MN0 (I1_I654_G27_0 I1_I654_P27_12n XI1_I654_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I198_XG_MN1 (XI1_I654_I198_XG_n1 I1_I654_G11_0n I1_I654_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I194_XG_MN2 (XI1_I654_I194_XG_n1 I1_I654_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I194_XG_MN0 (I1_I654_G23_0 I1_I654_P23_8n XI1_I654_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I194_XG_MN1 (XI1_I654_I194_XG_n1 I1_I654_G7_0n I1_I654_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I95_XG_MN2 (XI1_I1114_I95_XG_n1 I1_I1114_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I95_XG_MN0 (I1_I1114_G29_28 I1_I1114_pn29 XI1_I1114_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I95_XG_MN1 (XI1_I1114_I95_XG_n1 I1_I1114_gn28 I1_I1114_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I94_XG_MN2 (XI1_I1114_I94_XG_n1 I1_I1114_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I94_XG_MN0 (I1_I1114_G28_27 I1_I1114_pn28 XI1_I1114_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I94_XG_MN1 (XI1_I1114_I94_XG_n1 I1_I1114_gn27 I1_I1114_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I78_XG_MN2 (XI1_I1160_I78_XG_n1 I1_I1160_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I78_XG_MN0 (I1_I1160_G12_11 I1_I1160_pn12 XI1_I1160_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1160_I78_XG_MN1 (XI1_I1160_I78_XG_n1 I1_I1160_gn11 I1_I1160_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I201_XG_MN2 (XI1_I930_I201_XG_n1 I1_I930_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I201_XG_MN0 (I1_c8_m I1_I930_P30_15n XI1_I930_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I201_XG_MN1 (XI1_I930_I201_XG_n1 I1_I930_G14_0n I1_c8_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I199_XG_MN2 (XI1_I930_I199_XG_n1 I1_I930_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I199_XG_MN0 (I1_I930_G28_0 I1_I930_P28_13n XI1_I930_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I199_XG_MN1 (XI1_I930_I199_XG_n1 I1_I930_G12_0n I1_I930_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I192_XG_MN2 (XI1_I930_I192_XG_n1 I1_I930_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I192_XG_MN0 (I1_I930_G22_0 I1_I930_P22_7n XI1_I930_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I192_XG_MN1 (XI1_I930_I192_XG_n1 I1_I930_G6_0n I1_I930_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I195_XG_MN2 (XI1_I930_I195_XG_n1 I1_I930_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I195_XG_MN0 (I1_I930_G24_0 I1_I930_P24_9n XI1_I930_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I195_XG_MN1 (XI1_I930_I195_XG_n1 I1_I930_G8_0n I1_I930_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I137_XG_MN2 (XI1_I930_I137_XG_n1 I1_I930_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I137_XG_MN0 (I1_I930_G12_5 I1_I930_P12_9n XI1_I930_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I137_XG_MN1 (XI1_I930_I137_XG_n1 I1_I930_G8_5n I1_I930_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I185_XG_MN2 (XI1_I930_I185_XG_n1 I1_I930_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I185_XG_MN0 (I1_I930_G18_0 I1_I930_P18_3n XI1_I930_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I185_XG_MN1 (XI1_I930_I185_XG_n1 I1_I930_G2_0n I1_I930_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I133_XG_MN2 (XI1_I930_I133_XG_n1 I1_I930_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I133_XG_MN0 (I1_I930_G8_1 I1_I930_P8_5n XI1_I930_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I133_XG_MN1 (XI1_I930_I133_XG_n1 I1_I930_G4_1n I1_I930_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I131_XG_MN2 (XI1_I930_I131_XG_n1 I1_I930_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I131_XG_MN0 (I1_I930_G6_0 I1_I930_P6_3n XI1_I930_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I131_XG_MN1 (XI1_I930_I131_XG_n1 I1_I930_G2_0n I1_I930_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I134_XG_MN2 (XI1_I654_I134_XG_n1 I1_I654_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I134_XG_MN0 (I1_I654_G9_2 I1_I654_P9_6n XI1_I654_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I134_XG_MN1 (XI1_I654_I134_XG_n1 I1_I654_G5_2n I1_I654_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I136_XG_MN2 (XI1_I654_I136_XG_n1 I1_I654_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I136_XG_MN0 (I1_I654_G11_4 I1_I654_P11_8n XI1_I654_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I136_XG_MN1 (XI1_I654_I136_XG_n1 I1_I654_G7_4n I1_I654_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I138_XG_MN2 (XI1_I654_I138_XG_n1 I1_I654_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I138_XG_MN0 (I1_I654_G13_6 I1_I654_P13_10n XI1_I654_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I138_XG_MN1 (XI1_I654_I138_XG_n1 I1_I654_G9_6n I1_I654_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I142_XG_MN2 (XI1_I654_I142_XG_n1 I1_I654_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I142_XG_MN0 (I1_I654_G17_10 I1_I654_P17_14n XI1_I654_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I142_XG_MN1 (XI1_I654_I142_XG_n1 I1_I654_G13_10n I1_I654_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I196_XG_MN2 (XI1_I654_I196_XG_n1 I1_I654_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I196_XG_MN0 (I1_I654_G25_0 I1_I654_P25_10n XI1_I654_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I196_XG_MN1 (XI1_I654_I196_XG_n1 I1_I654_G9_0n I1_I654_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I140_XG_MN2 (XI1_I654_I140_XG_n1 I1_I654_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I140_XG_MN0 (I1_I654_G15_8 I1_I654_P15_12n XI1_I654_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I140_XG_MN1 (XI1_I654_I140_XG_n1 I1_I654_G11_8n I1_I654_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I144_XG_MN2 (XI1_I654_I144_XG_n1 I1_I654_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I144_XG_MN0 (I1_I654_G19_12 I1_I654_P19_16n XI1_I654_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I144_XG_MN1 (XI1_I654_I144_XG_n1 I1_I654_G15_12n I1_I654_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I146_XG_MN2 (XI1_I654_I146_XG_n1 I1_I654_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I146_XG_MN0 (I1_I654_G21_14 I1_I654_P21_18n XI1_I654_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I146_XG_MN1 (XI1_I654_I146_XG_n1 I1_I654_G17_14n I1_I654_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I148_XG_MN2 (XI1_I654_I148_XG_n1 I1_I654_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I148_XG_MN0 (I1_I654_G23_16 I1_I654_P23_20n XI1_I654_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I148_XG_MN1 (XI1_I654_I148_XG_n1 I1_I654_G19_16n I1_I654_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I200_XG_MN2 (XI1_I654_I200_XG_n1 I1_I654_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I200_XG_MN0 (I1_I654_G29_0 I1_I654_P29_14n XI1_I654_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I200_XG_MN1 (XI1_I654_I200_XG_n1 I1_I654_G13_0n I1_I654_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I202_XG_MN2 (XI1_I654_I202_XG_n1 I1_I654_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I202_XG_MN0 (I1_c2_o I1_I654_P31_16n XI1_I654_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I202_XG_MN1 (XI1_I654_I202_XG_n1 I1_I654_G15_0n I1_c2_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I93_XG_MN2 (XI1_I1436_I93_XG_n1 I1_I1436_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I93_XG_MN0 (I1_I1436_G27_26 I1_I1436_pn27 XI1_I1436_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I93_XG_MN1 (XI1_I1436_I93_XG_n1 I1_I1436_gn26 I1_I1436_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I92_XG_MN2 (XI1_I1436_I92_XG_n1 I1_I1436_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I92_XG_MN0 (I1_I1436_G26_25 I1_I1436_pn26 XI1_I1436_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I92_XG_MN1 (XI1_I1436_I92_XG_n1 I1_I1436_gn25 I1_I1436_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I87_XG_MN2 (XI1_I1436_I87_XG_n1 I1_I1436_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I87_XG_MN0 (I1_I1436_G21_20 I1_I1436_pn21 XI1_I1436_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I87_XG_MN1 (XI1_I1436_I87_XG_n1 I1_I1436_gn20 I1_I1436_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I86_XG_MN2 (XI1_I1436_I86_XG_n1 I1_I1436_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I86_XG_MN0 (I1_I1436_G20_19 I1_I1436_pn20 XI1_I1436_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I86_XG_MN1 (XI1_I1436_I86_XG_n1 I1_I1436_gn19 I1_I1436_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I85_XG_MN2 (XI1_I1436_I85_XG_n1 I1_I1436_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I85_XG_MN0 (I1_I1436_G19_18 I1_I1436_pn19 XI1_I1436_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I85_XG_MN1 (XI1_I1436_I85_XG_n1 I1_I1436_gn18 I1_I1436_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I84_XG_MN2 (XI1_I1436_I84_XG_n1 I1_I1436_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I84_XG_MN0 (I1_I1436_G18_17 I1_I1436_pn18 XI1_I1436_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I84_XG_MN1 (XI1_I1436_I84_XG_n1 I1_I1436_gn17 I1_I1436_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I81_XG_MN2 (XI1_I1436_I81_XG_n1 I1_I1436_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I81_XG_MN0 (I1_I1436_G15_14 I1_I1436_pn15 XI1_I1436_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I81_XG_MN1 (XI1_I1436_I81_XG_n1 I1_I1436_gn14 I1_I1436_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I80_XG_MN2 (XI1_I1436_I80_XG_n1 I1_I1436_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I80_XG_MN0 (I1_I1436_G14_13 I1_I1436_pn14 XI1_I1436_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I80_XG_MN1 (XI1_I1436_I80_XG_n1 I1_I1436_gn13 I1_I1436_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I79_XG_MN2 (XI1_I1436_I79_XG_n1 I1_I1436_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I79_XG_MN0 (I1_I1436_G13_12 I1_I1436_pn13 XI1_I1436_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I79_XG_MN1 (XI1_I1436_I79_XG_n1 I1_I1436_gn12 I1_I1436_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I78_XG_MN2 (XI1_I1436_I78_XG_n1 I1_I1436_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I78_XG_MN0 (I1_I1436_G12_11 I1_I1436_pn12 XI1_I1436_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I78_XG_MN1 (XI1_I1436_I78_XG_n1 I1_I1436_gn11 I1_I1436_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I77_XG_MN2 (XI1_I1436_I77_XG_n1 I1_I1436_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I77_XG_MN0 (I1_I1436_G11_10 I1_I1436_pn11 XI1_I1436_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I77_XG_MN1 (XI1_I1436_I77_XG_n1 I1_I1436_gn10 I1_I1436_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I65_XG_MN2 (XI1_I1390_I65_XG_n1 I1_I1390_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I65_XG_MN0 (I1_I1390_G0_0 I1_I1390_pn0 XI1_I1390_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1390_I65_XG_MN1 (XI1_I1390_I65_XG_n1 I1_I1390_cinn I1_I1390_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I93_XG_MN2 (XI1_I1114_I93_XG_n1 I1_I1114_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I93_XG_MN0 (I1_I1114_G27_26 I1_I1114_pn27 XI1_I1114_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I93_XG_MN1 (XI1_I1114_I93_XG_n1 I1_I1114_gn26 I1_I1114_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I96_XG_MN2 (XI1_I1114_I96_XG_n1 I1_I1114_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I96_XG_MN0 (I1_I1114_G30_29 I1_I1114_pn30 XI1_I1114_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I96_XG_MN1 (XI1_I1114_I96_XG_n1 I1_I1114_gn29 I1_I1114_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I155_XG_MN2 (XI1_I1114_I155_XG_n1 I1_I1114_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I155_XG_MN0 (I1_I1114_G30_23 I1_I1114_P30_27n XI1_I1114_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I155_XG_MN1 (XI1_I1114_I155_XG_n1 I1_I1114_G26_23n I1_I1114_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I97_XG_MN2 (XI1_I1114_I97_XG_n1 I1_I1114_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I97_XG_MN0 (I1_I1114_G31_30 I1_I1114_pn31 XI1_I1114_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I97_XG_MN1 (XI1_I1114_I97_XG_n1 I1_I1114_gn30 I1_I1114_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I201_XG_MN2 (XI1_I1114_I201_XG_n1 I1_I1114_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I201_XG_MN0 (I1_c12_m I1_I1114_P30_15n XI1_I1114_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I201_XG_MN1 (XI1_I1114_I201_XG_n1 I1_I1114_G14_0n I1_c12_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I95_XG_MN2 (XI1_I1068_I95_XG_n1 I1_I1068_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I95_XG_MN0 (I1_I1068_G29_28 I1_I1068_pn29 XI1_I1068_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I95_XG_MN1 (XI1_I1068_I95_XG_n1 I1_I1068_gn28 I1_I1068_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I188_XG_MN2 (XI1_I930_I188_XG_n1 I1_I930_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I188_XG_MN0 (I1_I930_G20_0 I1_I930_P20_5n XI1_I930_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I188_XG_MN1 (XI1_I930_I188_XG_n1 I1_I930_G4_0n I1_I930_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I183_XG_MN2 (XI1_I930_I183_XG_n1 I1_I930_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I183_XG_MN0 (I1_I930_G16_0 I1_I930_P16_1n XI1_I930_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I183_XG_MN1 (XI1_I930_I183_XG_n1 I1_I930_G0_0n I1_I930_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I128_XG_MN2 (XI1_I930_I128_XG_n1 I1_I930_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I128_XG_MN0 (I1_I930_G4_0 I1_I930_P4_1n XI1_I930_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I128_XG_MN1 (XI1_I930_I128_XG_n1 I1_I930_G0_0n I1_I930_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I68_XG_MN2 (XI1_I930_I68_XG_n1 I1_I930_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I68_XG_MN0 (I1_I930_G2_1 I1_I930_pn2 XI1_I930_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I68_XG_MN1 (XI1_I930_I68_XG_n1 I1_I930_gn1 I1_I930_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I68_XG_MN2 (XI1_I654_I68_XG_n1 I1_I654_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I68_XG_MN0 (I1_I654_G2_1 I1_I654_pn2 XI1_I654_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I68_XG_MN1 (XI1_I654_I68_XG_n1 I1_I654_gn1 I1_I654_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I67_XG_MN2 (XI1_I654_I67_XG_n1 I1_I654_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I67_XG_MN0 (I1_I654_G1_0 I1_I654_pn1 XI1_I654_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I67_XG_MN1 (XI1_I654_I67_XG_n1 I1_I654_G0_0n I1_I654_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I128_XG_MN2 (XI1_I654_I128_XG_n1 I1_I654_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I128_XG_MN0 (I1_I654_G4_0 I1_I654_P4_1n XI1_I654_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I128_XG_MN1 (XI1_I654_I128_XG_n1 I1_I654_G0_0n I1_I654_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I183_XG_MN2 (XI1_I654_I183_XG_n1 I1_I654_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I183_XG_MN0 (I1_I654_G16_0 I1_I654_P16_1n XI1_I654_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I183_XG_MN1 (XI1_I654_I183_XG_n1 I1_I654_G0_0n I1_I654_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I185_XG_MN2 (XI1_I654_I185_XG_n1 I1_I654_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I185_XG_MN0 (I1_I654_G18_0 I1_I654_P18_3n XI1_I654_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I185_XG_MN1 (XI1_I654_I185_XG_n1 I1_I654_G2_0n I1_I654_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I188_XG_MN2 (XI1_I654_I188_XG_n1 I1_I654_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I188_XG_MN0 (I1_I654_G20_0 I1_I654_P20_5n XI1_I654_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I188_XG_MN1 (XI1_I654_I188_XG_n1 I1_I654_G4_0n I1_I654_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I150_XG_MN2 (XI1_I654_I150_XG_n1 I1_I654_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I150_XG_MN0 (I1_I654_G25_18 I1_I654_P25_22n XI1_I654_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I150_XG_MN1 (XI1_I654_I150_XG_n1 I1_I654_G21_18n I1_I654_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I152_XG_MN2 (XI1_I654_I152_XG_n1 I1_I654_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I152_XG_MN0 (I1_I654_G27_20 I1_I654_P27_24n XI1_I654_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I152_XG_MN1 (XI1_I654_I152_XG_n1 I1_I654_G23_20n I1_I654_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I154_XG_MN2 (XI1_I654_I154_XG_n1 I1_I654_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I154_XG_MN0 (I1_I654_G29_22 I1_I654_P29_26n XI1_I654_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I154_XG_MN1 (XI1_I654_I154_XG_n1 I1_I654_G25_22n I1_I654_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I156_XG_MN2 (XI1_I654_I156_XG_n1 I1_I654_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I156_XG_MN0 (I1_I654_G31_24 I1_I654_P31_28n XI1_I654_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I156_XG_MN1 (XI1_I654_I156_XG_n1 I1_I654_G27_24n I1_I654_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I95_XG_MN2 (XI1_I1436_I95_XG_n1 I1_I1436_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I95_XG_MN0 (I1_I1436_G29_28 I1_I1436_pn29 XI1_I1436_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I95_XG_MN1 (XI1_I1436_I95_XG_n1 I1_I1436_gn28 I1_I1436_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I94_XG_MN2 (XI1_I1436_I94_XG_n1 I1_I1436_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I94_XG_MN0 (I1_I1436_G28_27 I1_I1436_pn28 XI1_I1436_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I94_XG_MN1 (XI1_I1436_I94_XG_n1 I1_I1436_gn27 I1_I1436_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I153_XG_MN2 (XI1_I1436_I153_XG_n1 I1_I1436_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I153_XG_MN0 (I1_I1436_G28_21 I1_I1436_P28_25n XI1_I1436_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I153_XG_MN1 (XI1_I1436_I153_XG_n1 I1_I1436_G24_21n I1_I1436_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I147_XG_MN2 (XI1_I1436_I147_XG_n1 I1_I1436_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I147_XG_MN0 (I1_I1436_G22_15 I1_I1436_P22_19n XI1_I1436_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I147_XG_MN1 (XI1_I1436_I147_XG_n1 I1_I1436_G18_15n I1_I1436_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I149_XG_MN2 (XI1_I1436_I149_XG_n1 I1_I1436_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I149_XG_MN0 (I1_I1436_G24_17 I1_I1436_P24_21n XI1_I1436_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I149_XG_MN1 (XI1_I1436_I149_XG_n1 I1_I1436_G20_17n I1_I1436_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I139_XG_MN2 (XI1_I1436_I139_XG_n1 I1_I1436_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I139_XG_MN0 (I1_I1436_G14_7 I1_I1436_P14_11n XI1_I1436_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I139_XG_MN1 (XI1_I1436_I139_XG_n1 I1_I1436_G10_7n I1_I1436_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I141_XG_MN2 (XI1_I1436_I141_XG_n1 I1_I1436_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I141_XG_MN0 (I1_I1436_G16_9 I1_I1436_P16_13n XI1_I1436_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I141_XG_MN1 (XI1_I1436_I141_XG_n1 I1_I1436_G12_9n I1_I1436_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I137_XG_MN2 (XI1_I1436_I137_XG_n1 I1_I1436_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I137_XG_MN0 (I1_I1436_G12_5 I1_I1436_P12_9n XI1_I1436_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I137_XG_MN1 (XI1_I1436_I137_XG_n1 I1_I1436_G8_5n I1_I1436_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I135_XG_MN2 (XI1_I1436_I135_XG_n1 I1_I1436_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I135_XG_MN0 (I1_I1436_G10_3 I1_I1436_P10_7n XI1_I1436_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I135_XG_MN1 (XI1_I1436_I135_XG_n1 I1_I1436_G6_3n I1_I1436_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I72_XG_MN2 (XI1_I1436_I72_XG_n1 I1_I1436_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I72_XG_MN0 (I1_I1436_G6_5 I1_I1436_pn6 XI1_I1436_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I72_XG_MN1 (XI1_I1436_I72_XG_n1 I1_I1436_gn5 I1_I1436_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I71_XG_MN2 (XI1_I1436_I71_XG_n1 I1_I1436_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I71_XG_MN0 (I1_I1436_G5_4 I1_I1436_pn5 XI1_I1436_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I71_XG_MN1 (XI1_I1436_I71_XG_n1 I1_I1436_gn4 I1_I1436_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I70_XG_MN2 (XI1_I1436_I70_XG_n1 I1_I1436_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I70_XG_MN0 (I1_I1436_G4_3 I1_I1436_pn4 XI1_I1436_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I70_XG_MN1 (XI1_I1436_I70_XG_n1 I1_I1436_gn3 I1_I1436_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I156_XG_MN2 (XI1_I1114_I156_XG_n1 I1_I1114_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I156_XG_MN0 (I1_I1114_G31_24 I1_I1114_P31_28n XI1_I1114_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I156_XG_MN1 (XI1_I1114_I156_XG_n1 I1_I1114_G27_24n I1_I1114_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I91_XG_MN2 (XI1_I1114_I91_XG_n1 I1_I1114_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I91_XG_MN0 (I1_I1114_G25_24 I1_I1114_pn25 XI1_I1114_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I91_XG_MN1 (XI1_I1114_I91_XG_n1 I1_I1114_gn24 I1_I1114_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I92_XG_MN2 (XI1_I1114_I92_XG_n1 I1_I1114_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I92_XG_MN0 (I1_I1114_G26_25 I1_I1114_pn26 XI1_I1114_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I92_XG_MN1 (XI1_I1114_I92_XG_n1 I1_I1114_gn25 I1_I1114_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I90_XG_MN2 (XI1_I1114_I90_XG_n1 I1_I1114_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I90_XG_MN0 (I1_I1114_G24_23 I1_I1114_pn24 XI1_I1114_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I90_XG_MN1 (XI1_I1114_I90_XG_n1 I1_I1114_gn23 I1_I1114_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I192_XG_MN2 (XI1_I1114_I192_XG_n1 I1_I1114_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I192_XG_MN0 (I1_I1114_G22_0 I1_I1114_P22_7n XI1_I1114_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I192_XG_MN1 (XI1_I1114_I192_XG_n1 I1_I1114_G6_0n I1_I1114_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I94_XG_MN2 (XI1_I1068_I94_XG_n1 I1_I1068_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I94_XG_MN0 (I1_I1068_G28_27 I1_I1068_pn28 XI1_I1068_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I94_XG_MN1 (XI1_I1068_I94_XG_n1 I1_I1068_gn27 I1_I1068_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I93_XG_MN2 (XI1_I1068_I93_XG_n1 I1_I1068_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I93_XG_MN0 (I1_I1068_G27_26 I1_I1068_pn27 XI1_I1068_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I93_XG_MN1 (XI1_I1068_I93_XG_n1 I1_I1068_gn26 I1_I1068_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I96_XG_MN2 (XI1_I1068_I96_XG_n1 I1_I1068_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I96_XG_MN0 (I1_I1068_G30_29 I1_I1068_pn30 XI1_I1068_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I96_XG_MN1 (XI1_I1068_I96_XG_n1 I1_I1068_gn29 I1_I1068_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I97_XG_MN2 (XI1_I1068_I97_XG_n1 I1_I1068_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I97_XG_MN0 (I1_I1068_G31_30 I1_I1068_pn31 XI1_I1068_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I97_XG_MN1 (XI1_I1068_I97_XG_n1 I1_I1068_gn30 I1_I1068_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I96_XG_MN2 (XI1_I976_I96_XG_n1 I1_I976_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I96_XG_MN0 (I1_I976_G30_29 I1_I976_pn30 XI1_I976_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I96_XG_MN1 (XI1_I976_I96_XG_n1 I1_I976_gn29 I1_I976_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I94_XG_MN2 (XI1_I976_I94_XG_n1 I1_I976_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I94_XG_MN0 (I1_I976_G28_27 I1_I976_pn28 XI1_I976_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I94_XG_MN1 (XI1_I976_I94_XG_n1 I1_I976_gn27 I1_I976_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I93_XG_MN2 (XI1_I976_I93_XG_n1 I1_I976_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I93_XG_MN0 (I1_I976_G27_26 I1_I976_pn27 XI1_I976_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I93_XG_MN1 (XI1_I976_I93_XG_n1 I1_I976_gn26 I1_I976_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I92_XG_MN2 (XI1_I976_I92_XG_n1 I1_I976_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I92_XG_MN0 (I1_I976_G26_25 I1_I976_pn26 XI1_I976_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I92_XG_MN1 (XI1_I976_I92_XG_n1 I1_I976_gn25 I1_I976_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I89_XG_MN2 (XI1_I976_I89_XG_n1 I1_I976_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I89_XG_MN0 (I1_I976_G23_22 I1_I976_pn23 XI1_I976_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I89_XG_MN1 (XI1_I976_I89_XG_n1 I1_I976_gn22 I1_I976_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I88_XG_MN2 (XI1_I976_I88_XG_n1 I1_I976_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I88_XG_MN0 (I1_I976_G22_21 I1_I976_pn22 XI1_I976_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I88_XG_MN1 (XI1_I976_I88_XG_n1 I1_I976_gn21 I1_I976_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I86_XG_MN2 (XI1_I976_I86_XG_n1 I1_I976_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I86_XG_MN0 (I1_I976_G20_19 I1_I976_pn20 XI1_I976_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I86_XG_MN1 (XI1_I976_I86_XG_n1 I1_I976_gn19 I1_I976_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I87_XG_MN2 (XI1_I976_I87_XG_n1 I1_I976_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I87_XG_MN0 (I1_I976_G21_20 I1_I976_pn21 XI1_I976_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I87_XG_MN1 (XI1_I976_I87_XG_n1 I1_I976_gn20 I1_I976_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I85_XG_MN2 (XI1_I976_I85_XG_n1 I1_I976_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I85_XG_MN0 (I1_I976_G19_18 I1_I976_pn19 XI1_I976_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I85_XG_MN1 (XI1_I976_I85_XG_n1 I1_I976_gn18 I1_I976_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I67_XG_MN2 (XI1_I930_I67_XG_n1 I1_I930_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I67_XG_MN0 (I1_I930_G1_0 I1_I930_pn1 XI1_I930_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I67_XG_MN1 (XI1_I930_I67_XG_n1 I1_I930_G0_0n I1_I930_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I65_XG_MN2 (XI1_I884_I65_XG_n1 I1_I884_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I65_XG_MN0 (I1_I884_G0_0 I1_I884_pn0 XI1_I884_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I884_I65_XG_MN1 (XI1_I884_I65_XG_n1 I1_I884_cinn I1_I884_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I69_XG_MN2 (XI1_I654_I69_XG_n1 I1_I654_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I69_XG_MN0 (I1_I654_G3_2 I1_I654_pn3 XI1_I654_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I69_XG_MN1 (XI1_I654_I69_XG_n1 I1_I654_gn2 I1_I654_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I133_XG_MN2 (XI1_I654_I133_XG_n1 I1_I654_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I133_XG_MN0 (I1_I654_G8_1 I1_I654_P8_5n XI1_I654_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I133_XG_MN1 (XI1_I654_I133_XG_n1 I1_I654_G4_1n I1_I654_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I131_XG_MN2 (XI1_I654_I131_XG_n1 I1_I654_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I131_XG_MN0 (I1_I654_G6_0 I1_I654_P6_3n XI1_I654_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I131_XG_MN1 (XI1_I654_I131_XG_n1 I1_I654_G2_0n I1_I654_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I137_XG_MN2 (XI1_I654_I137_XG_n1 I1_I654_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I137_XG_MN0 (I1_I654_G12_5 I1_I654_P12_9n XI1_I654_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I137_XG_MN1 (XI1_I654_I137_XG_n1 I1_I654_G8_5n I1_I654_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I195_XG_MN2 (XI1_I654_I195_XG_n1 I1_I654_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I195_XG_MN0 (I1_I654_G24_0 I1_I654_P24_9n XI1_I654_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I195_XG_MN1 (XI1_I654_I195_XG_n1 I1_I654_G8_0n I1_I654_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I197_XG_MN2 (XI1_I654_I197_XG_n1 I1_I654_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I197_XG_MN0 (I1_I654_G26_0 I1_I654_P26_11n XI1_I654_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I197_XG_MN1 (XI1_I654_I197_XG_n1 I1_I654_G10_0n I1_I654_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I199_XG_MN2 (XI1_I654_I199_XG_n1 I1_I654_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I199_XG_MN0 (I1_I654_G28_0 I1_I654_P28_13n XI1_I654_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I199_XG_MN1 (XI1_I654_I199_XG_n1 I1_I654_G12_0n I1_I654_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I192_XG_MN2 (XI1_I654_I192_XG_n1 I1_I654_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I192_XG_MN0 (I1_I654_G22_0 I1_I654_P22_7n XI1_I654_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I192_XG_MN1 (XI1_I654_I192_XG_n1 I1_I654_G6_0n I1_I654_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I201_XG_MN2 (XI1_I654_I201_XG_n1 I1_I654_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I201_XG_MN0 (I1_c2_m I1_I654_P30_15n XI1_I654_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I201_XG_MN1 (XI1_I654_I201_XG_n1 I1_I654_G14_0n I1_c2_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I155_XG_MN2 (XI1_I654_I155_XG_n1 I1_I654_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I155_XG_MN0 (I1_I654_G30_23 I1_I654_P30_27n XI1_I654_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I155_XG_MN1 (XI1_I654_I155_XG_n1 I1_I654_G26_23n I1_I654_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I96_XG_MN2 (XI1_I1436_I96_XG_n1 I1_I1436_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I96_XG_MN0 (I1_I1436_G30_29 I1_I1436_pn30 XI1_I1436_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I96_XG_MN1 (XI1_I1436_I96_XG_n1 I1_I1436_gn29 I1_I1436_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I155_XG_MN2 (XI1_I1436_I155_XG_n1 I1_I1436_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I155_XG_MN0 (I1_I1436_G30_23 I1_I1436_P30_27n XI1_I1436_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I155_XG_MN1 (XI1_I1436_I155_XG_n1 I1_I1436_G26_23n I1_I1436_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I201_XG_MN2 (XI1_I1436_I201_XG_n1 I1_I1436_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I201_XG_MN0 (I1_c19_m I1_I1436_P30_15n XI1_I1436_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I201_XG_MN1 (XI1_I1436_I201_XG_n1 I1_I1436_G14_0n I1_c19_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I199_XG_MN2 (XI1_I1436_I199_XG_n1 I1_I1436_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I199_XG_MN0 (I1_I1436_G28_0 I1_I1436_P28_13n XI1_I1436_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I199_XG_MN1 (XI1_I1436_I199_XG_n1 I1_I1436_G12_0n I1_I1436_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I151_XG_MN2 (XI1_I1436_I151_XG_n1 I1_I1436_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I151_XG_MN0 (I1_I1436_G26_19 I1_I1436_P26_23n XI1_I1436_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I151_XG_MN1 (XI1_I1436_I151_XG_n1 I1_I1436_G22_19n I1_I1436_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I192_XG_MN2 (XI1_I1436_I192_XG_n1 I1_I1436_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I192_XG_MN0 (I1_I1436_G22_0 I1_I1436_P22_7n XI1_I1436_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I192_XG_MN1 (XI1_I1436_I192_XG_n1 I1_I1436_G6_0n I1_I1436_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I197_XG_MN2 (XI1_I1436_I197_XG_n1 I1_I1436_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I197_XG_MN0 (I1_I1436_G26_0 I1_I1436_P26_11n XI1_I1436_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I197_XG_MN1 (XI1_I1436_I197_XG_n1 I1_I1436_G10_0n I1_I1436_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I133_XG_MN2 (XI1_I1436_I133_XG_n1 I1_I1436_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I133_XG_MN0 (I1_I1436_G8_1 I1_I1436_P8_5n XI1_I1436_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I133_XG_MN1 (XI1_I1436_I133_XG_n1 I1_I1436_G4_1n I1_I1436_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I131_XG_MN2 (XI1_I1436_I131_XG_n1 I1_I1436_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I131_XG_MN0 (I1_I1436_G6_0 I1_I1436_P6_3n XI1_I1436_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I131_XG_MN1 (XI1_I1436_I131_XG_n1 I1_I1436_G2_0n I1_I1436_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I128_XG_MN2 (XI1_I1436_I128_XG_n1 I1_I1436_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I128_XG_MN0 (I1_I1436_G4_0 I1_I1436_P4_1n XI1_I1436_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I128_XG_MN1 (XI1_I1436_I128_XG_n1 I1_I1436_G0_0n I1_I1436_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I69_XG_MN2 (XI1_I1436_I69_XG_n1 I1_I1436_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I69_XG_MN0 (I1_I1436_G3_2 I1_I1436_pn3 XI1_I1436_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I69_XG_MN1 (XI1_I1436_I69_XG_n1 I1_I1436_gn2 I1_I1436_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I68_XG_MN2 (XI1_I1436_I68_XG_n1 I1_I1436_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I68_XG_MN0 (I1_I1436_G2_1 I1_I1436_pn2 XI1_I1436_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I68_XG_MN1 (XI1_I1436_I68_XG_n1 I1_I1436_gn1 I1_I1436_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I152_XG_MN2 (XI1_I1114_I152_XG_n1 I1_I1114_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I152_XG_MN0 (I1_I1114_G27_20 I1_I1114_P27_24n XI1_I1114_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I152_XG_MN1 (XI1_I1114_I152_XG_n1 I1_I1114_G23_20n I1_I1114_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I151_XG_MN2 (XI1_I1114_I151_XG_n1 I1_I1114_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I151_XG_MN0 (I1_I1114_G26_19 I1_I1114_P26_23n XI1_I1114_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I151_XG_MN1 (XI1_I1114_I151_XG_n1 I1_I1114_G22_19n I1_I1114_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I147_XG_MN2 (XI1_I1114_I147_XG_n1 I1_I1114_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I147_XG_MN0 (I1_I1114_G22_15 I1_I1114_P22_19n XI1_I1114_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I147_XG_MN1 (XI1_I1114_I147_XG_n1 I1_I1114_G18_15n I1_I1114_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I89_XG_MN2 (XI1_I1114_I89_XG_n1 I1_I1114_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I89_XG_MN0 (I1_I1114_G23_22 I1_I1114_pn23 XI1_I1114_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I89_XG_MN1 (XI1_I1114_I89_XG_n1 I1_I1114_gn22 I1_I1114_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I199_XG_MN2 (XI1_I1068_I199_XG_n1 I1_I1068_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I199_XG_MN0 (I1_I1068_G28_0 I1_I1068_P28_13n XI1_I1068_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I199_XG_MN1 (XI1_I1068_I199_XG_n1 I1_I1068_G12_0n I1_I1068_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I201_XG_MN2 (XI1_I1068_I201_XG_n1 I1_I1068_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I201_XG_MN0 (I1_c11_m I1_I1068_P30_15n XI1_I1068_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I201_XG_MN1 (XI1_I1068_I201_XG_n1 I1_I1068_G14_0n I1_c11_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I155_XG_MN2 (XI1_I1068_I155_XG_n1 I1_I1068_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I155_XG_MN0 (I1_I1068_G30_23 I1_I1068_P30_27n XI1_I1068_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I155_XG_MN1 (XI1_I1068_I155_XG_n1 I1_I1068_G26_23n I1_I1068_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I202_XG_MN2 (XI1_I1068_I202_XG_n1 I1_I1068_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I202_XG_MN0 (I1_c11_o I1_I1068_P31_16n XI1_I1068_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I202_XG_MN1 (XI1_I1068_I202_XG_n1 I1_I1068_G15_0n I1_c11_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I156_XG_MN2 (XI1_I1068_I156_XG_n1 I1_I1068_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I156_XG_MN0 (I1_I1068_G31_24 I1_I1068_P31_28n XI1_I1068_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I156_XG_MN1 (XI1_I1068_I156_XG_n1 I1_I1068_G27_24n I1_I1068_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I92_XG_MN2 (XI1_I1068_I92_XG_n1 I1_I1068_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I92_XG_MN0 (I1_I1068_G26_25 I1_I1068_pn26 XI1_I1068_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I92_XG_MN1 (XI1_I1068_I92_XG_n1 I1_I1068_gn25 I1_I1068_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I91_XG_MN2 (XI1_I1068_I91_XG_n1 I1_I1068_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I91_XG_MN0 (I1_I1068_G25_24 I1_I1068_pn25 XI1_I1068_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I91_XG_MN1 (XI1_I1068_I91_XG_n1 I1_I1068_gn24 I1_I1068_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I156_XG_MN2 (XI1_I976_I156_XG_n1 I1_I976_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I156_XG_MN0 (I1_I976_G31_24 I1_I976_P31_28n XI1_I976_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I156_XG_MN1 (XI1_I976_I156_XG_n1 I1_I976_G27_24n I1_I976_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I154_XG_MN2 (XI1_I976_I154_XG_n1 I1_I976_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I154_XG_MN0 (I1_I976_G29_22 I1_I976_P29_26n XI1_I976_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I154_XG_MN1 (XI1_I976_I154_XG_n1 I1_I976_G25_22n I1_I976_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I84_XG_MN2 (XI1_I976_I84_XG_n1 I1_I976_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I84_XG_MN0 (I1_I976_G18_17 I1_I976_pn18 XI1_I976_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I84_XG_MN1 (XI1_I976_I84_XG_n1 I1_I976_gn17 I1_I976_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I83_XG_MN2 (XI1_I976_I83_XG_n1 I1_I976_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I83_XG_MN0 (I1_I976_G17_16 I1_I976_pn17 XI1_I976_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I83_XG_MN1 (XI1_I976_I83_XG_n1 I1_I976_gn16 I1_I976_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I150_XG_MN2 (XI1_I976_I150_XG_n1 I1_I976_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I150_XG_MN0 (I1_I976_G25_18 I1_I976_P25_22n XI1_I976_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I150_XG_MN1 (XI1_I976_I150_XG_n1 I1_I976_G21_18n I1_I976_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I79_XG_MN2 (XI1_I976_I79_XG_n1 I1_I976_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I79_XG_MN0 (I1_I976_G13_12 I1_I976_pn13 XI1_I976_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I79_XG_MN1 (XI1_I976_I79_XG_n1 I1_I976_gn12 I1_I976_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I142_XG_MN2 (XI1_I976_I142_XG_n1 I1_I976_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I142_XG_MN0 (I1_I976_G17_10 I1_I976_P17_14n XI1_I976_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I142_XG_MN1 (XI1_I976_I142_XG_n1 I1_I976_G13_10n I1_I976_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I78_XG_MN2 (XI1_I976_I78_XG_n1 I1_I976_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I78_XG_MN0 (I1_I976_G12_11 I1_I976_pn12 XI1_I976_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I78_XG_MN1 (XI1_I976_I78_XG_n1 I1_I976_gn11 I1_I976_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I77_XG_MN2 (XI1_I976_I77_XG_n1 I1_I976_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I77_XG_MN0 (I1_I976_G11_10 I1_I976_pn11 XI1_I976_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I77_XG_MN1 (XI1_I976_I77_XG_n1 I1_I976_gn10 I1_I976_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I70_XG_MN2 (XI1_I654_I70_XG_n1 I1_I654_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I70_XG_MN0 (I1_I654_G4_3 I1_I654_pn4 XI1_I654_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I70_XG_MN1 (XI1_I654_I70_XG_n1 I1_I654_gn3 I1_I654_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I71_XG_MN2 (XI1_I654_I71_XG_n1 I1_I654_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I71_XG_MN0 (I1_I654_G5_4 I1_I654_pn5 XI1_I654_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I71_XG_MN1 (XI1_I654_I71_XG_n1 I1_I654_gn4 I1_I654_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I72_XG_MN2 (XI1_I654_I72_XG_n1 I1_I654_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I72_XG_MN0 (I1_I654_G6_5 I1_I654_pn6 XI1_I654_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I72_XG_MN1 (XI1_I654_I72_XG_n1 I1_I654_gn5 I1_I654_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I73_XG_MN2 (XI1_I654_I73_XG_n1 I1_I654_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I73_XG_MN0 (I1_I654_G7_6 I1_I654_pn7 XI1_I654_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I73_XG_MN1 (XI1_I654_I73_XG_n1 I1_I654_gn6 I1_I654_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I75_XG_MN2 (XI1_I654_I75_XG_n1 I1_I654_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I75_XG_MN0 (I1_I654_G9_8 I1_I654_pn9 XI1_I654_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I75_XG_MN1 (XI1_I654_I75_XG_n1 I1_I654_gn8 I1_I654_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I135_XG_MN2 (XI1_I654_I135_XG_n1 I1_I654_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I135_XG_MN0 (I1_I654_G10_3 I1_I654_P10_7n XI1_I654_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I135_XG_MN1 (XI1_I654_I135_XG_n1 I1_I654_G6_3n I1_I654_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I141_XG_MN2 (XI1_I654_I141_XG_n1 I1_I654_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I141_XG_MN0 (I1_I654_G16_9 I1_I654_P16_13n XI1_I654_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I141_XG_MN1 (XI1_I654_I141_XG_n1 I1_I654_G12_9n I1_I654_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I139_XG_MN2 (XI1_I654_I139_XG_n1 I1_I654_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I139_XG_MN0 (I1_I654_G14_7 I1_I654_P14_11n XI1_I654_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I139_XG_MN1 (XI1_I654_I139_XG_n1 I1_I654_G10_7n I1_I654_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I143_XG_MN2 (XI1_I654_I143_XG_n1 I1_I654_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I143_XG_MN0 (I1_I654_G18_11 I1_I654_P18_15n XI1_I654_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I143_XG_MN1 (XI1_I654_I143_XG_n1 I1_I654_G14_11n I1_I654_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I145_XG_MN2 (XI1_I654_I145_XG_n1 I1_I654_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I145_XG_MN0 (I1_I654_G20_13 I1_I654_P20_17n XI1_I654_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I145_XG_MN1 (XI1_I654_I145_XG_n1 I1_I654_G16_13n I1_I654_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I149_XG_MN2 (XI1_I654_I149_XG_n1 I1_I654_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I149_XG_MN0 (I1_I654_G24_17 I1_I654_P24_21n XI1_I654_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I149_XG_MN1 (XI1_I654_I149_XG_n1 I1_I654_G20_17n I1_I654_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I147_XG_MN2 (XI1_I654_I147_XG_n1 I1_I654_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I147_XG_MN0 (I1_I654_G22_15 I1_I654_P22_19n XI1_I654_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I147_XG_MN1 (XI1_I654_I147_XG_n1 I1_I654_G18_15n I1_I654_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I151_XG_MN2 (XI1_I654_I151_XG_n1 I1_I654_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I151_XG_MN0 (I1_I654_G26_19 I1_I654_P26_23n XI1_I654_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I151_XG_MN1 (XI1_I654_I151_XG_n1 I1_I654_G22_19n I1_I654_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I153_XG_MN2 (XI1_I654_I153_XG_n1 I1_I654_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I153_XG_MN0 (I1_I654_G28_21 I1_I654_P28_25n XI1_I654_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I153_XG_MN1 (XI1_I654_I153_XG_n1 I1_I654_G24_21n I1_I654_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I90_XG_MN2 (XI1_I654_I90_XG_n1 I1_I654_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I90_XG_MN0 (I1_I654_G24_23 I1_I654_pn24 XI1_I654_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I90_XG_MN1 (XI1_I654_I90_XG_n1 I1_I654_gn23 I1_I654_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I91_XG_MN2 (XI1_I654_I91_XG_n1 I1_I654_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I91_XG_MN0 (I1_I654_G25_24 I1_I654_pn25 XI1_I654_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I91_XG_MN1 (XI1_I654_I91_XG_n1 I1_I654_gn24 I1_I654_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I92_XG_MN2 (XI1_I654_I92_XG_n1 I1_I654_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I92_XG_MN0 (I1_I654_G26_25 I1_I654_pn26 XI1_I654_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I92_XG_MN1 (XI1_I654_I92_XG_n1 I1_I654_gn25 I1_I654_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I93_XG_MN2 (XI1_I654_I93_XG_n1 I1_I654_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I93_XG_MN0 (I1_I654_G27_26 I1_I654_pn27 XI1_I654_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I93_XG_MN1 (XI1_I654_I93_XG_n1 I1_I654_gn26 I1_I654_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I96_XG_MN2 (XI1_I654_I96_XG_n1 I1_I654_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I96_XG_MN0 (I1_I654_G30_29 I1_I654_pn30 XI1_I654_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I96_XG_MN1 (XI1_I654_I96_XG_n1 I1_I654_gn29 I1_I654_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I188_XG_MN2 (XI1_I1436_I188_XG_n1 I1_I1436_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I188_XG_MN0 (I1_I1436_G20_0 I1_I1436_P20_5n XI1_I1436_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I188_XG_MN1 (XI1_I1436_I188_XG_n1 I1_I1436_G4_0n I1_I1436_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I195_XG_MN2 (XI1_I1436_I195_XG_n1 I1_I1436_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I195_XG_MN0 (I1_I1436_G24_0 I1_I1436_P24_9n XI1_I1436_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I195_XG_MN1 (XI1_I1436_I195_XG_n1 I1_I1436_G8_0n I1_I1436_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I185_XG_MN2 (XI1_I1436_I185_XG_n1 I1_I1436_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I185_XG_MN0 (I1_I1436_G18_0 I1_I1436_P18_3n XI1_I1436_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I185_XG_MN1 (XI1_I1436_I185_XG_n1 I1_I1436_G2_0n I1_I1436_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I183_XG_MN2 (XI1_I1436_I183_XG_n1 I1_I1436_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I183_XG_MN0 (I1_I1436_G16_0 I1_I1436_P16_1n XI1_I1436_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I183_XG_MN1 (XI1_I1436_I183_XG_n1 I1_I1436_G0_0n I1_I1436_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I67_XG_MN2 (XI1_I1436_I67_XG_n1 I1_I1436_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I67_XG_MN0 (I1_I1436_G1_0 I1_I1436_pn1 XI1_I1436_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I67_XG_MN1 (XI1_I1436_I67_XG_n1 I1_I1436_G0_0n I1_I1436_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I148_XG_MN2 (XI1_I1114_I148_XG_n1 I1_I1114_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I148_XG_MN0 (I1_I1114_G23_16 I1_I1114_P23_20n XI1_I1114_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I148_XG_MN1 (XI1_I1114_I148_XG_n1 I1_I1114_G19_16n I1_I1114_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I194_XG_MN2 (XI1_I1114_I194_XG_n1 I1_I1114_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I194_XG_MN0 (I1_I1114_G23_0 I1_I1114_P23_8n XI1_I1114_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I194_XG_MN1 (XI1_I1114_I194_XG_n1 I1_I1114_G7_0n I1_I1114_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I150_XG_MN2 (XI1_I1114_I150_XG_n1 I1_I1114_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I150_XG_MN0 (I1_I1114_G25_18 I1_I1114_P25_22n XI1_I1114_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I150_XG_MN1 (XI1_I1114_I150_XG_n1 I1_I1114_G21_18n I1_I1114_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I200_XG_MN2 (XI1_I1114_I200_XG_n1 I1_I1114_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I200_XG_MN0 (I1_I1114_G29_0 I1_I1114_P29_14n XI1_I1114_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I200_XG_MN1 (XI1_I1114_I200_XG_n1 I1_I1114_G13_0n I1_I1114_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I153_XG_MN2 (XI1_I1114_I153_XG_n1 I1_I1114_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I153_XG_MN0 (I1_I1114_G28_21 I1_I1114_P28_25n XI1_I1114_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I153_XG_MN1 (XI1_I1114_I153_XG_n1 I1_I1114_G24_21n I1_I1114_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I88_XG_MN2 (XI1_I1114_I88_XG_n1 I1_I1114_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I88_XG_MN0 (I1_I1114_G22_21 I1_I1114_pn22 XI1_I1114_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I88_XG_MN1 (XI1_I1114_I88_XG_n1 I1_I1114_gn21 I1_I1114_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I87_XG_MN2 (XI1_I1114_I87_XG_n1 I1_I1114_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I87_XG_MN0 (I1_I1114_G21_20 I1_I1114_pn21 XI1_I1114_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I87_XG_MN1 (XI1_I1114_I87_XG_n1 I1_I1114_gn20 I1_I1114_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I86_XG_MN2 (XI1_I1114_I86_XG_n1 I1_I1114_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I86_XG_MN0 (I1_I1114_G20_19 I1_I1114_pn20 XI1_I1114_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I86_XG_MN1 (XI1_I1114_I86_XG_n1 I1_I1114_gn19 I1_I1114_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I85_XG_MN2 (XI1_I1114_I85_XG_n1 I1_I1114_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I85_XG_MN0 (I1_I1114_G19_18 I1_I1114_pn19 XI1_I1114_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I85_XG_MN1 (XI1_I1114_I85_XG_n1 I1_I1114_gn18 I1_I1114_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I153_XG_MN2 (XI1_I1068_I153_XG_n1 I1_I1068_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I153_XG_MN0 (I1_I1068_G28_21 I1_I1068_P28_25n XI1_I1068_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I153_XG_MN1 (XI1_I1068_I153_XG_n1 I1_I1068_G24_21n I1_I1068_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I200_XG_MN2 (XI1_I1068_I200_XG_n1 I1_I1068_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I200_XG_MN0 (I1_I1068_G29_0 I1_I1068_P29_14n XI1_I1068_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I200_XG_MN1 (XI1_I1068_I200_XG_n1 I1_I1068_G13_0n I1_I1068_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I154_XG_MN2 (XI1_I1068_I154_XG_n1 I1_I1068_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I154_XG_MN0 (I1_I1068_G29_22 I1_I1068_P29_26n XI1_I1068_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I154_XG_MN1 (XI1_I1068_I154_XG_n1 I1_I1068_G25_22n I1_I1068_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I90_XG_MN2 (XI1_I1068_I90_XG_n1 I1_I1068_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I90_XG_MN0 (I1_I1068_G24_23 I1_I1068_pn24 XI1_I1068_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I90_XG_MN1 (XI1_I1068_I90_XG_n1 I1_I1068_gn23 I1_I1068_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I89_XG_MN2 (XI1_I1068_I89_XG_n1 I1_I1068_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I89_XG_MN0 (I1_I1068_G23_22 I1_I1068_pn23 XI1_I1068_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I89_XG_MN1 (XI1_I1068_I89_XG_n1 I1_I1068_gn22 I1_I1068_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I96_XG_MN2 (XI1_I1022_I96_XG_n1 I1_I1022_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I96_XG_MN0 (I1_I1022_G30_29 I1_I1022_pn30 XI1_I1022_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I96_XG_MN1 (XI1_I1022_I96_XG_n1 I1_I1022_gn29 I1_I1022_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I97_XG_MN2 (XI1_I1022_I97_XG_n1 I1_I1022_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I97_XG_MN0 (I1_I1022_G31_30 I1_I1022_pn31 XI1_I1022_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I97_XG_MN1 (XI1_I1022_I97_XG_n1 I1_I1022_gn30 I1_I1022_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I202_XG_MN2 (XI1_I976_I202_XG_n1 I1_I976_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I202_XG_MN0 (I1_c9_o I1_I976_P31_16n XI1_I976_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I202_XG_MN1 (XI1_I976_I202_XG_n1 I1_I976_G15_0n I1_c9_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I152_XG_MN2 (XI1_I976_I152_XG_n1 I1_I976_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I152_XG_MN0 (I1_I976_G27_20 I1_I976_P27_24n XI1_I976_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I152_XG_MN1 (XI1_I976_I152_XG_n1 I1_I976_G23_20n I1_I976_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I144_XG_MN2 (XI1_I976_I144_XG_n1 I1_I976_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I144_XG_MN0 (I1_I976_G19_12 I1_I976_P19_16n XI1_I976_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I144_XG_MN1 (XI1_I976_I144_XG_n1 I1_I976_G15_12n I1_I976_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I146_XG_MN2 (XI1_I976_I146_XG_n1 I1_I976_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I146_XG_MN0 (I1_I976_G21_14 I1_I976_P21_18n XI1_I976_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I146_XG_MN1 (XI1_I976_I146_XG_n1 I1_I976_G17_14n I1_I976_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I196_XG_MN2 (XI1_I976_I196_XG_n1 I1_I976_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I196_XG_MN0 (I1_I976_G25_0 I1_I976_P25_10n XI1_I976_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I196_XG_MN1 (XI1_I976_I196_XG_n1 I1_I976_G9_0n I1_I976_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I138_XG_MN2 (XI1_I976_I138_XG_n1 I1_I976_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I138_XG_MN0 (I1_I976_G13_6 I1_I976_P13_10n XI1_I976_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I138_XG_MN1 (XI1_I976_I138_XG_n1 I1_I976_G9_6n I1_I976_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I76_XG_MN2 (XI1_I976_I76_XG_n1 I1_I976_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I76_XG_MN0 (I1_I976_G10_9 I1_I976_pn10 XI1_I976_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I76_XG_MN1 (XI1_I976_I76_XG_n1 I1_I976_gn9 I1_I976_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I75_XG_MN2 (XI1_I976_I75_XG_n1 I1_I976_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I75_XG_MN0 (I1_I976_G9_8 I1_I976_pn9 XI1_I976_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I75_XG_MN1 (XI1_I976_I75_XG_n1 I1_I976_gn8 I1_I976_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I74_XG_MN2 (XI1_I976_I74_XG_n1 I1_I976_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I74_XG_MN0 (I1_I976_G8_7 I1_I976_pn8 XI1_I976_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I74_XG_MN1 (XI1_I976_I74_XG_n1 I1_I976_gn7 I1_I976_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I73_XG_MN2 (XI1_I976_I73_XG_n1 I1_I976_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I73_XG_MN0 (I1_I976_G7_6 I1_I976_pn7 XI1_I976_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I73_XG_MN1 (XI1_I976_I73_XG_n1 I1_I976_gn6 I1_I976_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I74_XG_MN2 (XI1_I654_I74_XG_n1 I1_I654_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I74_XG_MN0 (I1_I654_G8_7 I1_I654_pn8 XI1_I654_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I74_XG_MN1 (XI1_I654_I74_XG_n1 I1_I654_gn7 I1_I654_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I76_XG_MN2 (XI1_I654_I76_XG_n1 I1_I654_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I76_XG_MN0 (I1_I654_G10_9 I1_I654_pn10 XI1_I654_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I76_XG_MN1 (XI1_I654_I76_XG_n1 I1_I654_gn9 I1_I654_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I77_XG_MN2 (XI1_I654_I77_XG_n1 I1_I654_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I77_XG_MN0 (I1_I654_G11_10 I1_I654_pn11 XI1_I654_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I77_XG_MN1 (XI1_I654_I77_XG_n1 I1_I654_gn10 I1_I654_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I78_XG_MN2 (XI1_I654_I78_XG_n1 I1_I654_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I78_XG_MN0 (I1_I654_G12_11 I1_I654_pn12 XI1_I654_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I78_XG_MN1 (XI1_I654_I78_XG_n1 I1_I654_gn11 I1_I654_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I79_XG_MN2 (XI1_I654_I79_XG_n1 I1_I654_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I79_XG_MN0 (I1_I654_G13_12 I1_I654_pn13 XI1_I654_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I79_XG_MN1 (XI1_I654_I79_XG_n1 I1_I654_gn12 I1_I654_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I80_XG_MN2 (XI1_I654_I80_XG_n1 I1_I654_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I80_XG_MN0 (I1_I654_G14_13 I1_I654_pn14 XI1_I654_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I80_XG_MN1 (XI1_I654_I80_XG_n1 I1_I654_gn13 I1_I654_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I81_XG_MN2 (XI1_I654_I81_XG_n1 I1_I654_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I81_XG_MN0 (I1_I654_G15_14 I1_I654_pn15 XI1_I654_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I81_XG_MN1 (XI1_I654_I81_XG_n1 I1_I654_gn14 I1_I654_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I82_XG_MN2 (XI1_I654_I82_XG_n1 I1_I654_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I82_XG_MN0 (I1_I654_G16_15 I1_I654_pn16 XI1_I654_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I82_XG_MN1 (XI1_I654_I82_XG_n1 I1_I654_gn15 I1_I654_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I83_XG_MN2 (XI1_I654_I83_XG_n1 I1_I654_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I83_XG_MN0 (I1_I654_G17_16 I1_I654_pn17 XI1_I654_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I83_XG_MN1 (XI1_I654_I83_XG_n1 I1_I654_gn16 I1_I654_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I84_XG_MN2 (XI1_I654_I84_XG_n1 I1_I654_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I84_XG_MN0 (I1_I654_G18_17 I1_I654_pn18 XI1_I654_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I84_XG_MN1 (XI1_I654_I84_XG_n1 I1_I654_gn17 I1_I654_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I85_XG_MN2 (XI1_I654_I85_XG_n1 I1_I654_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I85_XG_MN0 (I1_I654_G19_18 I1_I654_pn19 XI1_I654_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I85_XG_MN1 (XI1_I654_I85_XG_n1 I1_I654_gn18 I1_I654_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I86_XG_MN2 (XI1_I654_I86_XG_n1 I1_I654_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I86_XG_MN0 (I1_I654_G20_19 I1_I654_pn20 XI1_I654_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I86_XG_MN1 (XI1_I654_I86_XG_n1 I1_I654_gn19 I1_I654_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I87_XG_MN2 (XI1_I654_I87_XG_n1 I1_I654_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I87_XG_MN0 (I1_I654_G21_20 I1_I654_pn21 XI1_I654_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I87_XG_MN1 (XI1_I654_I87_XG_n1 I1_I654_gn20 I1_I654_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I88_XG_MN2 (XI1_I654_I88_XG_n1 I1_I654_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I88_XG_MN0 (I1_I654_G22_21 I1_I654_pn22 XI1_I654_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I88_XG_MN1 (XI1_I654_I88_XG_n1 I1_I654_gn21 I1_I654_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I89_XG_MN2 (XI1_I654_I89_XG_n1 I1_I654_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I89_XG_MN0 (I1_I654_G23_22 I1_I654_pn23 XI1_I654_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I89_XG_MN1 (XI1_I654_I89_XG_n1 I1_I654_gn22 I1_I654_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I97_XG_MN2 (XI1_I1436_I97_XG_n1 I1_I1436_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I97_XG_MN0 (I1_I1436_G31_30 I1_I1436_pn31 XI1_I1436_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I97_XG_MN1 (XI1_I1436_I97_XG_n1 I1_I1436_gn30 I1_I1436_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I156_XG_MN2 (XI1_I1436_I156_XG_n1 I1_I1436_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I156_XG_MN0 (I1_I1436_G31_24 I1_I1436_P31_28n XI1_I1436_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I156_XG_MN1 (XI1_I1436_I156_XG_n1 I1_I1436_G27_24n I1_I1436_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I154_XG_MN2 (XI1_I1436_I154_XG_n1 I1_I1436_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I154_XG_MN0 (I1_I1436_G29_22 I1_I1436_P29_26n XI1_I1436_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I154_XG_MN1 (XI1_I1436_I154_XG_n1 I1_I1436_G25_22n I1_I1436_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I152_XG_MN2 (XI1_I1436_I152_XG_n1 I1_I1436_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I152_XG_MN0 (I1_I1436_G27_20 I1_I1436_P27_24n XI1_I1436_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I152_XG_MN1 (XI1_I1436_I152_XG_n1 I1_I1436_G23_20n I1_I1436_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I200_XG_MN2 (XI1_I1436_I200_XG_n1 I1_I1436_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I200_XG_MN0 (I1_I1436_G29_0 I1_I1436_P29_14n XI1_I1436_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I200_XG_MN1 (XI1_I1436_I200_XG_n1 I1_I1436_G13_0n I1_I1436_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I150_XG_MN2 (XI1_I1436_I150_XG_n1 I1_I1436_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I150_XG_MN0 (I1_I1436_G25_18 I1_I1436_P25_22n XI1_I1436_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I150_XG_MN1 (XI1_I1436_I150_XG_n1 I1_I1436_G21_18n I1_I1436_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I146_XG_MN2 (XI1_I1436_I146_XG_n1 I1_I1436_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I146_XG_MN0 (I1_I1436_G21_14 I1_I1436_P21_18n XI1_I1436_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I146_XG_MN1 (XI1_I1436_I146_XG_n1 I1_I1436_G17_14n I1_I1436_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I142_XG_MN2 (XI1_I1436_I142_XG_n1 I1_I1436_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I142_XG_MN0 (I1_I1436_G17_10 I1_I1436_P17_14n XI1_I1436_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I142_XG_MN1 (XI1_I1436_I142_XG_n1 I1_I1436_G13_10n I1_I1436_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I138_XG_MN2 (XI1_I1436_I138_XG_n1 I1_I1436_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I138_XG_MN0 (I1_I1436_G13_6 I1_I1436_P13_10n XI1_I1436_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I138_XG_MN1 (XI1_I1436_I138_XG_n1 I1_I1436_G9_6n I1_I1436_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I134_XG_MN2 (XI1_I1436_I134_XG_n1 I1_I1436_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I134_XG_MN0 (I1_I1436_G9_2 I1_I1436_P9_6n XI1_I1436_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I134_XG_MN1 (XI1_I1436_I134_XG_n1 I1_I1436_G5_2n I1_I1436_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I130_XG_MN2 (XI1_I1436_I130_XG_n1 I1_I1436_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I130_XG_MN0 (I1_I1436_G5_0 I1_I1436_P5_2n XI1_I1436_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I130_XG_MN1 (XI1_I1436_I130_XG_n1 I1_I1436_G1_0n I1_I1436_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I65_XG_MN2 (XI1_I1436_I65_XG_n1 I1_I1436_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I65_XG_MN0 (I1_I1436_G0_0 I1_I1436_pn0 XI1_I1436_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I65_XG_MN1 (XI1_I1436_I65_XG_n1 I1_I1436_cinn I1_I1436_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I146_XG_MN2 (XI1_I1114_I146_XG_n1 I1_I1114_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I146_XG_MN0 (I1_I1114_G21_14 I1_I1114_P21_18n XI1_I1114_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I146_XG_MN1 (XI1_I1114_I146_XG_n1 I1_I1114_G17_14n I1_I1114_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I190_XG_MN2 (XI1_I1114_I190_XG_n1 I1_I1114_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I190_XG_MN0 (I1_I1114_G21_0 I1_I1114_P21_6n XI1_I1114_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I190_XG_MN1 (XI1_I1114_I190_XG_n1 I1_I1114_G5_0n I1_I1114_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I149_XG_MN2 (XI1_I1114_I149_XG_n1 I1_I1114_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I149_XG_MN0 (I1_I1114_G24_17 I1_I1114_P24_21n XI1_I1114_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I149_XG_MN1 (XI1_I1114_I149_XG_n1 I1_I1114_G20_17n I1_I1114_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I199_XG_MN2 (XI1_I1114_I199_XG_n1 I1_I1114_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I199_XG_MN0 (I1_I1114_G28_0 I1_I1114_P28_13n XI1_I1114_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I199_XG_MN1 (XI1_I1114_I199_XG_n1 I1_I1114_G12_0n I1_I1114_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I197_XG_MN2 (XI1_I1114_I197_XG_n1 I1_I1114_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I197_XG_MN0 (I1_I1114_G26_0 I1_I1114_P26_11n XI1_I1114_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I197_XG_MN1 (XI1_I1114_I197_XG_n1 I1_I1114_G10_0n I1_I1114_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I143_XG_MN2 (XI1_I1114_I143_XG_n1 I1_I1114_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I143_XG_MN0 (I1_I1114_G18_11 I1_I1114_P18_15n XI1_I1114_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I143_XG_MN1 (XI1_I1114_I143_XG_n1 I1_I1114_G14_11n I1_I1114_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I83_XG_MN2 (XI1_I1114_I83_XG_n1 I1_I1114_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I83_XG_MN0 (I1_I1114_G17_16 I1_I1114_pn17 XI1_I1114_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I83_XG_MN1 (XI1_I1114_I83_XG_n1 I1_I1114_gn16 I1_I1114_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I84_XG_MN2 (XI1_I1114_I84_XG_n1 I1_I1114_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I84_XG_MN0 (I1_I1114_G18_17 I1_I1114_pn18 XI1_I1114_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I84_XG_MN1 (XI1_I1114_I84_XG_n1 I1_I1114_gn17 I1_I1114_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I192_XG_MN2 (XI1_I1068_I192_XG_n1 I1_I1068_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I192_XG_MN0 (I1_I1068_G22_0 I1_I1068_P22_7n XI1_I1068_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I192_XG_MN1 (XI1_I1068_I192_XG_n1 I1_I1068_G6_0n I1_I1068_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I147_XG_MN2 (XI1_I1068_I147_XG_n1 I1_I1068_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I147_XG_MN0 (I1_I1068_G22_15 I1_I1068_P22_19n XI1_I1068_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I147_XG_MN1 (XI1_I1068_I147_XG_n1 I1_I1068_G18_15n I1_I1068_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I151_XG_MN2 (XI1_I1068_I151_XG_n1 I1_I1068_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I151_XG_MN0 (I1_I1068_G26_19 I1_I1068_P26_23n XI1_I1068_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I151_XG_MN1 (XI1_I1068_I151_XG_n1 I1_I1068_G22_19n I1_I1068_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I194_XG_MN2 (XI1_I1068_I194_XG_n1 I1_I1068_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I194_XG_MN0 (I1_I1068_G23_0 I1_I1068_P23_8n XI1_I1068_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I194_XG_MN1 (XI1_I1068_I194_XG_n1 I1_I1068_G7_0n I1_I1068_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I152_XG_MN2 (XI1_I1068_I152_XG_n1 I1_I1068_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I152_XG_MN0 (I1_I1068_G27_20 I1_I1068_P27_24n XI1_I1068_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I152_XG_MN1 (XI1_I1068_I152_XG_n1 I1_I1068_G23_20n I1_I1068_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I148_XG_MN2 (XI1_I1068_I148_XG_n1 I1_I1068_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I148_XG_MN0 (I1_I1068_G23_16 I1_I1068_P23_20n XI1_I1068_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I148_XG_MN1 (XI1_I1068_I148_XG_n1 I1_I1068_G19_16n I1_I1068_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I88_XG_MN2 (XI1_I1068_I88_XG_n1 I1_I1068_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I88_XG_MN0 (I1_I1068_G22_21 I1_I1068_pn22 XI1_I1068_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I88_XG_MN1 (XI1_I1068_I88_XG_n1 I1_I1068_gn21 I1_I1068_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I94_XG_MN2 (XI1_I1022_I94_XG_n1 I1_I1022_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I94_XG_MN0 (I1_I1022_G28_27 I1_I1022_pn28 XI1_I1022_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I94_XG_MN1 (XI1_I1022_I94_XG_n1 I1_I1022_gn27 I1_I1022_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I95_XG_MN2 (XI1_I1022_I95_XG_n1 I1_I1022_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I95_XG_MN0 (I1_I1022_G29_28 I1_I1022_pn29 XI1_I1022_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I95_XG_MN1 (XI1_I1022_I95_XG_n1 I1_I1022_gn28 I1_I1022_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I93_XG_MN2 (XI1_I1022_I93_XG_n1 I1_I1022_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I93_XG_MN0 (I1_I1022_G27_26 I1_I1022_pn27 XI1_I1022_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I93_XG_MN1 (XI1_I1022_I93_XG_n1 I1_I1022_gn26 I1_I1022_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I155_XG_MN2 (XI1_I976_I155_XG_n1 I1_I976_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I155_XG_MN0 (I1_I976_G30_23 I1_I976_P30_27n XI1_I976_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I155_XG_MN1 (XI1_I976_I155_XG_n1 I1_I976_G26_23n I1_I976_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I194_XG_MN2 (XI1_I976_I194_XG_n1 I1_I976_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I194_XG_MN0 (I1_I976_G23_0 I1_I976_P23_8n XI1_I976_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I194_XG_MN1 (XI1_I976_I194_XG_n1 I1_I976_G7_0n I1_I976_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I198_XG_MN2 (XI1_I976_I198_XG_n1 I1_I976_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I198_XG_MN0 (I1_I976_G27_0 I1_I976_P27_12n XI1_I976_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I198_XG_MN1 (XI1_I976_I198_XG_n1 I1_I976_G11_0n I1_I976_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I140_XG_MN2 (XI1_I976_I140_XG_n1 I1_I976_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I140_XG_MN0 (I1_I976_G15_8 I1_I976_P15_12n XI1_I976_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I140_XG_MN1 (XI1_I976_I140_XG_n1 I1_I976_G11_8n I1_I976_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I190_XG_MN2 (XI1_I976_I190_XG_n1 I1_I976_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I190_XG_MN0 (I1_I976_G21_0 I1_I976_P21_6n XI1_I976_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I190_XG_MN1 (XI1_I976_I190_XG_n1 I1_I976_G5_0n I1_I976_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I136_XG_MN2 (XI1_I976_I136_XG_n1 I1_I976_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I136_XG_MN0 (I1_I976_G11_4 I1_I976_P11_8n XI1_I976_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I136_XG_MN1 (XI1_I976_I136_XG_n1 I1_I976_G7_4n I1_I976_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I134_XG_MN2 (XI1_I976_I134_XG_n1 I1_I976_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I134_XG_MN0 (I1_I976_G9_2 I1_I976_P9_6n XI1_I976_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I134_XG_MN1 (XI1_I976_I134_XG_n1 I1_I976_G5_2n I1_I976_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I65_XG_MN2 (XI1_I654_I65_XG_n1 I1_I654_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I65_XG_MN0 (I1_I654_G0_0 I1_I654_pn0 XI1_I654_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I65_XG_MN1 (XI1_I654_I65_XG_n1 I1_I654_cinn I1_I654_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I97_XG_MN2 (XI1_I654_I97_XG_n1 I1_I654_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I97_XG_MN0 (I1_I654_G31_30 I1_I654_pn31 XI1_I654_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I654_I97_XG_MN1 (XI1_I654_I97_XG_n1 I1_I654_gn30 I1_I654_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I148_XG_MN2 (XI1_I1436_I148_XG_n1 I1_I1436_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I148_XG_MN0 (I1_I1436_G23_16 I1_I1436_P23_20n XI1_I1436_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I148_XG_MN1 (XI1_I1436_I148_XG_n1 I1_I1436_G19_16n I1_I1436_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I196_XG_MN2 (XI1_I1436_I196_XG_n1 I1_I1436_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I196_XG_MN0 (I1_I1436_G25_0 I1_I1436_P25_10n XI1_I1436_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I196_XG_MN1 (XI1_I1436_I196_XG_n1 I1_I1436_G9_0n I1_I1436_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I190_XG_MN2 (XI1_I1436_I190_XG_n1 I1_I1436_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I190_XG_MN0 (I1_I1436_G21_0 I1_I1436_P21_6n XI1_I1436_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I190_XG_MN1 (XI1_I1436_I190_XG_n1 I1_I1436_G5_0n I1_I1436_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I144_XG_MN2 (XI1_I1436_I144_XG_n1 I1_I1436_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I144_XG_MN0 (I1_I1436_G19_12 I1_I1436_P19_16n XI1_I1436_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I144_XG_MN1 (XI1_I1436_I144_XG_n1 I1_I1436_G15_12n I1_I1436_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I140_XG_MN2 (XI1_I1436_I140_XG_n1 I1_I1436_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I140_XG_MN0 (I1_I1436_G15_8 I1_I1436_P15_12n XI1_I1436_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I140_XG_MN1 (XI1_I1436_I140_XG_n1 I1_I1436_G11_8n I1_I1436_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I186_XG_MN2 (XI1_I1436_I186_XG_n1 I1_I1436_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I186_XG_MN0 (I1_I1436_G19_0 I1_I1436_P19_4n XI1_I1436_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I186_XG_MN1 (XI1_I1436_I186_XG_n1 I1_I1436_G3_0n I1_I1436_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I136_XG_MN2 (XI1_I1436_I136_XG_n1 I1_I1436_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I136_XG_MN0 (I1_I1436_G11_4 I1_I1436_P11_8n XI1_I1436_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I136_XG_MN1 (XI1_I1436_I136_XG_n1 I1_I1436_G7_4n I1_I1436_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I184_XG_MN2 (XI1_I1436_I184_XG_n1 I1_I1436_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I184_XG_MN0 (I1_I1436_G17_0 I1_I1436_P17_2n XI1_I1436_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I184_XG_MN1 (XI1_I1436_I184_XG_n1 I1_I1436_G1_0n I1_I1436_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I132_XG_MN2 (XI1_I1436_I132_XG_n1 I1_I1436_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I132_XG_MN0 (I1_I1436_G7_0 I1_I1436_P7_4n XI1_I1436_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I132_XG_MN1 (XI1_I1436_I132_XG_n1 I1_I1436_G3_0n I1_I1436_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I198_XG_MN2 (XI1_I1114_I198_XG_n1 I1_I1114_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I198_XG_MN0 (I1_I1114_G27_0 I1_I1114_P27_12n XI1_I1114_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I198_XG_MN1 (XI1_I1114_I198_XG_n1 I1_I1114_G11_0n I1_I1114_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I144_XG_MN2 (XI1_I1114_I144_XG_n1 I1_I1114_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I144_XG_MN0 (I1_I1114_G19_12 I1_I1114_P19_16n XI1_I1114_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I144_XG_MN1 (XI1_I1114_I144_XG_n1 I1_I1114_G15_12n I1_I1114_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I196_XG_MN2 (XI1_I1114_I196_XG_n1 I1_I1114_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I196_XG_MN0 (I1_I1114_G25_0 I1_I1114_P25_10n XI1_I1114_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I196_XG_MN1 (XI1_I1114_I196_XG_n1 I1_I1114_G9_0n I1_I1114_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I145_XG_MN2 (XI1_I1114_I145_XG_n1 I1_I1114_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I145_XG_MN0 (I1_I1114_G20_13 I1_I1114_P20_17n XI1_I1114_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I145_XG_MN1 (XI1_I1114_I145_XG_n1 I1_I1114_G16_13n I1_I1114_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I185_XG_MN2 (XI1_I1114_I185_XG_n1 I1_I1114_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I185_XG_MN0 (I1_I1114_G18_0 I1_I1114_P18_3n XI1_I1114_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I185_XG_MN1 (XI1_I1114_I185_XG_n1 I1_I1114_G2_0n I1_I1114_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I81_XG_MN2 (XI1_I1114_I81_XG_n1 I1_I1114_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I81_XG_MN0 (I1_I1114_G15_14 I1_I1114_pn15 XI1_I1114_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I81_XG_MN1 (XI1_I1114_I81_XG_n1 I1_I1114_gn14 I1_I1114_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I82_XG_MN2 (XI1_I1114_I82_XG_n1 I1_I1114_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I82_XG_MN0 (I1_I1114_G16_15 I1_I1114_pn16 XI1_I1114_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I82_XG_MN1 (XI1_I1114_I82_XG_n1 I1_I1114_gn15 I1_I1114_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I197_XG_MN2 (XI1_I1068_I197_XG_n1 I1_I1068_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I197_XG_MN0 (I1_I1068_G26_0 I1_I1068_P26_11n XI1_I1068_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I197_XG_MN1 (XI1_I1068_I197_XG_n1 I1_I1068_G10_0n I1_I1068_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I149_XG_MN2 (XI1_I1068_I149_XG_n1 I1_I1068_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I149_XG_MN0 (I1_I1068_G24_17 I1_I1068_P24_21n XI1_I1068_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I149_XG_MN1 (XI1_I1068_I149_XG_n1 I1_I1068_G20_17n I1_I1068_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I190_XG_MN2 (XI1_I1068_I190_XG_n1 I1_I1068_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I190_XG_MN0 (I1_I1068_G21_0 I1_I1068_P21_6n XI1_I1068_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I190_XG_MN1 (XI1_I1068_I190_XG_n1 I1_I1068_G5_0n I1_I1068_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I198_XG_MN2 (XI1_I1068_I198_XG_n1 I1_I1068_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I198_XG_MN0 (I1_I1068_G27_0 I1_I1068_P27_12n XI1_I1068_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I198_XG_MN1 (XI1_I1068_I198_XG_n1 I1_I1068_G11_0n I1_I1068_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I146_XG_MN2 (XI1_I1068_I146_XG_n1 I1_I1068_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I146_XG_MN0 (I1_I1068_G21_14 I1_I1068_P21_18n XI1_I1068_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I146_XG_MN1 (XI1_I1068_I146_XG_n1 I1_I1068_G17_14n I1_I1068_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I150_XG_MN2 (XI1_I1068_I150_XG_n1 I1_I1068_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I150_XG_MN0 (I1_I1068_G25_18 I1_I1068_P25_22n XI1_I1068_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I150_XG_MN1 (XI1_I1068_I150_XG_n1 I1_I1068_G21_18n I1_I1068_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I86_XG_MN2 (XI1_I1068_I86_XG_n1 I1_I1068_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I86_XG_MN0 (I1_I1068_G20_19 I1_I1068_pn20 XI1_I1068_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I86_XG_MN1 (XI1_I1068_I86_XG_n1 I1_I1068_gn19 I1_I1068_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I87_XG_MN2 (XI1_I1068_I87_XG_n1 I1_I1068_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I87_XG_MN0 (I1_I1068_G21_20 I1_I1068_pn21 XI1_I1068_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I87_XG_MN1 (XI1_I1068_I87_XG_n1 I1_I1068_gn20 I1_I1068_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I92_XG_MN2 (XI1_I1022_I92_XG_n1 I1_I1022_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I92_XG_MN0 (I1_I1022_G26_25 I1_I1022_pn26 XI1_I1022_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I92_XG_MN1 (XI1_I1022_I92_XG_n1 I1_I1022_gn25 I1_I1022_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I91_XG_MN2 (XI1_I1022_I91_XG_n1 I1_I1022_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I91_XG_MN0 (I1_I1022_G25_24 I1_I1022_pn25 XI1_I1022_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I91_XG_MN1 (XI1_I1022_I91_XG_n1 I1_I1022_gn24 I1_I1022_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I90_XG_MN2 (XI1_I1022_I90_XG_n1 I1_I1022_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I90_XG_MN0 (I1_I1022_G24_23 I1_I1022_pn24 XI1_I1022_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I90_XG_MN1 (XI1_I1022_I90_XG_n1 I1_I1022_gn23 I1_I1022_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I153_XG_MN2 (XI1_I976_I153_XG_n1 I1_I976_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I153_XG_MN0 (I1_I976_G28_21 I1_I976_P28_25n XI1_I976_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I153_XG_MN1 (XI1_I976_I153_XG_n1 I1_I976_G24_21n I1_I976_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I151_XG_MN2 (XI1_I976_I151_XG_n1 I1_I976_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I151_XG_MN0 (I1_I976_G26_19 I1_I976_P26_23n XI1_I976_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I151_XG_MN1 (XI1_I976_I151_XG_n1 I1_I976_G22_19n I1_I976_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I147_XG_MN2 (XI1_I976_I147_XG_n1 I1_I976_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I147_XG_MN0 (I1_I976_G22_15 I1_I976_P22_19n XI1_I976_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I147_XG_MN1 (XI1_I976_I147_XG_n1 I1_I976_G18_15n I1_I976_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I186_XG_MN2 (XI1_I976_I186_XG_n1 I1_I976_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I186_XG_MN0 (I1_I976_G19_0 I1_I976_P19_4n XI1_I976_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I186_XG_MN1 (XI1_I976_I186_XG_n1 I1_I976_G3_0n I1_I976_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I132_XG_MN2 (XI1_I976_I132_XG_n1 I1_I976_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I132_XG_MN0 (I1_I976_G7_0 I1_I976_P7_4n XI1_I976_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I132_XG_MN1 (XI1_I976_I132_XG_n1 I1_I976_G3_0n I1_I976_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I184_XG_MN2 (XI1_I976_I184_XG_n1 I1_I976_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I184_XG_MN0 (I1_I976_G17_0 I1_I976_P17_2n XI1_I976_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I184_XG_MN1 (XI1_I976_I184_XG_n1 I1_I976_G1_0n I1_I976_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I72_XG_MN2 (XI1_I976_I72_XG_n1 I1_I976_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I72_XG_MN0 (I1_I976_G6_5 I1_I976_pn6 XI1_I976_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I72_XG_MN1 (XI1_I976_I72_XG_n1 I1_I976_gn5 I1_I976_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I71_XG_MN2 (XI1_I976_I71_XG_n1 I1_I976_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I71_XG_MN0 (I1_I976_G5_4 I1_I976_pn5 XI1_I976_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I71_XG_MN1 (XI1_I976_I71_XG_n1 I1_I976_gn4 I1_I976_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I67_XG_MN2 (XI1_I608_I67_XG_n1 I1_I608_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I67_XG_MN0 (I1_I608_G1_0 I1_I608_pn1 XI1_I608_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I67_XG_MN1 (XI1_I608_I67_XG_n1 I1_I608_G0_0n I1_I608_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I183_XG_MN2 (XI1_I608_I183_XG_n1 I1_I608_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I183_XG_MN0 (I1_I608_G16_0 I1_I608_P16_1n XI1_I608_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I183_XG_MN1 (XI1_I608_I183_XG_n1 I1_I608_G0_0n I1_I608_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I185_XG_MN2 (XI1_I608_I185_XG_n1 I1_I608_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I185_XG_MN0 (I1_I608_G18_0 I1_I608_P18_3n XI1_I608_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I185_XG_MN1 (XI1_I608_I185_XG_n1 I1_I608_G2_0n I1_I608_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I195_XG_MN2 (XI1_I608_I195_XG_n1 I1_I608_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I195_XG_MN0 (I1_I608_G24_0 I1_I608_P24_9n XI1_I608_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I195_XG_MN1 (XI1_I608_I195_XG_n1 I1_I608_G8_0n I1_I608_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I188_XG_MN2 (XI1_I608_I188_XG_n1 I1_I608_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I188_XG_MN0 (I1_I608_G20_0 I1_I608_P20_5n XI1_I608_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I188_XG_MN1 (XI1_I608_I188_XG_n1 I1_I608_G4_0n I1_I608_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I192_XG_MN2 (XI1_I608_I192_XG_n1 I1_I608_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I192_XG_MN0 (I1_I608_G22_0 I1_I608_P22_7n XI1_I608_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I192_XG_MN1 (XI1_I608_I192_XG_n1 I1_I608_G6_0n I1_I608_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I201_XG_MN2 (XI1_I608_I201_XG_n1 I1_I608_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I201_XG_MN0 (I1_c1_m I1_I608_P30_15n XI1_I608_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I201_XG_MN1 (XI1_I608_I201_XG_n1 I1_I608_G14_0n I1_c1_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I202_XG_MN2 (XI1_I1436_I202_XG_n1 I1_I1436_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I202_XG_MN0 (I1_c19_o I1_I1436_P31_16n XI1_I1436_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I202_XG_MN1 (XI1_I1436_I202_XG_n1 I1_I1436_G15_0n I1_c19_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I198_XG_MN2 (XI1_I1436_I198_XG_n1 I1_I1436_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I198_XG_MN0 (I1_I1436_G27_0 I1_I1436_P27_12n XI1_I1436_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I198_XG_MN1 (XI1_I1436_I198_XG_n1 I1_I1436_G11_0n I1_I1436_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I194_XG_MN2 (XI1_I1436_I194_XG_n1 I1_I1436_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I194_XG_MN0 (I1_I1436_G23_0 I1_I1436_P23_8n XI1_I1436_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1436_I194_XG_MN1 (XI1_I1436_I194_XG_n1 I1_I1436_G7_0n I1_I1436_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I186_XG_MN2 (XI1_I1114_I186_XG_n1 I1_I1114_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I186_XG_MN0 (I1_I1114_G19_0 I1_I1114_P19_4n XI1_I1114_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I186_XG_MN1 (XI1_I1114_I186_XG_n1 I1_I1114_G3_0n I1_I1114_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I140_XG_MN2 (XI1_I1114_I140_XG_n1 I1_I1114_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I140_XG_MN0 (I1_I1114_G15_8 I1_I1114_P15_12n XI1_I1114_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I140_XG_MN1 (XI1_I1114_I140_XG_n1 I1_I1114_G11_8n I1_I1114_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I184_XG_MN2 (XI1_I1114_I184_XG_n1 I1_I1114_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I184_XG_MN0 (I1_I1114_G17_0 I1_I1114_P17_2n XI1_I1114_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I184_XG_MN1 (XI1_I1114_I184_XG_n1 I1_I1114_G1_0n I1_I1114_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I142_XG_MN2 (XI1_I1114_I142_XG_n1 I1_I1114_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I142_XG_MN0 (I1_I1114_G17_10 I1_I1114_P17_14n XI1_I1114_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I142_XG_MN1 (XI1_I1114_I142_XG_n1 I1_I1114_G13_10n I1_I1114_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I138_XG_MN2 (XI1_I1114_I138_XG_n1 I1_I1114_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I138_XG_MN0 (I1_I1114_G13_6 I1_I1114_P13_10n XI1_I1114_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I138_XG_MN1 (XI1_I1114_I138_XG_n1 I1_I1114_G9_6n I1_I1114_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I195_XG_MN2 (XI1_I1114_I195_XG_n1 I1_I1114_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I195_XG_MN0 (I1_I1114_G24_0 I1_I1114_P24_9n XI1_I1114_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I195_XG_MN1 (XI1_I1114_I195_XG_n1 I1_I1114_G8_0n I1_I1114_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I188_XG_MN2 (XI1_I1114_I188_XG_n1 I1_I1114_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I188_XG_MN0 (I1_I1114_G20_0 I1_I1114_P20_5n XI1_I1114_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I188_XG_MN1 (XI1_I1114_I188_XG_n1 I1_I1114_G4_0n I1_I1114_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I139_XG_MN2 (XI1_I1114_I139_XG_n1 I1_I1114_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I139_XG_MN0 (I1_I1114_G14_7 I1_I1114_P14_11n XI1_I1114_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I139_XG_MN1 (XI1_I1114_I139_XG_n1 I1_I1114_G10_7n I1_I1114_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I188_XG_MN2 (XI1_I1068_I188_XG_n1 I1_I1068_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I188_XG_MN0 (I1_I1068_G20_0 I1_I1068_P20_5n XI1_I1068_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I188_XG_MN1 (XI1_I1068_I188_XG_n1 I1_I1068_G4_0n I1_I1068_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I145_XG_MN2 (XI1_I1068_I145_XG_n1 I1_I1068_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I145_XG_MN0 (I1_I1068_G20_13 I1_I1068_P20_17n XI1_I1068_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I145_XG_MN1 (XI1_I1068_I145_XG_n1 I1_I1068_G16_13n I1_I1068_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I144_XG_MN2 (XI1_I1068_I144_XG_n1 I1_I1068_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I144_XG_MN0 (I1_I1068_G19_12 I1_I1068_P19_16n XI1_I1068_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I144_XG_MN1 (XI1_I1068_I144_XG_n1 I1_I1068_G15_12n I1_I1068_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I84_XG_MN2 (XI1_I1068_I84_XG_n1 I1_I1068_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I84_XG_MN0 (I1_I1068_G18_17 I1_I1068_pn18 XI1_I1068_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I84_XG_MN1 (XI1_I1068_I84_XG_n1 I1_I1068_gn17 I1_I1068_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I85_XG_MN2 (XI1_I1068_I85_XG_n1 I1_I1068_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I85_XG_MN0 (I1_I1068_G19_18 I1_I1068_pn19 XI1_I1068_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I85_XG_MN1 (XI1_I1068_I85_XG_n1 I1_I1068_gn18 I1_I1068_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I155_XG_MN2 (XI1_I1022_I155_XG_n1 I1_I1022_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I155_XG_MN0 (I1_I1022_G30_23 I1_I1022_P30_27n XI1_I1022_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I155_XG_MN1 (XI1_I1022_I155_XG_n1 I1_I1022_G26_23n I1_I1022_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I156_XG_MN2 (XI1_I1022_I156_XG_n1 I1_I1022_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I156_XG_MN0 (I1_I1022_G31_24 I1_I1022_P31_28n XI1_I1022_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I156_XG_MN1 (XI1_I1022_I156_XG_n1 I1_I1022_G27_24n I1_I1022_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I89_XG_MN2 (XI1_I1022_I89_XG_n1 I1_I1022_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I89_XG_MN0 (I1_I1022_G23_22 I1_I1022_pn23 XI1_I1022_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I89_XG_MN1 (XI1_I1022_I89_XG_n1 I1_I1022_gn22 I1_I1022_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I88_XG_MN2 (XI1_I1022_I88_XG_n1 I1_I1022_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I88_XG_MN0 (I1_I1022_G22_21 I1_I1022_pn22 XI1_I1022_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I88_XG_MN1 (XI1_I1022_I88_XG_n1 I1_I1022_gn21 I1_I1022_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I201_XG_MN2 (XI1_I976_I201_XG_n1 I1_I976_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I201_XG_MN0 (I1_c9_m I1_I976_P30_15n XI1_I976_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I201_XG_MN1 (XI1_I976_I201_XG_n1 I1_I976_G14_0n I1_c9_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I199_XG_MN2 (XI1_I976_I199_XG_n1 I1_I976_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I199_XG_MN0 (I1_I976_G28_0 I1_I976_P28_13n XI1_I976_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I199_XG_MN1 (XI1_I976_I199_XG_n1 I1_I976_G12_0n I1_I976_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I192_XG_MN2 (XI1_I976_I192_XG_n1 I1_I976_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I192_XG_MN0 (I1_I976_G22_0 I1_I976_P22_7n XI1_I976_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I192_XG_MN1 (XI1_I976_I192_XG_n1 I1_I976_G6_0n I1_I976_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I143_XG_MN2 (XI1_I976_I143_XG_n1 I1_I976_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I143_XG_MN0 (I1_I976_G18_11 I1_I976_P18_15n XI1_I976_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I143_XG_MN1 (XI1_I976_I143_XG_n1 I1_I976_G14_11n I1_I976_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I139_XG_MN2 (XI1_I976_I139_XG_n1 I1_I976_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I139_XG_MN0 (I1_I976_G14_7 I1_I976_P14_11n XI1_I976_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I139_XG_MN1 (XI1_I976_I139_XG_n1 I1_I976_G10_7n I1_I976_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I141_XG_MN2 (XI1_I976_I141_XG_n1 I1_I976_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I141_XG_MN0 (I1_I976_G16_9 I1_I976_P16_13n XI1_I976_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I141_XG_MN1 (XI1_I976_I141_XG_n1 I1_I976_G12_9n I1_I976_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I130_XG_MN2 (XI1_I976_I130_XG_n1 I1_I976_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I130_XG_MN0 (I1_I976_G5_0 I1_I976_P5_2n XI1_I976_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I130_XG_MN1 (XI1_I976_I130_XG_n1 I1_I976_G1_0n I1_I976_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I128_XG_MN2 (XI1_I608_I128_XG_n1 I1_I608_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I128_XG_MN0 (I1_I608_G4_0 I1_I608_P4_1n XI1_I608_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I128_XG_MN1 (XI1_I608_I128_XG_n1 I1_I608_G0_0n I1_I608_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I131_XG_MN2 (XI1_I608_I131_XG_n1 I1_I608_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I131_XG_MN0 (I1_I608_G6_0 I1_I608_P6_3n XI1_I608_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I131_XG_MN1 (XI1_I608_I131_XG_n1 I1_I608_G2_0n I1_I608_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I133_XG_MN2 (XI1_I608_I133_XG_n1 I1_I608_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I133_XG_MN0 (I1_I608_G8_1 I1_I608_P8_5n XI1_I608_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I133_XG_MN1 (XI1_I608_I133_XG_n1 I1_I608_G4_1n I1_I608_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I135_XG_MN2 (XI1_I608_I135_XG_n1 I1_I608_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I135_XG_MN0 (I1_I608_G10_3 I1_I608_P10_7n XI1_I608_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I135_XG_MN1 (XI1_I608_I135_XG_n1 I1_I608_G6_3n I1_I608_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I137_XG_MN2 (XI1_I608_I137_XG_n1 I1_I608_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I137_XG_MN0 (I1_I608_G12_5 I1_I608_P12_9n XI1_I608_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I137_XG_MN1 (XI1_I608_I137_XG_n1 I1_I608_G8_5n I1_I608_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I141_XG_MN2 (XI1_I608_I141_XG_n1 I1_I608_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I141_XG_MN0 (I1_I608_G16_9 I1_I608_P16_13n XI1_I608_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I141_XG_MN1 (XI1_I608_I141_XG_n1 I1_I608_G12_9n I1_I608_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I139_XG_MN2 (XI1_I608_I139_XG_n1 I1_I608_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I139_XG_MN0 (I1_I608_G14_7 I1_I608_P14_11n XI1_I608_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I139_XG_MN1 (XI1_I608_I139_XG_n1 I1_I608_G10_7n I1_I608_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I143_XG_MN2 (XI1_I608_I143_XG_n1 I1_I608_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I143_XG_MN0 (I1_I608_G18_11 I1_I608_P18_15n XI1_I608_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I143_XG_MN1 (XI1_I608_I143_XG_n1 I1_I608_G14_11n I1_I608_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I145_XG_MN2 (XI1_I608_I145_XG_n1 I1_I608_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I145_XG_MN0 (I1_I608_G20_13 I1_I608_P20_17n XI1_I608_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I145_XG_MN1 (XI1_I608_I145_XG_n1 I1_I608_G16_13n I1_I608_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I149_XG_MN2 (XI1_I608_I149_XG_n1 I1_I608_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I149_XG_MN0 (I1_I608_G24_17 I1_I608_P24_21n XI1_I608_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I149_XG_MN1 (XI1_I608_I149_XG_n1 I1_I608_G20_17n I1_I608_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I197_XG_MN2 (XI1_I608_I197_XG_n1 I1_I608_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I197_XG_MN0 (I1_I608_G26_0 I1_I608_P26_11n XI1_I608_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I197_XG_MN1 (XI1_I608_I197_XG_n1 I1_I608_G10_0n I1_I608_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I147_XG_MN2 (XI1_I608_I147_XG_n1 I1_I608_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I147_XG_MN0 (I1_I608_G22_15 I1_I608_P22_19n XI1_I608_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I147_XG_MN1 (XI1_I608_I147_XG_n1 I1_I608_G18_15n I1_I608_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I151_XG_MN2 (XI1_I608_I151_XG_n1 I1_I608_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I151_XG_MN0 (I1_I608_G26_19 I1_I608_P26_23n XI1_I608_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I151_XG_MN1 (XI1_I608_I151_XG_n1 I1_I608_G22_19n I1_I608_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I199_XG_MN2 (XI1_I608_I199_XG_n1 I1_I608_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I199_XG_MN0 (I1_I608_G28_0 I1_I608_P28_13n XI1_I608_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I199_XG_MN1 (XI1_I608_I199_XG_n1 I1_I608_G12_0n I1_I608_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I155_XG_MN2 (XI1_I608_I155_XG_n1 I1_I608_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I155_XG_MN0 (I1_I608_G30_23 I1_I608_P30_27n XI1_I608_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I155_XG_MN1 (XI1_I608_I155_XG_n1 I1_I608_G26_23n I1_I608_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I89_XG_MN2 (XI1_I1482_I89_XG_n1 I1_I1482_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I89_XG_MN0 (I1_I1482_G23_22 I1_I1482_pn23 XI1_I1482_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I89_XG_MN1 (XI1_I1482_I89_XG_n1 I1_I1482_gn22 I1_I1482_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I86_XG_MN2 (XI1_I1482_I86_XG_n1 I1_I1482_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I86_XG_MN0 (I1_I1482_G20_19 I1_I1482_pn20 XI1_I1482_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I86_XG_MN1 (XI1_I1482_I86_XG_n1 I1_I1482_gn19 I1_I1482_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I85_XG_MN2 (XI1_I1482_I85_XG_n1 I1_I1482_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I85_XG_MN0 (I1_I1482_G19_18 I1_I1482_pn19 XI1_I1482_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I85_XG_MN1 (XI1_I1482_I85_XG_n1 I1_I1482_gn18 I1_I1482_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I84_XG_MN2 (XI1_I1482_I84_XG_n1 I1_I1482_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I84_XG_MN0 (I1_I1482_G18_17 I1_I1482_pn18 XI1_I1482_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I84_XG_MN1 (XI1_I1482_I84_XG_n1 I1_I1482_gn17 I1_I1482_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I83_XG_MN2 (XI1_I1482_I83_XG_n1 I1_I1482_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I83_XG_MN0 (I1_I1482_G17_16 I1_I1482_pn17 XI1_I1482_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I83_XG_MN1 (XI1_I1482_I83_XG_n1 I1_I1482_gn16 I1_I1482_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I79_XG_MN2 (XI1_I1482_I79_XG_n1 I1_I1482_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I79_XG_MN0 (I1_I1482_G13_12 I1_I1482_pn13 XI1_I1482_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I79_XG_MN1 (XI1_I1482_I79_XG_n1 I1_I1482_gn12 I1_I1482_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I78_XG_MN2 (XI1_I1482_I78_XG_n1 I1_I1482_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I78_XG_MN0 (I1_I1482_G12_11 I1_I1482_pn12 XI1_I1482_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I78_XG_MN1 (XI1_I1482_I78_XG_n1 I1_I1482_gn11 I1_I1482_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I77_XG_MN2 (XI1_I1482_I77_XG_n1 I1_I1482_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I77_XG_MN0 (I1_I1482_G11_10 I1_I1482_pn11 XI1_I1482_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I77_XG_MN1 (XI1_I1482_I77_XG_n1 I1_I1482_gn10 I1_I1482_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I74_XG_MN2 (XI1_I1482_I74_XG_n1 I1_I1482_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I74_XG_MN0 (I1_I1482_G8_7 I1_I1482_pn8 XI1_I1482_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I74_XG_MN1 (XI1_I1482_I74_XG_n1 I1_I1482_gn7 I1_I1482_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I73_XG_MN2 (XI1_I1482_I73_XG_n1 I1_I1482_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I73_XG_MN0 (I1_I1482_G7_6 I1_I1482_pn7 XI1_I1482_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I73_XG_MN1 (XI1_I1482_I73_XG_n1 I1_I1482_gn6 I1_I1482_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I72_XG_MN2 (XI1_I1482_I72_XG_n1 I1_I1482_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I72_XG_MN0 (I1_I1482_G6_5 I1_I1482_pn6 XI1_I1482_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I72_XG_MN1 (XI1_I1482_I72_XG_n1 I1_I1482_gn5 I1_I1482_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I136_XG_MN2 (XI1_I1114_I136_XG_n1 I1_I1114_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I136_XG_MN0 (I1_I1114_G11_4 I1_I1114_P11_8n XI1_I1114_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I136_XG_MN1 (XI1_I1114_I136_XG_n1 I1_I1114_G7_4n I1_I1114_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I134_XG_MN2 (XI1_I1114_I134_XG_n1 I1_I1114_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I134_XG_MN0 (I1_I1114_G9_2 I1_I1114_P9_6n XI1_I1114_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I134_XG_MN1 (XI1_I1114_I134_XG_n1 I1_I1114_G5_2n I1_I1114_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I137_XG_MN2 (XI1_I1114_I137_XG_n1 I1_I1114_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I137_XG_MN0 (I1_I1114_G12_5 I1_I1114_P12_9n XI1_I1114_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I137_XG_MN1 (XI1_I1114_I137_XG_n1 I1_I1114_G8_5n I1_I1114_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I141_XG_MN2 (XI1_I1114_I141_XG_n1 I1_I1114_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I141_XG_MN0 (I1_I1114_G16_9 I1_I1114_P16_13n XI1_I1114_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I141_XG_MN1 (XI1_I1114_I141_XG_n1 I1_I1114_G12_9n I1_I1114_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I80_XG_MN2 (XI1_I1114_I80_XG_n1 I1_I1114_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I80_XG_MN0 (I1_I1114_G14_13 I1_I1114_pn14 XI1_I1114_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I80_XG_MN1 (XI1_I1114_I80_XG_n1 I1_I1114_gn13 I1_I1114_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I79_XG_MN2 (XI1_I1114_I79_XG_n1 I1_I1114_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I79_XG_MN0 (I1_I1114_G13_12 I1_I1114_pn13 XI1_I1114_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I79_XG_MN1 (XI1_I1114_I79_XG_n1 I1_I1114_gn12 I1_I1114_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I185_XG_MN2 (XI1_I1068_I185_XG_n1 I1_I1068_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I185_XG_MN0 (I1_I1068_G18_0 I1_I1068_P18_3n XI1_I1068_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I185_XG_MN1 (XI1_I1068_I185_XG_n1 I1_I1068_G2_0n I1_I1068_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I143_XG_MN2 (XI1_I1068_I143_XG_n1 I1_I1068_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I143_XG_MN0 (I1_I1068_G18_11 I1_I1068_P18_15n XI1_I1068_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I143_XG_MN1 (XI1_I1068_I143_XG_n1 I1_I1068_G14_11n I1_I1068_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I186_XG_MN2 (XI1_I1068_I186_XG_n1 I1_I1068_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I186_XG_MN0 (I1_I1068_G19_0 I1_I1068_P19_4n XI1_I1068_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I186_XG_MN1 (XI1_I1068_I186_XG_n1 I1_I1068_G3_0n I1_I1068_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I140_XG_MN2 (XI1_I1068_I140_XG_n1 I1_I1068_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I140_XG_MN0 (I1_I1068_G15_8 I1_I1068_P15_12n XI1_I1068_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I140_XG_MN1 (XI1_I1068_I140_XG_n1 I1_I1068_G11_8n I1_I1068_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I81_XG_MN2 (XI1_I1068_I81_XG_n1 I1_I1068_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I81_XG_MN0 (I1_I1068_G15_14 I1_I1068_pn15 XI1_I1068_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I81_XG_MN1 (XI1_I1068_I81_XG_n1 I1_I1068_gn14 I1_I1068_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I82_XG_MN2 (XI1_I1068_I82_XG_n1 I1_I1068_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I82_XG_MN0 (I1_I1068_G16_15 I1_I1068_pn16 XI1_I1068_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I82_XG_MN1 (XI1_I1068_I82_XG_n1 I1_I1068_gn15 I1_I1068_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I83_XG_MN2 (XI1_I1068_I83_XG_n1 I1_I1068_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I83_XG_MN0 (I1_I1068_G17_16 I1_I1068_pn17 XI1_I1068_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I83_XG_MN1 (XI1_I1068_I83_XG_n1 I1_I1068_gn16 I1_I1068_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I201_XG_MN2 (XI1_I1022_I201_XG_n1 I1_I1022_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I201_XG_MN0 (I1_c10_m I1_I1022_P30_15n XI1_I1022_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I201_XG_MN1 (XI1_I1022_I201_XG_n1 I1_I1022_G14_0n I1_c10_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I151_XG_MN2 (XI1_I1022_I151_XG_n1 I1_I1022_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I151_XG_MN0 (I1_I1022_G26_19 I1_I1022_P26_23n XI1_I1022_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I151_XG_MN1 (XI1_I1022_I151_XG_n1 I1_I1022_G22_19n I1_I1022_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I153_XG_MN2 (XI1_I1022_I153_XG_n1 I1_I1022_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I153_XG_MN0 (I1_I1022_G28_21 I1_I1022_P28_25n XI1_I1022_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I153_XG_MN1 (XI1_I1022_I153_XG_n1 I1_I1022_G24_21n I1_I1022_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I154_XG_MN2 (XI1_I1022_I154_XG_n1 I1_I1022_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I154_XG_MN0 (I1_I1022_G29_22 I1_I1022_P29_26n XI1_I1022_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I154_XG_MN1 (XI1_I1022_I154_XG_n1 I1_I1022_G25_22n I1_I1022_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I152_XG_MN2 (XI1_I1022_I152_XG_n1 I1_I1022_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I152_XG_MN0 (I1_I1022_G27_20 I1_I1022_P27_24n XI1_I1022_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I152_XG_MN1 (XI1_I1022_I152_XG_n1 I1_I1022_G23_20n I1_I1022_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I86_XG_MN2 (XI1_I1022_I86_XG_n1 I1_I1022_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I86_XG_MN0 (I1_I1022_G20_19 I1_I1022_pn20 XI1_I1022_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I86_XG_MN1 (XI1_I1022_I86_XG_n1 I1_I1022_gn19 I1_I1022_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I87_XG_MN2 (XI1_I1022_I87_XG_n1 I1_I1022_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I87_XG_MN0 (I1_I1022_G21_20 I1_I1022_pn21 XI1_I1022_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I87_XG_MN1 (XI1_I1022_I87_XG_n1 I1_I1022_gn20 I1_I1022_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I197_XG_MN2 (XI1_I976_I197_XG_n1 I1_I976_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I197_XG_MN0 (I1_I976_G26_0 I1_I976_P26_11n XI1_I976_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I197_XG_MN1 (XI1_I976_I197_XG_n1 I1_I976_G10_0n I1_I976_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I195_XG_MN2 (XI1_I976_I195_XG_n1 I1_I976_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I195_XG_MN0 (I1_I976_G24_0 I1_I976_P24_9n XI1_I976_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I195_XG_MN1 (XI1_I976_I195_XG_n1 I1_I976_G8_0n I1_I976_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I135_XG_MN2 (XI1_I976_I135_XG_n1 I1_I976_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I135_XG_MN0 (I1_I976_G10_3 I1_I976_P10_7n XI1_I976_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I135_XG_MN1 (XI1_I976_I135_XG_n1 I1_I976_G6_3n I1_I976_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I137_XG_MN2 (XI1_I976_I137_XG_n1 I1_I976_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I137_XG_MN0 (I1_I976_G12_5 I1_I976_P12_9n XI1_I976_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I137_XG_MN1 (XI1_I976_I137_XG_n1 I1_I976_G8_5n I1_I976_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I70_XG_MN2 (XI1_I976_I70_XG_n1 I1_I976_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I70_XG_MN0 (I1_I976_G4_3 I1_I976_pn4 XI1_I976_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I70_XG_MN1 (XI1_I976_I70_XG_n1 I1_I976_gn3 I1_I976_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I68_XG_MN2 (XI1_I608_I68_XG_n1 I1_I608_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I68_XG_MN0 (I1_I608_G2_1 I1_I608_pn2 XI1_I608_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I68_XG_MN1 (XI1_I608_I68_XG_n1 I1_I608_gn1 I1_I608_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I153_XG_MN2 (XI1_I608_I153_XG_n1 I1_I608_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I153_XG_MN0 (I1_I608_G28_21 I1_I608_P28_25n XI1_I608_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I153_XG_MN1 (XI1_I608_I153_XG_n1 I1_I608_G24_21n I1_I608_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I96_XG_MN2 (XI1_I608_I96_XG_n1 I1_I608_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I96_XG_MN0 (I1_I608_G30_29 I1_I608_pn30 XI1_I608_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I96_XG_MN1 (XI1_I608_I96_XG_n1 I1_I608_gn29 I1_I608_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I91_XG_MN2 (XI1_I1482_I91_XG_n1 I1_I1482_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I91_XG_MN0 (I1_I1482_G25_24 I1_I1482_pn25 XI1_I1482_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I91_XG_MN1 (XI1_I1482_I91_XG_n1 I1_I1482_gn24 I1_I1482_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I90_XG_MN2 (XI1_I1482_I90_XG_n1 I1_I1482_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I90_XG_MN0 (I1_I1482_G24_23 I1_I1482_pn24 XI1_I1482_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I90_XG_MN1 (XI1_I1482_I90_XG_n1 I1_I1482_gn23 I1_I1482_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I88_XG_MN2 (XI1_I1482_I88_XG_n1 I1_I1482_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I88_XG_MN0 (I1_I1482_G22_21 I1_I1482_pn22 XI1_I1482_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I88_XG_MN1 (XI1_I1482_I88_XG_n1 I1_I1482_gn21 I1_I1482_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I87_XG_MN2 (XI1_I1482_I87_XG_n1 I1_I1482_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I87_XG_MN0 (I1_I1482_G21_20 I1_I1482_pn21 XI1_I1482_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I87_XG_MN1 (XI1_I1482_I87_XG_n1 I1_I1482_gn20 I1_I1482_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I144_XG_MN2 (XI1_I1482_I144_XG_n1 I1_I1482_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I144_XG_MN0 (I1_I1482_G19_12 I1_I1482_P19_16n XI1_I1482_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I144_XG_MN1 (XI1_I1482_I144_XG_n1 I1_I1482_G15_12n I1_I1482_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I138_XG_MN2 (XI1_I1482_I138_XG_n1 I1_I1482_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I138_XG_MN0 (I1_I1482_G13_6 I1_I1482_P13_10n XI1_I1482_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I138_XG_MN1 (XI1_I1482_I138_XG_n1 I1_I1482_G9_6n I1_I1482_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I136_XG_MN2 (XI1_I1482_I136_XG_n1 I1_I1482_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I136_XG_MN0 (I1_I1482_G11_4 I1_I1482_P11_8n XI1_I1482_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I136_XG_MN1 (XI1_I1482_I136_XG_n1 I1_I1482_G7_4n I1_I1482_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I134_XG_MN2 (XI1_I1482_I134_XG_n1 I1_I1482_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I134_XG_MN0 (I1_I1482_G9_2 I1_I1482_P9_6n XI1_I1482_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I134_XG_MN1 (XI1_I1482_I134_XG_n1 I1_I1482_G5_2n I1_I1482_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I132_XG_MN2 (XI1_I1482_I132_XG_n1 I1_I1482_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I132_XG_MN0 (I1_I1482_G7_0 I1_I1482_P7_4n XI1_I1482_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I132_XG_MN1 (XI1_I1482_I132_XG_n1 I1_I1482_G3_0n I1_I1482_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I132_XG_MN2 (XI1_I1114_I132_XG_n1 I1_I1114_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I132_XG_MN0 (I1_I1114_G7_0 I1_I1114_P7_4n XI1_I1114_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I132_XG_MN1 (XI1_I1114_I132_XG_n1 I1_I1114_G3_0n I1_I1114_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I130_XG_MN2 (XI1_I1114_I130_XG_n1 I1_I1114_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I130_XG_MN0 (I1_I1114_G5_0 I1_I1114_P5_2n XI1_I1114_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I130_XG_MN1 (XI1_I1114_I130_XG_n1 I1_I1114_G1_0n I1_I1114_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I77_XG_MN2 (XI1_I1114_I77_XG_n1 I1_I1114_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I77_XG_MN0 (I1_I1114_G11_10 I1_I1114_pn11 XI1_I1114_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I77_XG_MN1 (XI1_I1114_I77_XG_n1 I1_I1114_gn10 I1_I1114_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I183_XG_MN2 (XI1_I1114_I183_XG_n1 I1_I1114_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I183_XG_MN0 (I1_I1114_G16_0 I1_I1114_P16_1n XI1_I1114_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I183_XG_MN1 (XI1_I1114_I183_XG_n1 I1_I1114_G0_0n I1_I1114_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I78_XG_MN2 (XI1_I1114_I78_XG_n1 I1_I1114_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I78_XG_MN0 (I1_I1114_G12_11 I1_I1114_pn12 XI1_I1114_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I78_XG_MN1 (XI1_I1114_I78_XG_n1 I1_I1114_gn11 I1_I1114_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I139_XG_MN2 (XI1_I1068_I139_XG_n1 I1_I1068_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I139_XG_MN0 (I1_I1068_G14_7 I1_I1068_P14_11n XI1_I1068_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I139_XG_MN1 (XI1_I1068_I139_XG_n1 I1_I1068_G10_7n I1_I1068_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I196_XG_MN2 (XI1_I1068_I196_XG_n1 I1_I1068_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I196_XG_MN0 (I1_I1068_G25_0 I1_I1068_P25_10n XI1_I1068_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I196_XG_MN1 (XI1_I1068_I196_XG_n1 I1_I1068_G9_0n I1_I1068_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I138_XG_MN2 (XI1_I1068_I138_XG_n1 I1_I1068_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I138_XG_MN0 (I1_I1068_G13_6 I1_I1068_P13_10n XI1_I1068_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I138_XG_MN1 (XI1_I1068_I138_XG_n1 I1_I1068_G9_6n I1_I1068_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I142_XG_MN2 (XI1_I1068_I142_XG_n1 I1_I1068_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I142_XG_MN0 (I1_I1068_G17_10 I1_I1068_P17_14n XI1_I1068_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I142_XG_MN1 (XI1_I1068_I142_XG_n1 I1_I1068_G13_10n I1_I1068_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I80_XG_MN2 (XI1_I1068_I80_XG_n1 I1_I1068_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I80_XG_MN0 (I1_I1068_G14_13 I1_I1068_pn14 XI1_I1068_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I80_XG_MN1 (XI1_I1068_I80_XG_n1 I1_I1068_gn13 I1_I1068_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I192_XG_MN2 (XI1_I1022_I192_XG_n1 I1_I1022_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I192_XG_MN0 (I1_I1022_G22_0 I1_I1022_P22_7n XI1_I1022_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I192_XG_MN1 (XI1_I1022_I192_XG_n1 I1_I1022_G6_0n I1_I1022_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I147_XG_MN2 (XI1_I1022_I147_XG_n1 I1_I1022_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I147_XG_MN0 (I1_I1022_G22_15 I1_I1022_P22_19n XI1_I1022_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I147_XG_MN1 (XI1_I1022_I147_XG_n1 I1_I1022_G18_15n I1_I1022_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I202_XG_MN2 (XI1_I1022_I202_XG_n1 I1_I1022_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I202_XG_MN0 (I1_c10_o I1_I1022_P31_16n XI1_I1022_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I202_XG_MN1 (XI1_I1022_I202_XG_n1 I1_I1022_G15_0n I1_c10_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I194_XG_MN2 (XI1_I1022_I194_XG_n1 I1_I1022_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I194_XG_MN0 (I1_I1022_G23_0 I1_I1022_P23_8n XI1_I1022_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I194_XG_MN1 (XI1_I1022_I194_XG_n1 I1_I1022_G7_0n I1_I1022_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I148_XG_MN2 (XI1_I1022_I148_XG_n1 I1_I1022_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I148_XG_MN0 (I1_I1022_G23_16 I1_I1022_P23_20n XI1_I1022_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I148_XG_MN1 (XI1_I1022_I148_XG_n1 I1_I1022_G19_16n I1_I1022_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I150_XG_MN2 (XI1_I1022_I150_XG_n1 I1_I1022_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I150_XG_MN0 (I1_I1022_G25_18 I1_I1022_P25_22n XI1_I1022_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I150_XG_MN1 (XI1_I1022_I150_XG_n1 I1_I1022_G21_18n I1_I1022_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I85_XG_MN2 (XI1_I1022_I85_XG_n1 I1_I1022_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I85_XG_MN0 (I1_I1022_G19_18 I1_I1022_pn19 XI1_I1022_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I85_XG_MN1 (XI1_I1022_I85_XG_n1 I1_I1022_gn18 I1_I1022_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I84_XG_MN2 (XI1_I1022_I84_XG_n1 I1_I1022_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I84_XG_MN0 (I1_I1022_G18_17 I1_I1022_pn18 XI1_I1022_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I84_XG_MN1 (XI1_I1022_I84_XG_n1 I1_I1022_gn17 I1_I1022_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I83_XG_MN2 (XI1_I1022_I83_XG_n1 I1_I1022_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I83_XG_MN0 (I1_I1022_G17_16 I1_I1022_pn17 XI1_I1022_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I83_XG_MN1 (XI1_I1022_I83_XG_n1 I1_I1022_gn16 I1_I1022_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I188_XG_MN2 (XI1_I976_I188_XG_n1 I1_I976_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I188_XG_MN0 (I1_I976_G20_0 I1_I976_P20_5n XI1_I976_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I188_XG_MN1 (XI1_I976_I188_XG_n1 I1_I976_G4_0n I1_I976_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I185_XG_MN2 (XI1_I976_I185_XG_n1 I1_I976_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I185_XG_MN0 (I1_I976_G18_0 I1_I976_P18_3n XI1_I976_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I185_XG_MN1 (XI1_I976_I185_XG_n1 I1_I976_G2_0n I1_I976_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I131_XG_MN2 (XI1_I976_I131_XG_n1 I1_I976_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I131_XG_MN0 (I1_I976_G6_0 I1_I976_P6_3n XI1_I976_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I131_XG_MN1 (XI1_I976_I131_XG_n1 I1_I976_G2_0n I1_I976_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I183_XG_MN2 (XI1_I976_I183_XG_n1 I1_I976_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I183_XG_MN0 (I1_I976_G16_0 I1_I976_P16_1n XI1_I976_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I183_XG_MN1 (XI1_I976_I183_XG_n1 I1_I976_G0_0n I1_I976_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I133_XG_MN2 (XI1_I976_I133_XG_n1 I1_I976_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I133_XG_MN0 (I1_I976_G8_1 I1_I976_P8_5n XI1_I976_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I133_XG_MN1 (XI1_I976_I133_XG_n1 I1_I976_G4_1n I1_I976_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I128_XG_MN2 (XI1_I976_I128_XG_n1 I1_I976_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I128_XG_MN0 (I1_I976_G4_0 I1_I976_P4_1n XI1_I976_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I128_XG_MN1 (XI1_I976_I128_XG_n1 I1_I976_G0_0n I1_I976_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I69_XG_MN2 (XI1_I976_I69_XG_n1 I1_I976_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I69_XG_MN0 (I1_I976_G3_2 I1_I976_pn3 XI1_I976_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I69_XG_MN1 (XI1_I976_I69_XG_n1 I1_I976_gn2 I1_I976_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I65_XG_MN2 (XI1_I608_I65_XG_n1 I1_I608_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I65_XG_MN0 (I1_I608_G0_0 I1_I608_pn0 XI1_I608_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I65_XG_MN1 (XI1_I608_I65_XG_n1 I1_I608_cinn I1_I608_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I69_XG_MN2 (XI1_I608_I69_XG_n1 I1_I608_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I69_XG_MN0 (I1_I608_G3_2 I1_I608_pn3 XI1_I608_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I69_XG_MN1 (XI1_I608_I69_XG_n1 I1_I608_gn2 I1_I608_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I70_XG_MN2 (XI1_I608_I70_XG_n1 I1_I608_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I70_XG_MN0 (I1_I608_G4_3 I1_I608_pn4 XI1_I608_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I70_XG_MN1 (XI1_I608_I70_XG_n1 I1_I608_gn3 I1_I608_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I130_XG_MN2 (XI1_I608_I130_XG_n1 I1_I608_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I130_XG_MN0 (I1_I608_G5_0 I1_I608_P5_2n XI1_I608_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I130_XG_MN1 (XI1_I608_I130_XG_n1 I1_I608_G1_0n I1_I608_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I132_XG_MN2 (XI1_I608_I132_XG_n1 I1_I608_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I132_XG_MN0 (I1_I608_G7_0 I1_I608_P7_4n XI1_I608_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I132_XG_MN1 (XI1_I608_I132_XG_n1 I1_I608_G3_0n I1_I608_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I134_XG_MN2 (XI1_I608_I134_XG_n1 I1_I608_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I134_XG_MN0 (I1_I608_G9_2 I1_I608_P9_6n XI1_I608_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I134_XG_MN1 (XI1_I608_I134_XG_n1 I1_I608_G5_2n I1_I608_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I184_XG_MN2 (XI1_I608_I184_XG_n1 I1_I608_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I184_XG_MN0 (I1_I608_G17_0 I1_I608_P17_2n XI1_I608_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I184_XG_MN1 (XI1_I608_I184_XG_n1 I1_I608_G1_0n I1_I608_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I186_XG_MN2 (XI1_I608_I186_XG_n1 I1_I608_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I186_XG_MN0 (I1_I608_G19_0 I1_I608_P19_4n XI1_I608_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I186_XG_MN1 (XI1_I608_I186_XG_n1 I1_I608_G3_0n I1_I608_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I196_XG_MN2 (XI1_I608_I196_XG_n1 I1_I608_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I196_XG_MN0 (I1_I608_G25_0 I1_I608_P25_10n XI1_I608_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I196_XG_MN1 (XI1_I608_I196_XG_n1 I1_I608_G9_0n I1_I608_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I190_XG_MN2 (XI1_I608_I190_XG_n1 I1_I608_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I190_XG_MN0 (I1_I608_G21_0 I1_I608_P21_6n XI1_I608_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I190_XG_MN1 (XI1_I608_I190_XG_n1 I1_I608_G5_0n I1_I608_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I198_XG_MN2 (XI1_I608_I198_XG_n1 I1_I608_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I198_XG_MN0 (I1_I608_G27_0 I1_I608_P27_12n XI1_I608_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I198_XG_MN1 (XI1_I608_I198_XG_n1 I1_I608_G11_0n I1_I608_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I194_XG_MN2 (XI1_I608_I194_XG_n1 I1_I608_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I194_XG_MN0 (I1_I608_G23_0 I1_I608_P23_8n XI1_I608_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I194_XG_MN1 (XI1_I608_I194_XG_n1 I1_I608_G7_0n I1_I608_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I200_XG_MN2 (XI1_I608_I200_XG_n1 I1_I608_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I200_XG_MN0 (I1_I608_G29_0 I1_I608_P29_14n XI1_I608_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I200_XG_MN1 (XI1_I608_I200_XG_n1 I1_I608_G13_0n I1_I608_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I202_XG_MN2 (XI1_I608_I202_XG_n1 I1_I608_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I202_XG_MN0 (I1_c1_o I1_I608_P31_16n XI1_I608_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I202_XG_MN1 (XI1_I608_I202_XG_n1 I1_I608_G15_0n I1_c1_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I156_XG_MN2 (XI1_I608_I156_XG_n1 I1_I608_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I156_XG_MN0 (I1_I608_G31_24 I1_I608_P31_28n XI1_I608_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I156_XG_MN1 (XI1_I608_I156_XG_n1 I1_I608_G27_24n I1_I608_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I97_XG_MN2 (XI1_I608_I97_XG_n1 I1_I608_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I97_XG_MN0 (I1_I608_G31_30 I1_I608_pn31 XI1_I608_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I97_XG_MN1 (XI1_I608_I97_XG_n1 I1_I608_gn30 I1_I608_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I202_XG_MN2 (XI1_I1482_I202_XG_n1 I1_I1482_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I202_XG_MN0 (I1_c20_o I1_I1482_P31_16n XI1_I1482_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I202_XG_MN1 (XI1_I1482_I202_XG_n1 I1_I1482_G15_0n I1_c20_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I148_XG_MN2 (XI1_I1482_I148_XG_n1 I1_I1482_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I148_XG_MN0 (I1_I1482_G23_16 I1_I1482_P23_20n XI1_I1482_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I148_XG_MN1 (XI1_I1482_I148_XG_n1 I1_I1482_G19_16n I1_I1482_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I194_XG_MN2 (XI1_I1482_I194_XG_n1 I1_I1482_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I194_XG_MN0 (I1_I1482_G23_0 I1_I1482_P23_8n XI1_I1482_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I194_XG_MN1 (XI1_I1482_I194_XG_n1 I1_I1482_G7_0n I1_I1482_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I150_XG_MN2 (XI1_I1482_I150_XG_n1 I1_I1482_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I150_XG_MN0 (I1_I1482_G25_18 I1_I1482_P25_22n XI1_I1482_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I150_XG_MN1 (XI1_I1482_I150_XG_n1 I1_I1482_G21_18n I1_I1482_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I146_XG_MN2 (XI1_I1482_I146_XG_n1 I1_I1482_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I146_XG_MN0 (I1_I1482_G21_14 I1_I1482_P21_18n XI1_I1482_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I146_XG_MN1 (XI1_I1482_I146_XG_n1 I1_I1482_G17_14n I1_I1482_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I190_XG_MN2 (XI1_I1482_I190_XG_n1 I1_I1482_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I190_XG_MN0 (I1_I1482_G21_0 I1_I1482_P21_6n XI1_I1482_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I190_XG_MN1 (XI1_I1482_I190_XG_n1 I1_I1482_G5_0n I1_I1482_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I186_XG_MN2 (XI1_I1482_I186_XG_n1 I1_I1482_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I186_XG_MN0 (I1_I1482_G19_0 I1_I1482_P19_4n XI1_I1482_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I186_XG_MN1 (XI1_I1482_I186_XG_n1 I1_I1482_G3_0n I1_I1482_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I184_XG_MN2 (XI1_I1482_I184_XG_n1 I1_I1482_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I184_XG_MN0 (I1_I1482_G17_0 I1_I1482_P17_2n XI1_I1482_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I184_XG_MN1 (XI1_I1482_I184_XG_n1 I1_I1482_G1_0n I1_I1482_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I130_XG_MN2 (XI1_I1482_I130_XG_n1 I1_I1482_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I130_XG_MN0 (I1_I1482_G5_0 I1_I1482_P5_2n XI1_I1482_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I130_XG_MN1 (XI1_I1482_I130_XG_n1 I1_I1482_G1_0n I1_I1482_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I67_XG_MN2 (XI1_I1482_I67_XG_n1 I1_I1482_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I67_XG_MN0 (I1_I1482_G1_0 I1_I1482_pn1 XI1_I1482_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I67_XG_MN1 (XI1_I1482_I67_XG_n1 I1_I1482_G0_0n I1_I1482_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I76_XG_MN2 (XI1_I1114_I76_XG_n1 I1_I1114_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I76_XG_MN0 (I1_I1114_G10_9 I1_I1114_pn10 XI1_I1114_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I76_XG_MN1 (XI1_I1114_I76_XG_n1 I1_I1114_gn9 I1_I1114_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I133_XG_MN2 (XI1_I1114_I133_XG_n1 I1_I1114_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I133_XG_MN0 (I1_I1114_G8_1 I1_I1114_P8_5n XI1_I1114_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I133_XG_MN1 (XI1_I1114_I133_XG_n1 I1_I1114_G4_1n I1_I1114_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I128_XG_MN2 (XI1_I1114_I128_XG_n1 I1_I1114_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I128_XG_MN0 (I1_I1114_G4_0 I1_I1114_P4_1n XI1_I1114_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I128_XG_MN1 (XI1_I1114_I128_XG_n1 I1_I1114_G0_0n I1_I1114_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I67_XG_MN2 (XI1_I1114_I67_XG_n1 I1_I1114_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I67_XG_MN0 (I1_I1114_G1_0 I1_I1114_pn1 XI1_I1114_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I67_XG_MN1 (XI1_I1114_I67_XG_n1 I1_I1114_G0_0n I1_I1114_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I195_XG_MN2 (XI1_I1068_I195_XG_n1 I1_I1068_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I195_XG_MN0 (I1_I1068_G24_0 I1_I1068_P24_9n XI1_I1068_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I195_XG_MN1 (XI1_I1068_I195_XG_n1 I1_I1068_G8_0n I1_I1068_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I141_XG_MN2 (XI1_I1068_I141_XG_n1 I1_I1068_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I141_XG_MN0 (I1_I1068_G16_9 I1_I1068_P16_13n XI1_I1068_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I141_XG_MN1 (XI1_I1068_I141_XG_n1 I1_I1068_G12_9n I1_I1068_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I137_XG_MN2 (XI1_I1068_I137_XG_n1 I1_I1068_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I137_XG_MN0 (I1_I1068_G12_5 I1_I1068_P12_9n XI1_I1068_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I137_XG_MN1 (XI1_I1068_I137_XG_n1 I1_I1068_G8_5n I1_I1068_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I184_XG_MN2 (XI1_I1068_I184_XG_n1 I1_I1068_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I184_XG_MN0 (I1_I1068_G17_0 I1_I1068_P17_2n XI1_I1068_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I184_XG_MN1 (XI1_I1068_I184_XG_n1 I1_I1068_G1_0n I1_I1068_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I132_XG_MN2 (XI1_I1068_I132_XG_n1 I1_I1068_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I132_XG_MN0 (I1_I1068_G7_0 I1_I1068_P7_4n XI1_I1068_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I132_XG_MN1 (XI1_I1068_I132_XG_n1 I1_I1068_G3_0n I1_I1068_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I136_XG_MN2 (XI1_I1068_I136_XG_n1 I1_I1068_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I136_XG_MN0 (I1_I1068_G11_4 I1_I1068_P11_8n XI1_I1068_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I136_XG_MN1 (XI1_I1068_I136_XG_n1 I1_I1068_G7_4n I1_I1068_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I79_XG_MN2 (XI1_I1068_I79_XG_n1 I1_I1068_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I79_XG_MN0 (I1_I1068_G13_12 I1_I1068_pn13 XI1_I1068_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I79_XG_MN1 (XI1_I1068_I79_XG_n1 I1_I1068_gn12 I1_I1068_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I77_XG_MN2 (XI1_I1068_I77_XG_n1 I1_I1068_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I77_XG_MN0 (I1_I1068_G11_10 I1_I1068_pn11 XI1_I1068_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I77_XG_MN1 (XI1_I1068_I77_XG_n1 I1_I1068_gn10 I1_I1068_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I78_XG_MN2 (XI1_I1068_I78_XG_n1 I1_I1068_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I78_XG_MN0 (I1_I1068_G12_11 I1_I1068_pn12 XI1_I1068_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I78_XG_MN1 (XI1_I1068_I78_XG_n1 I1_I1068_gn11 I1_I1068_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I199_XG_MN2 (XI1_I1022_I199_XG_n1 I1_I1022_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I199_XG_MN0 (I1_I1022_G28_0 I1_I1022_P28_13n XI1_I1022_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I199_XG_MN1 (XI1_I1022_I199_XG_n1 I1_I1022_G12_0n I1_I1022_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I149_XG_MN2 (XI1_I1022_I149_XG_n1 I1_I1022_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I149_XG_MN0 (I1_I1022_G24_17 I1_I1022_P24_21n XI1_I1022_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I149_XG_MN1 (XI1_I1022_I149_XG_n1 I1_I1022_G20_17n I1_I1022_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I146_XG_MN2 (XI1_I1022_I146_XG_n1 I1_I1022_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I146_XG_MN0 (I1_I1022_G21_14 I1_I1022_P21_18n XI1_I1022_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I146_XG_MN1 (XI1_I1022_I146_XG_n1 I1_I1022_G17_14n I1_I1022_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I144_XG_MN2 (XI1_I1022_I144_XG_n1 I1_I1022_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I144_XG_MN0 (I1_I1022_G19_12 I1_I1022_P19_16n XI1_I1022_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I144_XG_MN1 (XI1_I1022_I144_XG_n1 I1_I1022_G15_12n I1_I1022_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I82_XG_MN2 (XI1_I1022_I82_XG_n1 I1_I1022_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I82_XG_MN0 (I1_I1022_G16_15 I1_I1022_pn16 XI1_I1022_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I82_XG_MN1 (XI1_I1022_I82_XG_n1 I1_I1022_gn15 I1_I1022_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I81_XG_MN2 (XI1_I1022_I81_XG_n1 I1_I1022_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I81_XG_MN0 (I1_I1022_G15_14 I1_I1022_pn15 XI1_I1022_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I81_XG_MN1 (XI1_I1022_I81_XG_n1 I1_I1022_gn14 I1_I1022_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I67_XG_MN2 (XI1_I976_I67_XG_n1 I1_I976_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I67_XG_MN0 (I1_I976_G1_0 I1_I976_pn1 XI1_I976_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I67_XG_MN1 (XI1_I976_I67_XG_n1 I1_I976_G0_0n I1_I976_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I68_XG_MN2 (XI1_I976_I68_XG_n1 I1_I976_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I68_XG_MN0 (I1_I976_G2_1 I1_I976_pn2 XI1_I976_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I68_XG_MN1 (XI1_I976_I68_XG_n1 I1_I976_gn1 I1_I976_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I65_XG_MN2 (XI1_I930_I65_XG_n1 I1_I930_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I65_XG_MN0 (I1_I930_G0_0 I1_I930_pn0 XI1_I930_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I930_I65_XG_MN1 (XI1_I930_I65_XG_n1 I1_I930_cinn I1_I930_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I71_XG_MN2 (XI1_I608_I71_XG_n1 I1_I608_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I71_XG_MN0 (I1_I608_G5_4 I1_I608_pn5 XI1_I608_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I71_XG_MN1 (XI1_I608_I71_XG_n1 I1_I608_gn4 I1_I608_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I72_XG_MN2 (XI1_I608_I72_XG_n1 I1_I608_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I72_XG_MN0 (I1_I608_G6_5 I1_I608_pn6 XI1_I608_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I72_XG_MN1 (XI1_I608_I72_XG_n1 I1_I608_gn5 I1_I608_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I73_XG_MN2 (XI1_I608_I73_XG_n1 I1_I608_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I73_XG_MN0 (I1_I608_G7_6 I1_I608_pn7 XI1_I608_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I73_XG_MN1 (XI1_I608_I73_XG_n1 I1_I608_gn6 I1_I608_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I75_XG_MN2 (XI1_I608_I75_XG_n1 I1_I608_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I75_XG_MN0 (I1_I608_G9_8 I1_I608_pn9 XI1_I608_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I75_XG_MN1 (XI1_I608_I75_XG_n1 I1_I608_gn8 I1_I608_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I76_XG_MN2 (XI1_I608_I76_XG_n1 I1_I608_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I76_XG_MN0 (I1_I608_G10_9 I1_I608_pn10 XI1_I608_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I76_XG_MN1 (XI1_I608_I76_XG_n1 I1_I608_gn9 I1_I608_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I136_XG_MN2 (XI1_I608_I136_XG_n1 I1_I608_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I136_XG_MN0 (I1_I608_G11_4 I1_I608_P11_8n XI1_I608_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I136_XG_MN1 (XI1_I608_I136_XG_n1 I1_I608_G7_4n I1_I608_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I138_XG_MN2 (XI1_I608_I138_XG_n1 I1_I608_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I138_XG_MN0 (I1_I608_G13_6 I1_I608_P13_10n XI1_I608_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I138_XG_MN1 (XI1_I608_I138_XG_n1 I1_I608_G9_6n I1_I608_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I142_XG_MN2 (XI1_I608_I142_XG_n1 I1_I608_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I142_XG_MN0 (I1_I608_G17_10 I1_I608_P17_14n XI1_I608_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I142_XG_MN1 (XI1_I608_I142_XG_n1 I1_I608_G13_10n I1_I608_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I140_XG_MN2 (XI1_I608_I140_XG_n1 I1_I608_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I140_XG_MN0 (I1_I608_G15_8 I1_I608_P15_12n XI1_I608_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I140_XG_MN1 (XI1_I608_I140_XG_n1 I1_I608_G11_8n I1_I608_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I144_XG_MN2 (XI1_I608_I144_XG_n1 I1_I608_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I144_XG_MN0 (I1_I608_G19_12 I1_I608_P19_16n XI1_I608_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I144_XG_MN1 (XI1_I608_I144_XG_n1 I1_I608_G15_12n I1_I608_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I146_XG_MN2 (XI1_I608_I146_XG_n1 I1_I608_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I146_XG_MN0 (I1_I608_G21_14 I1_I608_P21_18n XI1_I608_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I146_XG_MN1 (XI1_I608_I146_XG_n1 I1_I608_G17_14n I1_I608_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I150_XG_MN2 (XI1_I608_I150_XG_n1 I1_I608_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I150_XG_MN0 (I1_I608_G25_18 I1_I608_P25_22n XI1_I608_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I150_XG_MN1 (XI1_I608_I150_XG_n1 I1_I608_G21_18n I1_I608_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I148_XG_MN2 (XI1_I608_I148_XG_n1 I1_I608_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I148_XG_MN0 (I1_I608_G23_16 I1_I608_P23_20n XI1_I608_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I148_XG_MN1 (XI1_I608_I148_XG_n1 I1_I608_G19_16n I1_I608_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I152_XG_MN2 (XI1_I608_I152_XG_n1 I1_I608_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I152_XG_MN0 (I1_I608_G27_20 I1_I608_P27_24n XI1_I608_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I152_XG_MN1 (XI1_I608_I152_XG_n1 I1_I608_G23_20n I1_I608_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I154_XG_MN2 (XI1_I608_I154_XG_n1 I1_I608_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I154_XG_MN0 (I1_I608_G29_22 I1_I608_P29_26n XI1_I608_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I154_XG_MN1 (XI1_I608_I154_XG_n1 I1_I608_G25_22n I1_I608_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I94_XG_MN2 (XI1_I608_I94_XG_n1 I1_I608_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I94_XG_MN0 (I1_I608_G28_27 I1_I608_pn28 XI1_I608_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I94_XG_MN1 (XI1_I608_I94_XG_n1 I1_I608_gn27 I1_I608_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I95_XG_MN2 (XI1_I608_I95_XG_n1 I1_I608_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I95_XG_MN0 (I1_I608_G29_28 I1_I608_pn29 XI1_I608_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I95_XG_MN1 (XI1_I608_I95_XG_n1 I1_I608_gn28 I1_I608_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I156_XG_MN2 (XI1_I1482_I156_XG_n1 I1_I1482_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I156_XG_MN0 (I1_I1482_G31_24 I1_I1482_P31_28n XI1_I1482_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I156_XG_MN1 (XI1_I1482_I156_XG_n1 I1_I1482_G27_24n I1_I1482_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I154_XG_MN2 (XI1_I1482_I154_XG_n1 I1_I1482_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I154_XG_MN0 (I1_I1482_G29_22 I1_I1482_P29_26n XI1_I1482_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I154_XG_MN1 (XI1_I1482_I154_XG_n1 I1_I1482_G25_22n I1_I1482_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I152_XG_MN2 (XI1_I1482_I152_XG_n1 I1_I1482_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I152_XG_MN0 (I1_I1482_G27_20 I1_I1482_P27_24n XI1_I1482_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I152_XG_MN1 (XI1_I1482_I152_XG_n1 I1_I1482_G23_20n I1_I1482_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I196_XG_MN2 (XI1_I1482_I196_XG_n1 I1_I1482_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I196_XG_MN0 (I1_I1482_G25_0 I1_I1482_P25_10n XI1_I1482_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I196_XG_MN1 (XI1_I1482_I196_XG_n1 I1_I1482_G9_0n I1_I1482_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I183_XG_MN2 (XI1_I1482_I183_XG_n1 I1_I1482_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I183_XG_MN0 (I1_I1482_G16_0 I1_I1482_P16_1n XI1_I1482_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I183_XG_MN1 (XI1_I1482_I183_XG_n1 I1_I1482_G0_0n I1_I1482_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I133_XG_MN2 (XI1_I1482_I133_XG_n1 I1_I1482_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I133_XG_MN0 (I1_I1482_G8_1 I1_I1482_P8_5n XI1_I1482_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I133_XG_MN1 (XI1_I1482_I133_XG_n1 I1_I1482_G4_1n I1_I1482_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I128_XG_MN2 (XI1_I1482_I128_XG_n1 I1_I1482_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I128_XG_MN0 (I1_I1482_G4_0 I1_I1482_P4_1n XI1_I1482_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I128_XG_MN1 (XI1_I1482_I128_XG_n1 I1_I1482_G0_0n I1_I1482_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I65_XG_MN2 (XI1_I1482_I65_XG_n1 I1_I1482_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I65_XG_MN0 (I1_I1482_G0_0 I1_I1482_pn0 XI1_I1482_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I65_XG_MN1 (XI1_I1482_I65_XG_n1 I1_I1482_cinn I1_I1482_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I75_XG_MN2 (XI1_I1114_I75_XG_n1 I1_I1114_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I75_XG_MN0 (I1_I1114_G9_8 I1_I1114_pn9 XI1_I1114_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I75_XG_MN1 (XI1_I1114_I75_XG_n1 I1_I1114_gn8 I1_I1114_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I74_XG_MN2 (XI1_I1114_I74_XG_n1 I1_I1114_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I74_XG_MN0 (I1_I1114_G8_7 I1_I1114_pn8 XI1_I1114_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I74_XG_MN1 (XI1_I1114_I74_XG_n1 I1_I1114_gn7 I1_I1114_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I73_XG_MN2 (XI1_I1114_I73_XG_n1 I1_I1114_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I73_XG_MN0 (I1_I1114_G7_6 I1_I1114_pn7 XI1_I1114_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I73_XG_MN1 (XI1_I1114_I73_XG_n1 I1_I1114_gn6 I1_I1114_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I183_XG_MN2 (XI1_I1068_I183_XG_n1 I1_I1068_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I183_XG_MN0 (I1_I1068_G16_0 I1_I1068_P16_1n XI1_I1068_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I183_XG_MN1 (XI1_I1068_I183_XG_n1 I1_I1068_G0_0n I1_I1068_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I135_XG_MN2 (XI1_I1068_I135_XG_n1 I1_I1068_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I135_XG_MN0 (I1_I1068_G10_3 I1_I1068_P10_7n XI1_I1068_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I135_XG_MN1 (XI1_I1068_I135_XG_n1 I1_I1068_G6_3n I1_I1068_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I134_XG_MN2 (XI1_I1068_I134_XG_n1 I1_I1068_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I134_XG_MN0 (I1_I1068_G9_2 I1_I1068_P9_6n XI1_I1068_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I134_XG_MN1 (XI1_I1068_I134_XG_n1 I1_I1068_G5_2n I1_I1068_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I75_XG_MN2 (XI1_I1068_I75_XG_n1 I1_I1068_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I75_XG_MN0 (I1_I1068_G9_8 I1_I1068_pn9 XI1_I1068_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I75_XG_MN1 (XI1_I1068_I75_XG_n1 I1_I1068_gn8 I1_I1068_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I76_XG_MN2 (XI1_I1068_I76_XG_n1 I1_I1068_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I76_XG_MN0 (I1_I1068_G10_9 I1_I1068_pn10 XI1_I1068_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I76_XG_MN1 (XI1_I1068_I76_XG_n1 I1_I1068_gn9 I1_I1068_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I197_XG_MN2 (XI1_I1022_I197_XG_n1 I1_I1022_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I197_XG_MN0 (I1_I1022_G26_0 I1_I1022_P26_11n XI1_I1022_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I197_XG_MN1 (XI1_I1022_I197_XG_n1 I1_I1022_G10_0n I1_I1022_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I139_XG_MN2 (XI1_I1022_I139_XG_n1 I1_I1022_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I139_XG_MN0 (I1_I1022_G14_7 I1_I1022_P14_11n XI1_I1022_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I139_XG_MN1 (XI1_I1022_I139_XG_n1 I1_I1022_G10_7n I1_I1022_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I143_XG_MN2 (XI1_I1022_I143_XG_n1 I1_I1022_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I143_XG_MN0 (I1_I1022_G18_11 I1_I1022_P18_15n XI1_I1022_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I143_XG_MN1 (XI1_I1022_I143_XG_n1 I1_I1022_G14_11n I1_I1022_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I145_XG_MN2 (XI1_I1022_I145_XG_n1 I1_I1022_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I145_XG_MN0 (I1_I1022_G20_13 I1_I1022_P20_17n XI1_I1022_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I145_XG_MN1 (XI1_I1022_I145_XG_n1 I1_I1022_G16_13n I1_I1022_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I200_XG_MN2 (XI1_I1022_I200_XG_n1 I1_I1022_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I200_XG_MN0 (I1_I1022_G29_0 I1_I1022_P29_14n XI1_I1022_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I200_XG_MN1 (XI1_I1022_I200_XG_n1 I1_I1022_G13_0n I1_I1022_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I198_XG_MN2 (XI1_I1022_I198_XG_n1 I1_I1022_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I198_XG_MN0 (I1_I1022_G27_0 I1_I1022_P27_12n XI1_I1022_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I198_XG_MN1 (XI1_I1022_I198_XG_n1 I1_I1022_G11_0n I1_I1022_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I186_XG_MN2 (XI1_I1022_I186_XG_n1 I1_I1022_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I186_XG_MN0 (I1_I1022_G19_0 I1_I1022_P19_4n XI1_I1022_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I186_XG_MN1 (XI1_I1022_I186_XG_n1 I1_I1022_G3_0n I1_I1022_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I140_XG_MN2 (XI1_I1022_I140_XG_n1 I1_I1022_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I140_XG_MN0 (I1_I1022_G15_8 I1_I1022_P15_12n XI1_I1022_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I140_XG_MN1 (XI1_I1022_I140_XG_n1 I1_I1022_G11_8n I1_I1022_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I80_XG_MN2 (XI1_I1022_I80_XG_n1 I1_I1022_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I80_XG_MN0 (I1_I1022_G14_13 I1_I1022_pn14 XI1_I1022_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I80_XG_MN1 (XI1_I1022_I80_XG_n1 I1_I1022_gn13 I1_I1022_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I74_XG_MN2 (XI1_I608_I74_XG_n1 I1_I608_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I74_XG_MN0 (I1_I608_G8_7 I1_I608_pn8 XI1_I608_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I74_XG_MN1 (XI1_I608_I74_XG_n1 I1_I608_gn7 I1_I608_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I77_XG_MN2 (XI1_I608_I77_XG_n1 I1_I608_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I77_XG_MN0 (I1_I608_G11_10 I1_I608_pn11 XI1_I608_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I77_XG_MN1 (XI1_I608_I77_XG_n1 I1_I608_gn10 I1_I608_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I80_XG_MN2 (XI1_I608_I80_XG_n1 I1_I608_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I80_XG_MN0 (I1_I608_G14_13 I1_I608_pn14 XI1_I608_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I80_XG_MN1 (XI1_I608_I80_XG_n1 I1_I608_gn13 I1_I608_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I81_XG_MN2 (XI1_I608_I81_XG_n1 I1_I608_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I81_XG_MN0 (I1_I608_G15_14 I1_I608_pn15 XI1_I608_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I81_XG_MN1 (XI1_I608_I81_XG_n1 I1_I608_gn14 I1_I608_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I82_XG_MN2 (XI1_I608_I82_XG_n1 I1_I608_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I82_XG_MN0 (I1_I608_G16_15 I1_I608_pn16 XI1_I608_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I82_XG_MN1 (XI1_I608_I82_XG_n1 I1_I608_gn15 I1_I608_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I83_XG_MN2 (XI1_I608_I83_XG_n1 I1_I608_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I83_XG_MN0 (I1_I608_G17_16 I1_I608_pn17 XI1_I608_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I83_XG_MN1 (XI1_I608_I83_XG_n1 I1_I608_gn16 I1_I608_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I85_XG_MN2 (XI1_I608_I85_XG_n1 I1_I608_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I85_XG_MN0 (I1_I608_G19_18 I1_I608_pn19 XI1_I608_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I85_XG_MN1 (XI1_I608_I85_XG_n1 I1_I608_gn18 I1_I608_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I86_XG_MN2 (XI1_I608_I86_XG_n1 I1_I608_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I86_XG_MN0 (I1_I608_G20_19 I1_I608_pn20 XI1_I608_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I86_XG_MN1 (XI1_I608_I86_XG_n1 I1_I608_gn19 I1_I608_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I87_XG_MN2 (XI1_I608_I87_XG_n1 I1_I608_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I87_XG_MN0 (I1_I608_G21_20 I1_I608_pn21 XI1_I608_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I87_XG_MN1 (XI1_I608_I87_XG_n1 I1_I608_gn20 I1_I608_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I88_XG_MN2 (XI1_I608_I88_XG_n1 I1_I608_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I88_XG_MN0 (I1_I608_G22_21 I1_I608_pn22 XI1_I608_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I88_XG_MN1 (XI1_I608_I88_XG_n1 I1_I608_gn21 I1_I608_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I89_XG_MN2 (XI1_I608_I89_XG_n1 I1_I608_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I89_XG_MN0 (I1_I608_G23_22 I1_I608_pn23 XI1_I608_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I89_XG_MN1 (XI1_I608_I89_XG_n1 I1_I608_gn22 I1_I608_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I90_XG_MN2 (XI1_I608_I90_XG_n1 I1_I608_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I90_XG_MN0 (I1_I608_G24_23 I1_I608_pn24 XI1_I608_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I90_XG_MN1 (XI1_I608_I90_XG_n1 I1_I608_gn23 I1_I608_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I91_XG_MN2 (XI1_I608_I91_XG_n1 I1_I608_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I91_XG_MN0 (I1_I608_G25_24 I1_I608_pn25 XI1_I608_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I91_XG_MN1 (XI1_I608_I91_XG_n1 I1_I608_gn24 I1_I608_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I93_XG_MN2 (XI1_I1482_I93_XG_n1 I1_I1482_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I93_XG_MN0 (I1_I1482_G27_26 I1_I1482_pn27 XI1_I1482_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I93_XG_MN1 (XI1_I1482_I93_XG_n1 I1_I1482_gn26 I1_I1482_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I92_XG_MN2 (XI1_I1482_I92_XG_n1 I1_I1482_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I92_XG_MN0 (I1_I1482_G26_25 I1_I1482_pn26 XI1_I1482_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I92_XG_MN1 (XI1_I1482_I92_XG_n1 I1_I1482_gn25 I1_I1482_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I145_XG_MN2 (XI1_I1482_I145_XG_n1 I1_I1482_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I145_XG_MN0 (I1_I1482_G20_13 I1_I1482_P20_17n XI1_I1482_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I145_XG_MN1 (XI1_I1482_I145_XG_n1 I1_I1482_G16_13n I1_I1482_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I141_XG_MN2 (XI1_I1482_I141_XG_n1 I1_I1482_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I141_XG_MN0 (I1_I1482_G16_9 I1_I1482_P16_13n XI1_I1482_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I141_XG_MN1 (XI1_I1482_I141_XG_n1 I1_I1482_G12_9n I1_I1482_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I137_XG_MN2 (XI1_I1482_I137_XG_n1 I1_I1482_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I137_XG_MN0 (I1_I1482_G12_5 I1_I1482_P12_9n XI1_I1482_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I137_XG_MN1 (XI1_I1482_I137_XG_n1 I1_I1482_G8_5n I1_I1482_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I131_XG_MN2 (XI1_I1482_I131_XG_n1 I1_I1482_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I131_XG_MN0 (I1_I1482_G6_0 I1_I1482_P6_3n XI1_I1482_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I131_XG_MN1 (XI1_I1482_I131_XG_n1 I1_I1482_G2_0n I1_I1482_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I68_XG_MN2 (XI1_I1114_I68_XG_n1 I1_I1114_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I68_XG_MN0 (I1_I1114_G2_1 I1_I1114_pn2 XI1_I1114_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I68_XG_MN1 (XI1_I1114_I68_XG_n1 I1_I1114_gn1 I1_I1114_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I133_XG_MN2 (XI1_I1068_I133_XG_n1 I1_I1068_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I133_XG_MN0 (I1_I1068_G8_1 I1_I1068_P8_5n XI1_I1068_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I133_XG_MN1 (XI1_I1068_I133_XG_n1 I1_I1068_G4_1n I1_I1068_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I131_XG_MN2 (XI1_I1068_I131_XG_n1 I1_I1068_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I131_XG_MN0 (I1_I1068_G6_0 I1_I1068_P6_3n XI1_I1068_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I131_XG_MN1 (XI1_I1068_I131_XG_n1 I1_I1068_G2_0n I1_I1068_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I130_XG_MN2 (XI1_I1068_I130_XG_n1 I1_I1068_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I130_XG_MN0 (I1_I1068_G5_0 I1_I1068_P5_2n XI1_I1068_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I130_XG_MN1 (XI1_I1068_I130_XG_n1 I1_I1068_G1_0n I1_I1068_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I74_XG_MN2 (XI1_I1068_I74_XG_n1 I1_I1068_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I74_XG_MN0 (I1_I1068_G8_7 I1_I1068_pn8 XI1_I1068_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I74_XG_MN1 (XI1_I1068_I74_XG_n1 I1_I1068_gn7 I1_I1068_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I65_XG_MN2 (XI1_I1114_I65_XG_n1 I1_I1114_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I65_XG_MN0 (I1_I1114_G0_0 I1_I1114_pn0 XI1_I1114_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1114_I65_XG_MN1 (XI1_I1114_I65_XG_n1 I1_I1114_cinn I1_I1114_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I185_XG_MN2 (XI1_I1022_I185_XG_n1 I1_I1022_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I185_XG_MN0 (I1_I1022_G18_0 I1_I1022_P18_3n XI1_I1022_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I185_XG_MN1 (XI1_I1022_I185_XG_n1 I1_I1022_G2_0n I1_I1022_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I135_XG_MN2 (XI1_I1022_I135_XG_n1 I1_I1022_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I135_XG_MN0 (I1_I1022_G10_3 I1_I1022_P10_7n XI1_I1022_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I135_XG_MN1 (XI1_I1022_I135_XG_n1 I1_I1022_G6_3n I1_I1022_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I195_XG_MN2 (XI1_I1022_I195_XG_n1 I1_I1022_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I195_XG_MN0 (I1_I1022_G24_0 I1_I1022_P24_9n XI1_I1022_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I195_XG_MN1 (XI1_I1022_I195_XG_n1 I1_I1022_G8_0n I1_I1022_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I141_XG_MN2 (XI1_I1022_I141_XG_n1 I1_I1022_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I141_XG_MN0 (I1_I1022_G16_9 I1_I1022_P16_13n XI1_I1022_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I141_XG_MN1 (XI1_I1022_I141_XG_n1 I1_I1022_G12_9n I1_I1022_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I196_XG_MN2 (XI1_I1022_I196_XG_n1 I1_I1022_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I196_XG_MN0 (I1_I1022_G25_0 I1_I1022_P25_10n XI1_I1022_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I196_XG_MN1 (XI1_I1022_I196_XG_n1 I1_I1022_G9_0n I1_I1022_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I142_XG_MN2 (XI1_I1022_I142_XG_n1 I1_I1022_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I142_XG_MN0 (I1_I1022_G17_10 I1_I1022_P17_14n XI1_I1022_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I142_XG_MN1 (XI1_I1022_I142_XG_n1 I1_I1022_G13_10n I1_I1022_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I132_XG_MN2 (XI1_I1022_I132_XG_n1 I1_I1022_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I132_XG_MN0 (I1_I1022_G7_0 I1_I1022_P7_4n XI1_I1022_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I132_XG_MN1 (XI1_I1022_I132_XG_n1 I1_I1022_G3_0n I1_I1022_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I136_XG_MN2 (XI1_I1022_I136_XG_n1 I1_I1022_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I136_XG_MN0 (I1_I1022_G11_4 I1_I1022_P11_8n XI1_I1022_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I136_XG_MN1 (XI1_I1022_I136_XG_n1 I1_I1022_G7_4n I1_I1022_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I76_XG_MN2 (XI1_I1022_I76_XG_n1 I1_I1022_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I76_XG_MN0 (I1_I1022_G10_9 I1_I1022_pn10 XI1_I1022_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I76_XG_MN1 (XI1_I1022_I76_XG_n1 I1_I1022_gn9 I1_I1022_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I77_XG_MN2 (XI1_I1022_I77_XG_n1 I1_I1022_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I77_XG_MN0 (I1_I1022_G11_10 I1_I1022_pn11 XI1_I1022_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I77_XG_MN1 (XI1_I1022_I77_XG_n1 I1_I1022_gn10 I1_I1022_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I84_XG_MN2 (XI1_I608_I84_XG_n1 I1_I608_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I84_XG_MN0 (I1_I608_G18_17 I1_I608_pn18 XI1_I608_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I608_I84_XG_MN1 (XI1_I608_I84_XG_n1 I1_I608_gn17 I1_I608_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I94_XG_MN2 (XI1_I1482_I94_XG_n1 I1_I1482_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I94_XG_MN0 (I1_I1482_G28_27 I1_I1482_pn28 XI1_I1482_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I94_XG_MN1 (XI1_I1482_I94_XG_n1 I1_I1482_gn27 I1_I1482_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I153_XG_MN2 (XI1_I1482_I153_XG_n1 I1_I1482_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I153_XG_MN0 (I1_I1482_G28_21 I1_I1482_P28_25n XI1_I1482_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I153_XG_MN1 (XI1_I1482_I153_XG_n1 I1_I1482_G24_21n I1_I1482_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I149_XG_MN2 (XI1_I1482_I149_XG_n1 I1_I1482_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I149_XG_MN0 (I1_I1482_G24_17 I1_I1482_P24_21n XI1_I1482_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I149_XG_MN1 (XI1_I1482_I149_XG_n1 I1_I1482_G20_17n I1_I1482_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I143_XG_MN2 (XI1_I1482_I143_XG_n1 I1_I1482_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I143_XG_MN0 (I1_I1482_G18_11 I1_I1482_P18_15n XI1_I1482_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I143_XG_MN1 (XI1_I1482_I143_XG_n1 I1_I1482_G14_11n I1_I1482_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I195_XG_MN2 (XI1_I1482_I195_XG_n1 I1_I1482_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I195_XG_MN0 (I1_I1482_G24_0 I1_I1482_P24_9n XI1_I1482_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I195_XG_MN1 (XI1_I1482_I195_XG_n1 I1_I1482_G8_0n I1_I1482_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I185_XG_MN2 (XI1_I1482_I185_XG_n1 I1_I1482_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I185_XG_MN0 (I1_I1482_G18_0 I1_I1482_P18_3n XI1_I1482_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I185_XG_MN1 (XI1_I1482_I185_XG_n1 I1_I1482_G2_0n I1_I1482_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I135_XG_MN2 (XI1_I1482_I135_XG_n1 I1_I1482_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I135_XG_MN0 (I1_I1482_G10_3 I1_I1482_P10_7n XI1_I1482_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I135_XG_MN1 (XI1_I1482_I135_XG_n1 I1_I1482_G6_3n I1_I1482_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I79_XG_MN2 (XI1_I1528_I79_XG_n1 I1_I1528_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I79_XG_MN0 (I1_I1528_G13_12 I1_I1528_pn13 XI1_I1528_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I79_XG_MN1 (XI1_I1528_I79_XG_n1 I1_I1528_gn12 I1_I1528_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I78_XG_MN2 (XI1_I1528_I78_XG_n1 I1_I1528_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I78_XG_MN0 (I1_I1528_G12_11 I1_I1528_pn12 XI1_I1528_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I78_XG_MN1 (XI1_I1528_I78_XG_n1 I1_I1528_gn11 I1_I1528_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I77_XG_MN2 (XI1_I1528_I77_XG_n1 I1_I1528_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I77_XG_MN0 (I1_I1528_G11_10 I1_I1528_pn11 XI1_I1528_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I77_XG_MN1 (XI1_I1528_I77_XG_n1 I1_I1528_gn10 I1_I1528_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I76_XG_MN2 (XI1_I1528_I76_XG_n1 I1_I1528_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I76_XG_MN0 (I1_I1528_G10_9 I1_I1528_pn10 XI1_I1528_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I76_XG_MN1 (XI1_I1528_I76_XG_n1 I1_I1528_gn9 I1_I1528_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I75_XG_MN2 (XI1_I1528_I75_XG_n1 I1_I1528_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I75_XG_MN0 (I1_I1528_G9_8 I1_I1528_pn9 XI1_I1528_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I75_XG_MN1 (XI1_I1528_I75_XG_n1 I1_I1528_gn8 I1_I1528_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I74_XG_MN2 (XI1_I1528_I74_XG_n1 I1_I1528_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I74_XG_MN0 (I1_I1528_G8_7 I1_I1528_pn8 XI1_I1528_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I74_XG_MN1 (XI1_I1528_I74_XG_n1 I1_I1528_gn7 I1_I1528_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I73_XG_MN2 (XI1_I1528_I73_XG_n1 I1_I1528_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I73_XG_MN0 (I1_I1528_G7_6 I1_I1528_pn7 XI1_I1528_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I73_XG_MN1 (XI1_I1528_I73_XG_n1 I1_I1528_gn6 I1_I1528_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I128_XG_MN2 (XI1_I1068_I128_XG_n1 I1_I1068_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I128_XG_MN0 (I1_I1068_G4_0 I1_I1068_P4_1n XI1_I1068_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I128_XG_MN1 (XI1_I1068_I128_XG_n1 I1_I1068_G0_0n I1_I1068_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I72_XG_MN2 (XI1_I1068_I72_XG_n1 I1_I1068_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I72_XG_MN0 (I1_I1068_G6_5 I1_I1068_pn6 XI1_I1068_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I72_XG_MN1 (XI1_I1068_I72_XG_n1 I1_I1068_gn5 I1_I1068_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I73_XG_MN2 (XI1_I1068_I73_XG_n1 I1_I1068_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I73_XG_MN0 (I1_I1068_G7_6 I1_I1068_pn7 XI1_I1068_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I73_XG_MN1 (XI1_I1068_I73_XG_n1 I1_I1068_gn6 I1_I1068_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I65_XG_MN2 (XI1_I1068_I65_XG_n1 I1_I1068_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I65_XG_MN0 (I1_I1068_G0_0 I1_I1068_pn0 XI1_I1068_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I65_XG_MN1 (XI1_I1068_I65_XG_n1 I1_I1068_cinn I1_I1068_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I131_XG_MN2 (XI1_I1022_I131_XG_n1 I1_I1022_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I131_XG_MN0 (I1_I1022_G6_0 I1_I1022_P6_3n XI1_I1022_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I131_XG_MN1 (XI1_I1022_I131_XG_n1 I1_I1022_G2_0n I1_I1022_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I188_XG_MN2 (XI1_I1022_I188_XG_n1 I1_I1022_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I188_XG_MN0 (I1_I1022_G20_0 I1_I1022_P20_5n XI1_I1022_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I188_XG_MN1 (XI1_I1022_I188_XG_n1 I1_I1022_G4_0n I1_I1022_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I137_XG_MN2 (XI1_I1022_I137_XG_n1 I1_I1022_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I137_XG_MN0 (I1_I1022_G12_5 I1_I1022_P12_9n XI1_I1022_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I137_XG_MN1 (XI1_I1022_I137_XG_n1 I1_I1022_G8_5n I1_I1022_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I190_XG_MN2 (XI1_I1022_I190_XG_n1 I1_I1022_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I190_XG_MN0 (I1_I1022_G21_0 I1_I1022_P21_6n XI1_I1022_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I190_XG_MN1 (XI1_I1022_I190_XG_n1 I1_I1022_G5_0n I1_I1022_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I184_XG_MN2 (XI1_I1022_I184_XG_n1 I1_I1022_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I184_XG_MN0 (I1_I1022_G17_0 I1_I1022_P17_2n XI1_I1022_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I184_XG_MN1 (XI1_I1022_I184_XG_n1 I1_I1022_G1_0n I1_I1022_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I138_XG_MN2 (XI1_I1022_I138_XG_n1 I1_I1022_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I138_XG_MN0 (I1_I1022_G13_6 I1_I1022_P13_10n XI1_I1022_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I138_XG_MN1 (XI1_I1022_I138_XG_n1 I1_I1022_G9_6n I1_I1022_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I134_XG_MN2 (XI1_I1022_I134_XG_n1 I1_I1022_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I134_XG_MN0 (I1_I1022_G9_2 I1_I1022_P9_6n XI1_I1022_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I134_XG_MN1 (XI1_I1022_I134_XG_n1 I1_I1022_G5_2n I1_I1022_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I75_XG_MN2 (XI1_I1022_I75_XG_n1 I1_I1022_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I75_XG_MN0 (I1_I1022_G9_8 I1_I1022_pn9 XI1_I1022_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I75_XG_MN1 (XI1_I1022_I75_XG_n1 I1_I1022_gn8 I1_I1022_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I71_XG_MN2 (XI1_I1022_I71_XG_n1 I1_I1022_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I71_XG_MN0 (I1_I1022_G5_4 I1_I1022_pn5 XI1_I1022_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I71_XG_MN1 (XI1_I1022_I71_XG_n1 I1_I1022_gn4 I1_I1022_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I74_XG_MN2 (XI1_I1022_I74_XG_n1 I1_I1022_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I74_XG_MN0 (I1_I1022_G8_7 I1_I1022_pn8 XI1_I1022_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I74_XG_MN1 (XI1_I1022_I74_XG_n1 I1_I1022_gn7 I1_I1022_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I72_XG_MN2 (XI1_I1022_I72_XG_n1 I1_I1022_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I72_XG_MN0 (I1_I1022_G6_5 I1_I1022_pn6 XI1_I1022_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I72_XG_MN1 (XI1_I1022_I72_XG_n1 I1_I1022_gn5 I1_I1022_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I73_XG_MN2 (XI1_I1022_I73_XG_n1 I1_I1022_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I73_XG_MN0 (I1_I1022_G7_6 I1_I1022_pn7 XI1_I1022_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I73_XG_MN1 (XI1_I1022_I73_XG_n1 I1_I1022_gn6 I1_I1022_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I65_XG_MN2 (XI1_I976_I65_XG_n1 I1_I976_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I65_XG_MN0 (I1_I976_G0_0 I1_I976_pn0 XI1_I976_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I976_I65_XG_MN1 (XI1_I976_I65_XG_n1 I1_I976_cinn I1_I976_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I67_XG_MN2 (XI1_I562_I67_XG_n1 I1_I562_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I67_XG_MN0 (I1_I562_G1_0 I1_I562_pn1 XI1_I562_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I67_XG_MN1 (XI1_I562_I67_XG_n1 I1_I562_G0_0n I1_I562_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I95_XG_MN2 (XI1_I1482_I95_XG_n1 I1_I1482_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I95_XG_MN0 (I1_I1482_G29_28 I1_I1482_pn29 XI1_I1482_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I95_XG_MN1 (XI1_I1482_I95_XG_n1 I1_I1482_gn28 I1_I1482_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I96_XG_MN2 (XI1_I1482_I96_XG_n1 I1_I1482_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I96_XG_MN0 (I1_I1482_G30_29 I1_I1482_pn30 XI1_I1482_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I96_XG_MN1 (XI1_I1482_I96_XG_n1 I1_I1482_gn29 I1_I1482_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I155_XG_MN2 (XI1_I1482_I155_XG_n1 I1_I1482_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I155_XG_MN0 (I1_I1482_G30_23 I1_I1482_P30_27n XI1_I1482_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I155_XG_MN1 (XI1_I1482_I155_XG_n1 I1_I1482_G26_23n I1_I1482_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I199_XG_MN2 (XI1_I1482_I199_XG_n1 I1_I1482_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I199_XG_MN0 (I1_I1482_G28_0 I1_I1482_P28_13n XI1_I1482_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I199_XG_MN1 (XI1_I1482_I199_XG_n1 I1_I1482_G12_0n I1_I1482_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I192_XG_MN2 (XI1_I1482_I192_XG_n1 I1_I1482_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I192_XG_MN0 (I1_I1482_G22_0 I1_I1482_P22_7n XI1_I1482_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I192_XG_MN1 (XI1_I1482_I192_XG_n1 I1_I1482_G6_0n I1_I1482_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I197_XG_MN2 (XI1_I1482_I197_XG_n1 I1_I1482_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I197_XG_MN0 (I1_I1482_G26_0 I1_I1482_P26_11n XI1_I1482_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I197_XG_MN1 (XI1_I1482_I197_XG_n1 I1_I1482_G10_0n I1_I1482_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I80_XG_MN2 (XI1_I1528_I80_XG_n1 I1_I1528_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I80_XG_MN0 (I1_I1528_G14_13 I1_I1528_pn14 XI1_I1528_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I80_XG_MN1 (XI1_I1528_I80_XG_n1 I1_I1528_gn13 I1_I1528_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I139_XG_MN2 (XI1_I1528_I139_XG_n1 I1_I1528_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I139_XG_MN0 (I1_I1528_G14_7 I1_I1528_P14_11n XI1_I1528_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I139_XG_MN1 (XI1_I1528_I139_XG_n1 I1_I1528_G10_7n I1_I1528_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I137_XG_MN2 (XI1_I1528_I137_XG_n1 I1_I1528_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I137_XG_MN0 (I1_I1528_G12_5 I1_I1528_P12_9n XI1_I1528_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I137_XG_MN1 (XI1_I1528_I137_XG_n1 I1_I1528_G8_5n I1_I1528_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I135_XG_MN2 (XI1_I1528_I135_XG_n1 I1_I1528_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I135_XG_MN0 (I1_I1528_G10_3 I1_I1528_P10_7n XI1_I1528_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I135_XG_MN1 (XI1_I1528_I135_XG_n1 I1_I1528_G6_3n I1_I1528_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I70_XG_MN2 (XI1_I1528_I70_XG_n1 I1_I1528_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I70_XG_MN0 (I1_I1528_G4_3 I1_I1528_pn4 XI1_I1528_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I70_XG_MN1 (XI1_I1528_I70_XG_n1 I1_I1528_gn3 I1_I1528_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I69_XG_MN2 (XI1_I1528_I69_XG_n1 I1_I1528_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I69_XG_MN0 (I1_I1528_G3_2 I1_I1528_pn3 XI1_I1528_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I69_XG_MN1 (XI1_I1528_I69_XG_n1 I1_I1528_gn2 I1_I1528_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I67_XG_MN2 (XI1_I1068_I67_XG_n1 I1_I1068_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I67_XG_MN0 (I1_I1068_G1_0 I1_I1068_pn1 XI1_I1068_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I67_XG_MN1 (XI1_I1068_I67_XG_n1 I1_I1068_G0_0n I1_I1068_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I68_XG_MN2 (XI1_I1068_I68_XG_n1 I1_I1068_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I68_XG_MN0 (I1_I1068_G2_1 I1_I1068_pn2 XI1_I1068_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I68_XG_MN1 (XI1_I1068_I68_XG_n1 I1_I1068_gn1 I1_I1068_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I69_XG_MN2 (XI1_I1068_I69_XG_n1 I1_I1068_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I69_XG_MN0 (I1_I1068_G3_2 I1_I1068_pn3 XI1_I1068_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I69_XG_MN1 (XI1_I1068_I69_XG_n1 I1_I1068_gn2 I1_I1068_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I70_XG_MN2 (XI1_I1068_I70_XG_n1 I1_I1068_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I70_XG_MN0 (I1_I1068_G4_3 I1_I1068_pn4 XI1_I1068_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I70_XG_MN1 (XI1_I1068_I70_XG_n1 I1_I1068_gn3 I1_I1068_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I71_XG_MN2 (XI1_I1068_I71_XG_n1 I1_I1068_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I71_XG_MN0 (I1_I1068_G5_4 I1_I1068_pn5 XI1_I1068_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1068_I71_XG_MN1 (XI1_I1068_I71_XG_n1 I1_I1068_gn4 I1_I1068_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I183_XG_MN2 (XI1_I1022_I183_XG_n1 I1_I1022_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I183_XG_MN0 (I1_I1022_G16_0 I1_I1022_P16_1n XI1_I1022_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I183_XG_MN1 (XI1_I1022_I183_XG_n1 I1_I1022_G0_0n I1_I1022_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I133_XG_MN2 (XI1_I1022_I133_XG_n1 I1_I1022_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I133_XG_MN0 (I1_I1022_G8_1 I1_I1022_P8_5n XI1_I1022_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I133_XG_MN1 (XI1_I1022_I133_XG_n1 I1_I1022_G4_1n I1_I1022_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I128_XG_MN2 (XI1_I1022_I128_XG_n1 I1_I1022_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I128_XG_MN0 (I1_I1022_G4_0 I1_I1022_P4_1n XI1_I1022_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I128_XG_MN1 (XI1_I1022_I128_XG_n1 I1_I1022_G0_0n I1_I1022_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I130_XG_MN2 (XI1_I1022_I130_XG_n1 I1_I1022_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I130_XG_MN0 (I1_I1022_G5_0 I1_I1022_P5_2n XI1_I1022_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I130_XG_MN1 (XI1_I1022_I130_XG_n1 I1_I1022_G1_0n I1_I1022_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I67_XG_MN2 (XI1_I1022_I67_XG_n1 I1_I1022_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I67_XG_MN0 (I1_I1022_G1_0 I1_I1022_pn1 XI1_I1022_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I67_XG_MN1 (XI1_I1022_I67_XG_n1 I1_I1022_G0_0n I1_I1022_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I68_XG_MN2 (XI1_I1022_I68_XG_n1 I1_I1022_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I68_XG_MN0 (I1_I1022_G2_1 I1_I1022_pn2 XI1_I1022_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I68_XG_MN1 (XI1_I1022_I68_XG_n1 I1_I1022_gn1 I1_I1022_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I65_XG_MN2 (XI1_I562_I65_XG_n1 I1_I562_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I65_XG_MN0 (I1_I562_G0_0 I1_I562_pn0 XI1_I562_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I65_XG_MN1 (XI1_I562_I65_XG_n1 I1_I562_cinn I1_I562_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I68_XG_MN2 (XI1_I562_I68_XG_n1 I1_I562_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I68_XG_MN0 (I1_I562_G2_1 I1_I562_pn2 XI1_I562_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I68_XG_MN1 (XI1_I562_I68_XG_n1 I1_I562_gn1 I1_I562_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I183_XG_MN2 (XI1_I562_I183_XG_n1 I1_I562_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I183_XG_MN0 (I1_I562_G16_0 I1_I562_P16_1n XI1_I562_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I183_XG_MN1 (XI1_I562_I183_XG_n1 I1_I562_G0_0n I1_I562_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I185_XG_MN2 (XI1_I562_I185_XG_n1 I1_I562_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I185_XG_MN0 (I1_I562_G18_0 I1_I562_P18_3n XI1_I562_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I185_XG_MN1 (XI1_I562_I185_XG_n1 I1_I562_G2_0n I1_I562_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I97_XG_MN2 (XI1_I1482_I97_XG_n1 I1_I1482_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I97_XG_MN0 (I1_I1482_G31_30 I1_I1482_pn31 XI1_I1482_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I97_XG_MN1 (XI1_I1482_I97_XG_n1 I1_I1482_gn30 I1_I1482_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I201_XG_MN2 (XI1_I1482_I201_XG_n1 I1_I1482_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I201_XG_MN0 (I1_c20_m I1_I1482_P30_15n XI1_I1482_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1482_I201_XG_MN1 (XI1_I1482_I201_XG_n1 I1_I1482_G14_0n I1_c20_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I84_XG_MN2 (XI1_I1528_I84_XG_n1 I1_I1528_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I84_XG_MN0 (I1_I1528_G18_17 I1_I1528_pn18 XI1_I1528_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I84_XG_MN1 (XI1_I1528_I84_XG_n1 I1_I1528_gn17 I1_I1528_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I83_XG_MN2 (XI1_I1528_I83_XG_n1 I1_I1528_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I83_XG_MN0 (I1_I1528_G17_16 I1_I1528_pn17 XI1_I1528_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I83_XG_MN1 (XI1_I1528_I83_XG_n1 I1_I1528_gn16 I1_I1528_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I149_XG_MN2 (XI1_I1528_I149_XG_n1 I1_I1528_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I149_XG_MN0 (I1_I1528_G24_17 I1_I1528_P24_21n XI1_I1528_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I149_XG_MN1 (XI1_I1528_I149_XG_n1 I1_I1528_G20_17n I1_I1528_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I141_XG_MN2 (XI1_I1528_I141_XG_n1 I1_I1528_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I141_XG_MN0 (I1_I1528_G16_9 I1_I1528_P16_13n XI1_I1528_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I141_XG_MN1 (XI1_I1528_I141_XG_n1 I1_I1528_G12_9n I1_I1528_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I195_XG_MN2 (XI1_I1528_I195_XG_n1 I1_I1528_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I195_XG_MN0 (I1_I1528_G24_0 I1_I1528_P24_9n XI1_I1528_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I195_XG_MN1 (XI1_I1528_I195_XG_n1 I1_I1528_G8_0n I1_I1528_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I131_XG_MN2 (XI1_I1528_I131_XG_n1 I1_I1528_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I131_XG_MN0 (I1_I1528_G6_0 I1_I1528_P6_3n XI1_I1528_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I131_XG_MN1 (XI1_I1528_I131_XG_n1 I1_I1528_G2_0n I1_I1528_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I133_XG_MN2 (XI1_I1528_I133_XG_n1 I1_I1528_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I133_XG_MN0 (I1_I1528_G8_1 I1_I1528_P8_5n XI1_I1528_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I133_XG_MN1 (XI1_I1528_I133_XG_n1 I1_I1528_G4_1n I1_I1528_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I68_XG_MN2 (XI1_I1528_I68_XG_n1 I1_I1528_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I68_XG_MN0 (I1_I1528_G2_1 I1_I1528_pn2 XI1_I1528_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I68_XG_MN1 (XI1_I1528_I68_XG_n1 I1_I1528_gn1 I1_I1528_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I65_XG_MN2 (XI1_I1022_I65_XG_n1 I1_I1022_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I65_XG_MN0 (I1_I1022_G0_0 I1_I1022_pn0 XI1_I1022_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1022_I65_XG_MN1 (XI1_I1022_I65_XG_n1 I1_I1022_cinn I1_I1022_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I69_XG_MN2 (XI1_I562_I69_XG_n1 I1_I562_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I69_XG_MN0 (I1_I562_G3_2 I1_I562_pn3 XI1_I562_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I69_XG_MN1 (XI1_I562_I69_XG_n1 I1_I562_gn2 I1_I562_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I70_XG_MN2 (XI1_I562_I70_XG_n1 I1_I562_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I70_XG_MN0 (I1_I562_G4_3 I1_I562_pn4 XI1_I562_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I70_XG_MN1 (XI1_I562_I70_XG_n1 I1_I562_gn3 I1_I562_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I133_XG_MN2 (XI1_I562_I133_XG_n1 I1_I562_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I133_XG_MN0 (I1_I562_G8_1 I1_I562_P8_5n XI1_I562_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I133_XG_MN1 (XI1_I562_I133_XG_n1 I1_I562_G4_1n I1_I562_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I135_XG_MN2 (XI1_I562_I135_XG_n1 I1_I562_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I135_XG_MN0 (I1_I562_G10_3 I1_I562_P10_7n XI1_I562_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I135_XG_MN1 (XI1_I562_I135_XG_n1 I1_I562_G6_3n I1_I562_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I195_XG_MN2 (XI1_I562_I195_XG_n1 I1_I562_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I195_XG_MN0 (I1_I562_G24_0 I1_I562_P24_9n XI1_I562_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I195_XG_MN1 (XI1_I562_I195_XG_n1 I1_I562_G8_0n I1_I562_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I188_XG_MN2 (XI1_I562_I188_XG_n1 I1_I562_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I188_XG_MN0 (I1_I562_G20_0 I1_I562_P20_5n XI1_I562_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I188_XG_MN1 (XI1_I562_I188_XG_n1 I1_I562_G4_0n I1_I562_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I197_XG_MN2 (XI1_I562_I197_XG_n1 I1_I562_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I197_XG_MN0 (I1_I562_G26_0 I1_I562_P26_11n XI1_I562_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I197_XG_MN1 (XI1_I562_I197_XG_n1 I1_I562_G10_0n I1_I562_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I192_XG_MN2 (XI1_I562_I192_XG_n1 I1_I562_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I192_XG_MN0 (I1_I562_G22_0 I1_I562_P22_7n XI1_I562_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I192_XG_MN1 (XI1_I562_I192_XG_n1 I1_I562_G6_0n I1_I562_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I199_XG_MN2 (XI1_I562_I199_XG_n1 I1_I562_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I199_XG_MN0 (I1_I562_G28_0 I1_I562_P28_13n XI1_I562_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I199_XG_MN1 (XI1_I562_I199_XG_n1 I1_I562_G12_0n I1_I562_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I201_XG_MN2 (XI1_I562_I201_XG_n1 I1_I562_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I201_XG_MN0 (I1_c0_m I1_I562_P30_15n XI1_I562_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I201_XG_MN1 (XI1_I562_I201_XG_n1 I1_I562_G14_0n I1_c0_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I90_XG_MN2 (XI1_I1528_I90_XG_n1 I1_I1528_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I90_XG_MN0 (I1_I1528_G24_23 I1_I1528_pn24 XI1_I1528_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I90_XG_MN1 (XI1_I1528_I90_XG_n1 I1_I1528_gn23 I1_I1528_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I89_XG_MN2 (XI1_I1528_I89_XG_n1 I1_I1528_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I89_XG_MN0 (I1_I1528_G23_22 I1_I1528_pn23 XI1_I1528_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I89_XG_MN1 (XI1_I1528_I89_XG_n1 I1_I1528_gn22 I1_I1528_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I88_XG_MN2 (XI1_I1528_I88_XG_n1 I1_I1528_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I88_XG_MN0 (I1_I1528_G22_21 I1_I1528_pn22 XI1_I1528_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I88_XG_MN1 (XI1_I1528_I88_XG_n1 I1_I1528_gn21 I1_I1528_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I87_XG_MN2 (XI1_I1528_I87_XG_n1 I1_I1528_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I87_XG_MN0 (I1_I1528_G21_20 I1_I1528_pn21 XI1_I1528_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I87_XG_MN1 (XI1_I1528_I87_XG_n1 I1_I1528_gn20 I1_I1528_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I153_XG_MN2 (XI1_I1528_I153_XG_n1 I1_I1528_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I153_XG_MN0 (I1_I1528_G28_21 I1_I1528_P28_25n XI1_I1528_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I153_XG_MN1 (XI1_I1528_I153_XG_n1 I1_I1528_G24_21n I1_I1528_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I151_XG_MN2 (XI1_I1528_I151_XG_n1 I1_I1528_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I151_XG_MN0 (I1_I1528_G26_19 I1_I1528_P26_23n XI1_I1528_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I151_XG_MN1 (XI1_I1528_I151_XG_n1 I1_I1528_G22_19n I1_I1528_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I147_XG_MN2 (XI1_I1528_I147_XG_n1 I1_I1528_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I147_XG_MN0 (I1_I1528_G22_15 I1_I1528_P22_19n XI1_I1528_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I147_XG_MN1 (XI1_I1528_I147_XG_n1 I1_I1528_G18_15n I1_I1528_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I192_XG_MN2 (XI1_I1528_I192_XG_n1 I1_I1528_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I192_XG_MN0 (I1_I1528_G22_0 I1_I1528_P22_7n XI1_I1528_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I192_XG_MN1 (XI1_I1528_I192_XG_n1 I1_I1528_G6_0n I1_I1528_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I185_XG_MN2 (XI1_I1528_I185_XG_n1 I1_I1528_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I185_XG_MN0 (I1_I1528_G18_0 I1_I1528_P18_3n XI1_I1528_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I185_XG_MN1 (XI1_I1528_I185_XG_n1 I1_I1528_G2_0n I1_I1528_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I183_XG_MN2 (XI1_I1528_I183_XG_n1 I1_I1528_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I183_XG_MN0 (I1_I1528_G16_0 I1_I1528_P16_1n XI1_I1528_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I183_XG_MN1 (XI1_I1528_I183_XG_n1 I1_I1528_G0_0n I1_I1528_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I128_XG_MN2 (XI1_I1528_I128_XG_n1 I1_I1528_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I128_XG_MN0 (I1_I1528_G4_0 I1_I1528_P4_1n XI1_I1528_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I128_XG_MN1 (XI1_I1528_I128_XG_n1 I1_I1528_G0_0n I1_I1528_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I67_XG_MN2 (XI1_I1528_I67_XG_n1 I1_I1528_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I67_XG_MN0 (I1_I1528_G1_0 I1_I1528_pn1 XI1_I1528_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I67_XG_MN1 (XI1_I1528_I67_XG_n1 I1_I1528_G0_0n I1_I1528_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I65_XG_MN2 (XI1_I1528_I65_XG_n1 I1_I1528_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I65_XG_MN0 (I1_I1528_G0_0 I1_I1528_pn0 XI1_I1528_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1528_I65_XG_MN1 (XI1_I1528_I65_XG_n1 I1_I1528_cinn I1_I1528_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I71_XG_MN2 (XI1_I562_I71_XG_n1 I1_I562_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I71_XG_MN0 (I1_I562_G5_4 I1_I562_pn5 XI1_I562_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I71_XG_MN1 (XI1_I562_I71_XG_n1 I1_I562_gn4 I1_I562_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I72_XG_MN2 (XI1_I562_I72_XG_n1 I1_I562_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I72_XG_MN0 (I1_I562_G6_5 I1_I562_pn6 XI1_I562_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I72_XG_MN1 (XI1_I562_I72_XG_n1 I1_I562_gn5 I1_I562_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I74_XG_MN2 (XI1_I562_I74_XG_n1 I1_I562_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I74_XG_MN0 (I1_I562_G8_7 I1_I562_pn8 XI1_I562_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I74_XG_MN1 (XI1_I562_I74_XG_n1 I1_I562_gn7 I1_I562_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I75_XG_MN2 (XI1_I562_I75_XG_n1 I1_I562_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I75_XG_MN0 (I1_I562_G9_8 I1_I562_pn9 XI1_I562_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I75_XG_MN1 (XI1_I562_I75_XG_n1 I1_I562_gn8 I1_I562_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I76_XG_MN2 (XI1_I562_I76_XG_n1 I1_I562_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I76_XG_MN0 (I1_I562_G10_9 I1_I562_pn10 XI1_I562_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I76_XG_MN1 (XI1_I562_I76_XG_n1 I1_I562_gn9 I1_I562_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I137_XG_MN2 (XI1_I562_I137_XG_n1 I1_I562_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I137_XG_MN0 (I1_I562_G12_5 I1_I562_P12_9n XI1_I562_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I137_XG_MN1 (XI1_I562_I137_XG_n1 I1_I562_G8_5n I1_I562_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I141_XG_MN2 (XI1_I562_I141_XG_n1 I1_I562_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I141_XG_MN0 (I1_I562_G16_9 I1_I562_P16_13n XI1_I562_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I141_XG_MN1 (XI1_I562_I141_XG_n1 I1_I562_G12_9n I1_I562_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I139_XG_MN2 (XI1_I562_I139_XG_n1 I1_I562_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I139_XG_MN0 (I1_I562_G14_7 I1_I562_P14_11n XI1_I562_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I139_XG_MN1 (XI1_I562_I139_XG_n1 I1_I562_G10_7n I1_I562_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I143_XG_MN2 (XI1_I562_I143_XG_n1 I1_I562_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I143_XG_MN0 (I1_I562_G18_11 I1_I562_P18_15n XI1_I562_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I143_XG_MN1 (XI1_I562_I143_XG_n1 I1_I562_G14_11n I1_I562_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I145_XG_MN2 (XI1_I562_I145_XG_n1 I1_I562_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I145_XG_MN0 (I1_I562_G20_13 I1_I562_P20_17n XI1_I562_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I145_XG_MN1 (XI1_I562_I145_XG_n1 I1_I562_G16_13n I1_I562_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I149_XG_MN2 (XI1_I562_I149_XG_n1 I1_I562_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I149_XG_MN0 (I1_I562_G24_17 I1_I562_P24_21n XI1_I562_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I562_I149_XG_MN1 (XI1_I562_I149_XG_n1 I1_I562_G20_17n I1_I562_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I147_XG_MN2 (XI1_I562_I147_XG_n1 I1_I562_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
