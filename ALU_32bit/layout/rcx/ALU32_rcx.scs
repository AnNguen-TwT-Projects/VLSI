    I_MXI0_I1385_MP41 (XI0_I1385_bp1 XI0_I1385_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP42 (XI0_I1385_bcon I0_pp7_4 XI0_I1385_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP45 (XI0_I1385_bp2 I0_cm22_2 XI0_I1385_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP43 (VDD XI0_I1385_s1 XI0_I1385_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP44 (XI0_I1385_bp2 I0_pp7_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1385_MP56 (VDD XI0_I1385_bcon I0_cm24_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1385_MP46 (XI0_I1385_bp3 XI0_I1385_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP48 (VDD I0_cm22_2 XI0_I1385_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP50_1 (XI0_I1385_bp4 XI0_I1385_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1385_MP26 (VDD XI0_I1385_asn XI0_I1385_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1385_MP18 (XI0_I1385_ap3 I0_pp4_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1385_MP21 (XI0_I1385_asn XI0_I1385_acon XI0_I1385_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP24 (XI0_I1385_ap5 I0_pp6_6 XI0_I1385_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1385_MP23 (XI0_I1385_ap4 I0_pp5_8 XI0_I1385_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP22 (VDD I0_pp4_10 XI0_I1385_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP22_1 (XI0_I1385_ap4 I0_pp4_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP23_1 (XI0_I1385_ap5 I0_pp5_8 XI0_I1385_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1385_MP24_1 (XI0_I1385_asn I0_pp6_6 XI0_I1385_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1385_MP17 (XI0_I1385_acon I0_pp6_6 XI0_I1385_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1385_MP14 (XI0_I1385_ap1 I0_pp5_8 XI0_I1385_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP13 (VDD I0_pp4_10 XI0_I1385_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP15 (XI0_I1385_ap2 I0_pp4_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP16 (VDD I0_pp5_8 XI0_I1385_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1385_MP28 (I0_cm24_2 XI0_I1385_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1385_MP19 (XI0_I1385_ap3 I0_pp5_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1385_MP20 (VDD I0_pp6_6 XI0_I1385_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1582_MP50 (VDD XI0_I1582_s1 XI0_I1582_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1582_MP47 (XI0_I1582_bp3 I0_cm162_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1582_MP49 (XI0_I1582_bsn XI0_I1582_bcon XI0_I1582_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1582_MP52 (XI0_I1582_bp5 I0_cm220_2 XI0_I1582_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1582_MP51 (XI0_I1582_bp4 I0_cm162_0 XI0_I1582_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP51_1 (XI0_I1582_bp5 I0_cm162_0 XI0_I1582_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP52_1 (XI0_I1582_bsn I0_cm220_2 XI0_I1582_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1582_MP54 (VDD XI0_I1582_bsn I0_cm221_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1582_MP41 (XI0_I1582_bp1 XI0_I1582_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP42 (XI0_I1582_bcon I0_cm162_0 XI0_I1582_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP45 (XI0_I1582_bp2 I0_cm220_2 XI0_I1582_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP43 (VDD XI0_I1582_s1 XI0_I1582_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP44 (XI0_I1582_bp2 I0_cm162_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1582_MP56 (VDD XI0_I1582_bcon I0_cm221_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1582_MP46 (XI0_I1582_bp3 XI0_I1582_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP48 (VDD I0_cm220_2 XI0_I1582_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP50_1 (XI0_I1582_bp4 XI0_I1582_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1582_MP26 (VDD XI0_I1582_asn XI0_I1582_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1582_MP18 (XI0_I1582_ap3 I0_cm159_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1582_MP21 (XI0_I1582_asn XI0_I1582_acon XI0_I1582_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP24 (XI0_I1582_ap5 I0_cm161_0 XI0_I1582_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1582_MP23 (XI0_I1582_ap4 I0_fa160_1 XI0_I1582_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP22 (VDD I0_cm159_1 XI0_I1582_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP22_1 (XI0_I1582_ap4 I0_cm159_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP23_1 (XI0_I1582_ap5 I0_fa160_1 XI0_I1582_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1582_MP24_1 (XI0_I1582_asn I0_cm161_0 XI0_I1582_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1582_MP17 (XI0_I1582_acon I0_cm161_0 XI0_I1582_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1582_MP14 (XI0_I1582_ap1 I0_fa160_1 XI0_I1582_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP13 (VDD I0_cm159_1 XI0_I1582_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP15 (XI0_I1582_ap2 I0_cm159_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP16 (VDD I0_fa160_1 XI0_I1582_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1582_MP28 (I0_cm221_2 XI0_I1582_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1582_MP19 (XI0_I1582_ap3 I0_fa160_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1582_MP20 (VDD I0_cm161_0 XI0_I1582_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1513_MP50 (VDD XI0_I1513_s1 XI0_I1513_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1513_MP47 (XI0_I1513_bp3 I0_cm31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1513_MP49 (XI0_I1513_bsn XI0_I1513_bcon XI0_I1513_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1513_MP52 (XI0_I1513_bp5 I0_cm151_2 XI0_I1513_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1513_MP51 (XI0_I1513_bp4 I0_cm31_0 XI0_I1513_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP51_1 (XI0_I1513_bp5 I0_cm31_0 XI0_I1513_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP52_1 (XI0_I1513_bsn I0_cm151_2 XI0_I1513_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1513_MP54 (VDD XI0_I1513_bsn I0_cm152_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1513_MP41 (XI0_I1513_bp1 XI0_I1513_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP42 (XI0_I1513_bcon I0_cm31_0 XI0_I1513_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP45 (XI0_I1513_bp2 I0_cm151_2 XI0_I1513_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP43 (VDD XI0_I1513_s1 XI0_I1513_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP44 (XI0_I1513_bp2 I0_cm31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1513_MP56 (VDD XI0_I1513_bcon I0_cm152_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1513_MP46 (XI0_I1513_bp3 XI0_I1513_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP48 (VDD I0_cm151_2 XI0_I1513_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP50_1 (XI0_I1513_bp4 XI0_I1513_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1513_MP26 (VDD XI0_I1513_asn XI0_I1513_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1513_MP18 (XI0_I1513_ap3 I0_cm28_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1513_MP21 (XI0_I1513_asn XI0_I1513_acon XI0_I1513_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP24 (XI0_I1513_ap5 I0_fa30_1 XI0_I1513_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1513_MP23 (XI0_I1513_ap4 I0_cm29_1 XI0_I1513_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP22 (VDD I0_cm28_1 XI0_I1513_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP22_1 (XI0_I1513_ap4 I0_cm28_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP23_1 (XI0_I1513_ap5 I0_cm29_1 XI0_I1513_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1513_MP24_1 (XI0_I1513_asn I0_fa30_1 XI0_I1513_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1513_MP17 (XI0_I1513_acon I0_fa30_1 XI0_I1513_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1513_MP14 (XI0_I1513_ap1 I0_cm29_1 XI0_I1513_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP13 (VDD I0_cm28_1 XI0_I1513_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP15 (XI0_I1513_ap2 I0_cm28_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP16 (VDD I0_cm29_1 XI0_I1513_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1513_MP28 (I0_cm152_2 XI0_I1513_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1513_MP19 (XI0_I1513_ap3 I0_cm29_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1513_MP20 (VDD I0_fa30_1 XI0_I1513_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1580_MP50 (VDD XI0_I1580_s1 XI0_I1580_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1580_MP47 (XI0_I1580_bp3 I0_fa158_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1580_MP49 (XI0_I1580_bsn XI0_I1580_bcon XI0_I1580_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1580_MP52 (XI0_I1580_bp5 I0_cm218_2 XI0_I1580_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1580_MP51 (XI0_I1580_bp4 I0_fa158_0 XI0_I1580_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP51_1 (XI0_I1580_bp5 I0_fa158_0 XI0_I1580_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP52_1 (XI0_I1580_bsn I0_cm218_2 XI0_I1580_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1580_MP54 (VDD XI0_I1580_bsn I0_cm219_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1580_MP41 (XI0_I1580_bp1 XI0_I1580_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP42 (XI0_I1580_bcon I0_fa158_0 XI0_I1580_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP45 (XI0_I1580_bp2 I0_cm218_2 XI0_I1580_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP43 (VDD XI0_I1580_s1 XI0_I1580_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP44 (XI0_I1580_bp2 I0_fa158_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1580_MP56 (VDD XI0_I1580_bcon I0_cm219_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1580_MP46 (XI0_I1580_bp3 XI0_I1580_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP48 (VDD I0_cm218_2 XI0_I1580_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP50_1 (XI0_I1580_bp4 XI0_I1580_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1580_MP26 (VDD XI0_I1580_asn XI0_I1580_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1580_MP18 (XI0_I1580_ap3 I0_cm155_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1580_MP21 (XI0_I1580_asn XI0_I1580_acon XI0_I1580_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP24 (XI0_I1580_ap5 I0_cm157_0 XI0_I1580_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1580_MP23 (XI0_I1580_ap4 I0_fa156_1 XI0_I1580_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP22 (VDD I0_cm155_1 XI0_I1580_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP22_1 (XI0_I1580_ap4 I0_cm155_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP23_1 (XI0_I1580_ap5 I0_fa156_1 XI0_I1580_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1580_MP24_1 (XI0_I1580_asn I0_cm157_0 XI0_I1580_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1580_MP17 (XI0_I1580_acon I0_cm157_0 XI0_I1580_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1580_MP14 (XI0_I1580_ap1 I0_fa156_1 XI0_I1580_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP13 (VDD I0_cm155_1 XI0_I1580_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP15 (XI0_I1580_ap2 I0_cm155_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP16 (VDD I0_fa156_1 XI0_I1580_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1580_MP28 (I0_cm219_2 XI0_I1580_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1580_MP19 (XI0_I1580_ap3 I0_fa156_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1580_MP20 (VDD I0_cm157_0 XI0_I1580_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1413_MP50 (VDD XI0_I1413_s1 XI0_I1413_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1413_MP47 (XI0_I1413_bp3 I0_pp11_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1413_MP49 (XI0_I1413_bsn XI0_I1413_bcon XI0_I1413_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1413_MP52 (XI0_I1413_bp5 I0_cm48_2 XI0_I1413_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1413_MP51 (XI0_I1413_bp4 I0_pp11_5 XI0_I1413_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP51_1 (XI0_I1413_bp5 I0_pp11_5 XI0_I1413_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP52_1 (XI0_I1413_bsn I0_cm48_2 XI0_I1413_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1413_MP54 (VDD XI0_I1413_bsn I0_cm52_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1413_MP41 (XI0_I1413_bp1 XI0_I1413_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP42 (XI0_I1413_bcon I0_pp11_5 XI0_I1413_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP45 (XI0_I1413_bp2 I0_cm48_2 XI0_I1413_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP43 (VDD XI0_I1413_s1 XI0_I1413_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP44 (XI0_I1413_bp2 I0_pp11_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1413_MP56 (VDD XI0_I1413_bcon I0_cm52_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1413_MP46 (XI0_I1413_bp3 XI0_I1413_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP48 (VDD I0_cm48_2 XI0_I1413_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP50_1 (XI0_I1413_bp4 XI0_I1413_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1413_MP26 (VDD XI0_I1413_asn XI0_I1413_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1413_MP18 (XI0_I1413_ap3 I0_pp8_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1413_MP21 (XI0_I1413_asn XI0_I1413_acon XI0_I1413_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP24 (XI0_I1413_ap5 I0_pp10_7 XI0_I1413_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1413_MP23 (XI0_I1413_ap4 I0_pp9_9 XI0_I1413_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP22 (VDD I0_pp8_11 XI0_I1413_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP22_1 (XI0_I1413_ap4 I0_pp8_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP23_1 (XI0_I1413_ap5 I0_pp9_9 XI0_I1413_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1413_MP24_1 (XI0_I1413_asn I0_pp10_7 XI0_I1413_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1413_MP17 (XI0_I1413_acon I0_pp10_7 XI0_I1413_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1413_MP14 (XI0_I1413_ap1 I0_pp9_9 XI0_I1413_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP13 (VDD I0_pp8_11 XI0_I1413_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP15 (XI0_I1413_ap2 I0_pp8_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP16 (VDD I0_pp9_9 XI0_I1413_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1413_MP28 (I0_cm52_2 XI0_I1413_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1413_MP19 (XI0_I1413_ap3 I0_pp9_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1413_MP20 (VDD I0_pp10_7 XI0_I1413_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1424_MP50 (VDD XI0_I1424_s1 XI0_I1424_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1424_MP47 (XI0_I1424_bp3 I0_pp11_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1424_MP49 (XI0_I1424_bsn XI0_I1424_bcon XI0_I1424_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1424_MP52 (XI0_I1424_bp5 I0_cm59_2 XI0_I1424_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1424_MP51 (XI0_I1424_bp4 I0_pp11_8 XI0_I1424_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP51_1 (XI0_I1424_bp5 I0_pp11_8 XI0_I1424_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP52_1 (XI0_I1424_bsn I0_cm59_2 XI0_I1424_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1424_MP54 (VDD XI0_I1424_bsn I0_cm63_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1424_MP41 (XI0_I1424_bp1 XI0_I1424_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP42 (XI0_I1424_bcon I0_pp11_8 XI0_I1424_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP45 (XI0_I1424_bp2 I0_cm59_2 XI0_I1424_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP43 (VDD XI0_I1424_s1 XI0_I1424_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP44 (XI0_I1424_bp2 I0_pp11_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1424_MP56 (VDD XI0_I1424_bcon I0_cm63_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1424_MP46 (XI0_I1424_bp3 XI0_I1424_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP48 (VDD I0_cm59_2 XI0_I1424_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP50_1 (XI0_I1424_bp4 XI0_I1424_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1424_MP26 (VDD XI0_I1424_asn XI0_I1424_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1424_MP18 (XI0_I1424_ap3 I0_pp8_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1424_MP21 (XI0_I1424_asn XI0_I1424_acon XI0_I1424_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP24 (XI0_I1424_ap5 I0_pp10_10 XI0_I1424_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1424_MP23 (XI0_I1424_ap4 I0_pp9_12 XI0_I1424_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP22 (VDD I0_pp8_14 XI0_I1424_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP22_1 (XI0_I1424_ap4 I0_pp8_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP23_1 (XI0_I1424_ap5 I0_pp9_12 XI0_I1424_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1424_MP24_1 (XI0_I1424_asn I0_pp10_10 XI0_I1424_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1424_MP17 (XI0_I1424_acon I0_pp10_10 XI0_I1424_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1424_MP14 (XI0_I1424_ap1 I0_pp9_12 XI0_I1424_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP13 (VDD I0_pp8_14 XI0_I1424_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP15 (XI0_I1424_ap2 I0_pp8_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP16 (VDD I0_pp9_12 XI0_I1424_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1424_MP28 (I0_cm63_2 XI0_I1424_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1424_MP19 (XI0_I1424_ap3 I0_pp9_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1424_MP20 (VDD I0_pp10_10 XI0_I1424_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1420_MP50 (VDD XI0_I1420_s1 XI0_I1420_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1420_MP47 (XI0_I1420_bp3 I0_pp11_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1420_MP49 (XI0_I1420_bsn XI0_I1420_bcon XI0_I1420_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1420_MP52 (XI0_I1420_bp5 I0_cm55_2 XI0_I1420_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1420_MP51 (XI0_I1420_bp4 I0_pp11_7 XI0_I1420_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP51_1 (XI0_I1420_bp5 I0_pp11_7 XI0_I1420_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP52_1 (XI0_I1420_bsn I0_cm55_2 XI0_I1420_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1420_MP54 (VDD XI0_I1420_bsn I0_cm59_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1420_MP41 (XI0_I1420_bp1 XI0_I1420_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP42 (XI0_I1420_bcon I0_pp11_7 XI0_I1420_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP45 (XI0_I1420_bp2 I0_cm55_2 XI0_I1420_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP43 (VDD XI0_I1420_s1 XI0_I1420_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP44 (XI0_I1420_bp2 I0_pp11_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1420_MP56 (VDD XI0_I1420_bcon I0_cm59_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1420_MP46 (XI0_I1420_bp3 XI0_I1420_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP48 (VDD I0_cm55_2 XI0_I1420_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP50_1 (XI0_I1420_bp4 XI0_I1420_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1420_MP26 (VDD XI0_I1420_asn XI0_I1420_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1420_MP18 (XI0_I1420_ap3 I0_pp8_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1420_MP21 (XI0_I1420_asn XI0_I1420_acon XI0_I1420_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP24 (XI0_I1420_ap5 I0_pp10_9 XI0_I1420_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1420_MP23 (XI0_I1420_ap4 I0_pp9_11 XI0_I1420_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP22 (VDD I0_pp8_13 XI0_I1420_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP22_1 (XI0_I1420_ap4 I0_pp8_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP23_1 (XI0_I1420_ap5 I0_pp9_11 XI0_I1420_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1420_MP24_1 (XI0_I1420_asn I0_pp10_9 XI0_I1420_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1420_MP17 (XI0_I1420_acon I0_pp10_9 XI0_I1420_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1420_MP14 (XI0_I1420_ap1 I0_pp9_11 XI0_I1420_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP13 (VDD I0_pp8_13 XI0_I1420_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP15 (XI0_I1420_ap2 I0_pp8_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP16 (VDD I0_pp9_11 XI0_I1420_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1420_MP28 (I0_cm59_2 XI0_I1420_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1420_MP19 (XI0_I1420_ap3 I0_pp9_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1420_MP20 (VDD I0_pp10_9 XI0_I1420_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1432_MP50 (VDD XI0_I1432_s1 XI0_I1432_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1432_MP47 (XI0_I1432_bp3 I0_pp11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1432_MP49 (XI0_I1432_bsn XI0_I1432_bcon XI0_I1432_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1432_MP52 (XI0_I1432_bp5 I0_cm67_2 XI0_I1432_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1432_MP51 (XI0_I1432_bp4 I0_pp11_10 XI0_I1432_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP51_1 (XI0_I1432_bp5 I0_pp11_10 XI0_I1432_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP52_1 (XI0_I1432_bsn I0_cm67_2 XI0_I1432_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1432_MP54 (VDD XI0_I1432_bsn I0_cm71_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1432_MP41 (XI0_I1432_bp1 XI0_I1432_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP42 (XI0_I1432_bcon I0_pp11_10 XI0_I1432_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP45 (XI0_I1432_bp2 I0_cm67_2 XI0_I1432_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP43 (VDD XI0_I1432_s1 XI0_I1432_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP44 (XI0_I1432_bp2 I0_pp11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1432_MP56 (VDD XI0_I1432_bcon I0_cm71_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1432_MP46 (XI0_I1432_bp3 XI0_I1432_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP48 (VDD I0_cm67_2 XI0_I1432_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP50_1 (XI0_I1432_bp4 XI0_I1432_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1432_MP26 (VDD XI0_I1432_asn XI0_I1432_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1432_MP18 (XI0_I1432_ap3 I0_pp8_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1432_MP21 (XI0_I1432_asn XI0_I1432_acon XI0_I1432_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP24 (XI0_I1432_ap5 I0_pp10_12 XI0_I1432_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1432_MP23 (XI0_I1432_ap4 I0_pp9_14 XI0_I1432_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP22 (VDD I0_pp8_16 XI0_I1432_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP22_1 (XI0_I1432_ap4 I0_pp8_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP23_1 (XI0_I1432_ap5 I0_pp9_14 XI0_I1432_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1432_MP24_1 (XI0_I1432_asn I0_pp10_12 XI0_I1432_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1432_MP17 (XI0_I1432_acon I0_pp10_12 XI0_I1432_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1432_MP14 (XI0_I1432_ap1 I0_pp9_14 XI0_I1432_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP13 (VDD I0_pp8_16 XI0_I1432_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP15 (XI0_I1432_ap2 I0_pp8_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP16 (VDD I0_pp9_14 XI0_I1432_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1432_MP28 (I0_cm71_2 XI0_I1432_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1432_MP19 (XI0_I1432_ap3 I0_pp9_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1432_MP20 (VDD I0_pp10_12 XI0_I1432_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1440_MP50 (VDD XI0_I1440_s1 XI0_I1440_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1440_MP47 (XI0_I1440_bp3 I0_pp11_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1440_MP49 (XI0_I1440_bsn XI0_I1440_bcon XI0_I1440_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1440_MP52 (XI0_I1440_bp5 I0_cm75_2 XI0_I1440_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1440_MP51 (XI0_I1440_bp4 I0_pp11_12 XI0_I1440_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP51_1 (XI0_I1440_bp5 I0_pp11_12 XI0_I1440_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP52_1 (XI0_I1440_bsn I0_cm75_2 XI0_I1440_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1440_MP54 (VDD XI0_I1440_bsn I0_cm79_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1440_MP41 (XI0_I1440_bp1 XI0_I1440_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP42 (XI0_I1440_bcon I0_pp11_12 XI0_I1440_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP45 (XI0_I1440_bp2 I0_cm75_2 XI0_I1440_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP43 (VDD XI0_I1440_s1 XI0_I1440_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP44 (XI0_I1440_bp2 I0_pp11_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1440_MP56 (VDD XI0_I1440_bcon I0_cm79_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1440_MP46 (XI0_I1440_bp3 XI0_I1440_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP48 (VDD I0_cm75_2 XI0_I1440_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP50_1 (XI0_I1440_bp4 XI0_I1440_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1440_MP26 (VDD XI0_I1440_asn XI0_I1440_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1440_MP18 (XI0_I1440_ap3 I0_pp8_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1440_MP21 (XI0_I1440_asn XI0_I1440_acon XI0_I1440_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP24 (XI0_I1440_ap5 I0_pp10_14 XI0_I1440_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1440_MP23 (XI0_I1440_ap4 I0_pp9_16 XI0_I1440_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP22 (VDD I0_pp8_18 XI0_I1440_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP22_1 (XI0_I1440_ap4 I0_pp8_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP23_1 (XI0_I1440_ap5 I0_pp9_16 XI0_I1440_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1440_MP24_1 (XI0_I1440_asn I0_pp10_14 XI0_I1440_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1440_MP17 (XI0_I1440_acon I0_pp10_14 XI0_I1440_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1440_MP14 (XI0_I1440_ap1 I0_pp9_16 XI0_I1440_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP13 (VDD I0_pp8_18 XI0_I1440_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP15 (XI0_I1440_ap2 I0_pp8_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP16 (VDD I0_pp9_16 XI0_I1440_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1440_MP28 (I0_cm79_2 XI0_I1440_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1440_MP19 (XI0_I1440_ap3 I0_pp9_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1440_MP20 (VDD I0_pp10_14 XI0_I1440_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1444_MP50 (VDD XI0_I1444_s1 XI0_I1444_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1444_MP47 (XI0_I1444_bp3 I0_pp11_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1444_MP49 (XI0_I1444_bsn XI0_I1444_bcon XI0_I1444_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1444_MP52 (XI0_I1444_bp5 I0_cm79_2 XI0_I1444_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1444_MP51 (XI0_I1444_bp4 I0_pp11_13 XI0_I1444_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP51_1 (XI0_I1444_bp5 I0_pp11_13 XI0_I1444_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP52_1 (XI0_I1444_bsn I0_cm79_2 XI0_I1444_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1444_MP54 (VDD XI0_I1444_bsn I0_cm83_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1444_MP41 (XI0_I1444_bp1 XI0_I1444_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP42 (XI0_I1444_bcon I0_pp11_13 XI0_I1444_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP45 (XI0_I1444_bp2 I0_cm79_2 XI0_I1444_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP43 (VDD XI0_I1444_s1 XI0_I1444_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP44 (XI0_I1444_bp2 I0_pp11_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1444_MP56 (VDD XI0_I1444_bcon I0_cm83_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1444_MP46 (XI0_I1444_bp3 XI0_I1444_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP48 (VDD I0_cm79_2 XI0_I1444_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP50_1 (XI0_I1444_bp4 XI0_I1444_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1444_MP26 (VDD XI0_I1444_asn XI0_I1444_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1444_MP18 (XI0_I1444_ap3 I0_pp8_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1444_MP21 (XI0_I1444_asn XI0_I1444_acon XI0_I1444_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP24 (XI0_I1444_ap5 I0_pp10_15 XI0_I1444_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1444_MP23 (XI0_I1444_ap4 I0_pp9_17 XI0_I1444_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP22 (VDD I0_pp8_19 XI0_I1444_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP22_1 (XI0_I1444_ap4 I0_pp8_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP23_1 (XI0_I1444_ap5 I0_pp9_17 XI0_I1444_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1444_MP24_1 (XI0_I1444_asn I0_pp10_15 XI0_I1444_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1444_MP17 (XI0_I1444_acon I0_pp10_15 XI0_I1444_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1444_MP14 (XI0_I1444_ap1 I0_pp9_17 XI0_I1444_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP13 (VDD I0_pp8_19 XI0_I1444_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP15 (XI0_I1444_ap2 I0_pp8_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP16 (VDD I0_pp9_17 XI0_I1444_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1444_MP28 (I0_cm83_2 XI0_I1444_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1444_MP19 (XI0_I1444_ap3 I0_pp9_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1444_MP20 (VDD I0_pp10_15 XI0_I1444_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1543_MP50 (VDD XI0_I1543_s1 XI0_I1543_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1543_MP47 (XI0_I1543_bp3 I0_pp14_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1543_MP49 (XI0_I1543_bsn XI0_I1543_bcon XI0_I1543_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1543_MP52 (XI0_I1543_bp5 I0_cm180_2 XI0_I1543_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1543_MP51 (XI0_I1543_bp4 I0_pp14_9 XI0_I1543_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP51_1 (XI0_I1543_bp5 I0_pp14_9 XI0_I1543_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP52_1 (XI0_I1543_bsn I0_cm180_2 XI0_I1543_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1543_MP54 (VDD XI0_I1543_bsn I0_cm182_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1543_MP41 (XI0_I1543_bp1 XI0_I1543_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP42 (XI0_I1543_bcon I0_pp14_9 XI0_I1543_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP45 (XI0_I1543_bp2 I0_cm180_2 XI0_I1543_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP43 (VDD XI0_I1543_s1 XI0_I1543_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP44 (XI0_I1543_bp2 I0_pp14_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1543_MP56 (VDD XI0_I1543_bcon I0_cm182_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1543_MP46 (XI0_I1543_bp3 XI0_I1543_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP48 (VDD I0_cm180_2 XI0_I1543_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP50_1 (XI0_I1543_bp4 XI0_I1543_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1543_MP26 (VDD XI0_I1543_asn XI0_I1543_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1543_MP18 (XI0_I1543_ap3 I0_cm89_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1543_MP21 (XI0_I1543_asn XI0_I1543_acon XI0_I1543_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP24 (XI0_I1543_ap5 I0_cm91_0 XI0_I1543_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1543_MP23 (XI0_I1543_ap4 I0_cm90_0 XI0_I1543_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP22 (VDD I0_cm89_0 XI0_I1543_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP22_1 (XI0_I1543_ap4 I0_cm89_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP23_1 (XI0_I1543_ap5 I0_cm90_0 XI0_I1543_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1543_MP24_1 (XI0_I1543_asn I0_cm91_0 XI0_I1543_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1543_MP17 (XI0_I1543_acon I0_cm91_0 XI0_I1543_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1543_MP14 (XI0_I1543_ap1 I0_cm90_0 XI0_I1543_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP13 (VDD I0_cm89_0 XI0_I1543_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP15 (XI0_I1543_ap2 I0_cm89_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP16 (VDD I0_cm90_0 XI0_I1543_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1543_MP28 (I0_cm182_2 XI0_I1543_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1543_MP19 (XI0_I1543_ap3 I0_cm90_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1543_MP20 (VDD I0_cm91_0 XI0_I1543_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1546_MP50 (VDD XI0_I1546_s1 XI0_I1546_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1546_MP47 (XI0_I1546_bp3 I0_cm95_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1546_MP49 (XI0_I1546_bsn XI0_I1546_bcon XI0_I1546_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1546_MP52 (XI0_I1546_bp5 I0_cm183_2 XI0_I1546_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1546_MP51 (XI0_I1546_bp4 I0_cm95_0 XI0_I1546_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP51_1 (XI0_I1546_bp5 I0_cm95_0 XI0_I1546_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP52_1 (XI0_I1546_bsn I0_cm183_2 XI0_I1546_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1546_MP54 (VDD XI0_I1546_bsn I0_cm185_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1546_MP41 (XI0_I1546_bp1 XI0_I1546_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP42 (XI0_I1546_bcon I0_cm95_0 XI0_I1546_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP45 (XI0_I1546_bp2 I0_cm183_2 XI0_I1546_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP43 (VDD XI0_I1546_s1 XI0_I1546_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP44 (XI0_I1546_bp2 I0_cm95_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1546_MP56 (VDD XI0_I1546_bcon I0_cm185_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1546_MP46 (XI0_I1546_bp3 XI0_I1546_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP48 (VDD I0_cm183_2 XI0_I1546_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP50_1 (XI0_I1546_bp4 XI0_I1546_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1546_MP26 (VDD XI0_I1546_asn XI0_I1546_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1546_MP18 (XI0_I1546_ap3 I0_cm92_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1546_MP21 (XI0_I1546_asn XI0_I1546_acon XI0_I1546_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP24 (XI0_I1546_ap5 I0_cm94_1 XI0_I1546_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1546_MP23 (XI0_I1546_ap4 I0_cm93_1 XI0_I1546_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP22 (VDD I0_cm92_1 XI0_I1546_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP22_1 (XI0_I1546_ap4 I0_cm92_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP23_1 (XI0_I1546_ap5 I0_cm93_1 XI0_I1546_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1546_MP24_1 (XI0_I1546_asn I0_cm94_1 XI0_I1546_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1546_MP17 (XI0_I1546_acon I0_cm94_1 XI0_I1546_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1546_MP14 (XI0_I1546_ap1 I0_cm93_1 XI0_I1546_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP13 (VDD I0_cm92_1 XI0_I1546_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP15 (XI0_I1546_ap2 I0_cm92_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP16 (VDD I0_cm93_1 XI0_I1546_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1546_MP28 (I0_cm185_2 XI0_I1546_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1546_MP19 (XI0_I1546_ap3 I0_cm93_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1546_MP20 (VDD I0_cm94_1 XI0_I1546_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1377_MP50 (VDD XI0_I1377_s1 XI0_I1377_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1377_MP47 (XI0_I1377_bp3 I0_pp7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1377_MP49 (XI0_I1377_bsn XI0_I1377_bcon XI0_I1377_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1377_MP52 (XI0_I1377_bp5 I0_B_15_b3_5 XI0_I1377_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1377_MP51 (XI0_I1377_bp4 I0_pp7_0 XI0_I1377_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP51_1 (XI0_I1377_bp5 I0_pp7_0 XI0_I1377_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP52_1 (XI0_I1377_bsn I0_B_15_b3_5 XI0_I1377_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1377_MP54 (VDD XI0_I1377_bsn I0_cm16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1377_MP41 (XI0_I1377_bp1 XI0_I1377_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP42 (XI0_I1377_bcon I0_pp7_0 XI0_I1377_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP45 (XI0_I1377_bp2 I0_B_15_b3_5 XI0_I1377_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP43 (VDD XI0_I1377_s1 XI0_I1377_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP44 (XI0_I1377_bp2 I0_pp7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1377_MP56 (VDD XI0_I1377_bcon I0_cm16_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1377_MP46 (XI0_I1377_bp3 XI0_I1377_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP48 (VDD I0_B_15_b3_5 XI0_I1377_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP50_1 (XI0_I1377_bp4 XI0_I1377_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1377_MP26 (VDD XI0_I1377_asn XI0_I1377_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1377_MP18 (XI0_I1377_ap3 I0_pp4_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1377_MP21 (XI0_I1377_asn XI0_I1377_acon XI0_I1377_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP24 (XI0_I1377_ap5 I0_pp6_2 XI0_I1377_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1377_MP23 (XI0_I1377_ap4 I0_pp5_4 XI0_I1377_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP22 (VDD I0_pp4_6 XI0_I1377_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP22_1 (XI0_I1377_ap4 I0_pp4_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP23_1 (XI0_I1377_ap5 I0_pp5_4 XI0_I1377_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1377_MP24_1 (XI0_I1377_asn I0_pp6_2 XI0_I1377_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1377_MP17 (XI0_I1377_acon I0_pp6_2 XI0_I1377_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1377_MP14 (XI0_I1377_ap1 I0_pp5_4 XI0_I1377_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP13 (VDD I0_pp4_6 XI0_I1377_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP15 (XI0_I1377_ap2 I0_pp4_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP16 (VDD I0_pp5_4 XI0_I1377_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1377_MP28 (I0_cm16_2 XI0_I1377_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1377_MP19 (XI0_I1377_ap3 I0_pp5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1377_MP20 (VDD I0_pp6_2 XI0_I1377_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1510_MP50 (VDD XI0_I1510_s1 XI0_I1510_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1510_MP47 (XI0_I1510_bp3 I0_cm26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1510_MP49 (XI0_I1510_bsn XI0_I1510_bcon XI0_I1510_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1510_MP52 (XI0_I1510_bp5 I0_cm148_2 XI0_I1510_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1510_MP51 (XI0_I1510_bp4 I0_cm26_0 XI0_I1510_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP51_1 (XI0_I1510_bp5 I0_cm26_0 XI0_I1510_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP52_1 (XI0_I1510_bsn I0_cm148_2 XI0_I1510_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1510_MP54 (VDD XI0_I1510_bsn I0_cm149_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1510_MP41 (XI0_I1510_bp1 XI0_I1510_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP42 (XI0_I1510_bcon I0_cm26_0 XI0_I1510_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP45 (XI0_I1510_bp2 I0_cm148_2 XI0_I1510_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP43 (VDD XI0_I1510_s1 XI0_I1510_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP44 (XI0_I1510_bp2 I0_cm26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1510_MP56 (VDD XI0_I1510_bcon I0_cm149_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1510_MP46 (XI0_I1510_bp3 XI0_I1510_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP48 (VDD I0_cm148_2 XI0_I1510_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP50_1 (XI0_I1510_bp4 XI0_I1510_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1510_MP26 (VDD XI0_I1510_asn XI0_I1510_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1510_MP18 (XI0_I1510_ap3 I0_cm23_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1510_MP21 (XI0_I1510_asn XI0_I1510_acon XI0_I1510_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP24 (XI0_I1510_ap5 I0_fa25_1 XI0_I1510_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1510_MP23 (XI0_I1510_ap4 I0_cm24_1 XI0_I1510_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP22 (VDD I0_cm23_1 XI0_I1510_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP22_1 (XI0_I1510_ap4 I0_cm23_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP23_1 (XI0_I1510_ap5 I0_cm24_1 XI0_I1510_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1510_MP24_1 (XI0_I1510_asn I0_fa25_1 XI0_I1510_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1510_MP17 (XI0_I1510_acon I0_fa25_1 XI0_I1510_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1510_MP14 (XI0_I1510_ap1 I0_cm24_1 XI0_I1510_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP13 (VDD I0_cm23_1 XI0_I1510_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP15 (XI0_I1510_ap2 I0_cm23_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP16 (VDD I0_cm24_1 XI0_I1510_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1510_MP28 (I0_cm149_2 XI0_I1510_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1510_MP19 (XI0_I1510_ap3 I0_cm24_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1510_MP20 (VDD I0_fa25_1 XI0_I1510_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1383_MP50 (VDD XI0_I1383_s1 XI0_I1383_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1383_MP47 (XI0_I1383_bp3 I0_pp7_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1383_MP49 (XI0_I1383_bsn XI0_I1383_bcon XI0_I1383_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1383_MP52 (XI0_I1383_bp5 I0_cm20_2 XI0_I1383_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1383_MP51 (XI0_I1383_bp4 I0_pp7_3 XI0_I1383_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP51_1 (XI0_I1383_bp5 I0_pp7_3 XI0_I1383_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP52_1 (XI0_I1383_bsn I0_cm20_2 XI0_I1383_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1383_MP54 (VDD XI0_I1383_bsn I0_cm22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1383_MP41 (XI0_I1383_bp1 XI0_I1383_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP42 (XI0_I1383_bcon I0_pp7_3 XI0_I1383_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP45 (XI0_I1383_bp2 I0_cm20_2 XI0_I1383_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP43 (VDD XI0_I1383_s1 XI0_I1383_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP44 (XI0_I1383_bp2 I0_pp7_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1383_MP56 (VDD XI0_I1383_bcon I0_cm22_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1383_MP46 (XI0_I1383_bp3 XI0_I1383_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP48 (VDD I0_cm20_2 XI0_I1383_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP50_1 (XI0_I1383_bp4 XI0_I1383_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1383_MP26 (VDD XI0_I1383_asn XI0_I1383_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1383_MP18 (XI0_I1383_ap3 I0_pp4_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1383_MP21 (XI0_I1383_asn XI0_I1383_acon XI0_I1383_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP24 (XI0_I1383_ap5 I0_pp6_5 XI0_I1383_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1383_MP23 (XI0_I1383_ap4 I0_pp5_7 XI0_I1383_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP22 (VDD I0_pp4_9 XI0_I1383_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP22_1 (XI0_I1383_ap4 I0_pp4_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP23_1 (XI0_I1383_ap5 I0_pp5_7 XI0_I1383_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1383_MP24_1 (XI0_I1383_asn I0_pp6_5 XI0_I1383_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1383_MP17 (XI0_I1383_acon I0_pp6_5 XI0_I1383_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1383_MP14 (XI0_I1383_ap1 I0_pp5_7 XI0_I1383_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP13 (VDD I0_pp4_9 XI0_I1383_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP15 (XI0_I1383_ap2 I0_pp4_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP16 (VDD I0_pp5_7 XI0_I1383_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1383_MP28 (I0_cm22_2 XI0_I1383_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1383_MP19 (XI0_I1383_ap3 I0_pp5_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1383_MP20 (VDD I0_pp6_5 XI0_I1383_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1509_MP50 (VDD XI0_I1509_s1 XI0_I1509_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1509_MP47 (XI0_I1509_bp3 I0_cm24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1509_MP49 (XI0_I1509_bsn XI0_I1509_bcon XI0_I1509_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1509_MP52 (XI0_I1509_bp5 I0_cm147_2 XI0_I1509_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1509_MP51 (XI0_I1509_bp4 I0_cm24_0 XI0_I1509_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP51_1 (XI0_I1509_bp5 I0_cm24_0 XI0_I1509_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP52_1 (XI0_I1509_bsn I0_cm147_2 XI0_I1509_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1509_MP54 (VDD XI0_I1509_bsn I0_cm148_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1509_MP41 (XI0_I1509_bp1 XI0_I1509_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP42 (XI0_I1509_bcon I0_cm24_0 XI0_I1509_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP45 (XI0_I1509_bp2 I0_cm147_2 XI0_I1509_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP43 (VDD XI0_I1509_s1 XI0_I1509_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP44 (XI0_I1509_bp2 I0_cm24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1509_MP56 (VDD XI0_I1509_bcon I0_cm148_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1509_MP46 (XI0_I1509_bp3 XI0_I1509_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP48 (VDD I0_cm147_2 XI0_I1509_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP50_1 (XI0_I1509_bp4 XI0_I1509_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1509_MP26 (VDD XI0_I1509_asn XI0_I1509_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1509_MP18 (XI0_I1509_ap3 I0_cm21_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1509_MP21 (XI0_I1509_asn XI0_I1509_acon XI0_I1509_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP24 (XI0_I1509_ap5 I0_cm23_0 XI0_I1509_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1509_MP23 (XI0_I1509_ap4 I0_cm22_1 XI0_I1509_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP22 (VDD I0_cm21_1 XI0_I1509_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP22_1 (XI0_I1509_ap4 I0_cm21_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP23_1 (XI0_I1509_ap5 I0_cm22_1 XI0_I1509_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1509_MP24_1 (XI0_I1509_asn I0_cm23_0 XI0_I1509_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1509_MP17 (XI0_I1509_acon I0_cm23_0 XI0_I1509_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1509_MP14 (XI0_I1509_ap1 I0_cm22_1 XI0_I1509_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP13 (VDD I0_cm21_1 XI0_I1509_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP15 (XI0_I1509_ap2 I0_cm21_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP16 (VDD I0_cm22_1 XI0_I1509_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1509_MP28 (I0_cm148_2 XI0_I1509_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1509_MP19 (XI0_I1509_ap3 I0_cm22_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1509_MP20 (VDD I0_cm23_0 XI0_I1509_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1578_MP50 (VDD XI0_I1578_s1 XI0_I1578_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1578_MP47 (XI0_I1578_bp3 I0_cm39_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1578_MP49 (XI0_I1578_bsn XI0_I1578_bcon XI0_I1578_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1578_MP52 (XI0_I1578_bp5 I0_cm216_2 XI0_I1578_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1578_MP51 (XI0_I1578_bp4 I0_cm39_0 XI0_I1578_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP51_1 (XI0_I1578_bp5 I0_cm39_0 XI0_I1578_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP52_1 (XI0_I1578_bsn I0_cm216_2 XI0_I1578_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1578_MP54 (VDD XI0_I1578_bsn I0_cm217_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1578_MP41 (XI0_I1578_bp1 XI0_I1578_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP42 (XI0_I1578_bcon I0_cm39_0 XI0_I1578_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP45 (XI0_I1578_bp2 I0_cm216_2 XI0_I1578_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP43 (VDD XI0_I1578_s1 XI0_I1578_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP44 (XI0_I1578_bp2 I0_cm39_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1578_MP56 (VDD XI0_I1578_bcon I0_cm217_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1578_MP46 (XI0_I1578_bp3 XI0_I1578_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP48 (VDD I0_cm216_2 XI0_I1578_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP50_1 (XI0_I1578_bp4 XI0_I1578_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1578_MP26 (VDD XI0_I1578_asn XI0_I1578_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1578_MP18 (XI0_I1578_ap3 I0_cm153_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1578_MP21 (XI0_I1578_asn XI0_I1578_acon XI0_I1578_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP24 (XI0_I1578_ap5 I0_cm38_0 XI0_I1578_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1578_MP23 (XI0_I1578_ap4 I0_cm154_0 XI0_I1578_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP22 (VDD I0_cm153_1 XI0_I1578_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP22_1 (XI0_I1578_ap4 I0_cm153_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP23_1 (XI0_I1578_ap5 I0_cm154_0 XI0_I1578_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1578_MP24_1 (XI0_I1578_asn I0_cm38_0 XI0_I1578_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1578_MP17 (XI0_I1578_acon I0_cm38_0 XI0_I1578_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1578_MP14 (XI0_I1578_ap1 I0_cm154_0 XI0_I1578_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP13 (VDD I0_cm153_1 XI0_I1578_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP15 (XI0_I1578_ap2 I0_cm153_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP16 (VDD I0_cm154_0 XI0_I1578_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1578_MP28 (I0_cm217_2 XI0_I1578_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1578_MP19 (XI0_I1578_ap3 I0_cm154_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1578_MP20 (VDD I0_cm38_0 XI0_I1578_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1406_MP50 (VDD XI0_I1406_s1 XI0_I1406_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1406_MP47 (XI0_I1406_bp3 I0_pp11_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1406_MP49 (XI0_I1406_bsn XI0_I1406_bcon XI0_I1406_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1406_MP52 (XI0_I1406_bp5 I0_cm42_2 XI0_I1406_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1406_MP51 (XI0_I1406_bp4 I0_pp11_3 XI0_I1406_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP51_1 (XI0_I1406_bp5 I0_pp11_3 XI0_I1406_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP52_1 (XI0_I1406_bsn I0_cm42_2 XI0_I1406_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1406_MP54 (VDD XI0_I1406_bsn I0_cm45_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1406_MP41 (XI0_I1406_bp1 XI0_I1406_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP42 (XI0_I1406_bcon I0_pp11_3 XI0_I1406_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP45 (XI0_I1406_bp2 I0_cm42_2 XI0_I1406_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP43 (VDD XI0_I1406_s1 XI0_I1406_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP44 (XI0_I1406_bp2 I0_pp11_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1406_MP56 (VDD XI0_I1406_bcon I0_cm45_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1406_MP46 (XI0_I1406_bp3 XI0_I1406_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP48 (VDD I0_cm42_2 XI0_I1406_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP50_1 (XI0_I1406_bp4 XI0_I1406_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1406_MP26 (VDD XI0_I1406_asn XI0_I1406_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1406_MP18 (XI0_I1406_ap3 I0_pp8_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1406_MP21 (XI0_I1406_asn XI0_I1406_acon XI0_I1406_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP24 (XI0_I1406_ap5 I0_pp10_5 XI0_I1406_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1406_MP23 (XI0_I1406_ap4 I0_pp9_7 XI0_I1406_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP22 (VDD I0_pp8_9 XI0_I1406_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP22_1 (XI0_I1406_ap4 I0_pp8_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP23_1 (XI0_I1406_ap5 I0_pp9_7 XI0_I1406_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1406_MP24_1 (XI0_I1406_asn I0_pp10_5 XI0_I1406_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1406_MP17 (XI0_I1406_acon I0_pp10_5 XI0_I1406_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1406_MP14 (XI0_I1406_ap1 I0_pp9_7 XI0_I1406_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP13 (VDD I0_pp8_9 XI0_I1406_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP15 (XI0_I1406_ap2 I0_pp8_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP16 (VDD I0_pp9_7 XI0_I1406_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1406_MP28 (I0_cm45_2 XI0_I1406_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1406_MP19 (XI0_I1406_ap3 I0_pp9_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1406_MP20 (VDD I0_pp10_5 XI0_I1406_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1409_MP50 (VDD XI0_I1409_s1 XI0_I1409_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1409_MP47 (XI0_I1409_bp3 I0_pp11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1409_MP49 (XI0_I1409_bsn XI0_I1409_bcon XI0_I1409_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1409_MP52 (XI0_I1409_bp5 I0_cm45_2 XI0_I1409_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1409_MP51 (XI0_I1409_bp4 I0_pp11_4 XI0_I1409_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP51_1 (XI0_I1409_bp5 I0_pp11_4 XI0_I1409_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP52_1 (XI0_I1409_bsn I0_cm45_2 XI0_I1409_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1409_MP54 (VDD XI0_I1409_bsn I0_cm48_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1409_MP41 (XI0_I1409_bp1 XI0_I1409_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP42 (XI0_I1409_bcon I0_pp11_4 XI0_I1409_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP45 (XI0_I1409_bp2 I0_cm45_2 XI0_I1409_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP43 (VDD XI0_I1409_s1 XI0_I1409_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP44 (XI0_I1409_bp2 I0_pp11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1409_MP56 (VDD XI0_I1409_bcon I0_cm48_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1409_MP46 (XI0_I1409_bp3 XI0_I1409_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP48 (VDD I0_cm45_2 XI0_I1409_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP50_1 (XI0_I1409_bp4 XI0_I1409_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1409_MP26 (VDD XI0_I1409_asn XI0_I1409_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1409_MP18 (XI0_I1409_ap3 I0_pp8_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1409_MP21 (XI0_I1409_asn XI0_I1409_acon XI0_I1409_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP24 (XI0_I1409_ap5 I0_pp10_6 XI0_I1409_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1409_MP23 (XI0_I1409_ap4 I0_pp9_8 XI0_I1409_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP22 (VDD I0_pp8_10 XI0_I1409_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP22_1 (XI0_I1409_ap4 I0_pp8_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP23_1 (XI0_I1409_ap5 I0_pp9_8 XI0_I1409_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1409_MP24_1 (XI0_I1409_asn I0_pp10_6 XI0_I1409_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1409_MP17 (XI0_I1409_acon I0_pp10_6 XI0_I1409_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1409_MP14 (XI0_I1409_ap1 I0_pp9_8 XI0_I1409_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP13 (VDD I0_pp8_10 XI0_I1409_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP15 (XI0_I1409_ap2 I0_pp8_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP16 (VDD I0_pp9_8 XI0_I1409_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1409_MP28 (I0_cm48_2 XI0_I1409_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1409_MP19 (XI0_I1409_ap3 I0_pp9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1409_MP20 (VDD I0_pp10_6 XI0_I1409_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1448_MP50 (VDD XI0_I1448_s1 XI0_I1448_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1448_MP47 (XI0_I1448_bp3 I0_pp12_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1448_MP49 (XI0_I1448_bsn XI0_I1448_bcon XI0_I1448_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1448_MP52 (XI0_I1448_bp5 I0_cm83_2 XI0_I1448_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1448_MP51 (XI0_I1448_bp4 I0_pp12_12 XI0_I1448_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP51_1 (XI0_I1448_bp5 I0_pp12_12 XI0_I1448_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP52_1 (XI0_I1448_bsn I0_cm83_2 XI0_I1448_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1448_MP54 (VDD XI0_I1448_bsn I0_cm87_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1448_MP41 (XI0_I1448_bp1 XI0_I1448_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP42 (XI0_I1448_bcon I0_pp12_12 XI0_I1448_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP45 (XI0_I1448_bp2 I0_cm83_2 XI0_I1448_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP43 (VDD XI0_I1448_s1 XI0_I1448_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP44 (XI0_I1448_bp2 I0_pp12_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1448_MP56 (VDD XI0_I1448_bcon I0_cm87_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1448_MP46 (XI0_I1448_bp3 XI0_I1448_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP48 (VDD I0_cm83_2 XI0_I1448_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP50_1 (XI0_I1448_bp4 XI0_I1448_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1448_MP26 (VDD XI0_I1448_asn XI0_I1448_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1448_MP18 (XI0_I1448_ap3 I0_pp9_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1448_MP21 (XI0_I1448_asn XI0_I1448_acon XI0_I1448_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP24 (XI0_I1448_ap5 I0_pp11_14 XI0_I1448_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1448_MP23 (XI0_I1448_ap4 I0_pp10_16 XI0_I1448_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP22 (VDD I0_pp9_18 XI0_I1448_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP22_1 (XI0_I1448_ap4 I0_pp9_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP23_1 (XI0_I1448_ap5 I0_pp10_16 XI0_I1448_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1448_MP24_1 (XI0_I1448_asn I0_pp11_14 XI0_I1448_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1448_MP17 (XI0_I1448_acon I0_pp11_14 XI0_I1448_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1448_MP14 (XI0_I1448_ap1 I0_pp10_16 XI0_I1448_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP13 (VDD I0_pp9_18 XI0_I1448_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP15 (XI0_I1448_ap2 I0_pp9_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP16 (VDD I0_pp10_16 XI0_I1448_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1448_MP28 (I0_cm87_2 XI0_I1448_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1448_MP19 (XI0_I1448_ap3 I0_pp10_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1448_MP20 (VDD I0_pp11_14 XI0_I1448_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1593_MP50 (VDD XI0_I1593_s1 XI0_I1593_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1593_MP47 (XI0_I1593_bp3 I0_cm184_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1593_MP49 (XI0_I1593_bsn XI0_I1593_bcon XI0_I1593_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1593_MP52 (XI0_I1593_bp5 I0_cm231_2 XI0_I1593_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1593_MP51 (XI0_I1593_bp4 I0_cm184_0 XI0_I1593_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP51_1 (XI0_I1593_bp5 I0_cm184_0 XI0_I1593_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP52_1 (XI0_I1593_bsn I0_cm231_2 XI0_I1593_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1593_MP54 (VDD XI0_I1593_bsn I0_cm232_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1593_MP41 (XI0_I1593_bp1 XI0_I1593_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP42 (XI0_I1593_bcon I0_cm184_0 XI0_I1593_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP45 (XI0_I1593_bp2 I0_cm231_2 XI0_I1593_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP43 (VDD XI0_I1593_s1 XI0_I1593_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP44 (XI0_I1593_bp2 I0_cm184_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1593_MP56 (VDD XI0_I1593_bcon I0_cm232_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1593_MP46 (XI0_I1593_bp3 XI0_I1593_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP48 (VDD I0_cm231_2 XI0_I1593_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP50_1 (XI0_I1593_bp4 XI0_I1593_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1593_MP26 (VDD XI0_I1593_asn XI0_I1593_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1593_MP18 (XI0_I1593_ap3 I0_cm181_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1593_MP21 (XI0_I1593_asn XI0_I1593_acon XI0_I1593_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP24 (XI0_I1593_ap5 I0_cm183_0 XI0_I1593_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1593_MP23 (XI0_I1593_ap4 I0_cm182_1 XI0_I1593_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP22 (VDD I0_cm181_1 XI0_I1593_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP22_1 (XI0_I1593_ap4 I0_cm181_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP23_1 (XI0_I1593_ap5 I0_cm182_1 XI0_I1593_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1593_MP24_1 (XI0_I1593_asn I0_cm183_0 XI0_I1593_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1593_MP17 (XI0_I1593_acon I0_cm183_0 XI0_I1593_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1593_MP14 (XI0_I1593_ap1 I0_cm182_1 XI0_I1593_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP13 (VDD I0_cm181_1 XI0_I1593_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP15 (XI0_I1593_ap2 I0_cm181_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP16 (VDD I0_cm182_1 XI0_I1593_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1593_MP28 (I0_cm232_2 XI0_I1593_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1593_MP19 (XI0_I1593_ap3 I0_cm182_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1593_MP20 (VDD I0_cm183_0 XI0_I1593_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1502_MP50 (VDD XI0_I1502_s1 XI0_I1502_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1502_MP47 (XI0_I1502_bp3 I0_pp4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1502_MP49 (XI0_I1502_bsn XI0_I1502_bcon XI0_I1502_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1502_MP52 (XI0_I1502_bp5 I0_pp5_1 XI0_I1502_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1502_MP51 (XI0_I1502_bp4 I0_pp4_3 XI0_I1502_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP51_1 (XI0_I1502_bp5 I0_pp4_3 XI0_I1502_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP52_1 (XI0_I1502_bsn I0_pp5_1 XI0_I1502_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1502_MP54 (VDD XI0_I1502_bsn I0_cm141_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1502_MP41 (XI0_I1502_bp1 XI0_I1502_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP42 (XI0_I1502_bcon I0_pp4_3 XI0_I1502_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP45 (XI0_I1502_bp2 I0_pp5_1 XI0_I1502_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP43 (VDD XI0_I1502_s1 XI0_I1502_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP44 (XI0_I1502_bp2 I0_pp4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1502_MP56 (VDD XI0_I1502_bcon I0_cm141_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1502_MP46 (XI0_I1502_bp3 XI0_I1502_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP48 (VDD I0_pp5_1 XI0_I1502_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP50_1 (XI0_I1502_bp4 XI0_I1502_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1502_MP26 (VDD XI0_I1502_asn XI0_I1502_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1502_MP18 (XI0_I1502_ap3 I0_cm8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1502_MP21 (XI0_I1502_asn XI0_I1502_acon XI0_I1502_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP24 (XI0_I1502_ap5 I0_cm10_0 XI0_I1502_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1502_MP23 (XI0_I1502_ap4 I0_fa9_1 XI0_I1502_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP22 (VDD I0_cm8_1 XI0_I1502_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP22_1 (XI0_I1502_ap4 I0_cm8_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP23_1 (XI0_I1502_ap5 I0_fa9_1 XI0_I1502_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1502_MP24_1 (XI0_I1502_asn I0_cm10_0 XI0_I1502_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1502_MP17 (XI0_I1502_acon I0_cm10_0 XI0_I1502_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1502_MP14 (XI0_I1502_ap1 I0_fa9_1 XI0_I1502_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP13 (VDD I0_cm8_1 XI0_I1502_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP15 (XI0_I1502_ap2 I0_cm8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP16 (VDD I0_fa9_1 XI0_I1502_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1502_MP28 (I0_cm141_2 XI0_I1502_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1502_MP19 (XI0_I1502_ap3 I0_fa9_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1502_MP20 (VDD I0_cm10_0 XI0_I1502_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1503_MP50 (VDD XI0_I1503_s1 XI0_I1503_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1503_MP47 (XI0_I1503_bp3 I0_B_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1503_MP49 (XI0_I1503_bsn XI0_I1503_bcon XI0_I1503_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1503_MP52 (XI0_I1503_bp5 I0_cm141_2 XI0_I1503_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1503_MP51 (XI0_I1503_bp4 I0_B_13_b3_5 XI0_I1503_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP51_1 (XI0_I1503_bp5 I0_B_13_b3_5 XI0_I1503_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP52_1 (XI0_I1503_bsn I0_cm141_2 XI0_I1503_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1503_MP54 (VDD XI0_I1503_bsn I0_cm142_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1503_MP41 (XI0_I1503_bp1 XI0_I1503_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP42 (XI0_I1503_bcon I0_B_13_b3_5 XI0_I1503_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP45 (XI0_I1503_bp2 I0_cm141_2 XI0_I1503_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP43 (VDD XI0_I1503_s1 XI0_I1503_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP44 (XI0_I1503_bp2 I0_B_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1503_MP56 (VDD XI0_I1503_bcon I0_cm142_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1503_MP46 (XI0_I1503_bp3 XI0_I1503_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP48 (VDD I0_cm141_2 XI0_I1503_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP50_1 (XI0_I1503_bp4 XI0_I1503_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1503_MP26 (VDD XI0_I1503_asn XI0_I1503_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1503_MP18 (XI0_I1503_ap3 I0_cm10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1503_MP21 (XI0_I1503_asn XI0_I1503_acon XI0_I1503_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP24 (XI0_I1503_ap5 I0_fa12_0 XI0_I1503_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1503_MP23 (XI0_I1503_ap4 I0_cm11_0 XI0_I1503_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP22 (VDD I0_cm10_1 XI0_I1503_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP22_1 (XI0_I1503_ap4 I0_cm10_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP23_1 (XI0_I1503_ap5 I0_cm11_0 XI0_I1503_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1503_MP24_1 (XI0_I1503_asn I0_fa12_0 XI0_I1503_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1503_MP17 (XI0_I1503_acon I0_fa12_0 XI0_I1503_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1503_MP14 (XI0_I1503_ap1 I0_cm11_0 XI0_I1503_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP13 (VDD I0_cm10_1 XI0_I1503_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP15 (XI0_I1503_ap2 I0_cm10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP16 (VDD I0_cm11_0 XI0_I1503_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1503_MP28 (I0_cm142_2 XI0_I1503_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1503_MP19 (XI0_I1503_ap3 I0_cm11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1503_MP20 (VDD I0_fa12_0 XI0_I1503_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1381_MP50 (VDD XI0_I1381_s1 XI0_I1381_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1381_MP47 (XI0_I1381_bp3 I0_pp7_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1381_MP49 (XI0_I1381_bsn XI0_I1381_bcon XI0_I1381_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1381_MP52 (XI0_I1381_bp5 I0_cm18_2 XI0_I1381_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1381_MP51 (XI0_I1381_bp4 I0_pp7_2 XI0_I1381_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP51_1 (XI0_I1381_bp5 I0_pp7_2 XI0_I1381_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP52_1 (XI0_I1381_bsn I0_cm18_2 XI0_I1381_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1381_MP54 (VDD XI0_I1381_bsn I0_cm20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1381_MP41 (XI0_I1381_bp1 XI0_I1381_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP42 (XI0_I1381_bcon I0_pp7_2 XI0_I1381_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP45 (XI0_I1381_bp2 I0_cm18_2 XI0_I1381_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP43 (VDD XI0_I1381_s1 XI0_I1381_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP44 (XI0_I1381_bp2 I0_pp7_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1381_MP56 (VDD XI0_I1381_bcon I0_cm20_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1381_MP46 (XI0_I1381_bp3 XI0_I1381_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP48 (VDD I0_cm18_2 XI0_I1381_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP50_1 (XI0_I1381_bp4 XI0_I1381_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1381_MP26 (VDD XI0_I1381_asn XI0_I1381_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1381_MP18 (XI0_I1381_ap3 I0_pp4_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1381_MP21 (XI0_I1381_asn XI0_I1381_acon XI0_I1381_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP24 (XI0_I1381_ap5 I0_pp6_4 XI0_I1381_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1381_MP23 (XI0_I1381_ap4 I0_pp5_6 XI0_I1381_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP22 (VDD I0_pp4_8 XI0_I1381_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP22_1 (XI0_I1381_ap4 I0_pp4_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP23_1 (XI0_I1381_ap5 I0_pp5_6 XI0_I1381_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1381_MP24_1 (XI0_I1381_asn I0_pp6_4 XI0_I1381_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1381_MP17 (XI0_I1381_acon I0_pp6_4 XI0_I1381_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1381_MP14 (XI0_I1381_ap1 I0_pp5_6 XI0_I1381_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP13 (VDD I0_pp4_8 XI0_I1381_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP15 (XI0_I1381_ap2 I0_pp4_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP16 (VDD I0_pp5_6 XI0_I1381_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1381_MP28 (I0_cm20_2 XI0_I1381_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1381_MP19 (XI0_I1381_ap3 I0_pp5_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1381_MP20 (VDD I0_pp6_4 XI0_I1381_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1379_MP50 (VDD XI0_I1379_s1 XI0_I1379_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1379_MP47 (XI0_I1379_bp3 I0_pp7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1379_MP49 (XI0_I1379_bsn XI0_I1379_bcon XI0_I1379_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1379_MP52 (XI0_I1379_bp5 I0_cm16_2 XI0_I1379_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1379_MP51 (XI0_I1379_bp4 I0_pp7_1 XI0_I1379_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP51_1 (XI0_I1379_bp5 I0_pp7_1 XI0_I1379_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP52_1 (XI0_I1379_bsn I0_cm16_2 XI0_I1379_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1379_MP54 (VDD XI0_I1379_bsn I0_cm18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1379_MP41 (XI0_I1379_bp1 XI0_I1379_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP42 (XI0_I1379_bcon I0_pp7_1 XI0_I1379_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP45 (XI0_I1379_bp2 I0_cm16_2 XI0_I1379_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP43 (VDD XI0_I1379_s1 XI0_I1379_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP44 (XI0_I1379_bp2 I0_pp7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1379_MP56 (VDD XI0_I1379_bcon I0_cm18_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1379_MP46 (XI0_I1379_bp3 XI0_I1379_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP48 (VDD I0_cm16_2 XI0_I1379_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP50_1 (XI0_I1379_bp4 XI0_I1379_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1379_MP26 (VDD XI0_I1379_asn XI0_I1379_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1379_MP18 (XI0_I1379_ap3 I0_pp4_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1379_MP21 (XI0_I1379_asn XI0_I1379_acon XI0_I1379_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP24 (XI0_I1379_ap5 I0_pp6_3 XI0_I1379_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1379_MP23 (XI0_I1379_ap4 I0_pp5_5 XI0_I1379_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP22 (VDD I0_pp4_7 XI0_I1379_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP22_1 (XI0_I1379_ap4 I0_pp4_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP23_1 (XI0_I1379_ap5 I0_pp5_5 XI0_I1379_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1379_MP24_1 (XI0_I1379_asn I0_pp6_3 XI0_I1379_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1379_MP17 (XI0_I1379_acon I0_pp6_3 XI0_I1379_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1379_MP14 (XI0_I1379_ap1 I0_pp5_5 XI0_I1379_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP13 (VDD I0_pp4_7 XI0_I1379_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP15 (XI0_I1379_ap2 I0_pp4_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP16 (VDD I0_pp5_5 XI0_I1379_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1379_MP28 (I0_cm18_2 XI0_I1379_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1379_MP19 (XI0_I1379_ap3 I0_pp5_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1379_MP20 (VDD I0_pp6_3 XI0_I1379_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1577_MP50 (VDD XI0_I1577_s1 XI0_I1577_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1577_MP47 (XI0_I1577_bp3 I0_cm36_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1577_MP49 (XI0_I1577_bsn XI0_I1577_bcon XI0_I1577_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1577_MP52 (XI0_I1577_bp5 I0_cm215_2 XI0_I1577_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1577_MP51 (XI0_I1577_bp4 I0_cm36_0 XI0_I1577_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP51_1 (XI0_I1577_bp5 I0_cm36_0 XI0_I1577_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP52_1 (XI0_I1577_bsn I0_cm215_2 XI0_I1577_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1577_MP54 (VDD XI0_I1577_bsn I0_cm216_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1577_MP41 (XI0_I1577_bp1 XI0_I1577_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP42 (XI0_I1577_bcon I0_cm36_0 XI0_I1577_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP45 (XI0_I1577_bp2 I0_cm215_2 XI0_I1577_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP43 (VDD XI0_I1577_s1 XI0_I1577_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP44 (XI0_I1577_bp2 I0_cm36_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1577_MP56 (VDD XI0_I1577_bcon I0_cm216_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1577_MP46 (XI0_I1577_bp3 XI0_I1577_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP48 (VDD I0_cm215_2 XI0_I1577_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP50_1 (XI0_I1577_bp4 XI0_I1577_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1577_MP26 (VDD XI0_I1577_asn XI0_I1577_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1577_MP18 (XI0_I1577_ap3 I0_cm152_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1577_MP21 (XI0_I1577_asn XI0_I1577_acon XI0_I1577_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP24 (XI0_I1577_ap5 I0_cm35_0 XI0_I1577_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1577_MP23 (XI0_I1577_ap4 I0_cm153_0 XI0_I1577_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP22 (VDD I0_cm152_1 XI0_I1577_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP22_1 (XI0_I1577_ap4 I0_cm152_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP23_1 (XI0_I1577_ap5 I0_cm153_0 XI0_I1577_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1577_MP24_1 (XI0_I1577_asn I0_cm35_0 XI0_I1577_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1577_MP17 (XI0_I1577_acon I0_cm35_0 XI0_I1577_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1577_MP14 (XI0_I1577_ap1 I0_cm153_0 XI0_I1577_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP13 (VDD I0_cm152_1 XI0_I1577_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP15 (XI0_I1577_ap2 I0_cm152_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP16 (VDD I0_cm153_0 XI0_I1577_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1577_MP28 (I0_cm216_2 XI0_I1577_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1577_MP19 (XI0_I1577_ap3 I0_cm153_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1577_MP20 (VDD I0_cm35_0 XI0_I1577_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1576_MP50 (VDD XI0_I1576_s1 XI0_I1576_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1576_MP47 (XI0_I1576_bp3 I0_fa33_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1576_MP49 (XI0_I1576_bsn XI0_I1576_bcon XI0_I1576_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1576_MP52 (XI0_I1576_bp5 I0_cm214_2 XI0_I1576_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1576_MP51 (XI0_I1576_bp4 I0_fa33_0 XI0_I1576_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP51_1 (XI0_I1576_bp5 I0_fa33_0 XI0_I1576_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP52_1 (XI0_I1576_bsn I0_cm214_2 XI0_I1576_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1576_MP54 (VDD XI0_I1576_bsn I0_cm215_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1576_MP41 (XI0_I1576_bp1 XI0_I1576_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP42 (XI0_I1576_bcon I0_fa33_0 XI0_I1576_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP45 (XI0_I1576_bp2 I0_cm214_2 XI0_I1576_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP43 (VDD XI0_I1576_s1 XI0_I1576_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP44 (XI0_I1576_bp2 I0_fa33_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1576_MP56 (VDD XI0_I1576_bcon I0_cm215_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1576_MP46 (XI0_I1576_bp3 XI0_I1576_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP48 (VDD I0_cm214_2 XI0_I1576_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP50_1 (XI0_I1576_bp4 XI0_I1576_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1576_MP26 (VDD XI0_I1576_asn XI0_I1576_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1576_MP18 (XI0_I1576_ap3 I0_cm151_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1576_MP21 (XI0_I1576_asn XI0_I1576_acon XI0_I1576_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP24 (XI0_I1576_ap5 I0_cm32_0 XI0_I1576_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1576_MP23 (XI0_I1576_ap4 I0_cm152_0 XI0_I1576_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP22 (VDD I0_cm151_1 XI0_I1576_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP22_1 (XI0_I1576_ap4 I0_cm151_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP23_1 (XI0_I1576_ap5 I0_cm152_0 XI0_I1576_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1576_MP24_1 (XI0_I1576_asn I0_cm32_0 XI0_I1576_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1576_MP17 (XI0_I1576_acon I0_cm32_0 XI0_I1576_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1576_MP14 (XI0_I1576_ap1 I0_cm152_0 XI0_I1576_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP13 (VDD I0_cm151_1 XI0_I1576_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP15 (XI0_I1576_ap2 I0_cm151_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP16 (VDD I0_cm152_0 XI0_I1576_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1576_MP28 (I0_cm215_2 XI0_I1576_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1576_MP19 (XI0_I1576_ap3 I0_cm152_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1576_MP20 (VDD I0_cm32_0 XI0_I1576_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1579_MP50 (VDD XI0_I1579_s1 XI0_I1579_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1579_MP47 (XI0_I1579_bp3 I0_B_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1579_MP49 (XI0_I1579_bsn XI0_I1579_bcon XI0_I1579_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1579_MP52 (XI0_I1579_bp5 I0_cm217_2 XI0_I1579_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1579_MP51 (XI0_I1579_bp4 I0_B_25_b3_5 XI0_I1579_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP51_1 (XI0_I1579_bp5 I0_B_25_b3_5 XI0_I1579_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP52_1 (XI0_I1579_bsn I0_cm217_2 XI0_I1579_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1579_MP54 (VDD XI0_I1579_bsn I0_cm218_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1579_MP41 (XI0_I1579_bp1 XI0_I1579_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP42 (XI0_I1579_bcon I0_B_25_b3_5 XI0_I1579_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP45 (XI0_I1579_bp2 I0_cm217_2 XI0_I1579_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP43 (VDD XI0_I1579_s1 XI0_I1579_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP44 (XI0_I1579_bp2 I0_B_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1579_MP56 (VDD XI0_I1579_bcon I0_cm218_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1579_MP46 (XI0_I1579_bp3 XI0_I1579_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP48 (VDD I0_cm217_2 XI0_I1579_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP50_1 (XI0_I1579_bp4 XI0_I1579_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1579_MP26 (VDD XI0_I1579_asn XI0_I1579_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1579_MP18 (XI0_I1579_ap3 I0_cm154_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1579_MP21 (XI0_I1579_asn XI0_I1579_acon XI0_I1579_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP24 (XI0_I1579_ap5 I0_fa156_0 XI0_I1579_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1579_MP23 (XI0_I1579_ap4 I0_cm155_0 XI0_I1579_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP22 (VDD I0_cm154_1 XI0_I1579_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP22_1 (XI0_I1579_ap4 I0_cm154_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP23_1 (XI0_I1579_ap5 I0_cm155_0 XI0_I1579_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1579_MP24_1 (XI0_I1579_asn I0_fa156_0 XI0_I1579_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1579_MP17 (XI0_I1579_acon I0_fa156_0 XI0_I1579_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1579_MP14 (XI0_I1579_ap1 I0_cm155_0 XI0_I1579_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP13 (VDD I0_cm154_1 XI0_I1579_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP15 (XI0_I1579_ap2 I0_cm154_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP16 (VDD I0_cm155_0 XI0_I1579_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1579_MP28 (I0_cm218_2 XI0_I1579_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1579_MP19 (XI0_I1579_ap3 I0_cm155_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1579_MP20 (VDD I0_fa156_0 XI0_I1579_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1445_MP50 (VDD XI0_I1445_s1 XI0_I1445_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1445_MP47 (XI0_I1445_bp3 I0_pp15_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1445_MP49 (XI0_I1445_bsn XI0_I1445_bcon XI0_I1445_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1445_MP52 (XI0_I1445_bp5 I0_cm80_2 XI0_I1445_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1445_MP51 (XI0_I1445_bp4 I0_pp15_5 XI0_I1445_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP51_1 (XI0_I1445_bp5 I0_pp15_5 XI0_I1445_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP52_1 (XI0_I1445_bsn I0_cm80_2 XI0_I1445_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1445_MP54 (VDD XI0_I1445_bsn I0_cm84_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1445_MP41 (XI0_I1445_bp1 XI0_I1445_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP42 (XI0_I1445_bcon I0_pp15_5 XI0_I1445_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP45 (XI0_I1445_bp2 I0_cm80_2 XI0_I1445_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP43 (VDD XI0_I1445_s1 XI0_I1445_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP44 (XI0_I1445_bp2 I0_pp15_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1445_MP56 (VDD XI0_I1445_bcon I0_cm84_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1445_MP46 (XI0_I1445_bp3 XI0_I1445_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP48 (VDD I0_cm80_2 XI0_I1445_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP50_1 (XI0_I1445_bp4 XI0_I1445_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1445_MP26 (VDD XI0_I1445_asn XI0_I1445_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1445_MP18 (XI0_I1445_ap3 I0_pp12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1445_MP21 (XI0_I1445_asn XI0_I1445_acon XI0_I1445_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP24 (XI0_I1445_ap5 I0_pp14_7 XI0_I1445_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1445_MP23 (XI0_I1445_ap4 I0_pp13_9 XI0_I1445_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP22 (VDD I0_pp12_11 XI0_I1445_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP22_1 (XI0_I1445_ap4 I0_pp12_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP23_1 (XI0_I1445_ap5 I0_pp13_9 XI0_I1445_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1445_MP24_1 (XI0_I1445_asn I0_pp14_7 XI0_I1445_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1445_MP17 (XI0_I1445_acon I0_pp14_7 XI0_I1445_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1445_MP14 (XI0_I1445_ap1 I0_pp13_9 XI0_I1445_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP13 (VDD I0_pp12_11 XI0_I1445_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP15 (XI0_I1445_ap2 I0_pp12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP16 (VDD I0_pp13_9 XI0_I1445_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1445_MP28 (I0_cm84_2 XI0_I1445_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1445_MP19 (XI0_I1445_ap3 I0_pp13_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1445_MP20 (VDD I0_pp14_7 XI0_I1445_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1545_MP50 (VDD XI0_I1545_s1 XI0_I1545_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1545_MP47 (XI0_I1545_bp3 I0_pp15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1545_MP49 (XI0_I1545_bsn XI0_I1545_bcon XI0_I1545_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1545_MP52 (XI0_I1545_bp5 I0_cm182_2 XI0_I1545_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1545_MP51 (XI0_I1545_bp4 I0_pp15_8 XI0_I1545_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP51_1 (XI0_I1545_bp5 I0_pp15_8 XI0_I1545_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP52_1 (XI0_I1545_bsn I0_cm182_2 XI0_I1545_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1545_MP54 (VDD XI0_I1545_bsn I0_cm184_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1545_MP41 (XI0_I1545_bp1 XI0_I1545_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP42 (XI0_I1545_bcon I0_pp15_8 XI0_I1545_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP45 (XI0_I1545_bp2 I0_cm182_2 XI0_I1545_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP43 (VDD XI0_I1545_s1 XI0_I1545_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP44 (XI0_I1545_bp2 I0_pp15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1545_MP56 (VDD XI0_I1545_bcon I0_cm184_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1545_MP46 (XI0_I1545_bp3 XI0_I1545_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP48 (VDD I0_cm182_2 XI0_I1545_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP50_1 (XI0_I1545_bp4 XI0_I1545_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1545_MP26 (VDD XI0_I1545_asn XI0_I1545_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1545_MP18 (XI0_I1545_ap3 I0_cm93_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1545_MP21 (XI0_I1545_asn XI0_I1545_acon XI0_I1545_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP24 (XI0_I1545_ap5 I0_pp14_10 XI0_I1545_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1545_MP23 (XI0_I1545_ap4 I0_cm94_0 XI0_I1545_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP22 (VDD I0_cm93_0 XI0_I1545_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP22_1 (XI0_I1545_ap4 I0_cm93_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP23_1 (XI0_I1545_ap5 I0_cm94_0 XI0_I1545_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1545_MP24_1 (XI0_I1545_asn I0_pp14_10 XI0_I1545_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1545_MP17 (XI0_I1545_acon I0_pp14_10 XI0_I1545_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1545_MP14 (XI0_I1545_ap1 I0_cm94_0 XI0_I1545_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP13 (VDD I0_cm93_0 XI0_I1545_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP15 (XI0_I1545_ap2 I0_cm93_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP16 (VDD I0_cm94_0 XI0_I1545_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1545_MP28 (I0_cm184_2 XI0_I1545_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1545_MP19 (XI0_I1545_ap3 I0_cm94_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1545_MP20 (VDD I0_pp14_10 XI0_I1545_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1594_MP50 (VDD XI0_I1594_s1 XI0_I1594_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1594_MP47 (XI0_I1594_bp3 I0_fa186_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1594_MP49 (XI0_I1594_bsn XI0_I1594_bcon XI0_I1594_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1594_MP52 (XI0_I1594_bp5 I0_cm232_2 XI0_I1594_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1594_MP51 (XI0_I1594_bp4 I0_fa186_0 XI0_I1594_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP51_1 (XI0_I1594_bp5 I0_fa186_0 XI0_I1594_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP52_1 (XI0_I1594_bsn I0_cm232_2 XI0_I1594_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1594_MP54 (VDD XI0_I1594_bsn I0_cm233_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1594_MP41 (XI0_I1594_bp1 XI0_I1594_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP42 (XI0_I1594_bcon I0_fa186_0 XI0_I1594_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP45 (XI0_I1594_bp2 I0_cm232_2 XI0_I1594_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP43 (VDD XI0_I1594_s1 XI0_I1594_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP44 (XI0_I1594_bp2 I0_fa186_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1594_MP56 (VDD XI0_I1594_bcon I0_cm233_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1594_MP46 (XI0_I1594_bp3 XI0_I1594_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP48 (VDD I0_cm232_2 XI0_I1594_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP50_1 (XI0_I1594_bp4 XI0_I1594_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1594_MP26 (VDD XI0_I1594_asn XI0_I1594_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1594_MP18 (XI0_I1594_ap3 I0_cm183_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1594_MP21 (XI0_I1594_asn XI0_I1594_acon XI0_I1594_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP24 (XI0_I1594_ap5 I0_cm185_0 XI0_I1594_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1594_MP23 (XI0_I1594_ap4 I0_cm184_1 XI0_I1594_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP22 (VDD I0_cm183_1 XI0_I1594_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP22_1 (XI0_I1594_ap4 I0_cm183_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP23_1 (XI0_I1594_ap5 I0_cm184_1 XI0_I1594_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1594_MP24_1 (XI0_I1594_asn I0_cm185_0 XI0_I1594_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1594_MP17 (XI0_I1594_acon I0_cm185_0 XI0_I1594_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1594_MP14 (XI0_I1594_ap1 I0_cm184_1 XI0_I1594_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP13 (VDD I0_cm183_1 XI0_I1594_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP15 (XI0_I1594_ap2 I0_cm183_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP16 (VDD I0_cm184_1 XI0_I1594_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1594_MP28 (I0_cm233_2 XI0_I1594_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1594_MP19 (XI0_I1594_ap3 I0_cm184_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1594_MP20 (VDD I0_cm185_0 XI0_I1594_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1505_MP50 (VDD XI0_I1505_s1 XI0_I1505_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1505_MP47 (XI0_I1505_bp3 I0_cm16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1505_MP49 (XI0_I1505_bsn XI0_I1505_bcon XI0_I1505_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1505_MP52 (XI0_I1505_bp5 I0_cm143_2 XI0_I1505_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1505_MP51 (XI0_I1505_bp4 I0_cm16_0 XI0_I1505_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP51_1 (XI0_I1505_bp5 I0_cm16_0 XI0_I1505_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP52_1 (XI0_I1505_bsn I0_cm143_2 XI0_I1505_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1505_MP54 (VDD XI0_I1505_bsn I0_cm144_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1505_MP41 (XI0_I1505_bp1 XI0_I1505_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP42 (XI0_I1505_bcon I0_cm16_0 XI0_I1505_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP45 (XI0_I1505_bp2 I0_cm143_2 XI0_I1505_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP43 (VDD XI0_I1505_s1 XI0_I1505_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP44 (XI0_I1505_bp2 I0_cm16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1505_MP56 (VDD XI0_I1505_bcon I0_cm144_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1505_MP46 (XI0_I1505_bp3 XI0_I1505_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP48 (VDD I0_cm143_2 XI0_I1505_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP50_1 (XI0_I1505_bp4 XI0_I1505_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1505_MP26 (VDD XI0_I1505_asn XI0_I1505_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1505_MP18 (XI0_I1505_ap3 I0_cm13_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1505_MP21 (XI0_I1505_asn XI0_I1505_acon XI0_I1505_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP24 (XI0_I1505_ap5 I0_cm15_0 XI0_I1505_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1505_MP23 (XI0_I1505_ap4 I0_fa14_1 XI0_I1505_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP22 (VDD I0_cm13_1 XI0_I1505_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP22_1 (XI0_I1505_ap4 I0_cm13_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP23_1 (XI0_I1505_ap5 I0_fa14_1 XI0_I1505_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1505_MP24_1 (XI0_I1505_asn I0_cm15_0 XI0_I1505_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1505_MP17 (XI0_I1505_acon I0_cm15_0 XI0_I1505_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1505_MP14 (XI0_I1505_ap1 I0_fa14_1 XI0_I1505_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP13 (VDD I0_cm13_1 XI0_I1505_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP15 (XI0_I1505_ap2 I0_cm13_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP16 (VDD I0_fa14_1 XI0_I1505_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1505_MP28 (I0_cm144_2 XI0_I1505_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1505_MP19 (XI0_I1505_ap3 I0_fa14_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1505_MP20 (VDD I0_cm15_0 XI0_I1505_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1504_MP50 (VDD XI0_I1504_s1 XI0_I1504_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1504_MP47 (XI0_I1504_bp3 I0_fa14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1504_MP49 (XI0_I1504_bsn XI0_I1504_bcon XI0_I1504_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1504_MP52 (XI0_I1504_bp5 I0_cm142_2 XI0_I1504_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1504_MP51 (XI0_I1504_bp4 I0_fa14_0 XI0_I1504_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP51_1 (XI0_I1504_bp5 I0_fa14_0 XI0_I1504_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP52_1 (XI0_I1504_bsn I0_cm142_2 XI0_I1504_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1504_MP54 (VDD XI0_I1504_bsn I0_cm143_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1504_MP41 (XI0_I1504_bp1 XI0_I1504_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP42 (XI0_I1504_bcon I0_fa14_0 XI0_I1504_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP45 (XI0_I1504_bp2 I0_cm142_2 XI0_I1504_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP43 (VDD XI0_I1504_s1 XI0_I1504_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP44 (XI0_I1504_bp2 I0_fa14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1504_MP56 (VDD XI0_I1504_bcon I0_cm143_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1504_MP46 (XI0_I1504_bp3 XI0_I1504_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP48 (VDD I0_cm142_2 XI0_I1504_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP50_1 (XI0_I1504_bp4 XI0_I1504_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1504_MP26 (VDD XI0_I1504_asn XI0_I1504_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1504_MP18 (XI0_I1504_ap3 I0_cm11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1504_MP21 (XI0_I1504_asn XI0_I1504_acon XI0_I1504_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP24 (XI0_I1504_ap5 I0_cm13_0 XI0_I1504_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1504_MP23 (XI0_I1504_ap4 I0_fa12_1 XI0_I1504_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP22 (VDD I0_cm11_1 XI0_I1504_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP22_1 (XI0_I1504_ap4 I0_cm11_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP23_1 (XI0_I1504_ap5 I0_fa12_1 XI0_I1504_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1504_MP24_1 (XI0_I1504_asn I0_cm13_0 XI0_I1504_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1504_MP17 (XI0_I1504_acon I0_cm13_0 XI0_I1504_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1504_MP14 (XI0_I1504_ap1 I0_fa12_1 XI0_I1504_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP13 (VDD I0_cm11_1 XI0_I1504_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP15 (XI0_I1504_ap2 I0_cm11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP16 (VDD I0_fa12_1 XI0_I1504_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1504_MP28 (I0_cm143_2 XI0_I1504_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1504_MP19 (XI0_I1504_ap3 I0_fa12_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1504_MP20 (VDD I0_cm13_0 XI0_I1504_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1507_MP50 (VDD XI0_I1507_s1 XI0_I1507_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1507_MP47 (XI0_I1507_bp3 I0_cm20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1507_MP49 (XI0_I1507_bsn XI0_I1507_bcon XI0_I1507_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1507_MP52 (XI0_I1507_bp5 I0_cm145_2 XI0_I1507_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1507_MP51 (XI0_I1507_bp4 I0_cm20_0 XI0_I1507_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP51_1 (XI0_I1507_bp5 I0_cm20_0 XI0_I1507_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP52_1 (XI0_I1507_bsn I0_cm145_2 XI0_I1507_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1507_MP54 (VDD XI0_I1507_bsn I0_cm146_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1507_MP41 (XI0_I1507_bp1 XI0_I1507_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP42 (XI0_I1507_bcon I0_cm20_0 XI0_I1507_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP45 (XI0_I1507_bp2 I0_cm145_2 XI0_I1507_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP43 (VDD XI0_I1507_s1 XI0_I1507_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP44 (XI0_I1507_bp2 I0_cm20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1507_MP56 (VDD XI0_I1507_bcon I0_cm146_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1507_MP46 (XI0_I1507_bp3 XI0_I1507_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP48 (VDD I0_cm145_2 XI0_I1507_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP50_1 (XI0_I1507_bp4 XI0_I1507_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1507_MP26 (VDD XI0_I1507_asn XI0_I1507_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1507_MP18 (XI0_I1507_ap3 I0_cm17_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1507_MP21 (XI0_I1507_asn XI0_I1507_acon XI0_I1507_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP24 (XI0_I1507_ap5 I0_cm19_0 XI0_I1507_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1507_MP23 (XI0_I1507_ap4 I0_cm18_1 XI0_I1507_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP22 (VDD I0_cm17_1 XI0_I1507_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP22_1 (XI0_I1507_ap4 I0_cm17_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP23_1 (XI0_I1507_ap5 I0_cm18_1 XI0_I1507_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1507_MP24_1 (XI0_I1507_asn I0_cm19_0 XI0_I1507_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1507_MP17 (XI0_I1507_acon I0_cm19_0 XI0_I1507_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1507_MP14 (XI0_I1507_ap1 I0_cm18_1 XI0_I1507_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP13 (VDD I0_cm17_1 XI0_I1507_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP15 (XI0_I1507_ap2 I0_cm17_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP16 (VDD I0_cm18_1 XI0_I1507_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1507_MP28 (I0_cm146_2 XI0_I1507_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1507_MP19 (XI0_I1507_ap3 I0_cm18_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1507_MP20 (VDD I0_cm19_0 XI0_I1507_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1575_MP50 (VDD XI0_I1575_s1 XI0_I1575_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1575_MP47 (XI0_I1575_bp3 I0_fa30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1575_MP49 (XI0_I1575_bsn XI0_I1575_bcon XI0_I1575_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1575_MP52 (XI0_I1575_bp5 I0_B_21_b3_5 XI0_I1575_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1575_MP51 (XI0_I1575_bp4 I0_fa30_0 XI0_I1575_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP51_1 (XI0_I1575_bp5 I0_fa30_0 XI0_I1575_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP52_1 (XI0_I1575_bsn I0_B_21_b3_5 XI0_I1575_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1575_MP54 (VDD XI0_I1575_bsn I0_cm214_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1575_MP41 (XI0_I1575_bp1 XI0_I1575_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP42 (XI0_I1575_bcon I0_fa30_0 XI0_I1575_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP45 (XI0_I1575_bp2 I0_B_21_b3_5 XI0_I1575_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP43 (VDD XI0_I1575_s1 XI0_I1575_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP44 (XI0_I1575_bp2 I0_fa30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1575_MP56 (VDD XI0_I1575_bcon I0_cm214_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1575_MP46 (XI0_I1575_bp3 XI0_I1575_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP48 (VDD I0_B_21_b3_5 XI0_I1575_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP50_1 (XI0_I1575_bp4 XI0_I1575_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1575_MP26 (VDD XI0_I1575_asn XI0_I1575_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1575_MP18 (XI0_I1575_ap3 I0_cm149_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1575_MP21 (XI0_I1575_asn XI0_I1575_acon XI0_I1575_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP24 (XI0_I1575_ap5 I0_cm151_0 XI0_I1575_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1575_MP23 (XI0_I1575_ap4 I0_fa150_1 XI0_I1575_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP22 (VDD I0_cm149_1 XI0_I1575_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP22_1 (XI0_I1575_ap4 I0_cm149_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP23_1 (XI0_I1575_ap5 I0_fa150_1 XI0_I1575_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1575_MP24_1 (XI0_I1575_asn I0_cm151_0 XI0_I1575_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1575_MP17 (XI0_I1575_acon I0_cm151_0 XI0_I1575_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1575_MP14 (XI0_I1575_ap1 I0_fa150_1 XI0_I1575_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP13 (VDD I0_cm149_1 XI0_I1575_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP15 (XI0_I1575_ap2 I0_cm149_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP16 (VDD I0_fa150_1 XI0_I1575_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1575_MP28 (I0_cm214_2 XI0_I1575_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1575_MP19 (XI0_I1575_ap3 I0_fa150_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1575_MP20 (VDD I0_cm151_0 XI0_I1575_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1508_MP50 (VDD XI0_I1508_s1 XI0_I1508_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1508_MP47 (XI0_I1508_bp3 I0_cm22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1508_MP49 (XI0_I1508_bsn XI0_I1508_bcon XI0_I1508_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1508_MP52 (XI0_I1508_bp5 I0_cm146_2 XI0_I1508_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1508_MP51 (XI0_I1508_bp4 I0_cm22_0 XI0_I1508_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP51_1 (XI0_I1508_bp5 I0_cm22_0 XI0_I1508_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP52_1 (XI0_I1508_bsn I0_cm146_2 XI0_I1508_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1508_MP54 (VDD XI0_I1508_bsn I0_cm147_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1508_MP41 (XI0_I1508_bp1 XI0_I1508_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP42 (XI0_I1508_bcon I0_cm22_0 XI0_I1508_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP45 (XI0_I1508_bp2 I0_cm146_2 XI0_I1508_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP43 (VDD XI0_I1508_s1 XI0_I1508_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP44 (XI0_I1508_bp2 I0_cm22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1508_MP56 (VDD XI0_I1508_bcon I0_cm147_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1508_MP46 (XI0_I1508_bp3 XI0_I1508_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP48 (VDD I0_cm146_2 XI0_I1508_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP50_1 (XI0_I1508_bp4 XI0_I1508_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1508_MP26 (VDD XI0_I1508_asn XI0_I1508_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1508_MP18 (XI0_I1508_ap3 I0_cm19_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1508_MP21 (XI0_I1508_asn XI0_I1508_acon XI0_I1508_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP24 (XI0_I1508_ap5 I0_cm21_0 XI0_I1508_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1508_MP23 (XI0_I1508_ap4 I0_cm20_1 XI0_I1508_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP22 (VDD I0_cm19_1 XI0_I1508_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP22_1 (XI0_I1508_ap4 I0_cm19_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP23_1 (XI0_I1508_ap5 I0_cm20_1 XI0_I1508_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1508_MP24_1 (XI0_I1508_asn I0_cm21_0 XI0_I1508_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1508_MP17 (XI0_I1508_acon I0_cm21_0 XI0_I1508_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1508_MP14 (XI0_I1508_ap1 I0_cm20_1 XI0_I1508_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP13 (VDD I0_cm19_1 XI0_I1508_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP15 (XI0_I1508_ap2 I0_cm19_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP16 (VDD I0_cm20_1 XI0_I1508_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1508_MP28 (I0_cm147_2 XI0_I1508_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1508_MP19 (XI0_I1508_ap3 I0_cm20_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1508_MP20 (VDD I0_cm21_0 XI0_I1508_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1403_MP50 (VDD XI0_I1403_s1 XI0_I1403_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1403_MP47 (XI0_I1403_bp3 I0_pp11_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1403_MP49 (XI0_I1403_bsn XI0_I1403_bcon XI0_I1403_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1403_MP52 (XI0_I1403_bp5 I0_cm39_2 XI0_I1403_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1403_MP51 (XI0_I1403_bp4 I0_pp11_2 XI0_I1403_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP51_1 (XI0_I1403_bp5 I0_pp11_2 XI0_I1403_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP52_1 (XI0_I1403_bsn I0_cm39_2 XI0_I1403_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1403_MP54 (VDD XI0_I1403_bsn I0_cm42_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1403_MP41 (XI0_I1403_bp1 XI0_I1403_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP42 (XI0_I1403_bcon I0_pp11_2 XI0_I1403_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP45 (XI0_I1403_bp2 I0_cm39_2 XI0_I1403_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP43 (VDD XI0_I1403_s1 XI0_I1403_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP44 (XI0_I1403_bp2 I0_pp11_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1403_MP56 (VDD XI0_I1403_bcon I0_cm42_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1403_MP46 (XI0_I1403_bp3 XI0_I1403_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP48 (VDD I0_cm39_2 XI0_I1403_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP50_1 (XI0_I1403_bp4 XI0_I1403_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1403_MP26 (VDD XI0_I1403_asn XI0_I1403_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1403_MP18 (XI0_I1403_ap3 I0_pp8_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1403_MP21 (XI0_I1403_asn XI0_I1403_acon XI0_I1403_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP24 (XI0_I1403_ap5 I0_pp10_4 XI0_I1403_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1403_MP23 (XI0_I1403_ap4 I0_pp9_6 XI0_I1403_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP22 (VDD I0_pp8_8 XI0_I1403_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP22_1 (XI0_I1403_ap4 I0_pp8_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP23_1 (XI0_I1403_ap5 I0_pp9_6 XI0_I1403_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1403_MP24_1 (XI0_I1403_asn I0_pp10_4 XI0_I1403_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1403_MP17 (XI0_I1403_acon I0_pp10_4 XI0_I1403_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1403_MP14 (XI0_I1403_ap1 I0_pp9_6 XI0_I1403_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP13 (VDD I0_pp8_8 XI0_I1403_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP15 (XI0_I1403_ap2 I0_pp8_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP16 (VDD I0_pp9_6 XI0_I1403_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1403_MP28 (I0_cm42_2 XI0_I1403_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1403_MP19 (XI0_I1403_ap3 I0_pp9_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1403_MP20 (VDD I0_pp10_4 XI0_I1403_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1441_MP50 (VDD XI0_I1441_s1 XI0_I1441_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1441_MP47 (XI0_I1441_bp3 I0_pp15_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1441_MP49 (XI0_I1441_bsn XI0_I1441_bcon XI0_I1441_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1441_MP52 (XI0_I1441_bp5 I0_cm76_2 XI0_I1441_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1441_MP51 (XI0_I1441_bp4 I0_pp15_4 XI0_I1441_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP51_1 (XI0_I1441_bp5 I0_pp15_4 XI0_I1441_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP52_1 (XI0_I1441_bsn I0_cm76_2 XI0_I1441_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1441_MP54 (VDD XI0_I1441_bsn I0_cm80_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1441_MP41 (XI0_I1441_bp1 XI0_I1441_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP42 (XI0_I1441_bcon I0_pp15_4 XI0_I1441_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP45 (XI0_I1441_bp2 I0_cm76_2 XI0_I1441_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP43 (VDD XI0_I1441_s1 XI0_I1441_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP44 (XI0_I1441_bp2 I0_pp15_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1441_MP56 (VDD XI0_I1441_bcon I0_cm80_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1441_MP46 (XI0_I1441_bp3 XI0_I1441_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP48 (VDD I0_cm76_2 XI0_I1441_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP50_1 (XI0_I1441_bp4 XI0_I1441_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1441_MP26 (VDD XI0_I1441_asn XI0_I1441_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1441_MP18 (XI0_I1441_ap3 I0_pp12_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1441_MP21 (XI0_I1441_asn XI0_I1441_acon XI0_I1441_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP24 (XI0_I1441_ap5 I0_pp14_6 XI0_I1441_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1441_MP23 (XI0_I1441_ap4 I0_pp13_8 XI0_I1441_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP22 (VDD I0_pp12_10 XI0_I1441_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP22_1 (XI0_I1441_ap4 I0_pp12_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP23_1 (XI0_I1441_ap5 I0_pp13_8 XI0_I1441_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1441_MP24_1 (XI0_I1441_asn I0_pp14_6 XI0_I1441_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1441_MP17 (XI0_I1441_acon I0_pp14_6 XI0_I1441_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1441_MP14 (XI0_I1441_ap1 I0_pp13_8 XI0_I1441_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP13 (VDD I0_pp12_10 XI0_I1441_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP15 (XI0_I1441_ap2 I0_pp12_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP16 (VDD I0_pp13_8 XI0_I1441_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1441_MP28 (I0_cm80_2 XI0_I1441_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1441_MP19 (XI0_I1441_ap3 I0_pp13_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1441_MP20 (VDD I0_pp14_6 XI0_I1441_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1452_MP50 (VDD XI0_I1452_s1 XI0_I1452_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1452_MP47 (XI0_I1452_bp3 I0_pp13_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1452_MP49 (XI0_I1452_bsn XI0_I1452_bcon XI0_I1452_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1452_MP52 (XI0_I1452_bp5 I0_cm87_2 XI0_I1452_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1452_MP51 (XI0_I1452_bp4 I0_pp13_11 XI0_I1452_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP51_1 (XI0_I1452_bp5 I0_pp13_11 XI0_I1452_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP52_1 (XI0_I1452_bsn I0_cm87_2 XI0_I1452_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1452_MP54 (VDD XI0_I1452_bsn I0_cm91_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1452_MP41 (XI0_I1452_bp1 XI0_I1452_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP42 (XI0_I1452_bcon I0_pp13_11 XI0_I1452_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP45 (XI0_I1452_bp2 I0_cm87_2 XI0_I1452_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP43 (VDD XI0_I1452_s1 XI0_I1452_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP44 (XI0_I1452_bp2 I0_pp13_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1452_MP56 (VDD XI0_I1452_bcon I0_cm91_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1452_MP46 (XI0_I1452_bp3 XI0_I1452_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP48 (VDD I0_cm87_2 XI0_I1452_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP50_1 (XI0_I1452_bp4 XI0_I1452_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1452_MP26 (VDD XI0_I1452_asn XI0_I1452_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1452_MP18 (XI0_I1452_ap3 I0_pp10_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1452_MP21 (XI0_I1452_asn XI0_I1452_acon XI0_I1452_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP24 (XI0_I1452_ap5 I0_pp12_13 XI0_I1452_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1452_MP23 (XI0_I1452_ap4 I0_pp11_15 XI0_I1452_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP22 (VDD I0_pp10_17 XI0_I1452_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP22_1 (XI0_I1452_ap4 I0_pp10_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP23_1 (XI0_I1452_ap5 I0_pp11_15 XI0_I1452_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1452_MP24_1 (XI0_I1452_asn I0_pp12_13 XI0_I1452_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1452_MP17 (XI0_I1452_acon I0_pp12_13 XI0_I1452_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1452_MP14 (XI0_I1452_ap1 I0_pp11_15 XI0_I1452_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP13 (VDD I0_pp10_17 XI0_I1452_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP15 (XI0_I1452_ap2 I0_pp10_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP16 (VDD I0_pp11_15 XI0_I1452_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1452_MP28 (I0_cm91_2 XI0_I1452_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1452_MP19 (XI0_I1452_ap3 I0_pp11_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1452_MP20 (VDD I0_pp12_13 XI0_I1452_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1506_MP50 (VDD XI0_I1506_s1 XI0_I1506_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1506_MP47 (XI0_I1506_bp3 I0_cm18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1506_MP49 (XI0_I1506_bsn XI0_I1506_bcon XI0_I1506_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1506_MP52 (XI0_I1506_bp5 I0_cm144_2 XI0_I1506_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1506_MP51 (XI0_I1506_bp4 I0_cm18_0 XI0_I1506_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP51_1 (XI0_I1506_bp5 I0_cm18_0 XI0_I1506_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP52_1 (XI0_I1506_bsn I0_cm144_2 XI0_I1506_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1506_MP54 (VDD XI0_I1506_bsn I0_cm145_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1506_MP41 (XI0_I1506_bp1 XI0_I1506_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP42 (XI0_I1506_bcon I0_cm18_0 XI0_I1506_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP45 (XI0_I1506_bp2 I0_cm144_2 XI0_I1506_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP43 (VDD XI0_I1506_s1 XI0_I1506_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP44 (XI0_I1506_bp2 I0_cm18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1506_MP56 (VDD XI0_I1506_bcon I0_cm145_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1506_MP46 (XI0_I1506_bp3 XI0_I1506_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP48 (VDD I0_cm144_2 XI0_I1506_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP50_1 (XI0_I1506_bp4 XI0_I1506_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1506_MP26 (VDD XI0_I1506_asn XI0_I1506_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1506_MP18 (XI0_I1506_ap3 I0_cm15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1506_MP21 (XI0_I1506_asn XI0_I1506_acon XI0_I1506_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP24 (XI0_I1506_ap5 I0_cm17_0 XI0_I1506_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1506_MP23 (XI0_I1506_ap4 I0_cm16_1 XI0_I1506_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP22 (VDD I0_cm15_1 XI0_I1506_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP22_1 (XI0_I1506_ap4 I0_cm15_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP23_1 (XI0_I1506_ap5 I0_cm16_1 XI0_I1506_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1506_MP24_1 (XI0_I1506_asn I0_cm17_0 XI0_I1506_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1506_MP17 (XI0_I1506_acon I0_cm17_0 XI0_I1506_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1506_MP14 (XI0_I1506_ap1 I0_cm16_1 XI0_I1506_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP13 (VDD I0_cm15_1 XI0_I1506_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP15 (XI0_I1506_ap2 I0_cm15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP16 (VDD I0_cm16_1 XI0_I1506_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1506_MP28 (I0_cm145_2 XI0_I1506_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1506_MP19 (XI0_I1506_ap3 I0_cm16_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1506_MP20 (VDD I0_cm17_0 XI0_I1506_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1400_MP50 (VDD XI0_I1400_s1 XI0_I1400_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1400_MP47 (XI0_I1400_bp3 I0_pp11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1400_MP49 (XI0_I1400_bsn XI0_I1400_bcon XI0_I1400_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1400_MP52 (XI0_I1400_bp5 I0_cm36_2 XI0_I1400_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1400_MP51 (XI0_I1400_bp4 I0_pp11_1 XI0_I1400_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP51_1 (XI0_I1400_bp5 I0_pp11_1 XI0_I1400_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP52_1 (XI0_I1400_bsn I0_cm36_2 XI0_I1400_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1400_MP54 (VDD XI0_I1400_bsn I0_cm39_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1400_MP41 (XI0_I1400_bp1 XI0_I1400_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP42 (XI0_I1400_bcon I0_pp11_1 XI0_I1400_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP45 (XI0_I1400_bp2 I0_cm36_2 XI0_I1400_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP43 (VDD XI0_I1400_s1 XI0_I1400_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP44 (XI0_I1400_bp2 I0_pp11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1400_MP56 (VDD XI0_I1400_bcon I0_cm39_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1400_MP46 (XI0_I1400_bp3 XI0_I1400_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP48 (VDD I0_cm36_2 XI0_I1400_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP50_1 (XI0_I1400_bp4 XI0_I1400_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1400_MP26 (VDD XI0_I1400_asn XI0_I1400_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1400_MP18 (XI0_I1400_ap3 I0_pp8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1400_MP21 (XI0_I1400_asn XI0_I1400_acon XI0_I1400_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP24 (XI0_I1400_ap5 I0_pp10_3 XI0_I1400_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1400_MP23 (XI0_I1400_ap4 I0_pp9_5 XI0_I1400_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP22 (VDD I0_pp8_7 XI0_I1400_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP22_1 (XI0_I1400_ap4 I0_pp8_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP23_1 (XI0_I1400_ap5 I0_pp9_5 XI0_I1400_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1400_MP24_1 (XI0_I1400_asn I0_pp10_3 XI0_I1400_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1400_MP17 (XI0_I1400_acon I0_pp10_3 XI0_I1400_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1400_MP14 (XI0_I1400_ap1 I0_pp9_5 XI0_I1400_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP13 (VDD I0_pp8_7 XI0_I1400_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP15 (XI0_I1400_ap2 I0_pp8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP16 (VDD I0_pp9_5 XI0_I1400_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1400_MP28 (I0_cm39_2 XI0_I1400_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1400_MP19 (XI0_I1400_ap3 I0_pp9_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1400_MP20 (VDD I0_pp10_3 XI0_I1400_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1455_MP50 (VDD XI0_I1455_s1 XI0_I1455_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1455_MP47 (XI0_I1455_bp3 I0_pp13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1455_MP49 (XI0_I1455_bsn XI0_I1455_bcon XI0_I1455_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1455_MP52 (XI0_I1455_bp5 I0_cm91_2 XI0_I1455_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1455_MP51 (XI0_I1455_bp4 I0_pp13_12 XI0_I1455_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP51_1 (XI0_I1455_bp5 I0_pp13_12 XI0_I1455_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP52_1 (XI0_I1455_bsn I0_cm91_2 XI0_I1455_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1455_MP54 (VDD XI0_I1455_bsn I0_cm94_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1455_MP41 (XI0_I1455_bp1 XI0_I1455_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP42 (XI0_I1455_bcon I0_pp13_12 XI0_I1455_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP45 (XI0_I1455_bp2 I0_cm91_2 XI0_I1455_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP43 (VDD XI0_I1455_s1 XI0_I1455_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP44 (XI0_I1455_bp2 I0_pp13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1455_MP56 (VDD XI0_I1455_bcon I0_cm94_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1455_MP46 (XI0_I1455_bp3 XI0_I1455_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP48 (VDD I0_cm91_2 XI0_I1455_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP50_1 (XI0_I1455_bp4 XI0_I1455_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1455_MP26 (VDD XI0_I1455_asn XI0_I1455_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1455_MP18 (XI0_I1455_ap3 I0_pp10_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1455_MP21 (XI0_I1455_asn XI0_I1455_acon XI0_I1455_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP24 (XI0_I1455_ap5 I0_pp12_14 XI0_I1455_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1455_MP23 (XI0_I1455_ap4 I0_pp11_16 XI0_I1455_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP22 (VDD I0_pp10_18 XI0_I1455_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP22_1 (XI0_I1455_ap4 I0_pp10_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP23_1 (XI0_I1455_ap5 I0_pp11_16 XI0_I1455_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1455_MP24_1 (XI0_I1455_asn I0_pp12_14 XI0_I1455_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1455_MP17 (XI0_I1455_acon I0_pp12_14 XI0_I1455_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1455_MP14 (XI0_I1455_ap1 I0_pp11_16 XI0_I1455_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP13 (VDD I0_pp10_18 XI0_I1455_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP15 (XI0_I1455_ap2 I0_pp10_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP16 (VDD I0_pp11_16 XI0_I1455_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1455_MP28 (I0_cm94_2 XI0_I1455_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1455_MP19 (XI0_I1455_ap3 I0_pp11_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1455_MP20 (VDD I0_pp12_14 XI0_I1455_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1457_MP50 (VDD XI0_I1457_s1 XI0_I1457_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1457_MP47 (XI0_I1457_bp3 I0_pp10_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1457_MP49 (XI0_I1457_bsn XI0_I1457_bcon XI0_I1457_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1457_MP52 (XI0_I1457_bp5 I0_cm93_2 XI0_I1457_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1457_MP51 (XI0_I1457_bp4 I0_pp10_19 XI0_I1457_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP51_1 (XI0_I1457_bp5 I0_pp10_19 XI0_I1457_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP52_1 (XI0_I1457_bsn I0_cm93_2 XI0_I1457_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1457_MP54 (VDD XI0_I1457_bsn I0_cm96_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1457_MP41 (XI0_I1457_bp1 XI0_I1457_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP42 (XI0_I1457_bcon I0_pp10_19 XI0_I1457_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP45 (XI0_I1457_bp2 I0_cm93_2 XI0_I1457_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP43 (VDD XI0_I1457_s1 XI0_I1457_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP44 (XI0_I1457_bp2 I0_pp10_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1457_MP56 (VDD XI0_I1457_bcon I0_cm96_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1457_MP46 (XI0_I1457_bp3 XI0_I1457_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP48 (VDD I0_cm93_2 XI0_I1457_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP50_1 (XI0_I1457_bp4 XI0_I1457_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1457_MP26 (VDD XI0_I1457_asn XI0_I1457_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1457_MP18 (XI0_I1457_ap3 I0_pp7_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1457_MP21 (XI0_I1457_asn XI0_I1457_acon XI0_I1457_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP24 (XI0_I1457_ap5 I0_pp9_21 XI0_I1457_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1457_MP23 (XI0_I1457_ap4 I0_pp8_23 XI0_I1457_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP22 (VDD I0_pp7_25 XI0_I1457_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP22_1 (XI0_I1457_ap4 I0_pp7_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP23_1 (XI0_I1457_ap5 I0_pp8_23 XI0_I1457_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1457_MP24_1 (XI0_I1457_asn I0_pp9_21 XI0_I1457_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1457_MP17 (XI0_I1457_acon I0_pp9_21 XI0_I1457_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1457_MP14 (XI0_I1457_ap1 I0_pp8_23 XI0_I1457_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP13 (VDD I0_pp7_25 XI0_I1457_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP15 (XI0_I1457_ap2 I0_pp7_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP16 (VDD I0_pp8_23 XI0_I1457_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1457_MP28 (I0_cm96_2 XI0_I1457_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1457_MP19 (XI0_I1457_ap3 I0_pp8_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1457_MP20 (VDD I0_pp9_21 XI0_I1457_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1397_MP50 (VDD XI0_I1397_s1 XI0_I1397_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1397_MP47 (XI0_I1397_bp3 I0_pp11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1397_MP49 (XI0_I1397_bsn XI0_I1397_bcon XI0_I1397_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1397_MP52 (XI0_I1397_bp5 I0_B_23_b3_5 XI0_I1397_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1397_MP51 (XI0_I1397_bp4 I0_pp11_0 XI0_I1397_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP51_1 (XI0_I1397_bp5 I0_pp11_0 XI0_I1397_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP52_1 (XI0_I1397_bsn I0_B_23_b3_5 XI0_I1397_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1397_MP54 (VDD XI0_I1397_bsn I0_cm36_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1397_MP41 (XI0_I1397_bp1 XI0_I1397_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP42 (XI0_I1397_bcon I0_pp11_0 XI0_I1397_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP45 (XI0_I1397_bp2 I0_B_23_b3_5 XI0_I1397_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP43 (VDD XI0_I1397_s1 XI0_I1397_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP44 (XI0_I1397_bp2 I0_pp11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1397_MP56 (VDD XI0_I1397_bcon I0_cm36_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1397_MP46 (XI0_I1397_bp3 XI0_I1397_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP48 (VDD I0_B_23_b3_5 XI0_I1397_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP50_1 (XI0_I1397_bp4 XI0_I1397_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1397_MP26 (VDD XI0_I1397_asn XI0_I1397_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1397_MP18 (XI0_I1397_ap3 I0_pp8_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1397_MP21 (XI0_I1397_asn XI0_I1397_acon XI0_I1397_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP24 (XI0_I1397_ap5 I0_pp10_2 XI0_I1397_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1397_MP23 (XI0_I1397_ap4 I0_pp9_4 XI0_I1397_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP22 (VDD I0_pp8_6 XI0_I1397_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP22_1 (XI0_I1397_ap4 I0_pp8_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP23_1 (XI0_I1397_ap5 I0_pp9_4 XI0_I1397_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1397_MP24_1 (XI0_I1397_asn I0_pp10_2 XI0_I1397_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1397_MP17 (XI0_I1397_acon I0_pp10_2 XI0_I1397_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1397_MP14 (XI0_I1397_ap1 I0_pp9_4 XI0_I1397_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP13 (VDD I0_pp8_6 XI0_I1397_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP15 (XI0_I1397_ap2 I0_pp8_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP16 (VDD I0_pp9_4 XI0_I1397_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1397_MP28 (I0_cm36_2 XI0_I1397_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1397_MP19 (XI0_I1397_ap3 I0_pp9_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1397_MP20 (VDD I0_pp10_2 XI0_I1397_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1437_MP50 (VDD XI0_I1437_s1 XI0_I1437_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1437_MP47 (XI0_I1437_bp3 I0_pp15_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1437_MP49 (XI0_I1437_bsn XI0_I1437_bcon XI0_I1437_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1437_MP52 (XI0_I1437_bp5 I0_cm72_2 XI0_I1437_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1437_MP51 (XI0_I1437_bp4 I0_pp15_3 XI0_I1437_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP51_1 (XI0_I1437_bp5 I0_pp15_3 XI0_I1437_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP52_1 (XI0_I1437_bsn I0_cm72_2 XI0_I1437_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1437_MP54 (VDD XI0_I1437_bsn I0_cm76_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1437_MP41 (XI0_I1437_bp1 XI0_I1437_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP42 (XI0_I1437_bcon I0_pp15_3 XI0_I1437_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP45 (XI0_I1437_bp2 I0_cm72_2 XI0_I1437_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP43 (VDD XI0_I1437_s1 XI0_I1437_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP44 (XI0_I1437_bp2 I0_pp15_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1437_MP56 (VDD XI0_I1437_bcon I0_cm76_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1437_MP46 (XI0_I1437_bp3 XI0_I1437_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP48 (VDD I0_cm72_2 XI0_I1437_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP50_1 (XI0_I1437_bp4 XI0_I1437_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1437_MP26 (VDD XI0_I1437_asn XI0_I1437_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1437_MP18 (XI0_I1437_ap3 I0_pp12_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1437_MP21 (XI0_I1437_asn XI0_I1437_acon XI0_I1437_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP24 (XI0_I1437_ap5 I0_pp14_5 XI0_I1437_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1437_MP23 (XI0_I1437_ap4 I0_pp13_7 XI0_I1437_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP22 (VDD I0_pp12_9 XI0_I1437_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP22_1 (XI0_I1437_ap4 I0_pp12_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP23_1 (XI0_I1437_ap5 I0_pp13_7 XI0_I1437_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1437_MP24_1 (XI0_I1437_asn I0_pp14_5 XI0_I1437_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1437_MP17 (XI0_I1437_acon I0_pp14_5 XI0_I1437_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1437_MP14 (XI0_I1437_ap1 I0_pp13_7 XI0_I1437_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP13 (VDD I0_pp12_9 XI0_I1437_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP15 (XI0_I1437_ap2 I0_pp12_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP16 (VDD I0_pp13_7 XI0_I1437_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1437_MP28 (I0_cm76_2 XI0_I1437_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1437_MP19 (XI0_I1437_ap3 I0_pp13_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1437_MP20 (VDD I0_pp14_5 XI0_I1437_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1458_MP50 (VDD XI0_I1458_s1 XI0_I1458_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1458_MP47 (XI0_I1458_bp3 I0_pp14_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1458_MP49 (XI0_I1458_bsn XI0_I1458_bcon XI0_I1458_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1458_MP52 (XI0_I1458_bp5 I0_cm94_2 XI0_I1458_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1458_MP51 (XI0_I1458_bp4 I0_pp14_11 XI0_I1458_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP51_1 (XI0_I1458_bp5 I0_pp14_11 XI0_I1458_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP52_1 (XI0_I1458_bsn I0_cm94_2 XI0_I1458_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1458_MP54 (VDD XI0_I1458_bsn I0_cm97_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1458_MP41 (XI0_I1458_bp1 XI0_I1458_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP42 (XI0_I1458_bcon I0_pp14_11 XI0_I1458_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP45 (XI0_I1458_bp2 I0_cm94_2 XI0_I1458_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP43 (VDD XI0_I1458_s1 XI0_I1458_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP44 (XI0_I1458_bp2 I0_pp14_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1458_MP56 (VDD XI0_I1458_bcon I0_cm97_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1458_MP46 (XI0_I1458_bp3 XI0_I1458_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP48 (VDD I0_cm94_2 XI0_I1458_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP50_1 (XI0_I1458_bp4 XI0_I1458_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1458_MP26 (VDD XI0_I1458_asn XI0_I1458_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1458_MP18 (XI0_I1458_ap3 I0_pp11_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1458_MP21 (XI0_I1458_asn XI0_I1458_acon XI0_I1458_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP24 (XI0_I1458_ap5 I0_pp13_13 XI0_I1458_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1458_MP23 (XI0_I1458_ap4 I0_pp12_15 XI0_I1458_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP22 (VDD I0_pp11_17 XI0_I1458_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP22_1 (XI0_I1458_ap4 I0_pp11_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP23_1 (XI0_I1458_ap5 I0_pp12_15 XI0_I1458_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1458_MP24_1 (XI0_I1458_asn I0_pp13_13 XI0_I1458_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1458_MP17 (XI0_I1458_acon I0_pp13_13 XI0_I1458_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1458_MP14 (XI0_I1458_ap1 I0_pp12_15 XI0_I1458_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP13 (VDD I0_pp11_17 XI0_I1458_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP15 (XI0_I1458_ap2 I0_pp11_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP16 (VDD I0_pp12_15 XI0_I1458_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1458_MP28 (I0_cm97_2 XI0_I1458_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1458_MP19 (XI0_I1458_ap3 I0_pp12_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1458_MP20 (VDD I0_pp13_13 XI0_I1458_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1460_MP50 (VDD XI0_I1460_s1 XI0_I1460_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1460_MP47 (XI0_I1460_bp3 I0_pp10_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1460_MP49 (XI0_I1460_bsn XI0_I1460_bcon XI0_I1460_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1460_MP52 (XI0_I1460_bp5 I0_cm96_2 XI0_I1460_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1460_MP51 (XI0_I1460_bp4 I0_pp10_20 XI0_I1460_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP51_1 (XI0_I1460_bp5 I0_pp10_20 XI0_I1460_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP52_1 (XI0_I1460_bsn I0_cm96_2 XI0_I1460_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1460_MP54 (VDD XI0_I1460_bsn I0_cm99_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1460_MP41 (XI0_I1460_bp1 XI0_I1460_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP42 (XI0_I1460_bcon I0_pp10_20 XI0_I1460_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP45 (XI0_I1460_bp2 I0_cm96_2 XI0_I1460_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP43 (VDD XI0_I1460_s1 XI0_I1460_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP44 (XI0_I1460_bp2 I0_pp10_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1460_MP56 (VDD XI0_I1460_bcon I0_cm99_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1460_MP46 (XI0_I1460_bp3 XI0_I1460_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP48 (VDD I0_cm96_2 XI0_I1460_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP50_1 (XI0_I1460_bp4 XI0_I1460_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1460_MP26 (VDD XI0_I1460_asn XI0_I1460_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1460_MP18 (XI0_I1460_ap3 I0_pp7_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1460_MP21 (XI0_I1460_asn XI0_I1460_acon XI0_I1460_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP24 (XI0_I1460_ap5 I0_pp9_22 XI0_I1460_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1460_MP23 (XI0_I1460_ap4 I0_pp8_24 XI0_I1460_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP22 (VDD I0_pp7_26 XI0_I1460_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP22_1 (XI0_I1460_ap4 I0_pp7_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP23_1 (XI0_I1460_ap5 I0_pp8_24 XI0_I1460_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1460_MP24_1 (XI0_I1460_asn I0_pp9_22 XI0_I1460_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1460_MP17 (XI0_I1460_acon I0_pp9_22 XI0_I1460_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1460_MP14 (XI0_I1460_ap1 I0_pp8_24 XI0_I1460_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP13 (VDD I0_pp7_26 XI0_I1460_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP15 (XI0_I1460_ap2 I0_pp7_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP16 (VDD I0_pp8_24 XI0_I1460_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1460_MP28 (I0_cm99_2 XI0_I1460_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1460_MP19 (XI0_I1460_ap3 I0_pp8_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1460_MP20 (VDD I0_pp9_22 XI0_I1460_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1548_MP50 (VDD XI0_I1548_s1 XI0_I1548_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1548_MP47 (XI0_I1548_bp3 I0_cm98_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1548_MP49 (XI0_I1548_bsn XI0_I1548_bcon XI0_I1548_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1548_MP52 (XI0_I1548_bp5 I0_cm185_2 XI0_I1548_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1548_MP51 (XI0_I1548_bp4 I0_cm98_0 XI0_I1548_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP51_1 (XI0_I1548_bp5 I0_cm98_0 XI0_I1548_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP52_1 (XI0_I1548_bsn I0_cm185_2 XI0_I1548_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1548_MP54 (VDD XI0_I1548_bsn I0_cm187_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1548_MP41 (XI0_I1548_bp1 XI0_I1548_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP42 (XI0_I1548_bcon I0_cm98_0 XI0_I1548_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP45 (XI0_I1548_bp2 I0_cm185_2 XI0_I1548_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP43 (VDD XI0_I1548_s1 XI0_I1548_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP44 (XI0_I1548_bp2 I0_cm98_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1548_MP56 (VDD XI0_I1548_bcon I0_cm187_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1548_MP46 (XI0_I1548_bp3 XI0_I1548_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP48 (VDD I0_cm185_2 XI0_I1548_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP50_1 (XI0_I1548_bp4 XI0_I1548_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1548_MP26 (VDD XI0_I1548_asn XI0_I1548_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1548_MP18 (XI0_I1548_ap3 I0_cm95_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1548_MP21 (XI0_I1548_asn XI0_I1548_acon XI0_I1548_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP24 (XI0_I1548_ap5 I0_cm97_1 XI0_I1548_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1548_MP23 (XI0_I1548_ap4 I0_cm96_1 XI0_I1548_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP22 (VDD I0_cm95_1 XI0_I1548_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP22_1 (XI0_I1548_ap4 I0_cm95_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP23_1 (XI0_I1548_ap5 I0_cm96_1 XI0_I1548_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1548_MP24_1 (XI0_I1548_asn I0_cm97_1 XI0_I1548_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1548_MP17 (XI0_I1548_acon I0_cm97_1 XI0_I1548_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1548_MP14 (XI0_I1548_ap1 I0_cm96_1 XI0_I1548_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP13 (VDD I0_cm95_1 XI0_I1548_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP15 (XI0_I1548_ap2 I0_cm95_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP16 (VDD I0_cm96_1 XI0_I1548_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1548_MP28 (I0_cm187_2 XI0_I1548_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1548_MP19 (XI0_I1548_ap3 I0_cm96_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1548_MP20 (VDD I0_cm97_1 XI0_I1548_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1429_MP50 (VDD XI0_I1429_s1 XI0_I1429_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1429_MP47 (XI0_I1429_bp3 I0_pp15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1429_MP49 (XI0_I1429_bsn XI0_I1429_bcon XI0_I1429_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1429_MP52 (XI0_I1429_bp5 I0_cm64_2 XI0_I1429_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1429_MP51 (XI0_I1429_bp4 I0_pp15_1 XI0_I1429_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP51_1 (XI0_I1429_bp5 I0_pp15_1 XI0_I1429_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP52_1 (XI0_I1429_bsn I0_cm64_2 XI0_I1429_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1429_MP54 (VDD XI0_I1429_bsn I0_cm68_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1429_MP41 (XI0_I1429_bp1 XI0_I1429_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP42 (XI0_I1429_bcon I0_pp15_1 XI0_I1429_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP45 (XI0_I1429_bp2 I0_cm64_2 XI0_I1429_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP43 (VDD XI0_I1429_s1 XI0_I1429_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP44 (XI0_I1429_bp2 I0_pp15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1429_MP56 (VDD XI0_I1429_bcon I0_cm68_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1429_MP46 (XI0_I1429_bp3 XI0_I1429_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP48 (VDD I0_cm64_2 XI0_I1429_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP50_1 (XI0_I1429_bp4 XI0_I1429_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1429_MP26 (VDD XI0_I1429_asn XI0_I1429_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1429_MP18 (XI0_I1429_ap3 I0_pp12_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1429_MP21 (XI0_I1429_asn XI0_I1429_acon XI0_I1429_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP24 (XI0_I1429_ap5 I0_pp14_3 XI0_I1429_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1429_MP23 (XI0_I1429_ap4 I0_pp13_5 XI0_I1429_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP22 (VDD I0_pp12_7 XI0_I1429_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP22_1 (XI0_I1429_ap4 I0_pp12_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP23_1 (XI0_I1429_ap5 I0_pp13_5 XI0_I1429_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1429_MP24_1 (XI0_I1429_asn I0_pp14_3 XI0_I1429_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1429_MP17 (XI0_I1429_acon I0_pp14_3 XI0_I1429_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1429_MP14 (XI0_I1429_ap1 I0_pp13_5 XI0_I1429_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP13 (VDD I0_pp12_7 XI0_I1429_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP15 (XI0_I1429_ap2 I0_pp12_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP16 (VDD I0_pp13_5 XI0_I1429_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1429_MP28 (I0_cm68_2 XI0_I1429_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1429_MP19 (XI0_I1429_ap3 I0_pp13_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1429_MP20 (VDD I0_pp14_3 XI0_I1429_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1433_MP50 (VDD XI0_I1433_s1 XI0_I1433_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1433_MP47 (XI0_I1433_bp3 I0_pp15_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1433_MP49 (XI0_I1433_bsn XI0_I1433_bcon XI0_I1433_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1433_MP52 (XI0_I1433_bp5 I0_cm68_2 XI0_I1433_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1433_MP51 (XI0_I1433_bp4 I0_pp15_2 XI0_I1433_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP51_1 (XI0_I1433_bp5 I0_pp15_2 XI0_I1433_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP52_1 (XI0_I1433_bsn I0_cm68_2 XI0_I1433_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1433_MP54 (VDD XI0_I1433_bsn I0_cm72_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1433_MP41 (XI0_I1433_bp1 XI0_I1433_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP42 (XI0_I1433_bcon I0_pp15_2 XI0_I1433_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP45 (XI0_I1433_bp2 I0_cm68_2 XI0_I1433_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP43 (VDD XI0_I1433_s1 XI0_I1433_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP44 (XI0_I1433_bp2 I0_pp15_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1433_MP56 (VDD XI0_I1433_bcon I0_cm72_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1433_MP46 (XI0_I1433_bp3 XI0_I1433_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP48 (VDD I0_cm68_2 XI0_I1433_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP50_1 (XI0_I1433_bp4 XI0_I1433_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1433_MP26 (VDD XI0_I1433_asn XI0_I1433_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1433_MP18 (XI0_I1433_ap3 I0_pp12_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1433_MP21 (XI0_I1433_asn XI0_I1433_acon XI0_I1433_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP24 (XI0_I1433_ap5 I0_pp14_4 XI0_I1433_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1433_MP23 (XI0_I1433_ap4 I0_pp13_6 XI0_I1433_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP22 (VDD I0_pp12_8 XI0_I1433_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP22_1 (XI0_I1433_ap4 I0_pp12_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP23_1 (XI0_I1433_ap5 I0_pp13_6 XI0_I1433_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1433_MP24_1 (XI0_I1433_asn I0_pp14_4 XI0_I1433_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1433_MP17 (XI0_I1433_acon I0_pp14_4 XI0_I1433_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1433_MP14 (XI0_I1433_ap1 I0_pp13_6 XI0_I1433_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP13 (VDD I0_pp12_8 XI0_I1433_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP15 (XI0_I1433_ap2 I0_pp12_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP16 (VDD I0_pp13_6 XI0_I1433_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1433_MP28 (I0_cm72_2 XI0_I1433_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1433_MP19 (XI0_I1433_ap3 I0_pp13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1433_MP20 (VDD I0_pp14_4 XI0_I1433_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1461_MP50 (VDD XI0_I1461_s1 XI0_I1461_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1461_MP47 (XI0_I1461_bp3 I0_pp14_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1461_MP49 (XI0_I1461_bsn XI0_I1461_bcon XI0_I1461_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1461_MP52 (XI0_I1461_bp5 I0_cm97_2 XI0_I1461_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1461_MP51 (XI0_I1461_bp4 I0_pp14_12 XI0_I1461_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP51_1 (XI0_I1461_bp5 I0_pp14_12 XI0_I1461_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP52_1 (XI0_I1461_bsn I0_cm97_2 XI0_I1461_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1461_MP54 (VDD XI0_I1461_bsn I0_cm100_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1461_MP41 (XI0_I1461_bp1 XI0_I1461_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP42 (XI0_I1461_bcon I0_pp14_12 XI0_I1461_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP45 (XI0_I1461_bp2 I0_cm97_2 XI0_I1461_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP43 (VDD XI0_I1461_s1 XI0_I1461_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP44 (XI0_I1461_bp2 I0_pp14_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1461_MP56 (VDD XI0_I1461_bcon I0_cm100_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1461_MP46 (XI0_I1461_bp3 XI0_I1461_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP48 (VDD I0_cm97_2 XI0_I1461_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP50_1 (XI0_I1461_bp4 XI0_I1461_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1461_MP26 (VDD XI0_I1461_asn XI0_I1461_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1461_MP18 (XI0_I1461_ap3 I0_pp11_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1461_MP21 (XI0_I1461_asn XI0_I1461_acon XI0_I1461_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP24 (XI0_I1461_ap5 I0_pp13_14 XI0_I1461_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1461_MP23 (XI0_I1461_ap4 I0_pp12_16 XI0_I1461_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP22 (VDD I0_pp11_18 XI0_I1461_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP22_1 (XI0_I1461_ap4 I0_pp11_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP23_1 (XI0_I1461_ap5 I0_pp12_16 XI0_I1461_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1461_MP24_1 (XI0_I1461_asn I0_pp13_14 XI0_I1461_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1461_MP17 (XI0_I1461_acon I0_pp13_14 XI0_I1461_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1461_MP14 (XI0_I1461_ap1 I0_pp12_16 XI0_I1461_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP13 (VDD I0_pp11_18 XI0_I1461_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP15 (XI0_I1461_ap2 I0_pp11_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP16 (VDD I0_pp12_16 XI0_I1461_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1461_MP28 (I0_cm100_2 XI0_I1461_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1461_MP19 (XI0_I1461_ap3 I0_pp12_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1461_MP20 (VDD I0_pp13_14 XI0_I1461_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1550_MP50 (VDD XI0_I1550_s1 XI0_I1550_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1550_MP47 (XI0_I1550_bp3 I0_cm101_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1550_MP49 (XI0_I1550_bsn XI0_I1550_bcon XI0_I1550_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1550_MP52 (XI0_I1550_bp5 I0_cm187_2 XI0_I1550_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1550_MP51 (XI0_I1550_bp4 I0_cm101_0 XI0_I1550_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP51_1 (XI0_I1550_bp5 I0_cm101_0 XI0_I1550_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP52_1 (XI0_I1550_bsn I0_cm187_2 XI0_I1550_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1550_MP54 (VDD XI0_I1550_bsn I0_cm189_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1550_MP41 (XI0_I1550_bp1 XI0_I1550_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP42 (XI0_I1550_bcon I0_cm101_0 XI0_I1550_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP45 (XI0_I1550_bp2 I0_cm187_2 XI0_I1550_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP43 (VDD XI0_I1550_s1 XI0_I1550_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP44 (XI0_I1550_bp2 I0_cm101_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1550_MP56 (VDD XI0_I1550_bcon I0_cm189_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1550_MP46 (XI0_I1550_bp3 XI0_I1550_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP48 (VDD I0_cm187_2 XI0_I1550_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP50_1 (XI0_I1550_bp4 XI0_I1550_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1550_MP26 (VDD XI0_I1550_asn XI0_I1550_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1550_MP18 (XI0_I1550_ap3 I0_cm98_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1550_MP21 (XI0_I1550_asn XI0_I1550_acon XI0_I1550_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP24 (XI0_I1550_ap5 I0_cm100_1 XI0_I1550_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1550_MP23 (XI0_I1550_ap4 I0_cm99_1 XI0_I1550_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP22 (VDD I0_cm98_1 XI0_I1550_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP22_1 (XI0_I1550_ap4 I0_cm98_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP23_1 (XI0_I1550_ap5 I0_cm99_1 XI0_I1550_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1550_MP24_1 (XI0_I1550_asn I0_cm100_1 XI0_I1550_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1550_MP17 (XI0_I1550_acon I0_cm100_1 XI0_I1550_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1550_MP14 (XI0_I1550_ap1 I0_cm99_1 XI0_I1550_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP13 (VDD I0_cm98_1 XI0_I1550_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP15 (XI0_I1550_ap2 I0_cm98_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP16 (VDD I0_cm99_1 XI0_I1550_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1550_MP28 (I0_cm189_2 XI0_I1550_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1550_MP19 (XI0_I1550_ap3 I0_cm99_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1550_MP20 (VDD I0_cm100_1 XI0_I1550_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1595_MP50 (VDD XI0_I1595_s1 XI0_I1595_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1595_MP47 (XI0_I1595_bp3 I0_fa188_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1595_MP49 (XI0_I1595_bsn XI0_I1595_bcon XI0_I1595_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1595_MP52 (XI0_I1595_bp5 I0_cm233_2 XI0_I1595_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1595_MP51 (XI0_I1595_bp4 I0_fa188_0 XI0_I1595_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP51_1 (XI0_I1595_bp5 I0_fa188_0 XI0_I1595_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP52_1 (XI0_I1595_bsn I0_cm233_2 XI0_I1595_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1595_MP54 (VDD XI0_I1595_bsn I0_cm234_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1595_MP41 (XI0_I1595_bp1 XI0_I1595_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP42 (XI0_I1595_bcon I0_fa188_0 XI0_I1595_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP45 (XI0_I1595_bp2 I0_cm233_2 XI0_I1595_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP43 (VDD XI0_I1595_s1 XI0_I1595_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP44 (XI0_I1595_bp2 I0_fa188_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1595_MP56 (VDD XI0_I1595_bcon I0_cm234_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1595_MP46 (XI0_I1595_bp3 XI0_I1595_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP48 (VDD I0_cm233_2 XI0_I1595_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP50_1 (XI0_I1595_bp4 XI0_I1595_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1595_MP26 (VDD XI0_I1595_asn XI0_I1595_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1595_MP18 (XI0_I1595_ap3 I0_cm185_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1595_MP21 (XI0_I1595_asn XI0_I1595_acon XI0_I1595_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP24 (XI0_I1595_ap5 I0_cm187_0 XI0_I1595_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1595_MP23 (XI0_I1595_ap4 I0_fa186_1 XI0_I1595_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP22 (VDD I0_cm185_1 XI0_I1595_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP22_1 (XI0_I1595_ap4 I0_cm185_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP23_1 (XI0_I1595_ap5 I0_fa186_1 XI0_I1595_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1595_MP24_1 (XI0_I1595_asn I0_cm187_0 XI0_I1595_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1595_MP17 (XI0_I1595_acon I0_cm187_0 XI0_I1595_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1595_MP14 (XI0_I1595_ap1 I0_fa186_1 XI0_I1595_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP13 (VDD I0_cm185_1 XI0_I1595_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP15 (XI0_I1595_ap2 I0_cm185_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP16 (VDD I0_fa186_1 XI0_I1595_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1595_MP28 (I0_cm234_2 XI0_I1595_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1595_MP19 (XI0_I1595_ap3 I0_fa186_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1595_MP20 (VDD I0_cm187_0 XI0_I1595_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1596_MP50 (VDD XI0_I1596_s1 XI0_I1596_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1596_MP47 (XI0_I1596_bp3 I0_cm102_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1596_MP49 (XI0_I1596_bsn XI0_I1596_bcon XI0_I1596_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1596_MP52 (XI0_I1596_bp5 I0_cm234_2 XI0_I1596_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1596_MP51 (XI0_I1596_bp4 I0_cm102_0 XI0_I1596_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP51_1 (XI0_I1596_bp5 I0_cm102_0 XI0_I1596_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP52_1 (XI0_I1596_bsn I0_cm234_2 XI0_I1596_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1596_MP54 (VDD XI0_I1596_bsn I0_cm235_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1596_MP41 (XI0_I1596_bp1 XI0_I1596_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP42 (XI0_I1596_bcon I0_cm102_0 XI0_I1596_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP45 (XI0_I1596_bp2 I0_cm234_2 XI0_I1596_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP43 (VDD XI0_I1596_s1 XI0_I1596_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP44 (XI0_I1596_bp2 I0_cm102_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1596_MP56 (VDD XI0_I1596_bcon I0_cm235_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1596_MP46 (XI0_I1596_bp3 XI0_I1596_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP48 (VDD I0_cm234_2 XI0_I1596_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP50_1 (XI0_I1596_bp4 XI0_I1596_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1596_MP26 (VDD XI0_I1596_asn XI0_I1596_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1596_MP18 (XI0_I1596_ap3 I0_cm187_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1596_MP21 (XI0_I1596_asn XI0_I1596_acon XI0_I1596_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP24 (XI0_I1596_ap5 I0_cm189_0 XI0_I1596_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1596_MP23 (XI0_I1596_ap4 I0_fa188_1 XI0_I1596_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP22 (VDD I0_cm187_1 XI0_I1596_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP22_1 (XI0_I1596_ap4 I0_cm187_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP23_1 (XI0_I1596_ap5 I0_fa188_1 XI0_I1596_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1596_MP24_1 (XI0_I1596_asn I0_cm189_0 XI0_I1596_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1596_MP17 (XI0_I1596_acon I0_cm189_0 XI0_I1596_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1596_MP14 (XI0_I1596_ap1 I0_fa188_1 XI0_I1596_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP13 (VDD I0_cm187_1 XI0_I1596_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP15 (XI0_I1596_ap2 I0_cm187_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP16 (VDD I0_fa188_1 XI0_I1596_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1596_MP28 (I0_cm235_2 XI0_I1596_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1596_MP19 (XI0_I1596_ap3 I0_fa188_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1596_MP20 (VDD I0_cm189_0 XI0_I1596_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1463_MP50 (VDD XI0_I1463_s1 XI0_I1463_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1463_MP47 (XI0_I1463_bp3 I0_pp11_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1463_MP49 (XI0_I1463_bsn XI0_I1463_bcon XI0_I1463_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1463_MP52 (XI0_I1463_bp5 I0_cm99_2 XI0_I1463_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1463_MP51 (XI0_I1463_bp4 I0_pp11_19 XI0_I1463_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP51_1 (XI0_I1463_bp5 I0_pp11_19 XI0_I1463_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP52_1 (XI0_I1463_bsn I0_cm99_2 XI0_I1463_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1463_MP54 (VDD XI0_I1463_bsn I0_cm102_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1463_MP41 (XI0_I1463_bp1 XI0_I1463_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP42 (XI0_I1463_bcon I0_pp11_19 XI0_I1463_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP45 (XI0_I1463_bp2 I0_cm99_2 XI0_I1463_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP43 (VDD XI0_I1463_s1 XI0_I1463_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP44 (XI0_I1463_bp2 I0_pp11_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1463_MP56 (VDD XI0_I1463_bcon I0_cm102_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1463_MP46 (XI0_I1463_bp3 XI0_I1463_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP48 (VDD I0_cm99_2 XI0_I1463_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP50_1 (XI0_I1463_bp4 XI0_I1463_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1463_MP26 (VDD XI0_I1463_asn XI0_I1463_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1463_MP18 (XI0_I1463_ap3 I0_pp8_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1463_MP21 (XI0_I1463_asn XI0_I1463_acon XI0_I1463_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP24 (XI0_I1463_ap5 I0_pp10_21 XI0_I1463_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1463_MP23 (XI0_I1463_ap4 I0_pp9_23 XI0_I1463_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP22 (VDD I0_pp8_25 XI0_I1463_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP22_1 (XI0_I1463_ap4 I0_pp8_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP23_1 (XI0_I1463_ap5 I0_pp9_23 XI0_I1463_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1463_MP24_1 (XI0_I1463_asn I0_pp10_21 XI0_I1463_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1463_MP17 (XI0_I1463_acon I0_pp10_21 XI0_I1463_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1463_MP14 (XI0_I1463_ap1 I0_pp9_23 XI0_I1463_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP13 (VDD I0_pp8_25 XI0_I1463_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP15 (XI0_I1463_ap2 I0_pp8_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP16 (VDD I0_pp9_23 XI0_I1463_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1463_MP28 (I0_cm102_2 XI0_I1463_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1463_MP19 (XI0_I1463_ap3 I0_pp9_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1463_MP20 (VDD I0_pp10_21 XI0_I1463_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1464_MP50 (VDD XI0_I1464_s1 XI0_I1464_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1464_MP47 (XI0_I1464_bp3 I0_pp15_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1464_MP49 (XI0_I1464_bsn XI0_I1464_bcon XI0_I1464_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1464_MP52 (XI0_I1464_bp5 I0_cm100_2 XI0_I1464_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1464_MP51 (XI0_I1464_bp4 I0_pp15_11 XI0_I1464_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP51_1 (XI0_I1464_bp5 I0_pp15_11 XI0_I1464_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP52_1 (XI0_I1464_bsn I0_cm100_2 XI0_I1464_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1464_MP54 (VDD XI0_I1464_bsn I0_cm103_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1464_MP41 (XI0_I1464_bp1 XI0_I1464_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP42 (XI0_I1464_bcon I0_pp15_11 XI0_I1464_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP45 (XI0_I1464_bp2 I0_cm100_2 XI0_I1464_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP43 (VDD XI0_I1464_s1 XI0_I1464_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP44 (XI0_I1464_bp2 I0_pp15_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1464_MP56 (VDD XI0_I1464_bcon I0_cm103_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1464_MP46 (XI0_I1464_bp3 XI0_I1464_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP48 (VDD I0_cm100_2 XI0_I1464_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP50_1 (XI0_I1464_bp4 XI0_I1464_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1464_MP26 (VDD XI0_I1464_asn XI0_I1464_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1464_MP18 (XI0_I1464_ap3 I0_pp12_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1464_MP21 (XI0_I1464_asn XI0_I1464_acon XI0_I1464_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP24 (XI0_I1464_ap5 I0_pp14_13 XI0_I1464_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1464_MP23 (XI0_I1464_ap4 I0_pp13_15 XI0_I1464_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP22 (VDD I0_pp12_17 XI0_I1464_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP22_1 (XI0_I1464_ap4 I0_pp12_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP23_1 (XI0_I1464_ap5 I0_pp13_15 XI0_I1464_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1464_MP24_1 (XI0_I1464_asn I0_pp14_13 XI0_I1464_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1464_MP17 (XI0_I1464_acon I0_pp14_13 XI0_I1464_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1464_MP14 (XI0_I1464_ap1 I0_pp13_15 XI0_I1464_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP13 (VDD I0_pp12_17 XI0_I1464_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP15 (XI0_I1464_ap2 I0_pp12_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP16 (VDD I0_pp13_15 XI0_I1464_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1464_MP28 (I0_cm103_2 XI0_I1464_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1464_MP19 (XI0_I1464_ap3 I0_pp13_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1464_MP20 (VDD I0_pp14_13 XI0_I1464_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1597_MP50 (VDD XI0_I1597_s1 XI0_I1597_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1597_MP47 (XI0_I1597_bp3 I0_cm106_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1597_MP49 (XI0_I1597_bsn XI0_I1597_bcon XI0_I1597_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1597_MP52 (XI0_I1597_bp5 I0_cm235_2 XI0_I1597_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1597_MP51 (XI0_I1597_bp4 I0_cm106_0 XI0_I1597_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP51_1 (XI0_I1597_bp5 I0_cm106_0 XI0_I1597_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP52_1 (XI0_I1597_bsn I0_cm235_2 XI0_I1597_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1597_MP54 (VDD XI0_I1597_bsn I0_cm236_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1597_MP41 (XI0_I1597_bp1 XI0_I1597_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP42 (XI0_I1597_bcon I0_cm106_0 XI0_I1597_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP45 (XI0_I1597_bp2 I0_cm235_2 XI0_I1597_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP43 (VDD XI0_I1597_s1 XI0_I1597_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP44 (XI0_I1597_bp2 I0_cm106_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1597_MP56 (VDD XI0_I1597_bcon I0_cm236_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1597_MP46 (XI0_I1597_bp3 XI0_I1597_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP48 (VDD I0_cm235_2 XI0_I1597_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP50_1 (XI0_I1597_bp4 XI0_I1597_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1597_MP26 (VDD XI0_I1597_asn XI0_I1597_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1597_MP18 (XI0_I1597_ap3 I0_cm189_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1597_MP21 (XI0_I1597_asn XI0_I1597_acon XI0_I1597_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP24 (XI0_I1597_ap5 I0_cm105_0 XI0_I1597_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1597_MP23 (XI0_I1597_ap4 I0_cm190_0 XI0_I1597_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP22 (VDD I0_cm189_1 XI0_I1597_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP22_1 (XI0_I1597_ap4 I0_cm189_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP23_1 (XI0_I1597_ap5 I0_cm190_0 XI0_I1597_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1597_MP24_1 (XI0_I1597_asn I0_cm105_0 XI0_I1597_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1597_MP17 (XI0_I1597_acon I0_cm105_0 XI0_I1597_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1597_MP14 (XI0_I1597_ap1 I0_cm190_0 XI0_I1597_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP13 (VDD I0_cm189_1 XI0_I1597_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP15 (XI0_I1597_ap2 I0_cm189_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP16 (VDD I0_cm190_0 XI0_I1597_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1597_MP28 (I0_cm236_2 XI0_I1597_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1597_MP19 (XI0_I1597_ap3 I0_cm190_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1597_MP20 (VDD I0_cm105_0 XI0_I1597_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1551_MP50 (VDD XI0_I1551_s1 XI0_I1551_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1551_MP47 (XI0_I1551_bp3 I0_cm104_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1551_MP49 (XI0_I1551_bsn XI0_I1551_bcon XI0_I1551_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1551_MP52 (XI0_I1551_bp5 I0_cm189_2 XI0_I1551_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1551_MP51 (XI0_I1551_bp4 I0_cm104_0 XI0_I1551_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP51_1 (XI0_I1551_bp5 I0_cm104_0 XI0_I1551_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP52_1 (XI0_I1551_bsn I0_cm189_2 XI0_I1551_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1551_MP54 (VDD XI0_I1551_bsn I0_cm190_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1551_MP41 (XI0_I1551_bp1 XI0_I1551_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP42 (XI0_I1551_bcon I0_cm104_0 XI0_I1551_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP45 (XI0_I1551_bp2 I0_cm189_2 XI0_I1551_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP43 (VDD XI0_I1551_s1 XI0_I1551_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP44 (XI0_I1551_bp2 I0_cm104_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1551_MP56 (VDD XI0_I1551_bcon I0_cm190_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1551_MP46 (XI0_I1551_bp3 XI0_I1551_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP48 (VDD I0_cm189_2 XI0_I1551_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP50_1 (XI0_I1551_bp4 XI0_I1551_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1551_MP26 (VDD XI0_I1551_asn XI0_I1551_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1551_MP18 (XI0_I1551_ap3 I0_cm101_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1551_MP21 (XI0_I1551_asn XI0_I1551_acon XI0_I1551_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP24 (XI0_I1551_ap5 I0_cm103_1 XI0_I1551_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1551_MP23 (XI0_I1551_ap4 I0_cm102_1 XI0_I1551_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP22 (VDD I0_cm101_1 XI0_I1551_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP22_1 (XI0_I1551_ap4 I0_cm101_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP23_1 (XI0_I1551_ap5 I0_cm102_1 XI0_I1551_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1551_MP24_1 (XI0_I1551_asn I0_cm103_1 XI0_I1551_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1551_MP17 (XI0_I1551_acon I0_cm103_1 XI0_I1551_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1551_MP14 (XI0_I1551_ap1 I0_cm102_1 XI0_I1551_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP13 (VDD I0_cm101_1 XI0_I1551_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP15 (XI0_I1551_ap2 I0_cm101_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP16 (VDD I0_cm102_1 XI0_I1551_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1551_MP28 (I0_cm190_2 XI0_I1551_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1551_MP19 (XI0_I1551_ap3 I0_cm102_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1551_MP20 (VDD I0_cm103_1 XI0_I1551_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1425_MP50 (VDD XI0_I1425_s1 XI0_I1425_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1425_MP47 (XI0_I1425_bp3 I0_pp15_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1425_MP49 (XI0_I1425_bsn XI0_I1425_bcon XI0_I1425_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1425_MP52 (XI0_I1425_bp5 I0_B_31_b3_5 XI0_I1425_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1425_MP51 (XI0_I1425_bp4 I0_pp15_0 XI0_I1425_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP51_1 (XI0_I1425_bp5 I0_pp15_0 XI0_I1425_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP52_1 (XI0_I1425_bsn I0_B_31_b3_5 XI0_I1425_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1425_MP54 (VDD XI0_I1425_bsn I0_cm64_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1425_MP41 (XI0_I1425_bp1 XI0_I1425_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP42 (XI0_I1425_bcon I0_pp15_0 XI0_I1425_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP45 (XI0_I1425_bp2 I0_B_31_b3_5 XI0_I1425_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP43 (VDD XI0_I1425_s1 XI0_I1425_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP44 (XI0_I1425_bp2 I0_pp15_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1425_MP56 (VDD XI0_I1425_bcon I0_cm64_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1425_MP46 (XI0_I1425_bp3 XI0_I1425_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP48 (VDD I0_B_31_b3_5 XI0_I1425_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP50_1 (XI0_I1425_bp4 XI0_I1425_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1425_MP26 (VDD XI0_I1425_asn XI0_I1425_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1425_MP18 (XI0_I1425_ap3 I0_pp12_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1425_MP21 (XI0_I1425_asn XI0_I1425_acon XI0_I1425_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP24 (XI0_I1425_ap5 I0_pp14_2 XI0_I1425_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1425_MP23 (XI0_I1425_ap4 I0_pp13_4 XI0_I1425_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP22 (VDD I0_pp12_6 XI0_I1425_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP22_1 (XI0_I1425_ap4 I0_pp12_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP23_1 (XI0_I1425_ap5 I0_pp13_4 XI0_I1425_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1425_MP24_1 (XI0_I1425_asn I0_pp14_2 XI0_I1425_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1425_MP17 (XI0_I1425_acon I0_pp14_2 XI0_I1425_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1425_MP14 (XI0_I1425_ap1 I0_pp13_4 XI0_I1425_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP13 (VDD I0_pp12_6 XI0_I1425_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP15 (XI0_I1425_ap2 I0_pp12_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP16 (VDD I0_pp13_4 XI0_I1425_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1425_MP28 (I0_cm64_2 XI0_I1425_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1425_MP19 (XI0_I1425_ap3 I0_pp13_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1425_MP20 (VDD I0_pp14_2 XI0_I1425_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1467_MP50 (VDD XI0_I1467_s1 XI0_I1467_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1467_MP47 (XI0_I1467_bp3 I0_pp15_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1467_MP49 (XI0_I1467_bsn XI0_I1467_bcon XI0_I1467_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1467_MP52 (XI0_I1467_bp5 I0_cm103_2 XI0_I1467_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1467_MP51 (XI0_I1467_bp4 I0_pp15_12 XI0_I1467_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP51_1 (XI0_I1467_bp5 I0_pp15_12 XI0_I1467_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP52_1 (XI0_I1467_bsn I0_cm103_2 XI0_I1467_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1467_MP54 (VDD XI0_I1467_bsn I0_cm106_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1467_MP41 (XI0_I1467_bp1 XI0_I1467_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP42 (XI0_I1467_bcon I0_pp15_12 XI0_I1467_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP45 (XI0_I1467_bp2 I0_cm103_2 XI0_I1467_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP43 (VDD XI0_I1467_s1 XI0_I1467_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP44 (XI0_I1467_bp2 I0_pp15_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1467_MP56 (VDD XI0_I1467_bcon I0_cm106_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1467_MP46 (XI0_I1467_bp3 XI0_I1467_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP48 (VDD I0_cm103_2 XI0_I1467_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP50_1 (XI0_I1467_bp4 XI0_I1467_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1467_MP26 (VDD XI0_I1467_asn XI0_I1467_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1467_MP18 (XI0_I1467_ap3 I0_pp12_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1467_MP21 (XI0_I1467_asn XI0_I1467_acon XI0_I1467_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP24 (XI0_I1467_ap5 I0_pp14_14 XI0_I1467_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1467_MP23 (XI0_I1467_ap4 I0_pp13_16 XI0_I1467_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP22 (VDD I0_pp12_18 XI0_I1467_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP22_1 (XI0_I1467_ap4 I0_pp12_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP23_1 (XI0_I1467_ap5 I0_pp13_16 XI0_I1467_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1467_MP24_1 (XI0_I1467_asn I0_pp14_14 XI0_I1467_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1467_MP17 (XI0_I1467_acon I0_pp14_14 XI0_I1467_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1467_MP14 (XI0_I1467_ap1 I0_pp13_16 XI0_I1467_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP13 (VDD I0_pp12_18 XI0_I1467_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP15 (XI0_I1467_ap2 I0_pp12_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP16 (VDD I0_pp13_16 XI0_I1467_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1467_MP28 (I0_cm106_2 XI0_I1467_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1467_MP19 (XI0_I1467_ap3 I0_pp13_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1467_MP20 (VDD I0_pp14_14 XI0_I1467_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1552_MP50 (VDD XI0_I1552_s1 XI0_I1552_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1552_MP47 (XI0_I1552_bp3 I0_cm107_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1552_MP49 (XI0_I1552_bsn XI0_I1552_bcon XI0_I1552_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1552_MP52 (XI0_I1552_bp5 I0_cm190_2 XI0_I1552_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1552_MP51 (XI0_I1552_bp4 I0_cm107_0 XI0_I1552_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP51_1 (XI0_I1552_bp5 I0_cm107_0 XI0_I1552_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP52_1 (XI0_I1552_bsn I0_cm190_2 XI0_I1552_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1552_MP54 (VDD XI0_I1552_bsn I0_cm191_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1552_MP41 (XI0_I1552_bp1 XI0_I1552_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP42 (XI0_I1552_bcon I0_cm107_0 XI0_I1552_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP45 (XI0_I1552_bp2 I0_cm190_2 XI0_I1552_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP43 (VDD XI0_I1552_s1 XI0_I1552_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP44 (XI0_I1552_bp2 I0_cm107_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1552_MP56 (VDD XI0_I1552_bcon I0_cm191_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1552_MP46 (XI0_I1552_bp3 XI0_I1552_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP48 (VDD I0_cm190_2 XI0_I1552_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP50_1 (XI0_I1552_bp4 XI0_I1552_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1552_MP26 (VDD XI0_I1552_asn XI0_I1552_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1552_MP18 (XI0_I1552_ap3 I0_cm104_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1552_MP21 (XI0_I1552_asn XI0_I1552_acon XI0_I1552_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP24 (XI0_I1552_ap5 I0_cm106_1 XI0_I1552_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1552_MP23 (XI0_I1552_ap4 I0_cm105_1 XI0_I1552_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP22 (VDD I0_cm104_1 XI0_I1552_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP22_1 (XI0_I1552_ap4 I0_cm104_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP23_1 (XI0_I1552_ap5 I0_cm105_1 XI0_I1552_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1552_MP24_1 (XI0_I1552_asn I0_cm106_1 XI0_I1552_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1552_MP17 (XI0_I1552_acon I0_cm106_1 XI0_I1552_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1552_MP14 (XI0_I1552_ap1 I0_cm105_1 XI0_I1552_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP13 (VDD I0_cm104_1 XI0_I1552_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP15 (XI0_I1552_ap2 I0_cm104_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP16 (VDD I0_cm105_1 XI0_I1552_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1552_MP28 (I0_cm191_2 XI0_I1552_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1552_MP19 (XI0_I1552_ap3 I0_cm105_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1552_MP20 (VDD I0_cm106_1 XI0_I1552_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1466_MP50 (VDD XI0_I1466_s1 XI0_I1466_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1466_MP47 (XI0_I1466_bp3 I0_pp11_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1466_MP49 (XI0_I1466_bsn XI0_I1466_bcon XI0_I1466_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1466_MP52 (XI0_I1466_bp5 I0_cm102_2 XI0_I1466_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1466_MP51 (XI0_I1466_bp4 I0_pp11_20 XI0_I1466_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP51_1 (XI0_I1466_bp5 I0_pp11_20 XI0_I1466_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP52_1 (XI0_I1466_bsn I0_cm102_2 XI0_I1466_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1466_MP54 (VDD XI0_I1466_bsn I0_cm105_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1466_MP41 (XI0_I1466_bp1 XI0_I1466_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP42 (XI0_I1466_bcon I0_pp11_20 XI0_I1466_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP45 (XI0_I1466_bp2 I0_cm102_2 XI0_I1466_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP43 (VDD XI0_I1466_s1 XI0_I1466_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP44 (XI0_I1466_bp2 I0_pp11_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1466_MP56 (VDD XI0_I1466_bcon I0_cm105_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1466_MP46 (XI0_I1466_bp3 XI0_I1466_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP48 (VDD I0_cm102_2 XI0_I1466_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP50_1 (XI0_I1466_bp4 XI0_I1466_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1466_MP26 (VDD XI0_I1466_asn XI0_I1466_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1466_MP18 (XI0_I1466_ap3 I0_pp8_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1466_MP21 (XI0_I1466_asn XI0_I1466_acon XI0_I1466_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP24 (XI0_I1466_ap5 I0_pp10_22 XI0_I1466_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1466_MP23 (XI0_I1466_ap4 I0_pp9_24 XI0_I1466_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP22 (VDD I0_pp8_26 XI0_I1466_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP22_1 (XI0_I1466_ap4 I0_pp8_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP23_1 (XI0_I1466_ap5 I0_pp9_24 XI0_I1466_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1466_MP24_1 (XI0_I1466_asn I0_pp10_22 XI0_I1466_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1466_MP17 (XI0_I1466_acon I0_pp10_22 XI0_I1466_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1466_MP14 (XI0_I1466_ap1 I0_pp9_24 XI0_I1466_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP13 (VDD I0_pp8_26 XI0_I1466_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP15 (XI0_I1466_ap2 I0_pp8_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP16 (VDD I0_pp9_24 XI0_I1466_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1466_MP28 (I0_cm105_2 XI0_I1466_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1466_MP19 (XI0_I1466_ap3 I0_pp9_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1466_MP20 (VDD I0_pp10_22 XI0_I1466_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1599_MP50 (VDD XI0_I1599_s1 XI0_I1599_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1599_MP47 (XI0_I1599_bp3 I0_cm111_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1599_MP49 (XI0_I1599_bsn XI0_I1599_bcon XI0_I1599_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1599_MP52 (XI0_I1599_bp5 I0_fa112_0 XI0_I1599_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1599_MP51 (XI0_I1599_bp4 I0_cm111_0 XI0_I1599_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP51_1 (XI0_I1599_bp5 I0_cm111_0 XI0_I1599_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP52_1 (XI0_I1599_bsn I0_fa112_0 XI0_I1599_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1599_MP54 (VDD XI0_I1599_bsn I0_cm238_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1599_MP41 (XI0_I1599_bp1 XI0_I1599_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP42 (XI0_I1599_bcon I0_cm111_0 XI0_I1599_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP45 (XI0_I1599_bp2 I0_fa112_0 XI0_I1599_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP43 (VDD XI0_I1599_s1 XI0_I1599_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP44 (XI0_I1599_bp2 I0_cm111_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1599_MP56 (VDD XI0_I1599_bcon I0_cm238_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1599_MP46 (XI0_I1599_bp3 XI0_I1599_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP48 (VDD I0_fa112_0 XI0_I1599_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP50_1 (XI0_I1599_bp4 XI0_I1599_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1599_MP26 (VDD XI0_I1599_asn XI0_I1599_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1599_MP18 (XI0_I1599_ap3 I0_cm191_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1599_MP21 (XI0_I1599_asn XI0_I1599_acon XI0_I1599_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP24 (XI0_I1599_ap5 I0_cm193_0 XI0_I1599_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1599_MP23 (XI0_I1599_ap4 I0_fa192_1 XI0_I1599_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP22 (VDD I0_cm191_1 XI0_I1599_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP22_1 (XI0_I1599_ap4 I0_cm191_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP23_1 (XI0_I1599_ap5 I0_fa192_1 XI0_I1599_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1599_MP24_1 (XI0_I1599_asn I0_cm193_0 XI0_I1599_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1599_MP17 (XI0_I1599_acon I0_cm193_0 XI0_I1599_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1599_MP14 (XI0_I1599_ap1 I0_fa192_1 XI0_I1599_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP13 (VDD I0_cm191_1 XI0_I1599_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP15 (XI0_I1599_ap2 I0_cm191_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP16 (VDD I0_fa192_1 XI0_I1599_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1599_MP28 (I0_cm238_2 XI0_I1599_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1599_MP19 (XI0_I1599_ap3 I0_fa192_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1599_MP20 (VDD I0_cm193_0 XI0_I1599_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1554_MP50 (VDD XI0_I1554_s1 XI0_I1554_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1554_MP47 (XI0_I1554_bp3 I0_cm110_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1554_MP49 (XI0_I1554_bsn XI0_I1554_bcon XI0_I1554_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1554_MP52 (XI0_I1554_bp5 I0_cm191_2 XI0_I1554_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1554_MP51 (XI0_I1554_bp4 I0_cm110_0 XI0_I1554_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP51_1 (XI0_I1554_bp5 I0_cm110_0 XI0_I1554_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP52_1 (XI0_I1554_bsn I0_cm191_2 XI0_I1554_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1554_MP54 (VDD XI0_I1554_bsn I0_cm193_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1554_MP41 (XI0_I1554_bp1 XI0_I1554_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP42 (XI0_I1554_bcon I0_cm110_0 XI0_I1554_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP45 (XI0_I1554_bp2 I0_cm191_2 XI0_I1554_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP43 (VDD XI0_I1554_s1 XI0_I1554_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP44 (XI0_I1554_bp2 I0_cm110_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1554_MP56 (VDD XI0_I1554_bcon I0_cm193_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1554_MP46 (XI0_I1554_bp3 XI0_I1554_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP48 (VDD I0_cm191_2 XI0_I1554_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP50_1 (XI0_I1554_bp4 XI0_I1554_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1554_MP26 (VDD XI0_I1554_asn XI0_I1554_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1554_MP18 (XI0_I1554_ap3 I0_cm107_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1554_MP21 (XI0_I1554_asn XI0_I1554_acon XI0_I1554_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP24 (XI0_I1554_ap5 I0_fa109_1 XI0_I1554_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1554_MP23 (XI0_I1554_ap4 I0_cm108_1 XI0_I1554_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP22 (VDD I0_cm107_1 XI0_I1554_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP22_1 (XI0_I1554_ap4 I0_cm107_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP23_1 (XI0_I1554_ap5 I0_cm108_1 XI0_I1554_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1554_MP24_1 (XI0_I1554_asn I0_fa109_1 XI0_I1554_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1554_MP17 (XI0_I1554_acon I0_fa109_1 XI0_I1554_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1554_MP14 (XI0_I1554_ap1 I0_cm108_1 XI0_I1554_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP13 (VDD I0_cm107_1 XI0_I1554_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP15 (XI0_I1554_ap2 I0_cm107_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP16 (VDD I0_cm108_1 XI0_I1554_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1554_MP28 (I0_cm193_2 XI0_I1554_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1554_MP19 (XI0_I1554_ap3 I0_cm108_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1554_MP20 (VDD I0_fa109_1 XI0_I1554_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1469_MP50 (VDD XI0_I1469_s1 XI0_I1469_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1469_MP47 (XI0_I1469_bp3 I0_pp12_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1469_MP49 (XI0_I1469_bsn XI0_I1469_bcon XI0_I1469_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1469_MP52 (XI0_I1469_bp5 I0_cm105_2 XI0_I1469_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1469_MP51 (XI0_I1469_bp4 I0_pp12_19 XI0_I1469_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP51_1 (XI0_I1469_bp5 I0_pp12_19 XI0_I1469_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP52_1 (XI0_I1469_bsn I0_cm105_2 XI0_I1469_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1469_MP54 (VDD XI0_I1469_bsn I0_cm108_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1469_MP41 (XI0_I1469_bp1 XI0_I1469_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP42 (XI0_I1469_bcon I0_pp12_19 XI0_I1469_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP45 (XI0_I1469_bp2 I0_cm105_2 XI0_I1469_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP43 (VDD XI0_I1469_s1 XI0_I1469_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP44 (XI0_I1469_bp2 I0_pp12_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1469_MP56 (VDD XI0_I1469_bcon I0_cm108_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1469_MP46 (XI0_I1469_bp3 XI0_I1469_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP48 (VDD I0_cm105_2 XI0_I1469_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP50_1 (XI0_I1469_bp4 XI0_I1469_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1469_MP26 (VDD XI0_I1469_asn XI0_I1469_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1469_MP18 (XI0_I1469_ap3 I0_pp9_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1469_MP21 (XI0_I1469_asn XI0_I1469_acon XI0_I1469_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP24 (XI0_I1469_ap5 I0_pp11_21 XI0_I1469_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1469_MP23 (XI0_I1469_ap4 I0_pp10_23 XI0_I1469_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP22 (VDD I0_pp9_25 XI0_I1469_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP22_1 (XI0_I1469_ap4 I0_pp9_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP23_1 (XI0_I1469_ap5 I0_pp10_23 XI0_I1469_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1469_MP24_1 (XI0_I1469_asn I0_pp11_21 XI0_I1469_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1469_MP17 (XI0_I1469_acon I0_pp11_21 XI0_I1469_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1469_MP14 (XI0_I1469_ap1 I0_pp10_23 XI0_I1469_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP13 (VDD I0_pp9_25 XI0_I1469_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP15 (XI0_I1469_ap2 I0_pp9_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP16 (VDD I0_pp10_23 XI0_I1469_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1469_MP28 (I0_cm108_2 XI0_I1469_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1469_MP19 (XI0_I1469_ap3 I0_pp10_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1469_MP20 (VDD I0_pp11_21 XI0_I1469_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1472_MP50 (VDD XI0_I1472_s1 XI0_I1472_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1472_MP47 (XI0_I1472_bp3 I0_pp12_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1472_MP49 (XI0_I1472_bsn XI0_I1472_bcon XI0_I1472_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1472_MP52 (XI0_I1472_bp5 I0_cm108_2 XI0_I1472_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1472_MP51 (XI0_I1472_bp4 I0_pp12_20 XI0_I1472_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP51_1 (XI0_I1472_bp5 I0_pp12_20 XI0_I1472_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP52_1 (XI0_I1472_bsn I0_cm108_2 XI0_I1472_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1472_MP54 (VDD XI0_I1472_bsn I0_cm111_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1472_MP41 (XI0_I1472_bp1 XI0_I1472_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP42 (XI0_I1472_bcon I0_pp12_20 XI0_I1472_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP45 (XI0_I1472_bp2 I0_cm108_2 XI0_I1472_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP43 (VDD XI0_I1472_s1 XI0_I1472_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP44 (XI0_I1472_bp2 I0_pp12_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1472_MP56 (VDD XI0_I1472_bcon I0_cm111_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1472_MP46 (XI0_I1472_bp3 XI0_I1472_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP48 (VDD I0_cm108_2 XI0_I1472_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP50_1 (XI0_I1472_bp4 XI0_I1472_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1472_MP26 (VDD XI0_I1472_asn XI0_I1472_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1472_MP18 (XI0_I1472_ap3 I0_pp9_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1472_MP21 (XI0_I1472_asn XI0_I1472_acon XI0_I1472_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP24 (XI0_I1472_ap5 I0_pp11_22 XI0_I1472_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1472_MP23 (XI0_I1472_ap4 I0_pp10_24 XI0_I1472_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP22 (VDD I0_pp9_26 XI0_I1472_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP22_1 (XI0_I1472_ap4 I0_pp9_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP23_1 (XI0_I1472_ap5 I0_pp10_24 XI0_I1472_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1472_MP24_1 (XI0_I1472_asn I0_pp11_22 XI0_I1472_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1472_MP17 (XI0_I1472_acon I0_pp11_22 XI0_I1472_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1472_MP14 (XI0_I1472_ap1 I0_pp10_24 XI0_I1472_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP13 (VDD I0_pp9_26 XI0_I1472_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP15 (XI0_I1472_ap2 I0_pp9_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP16 (VDD I0_pp10_24 XI0_I1472_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1472_MP28 (I0_cm111_2 XI0_I1472_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1472_MP19 (XI0_I1472_ap3 I0_pp10_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1472_MP20 (VDD I0_pp11_22 XI0_I1472_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1471_MP50 (VDD XI0_I1471_s1 XI0_I1471_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1471_MP47 (XI0_I1471_bp3 I0_pp8_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1471_MP49 (XI0_I1471_bsn XI0_I1471_bcon XI0_I1471_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1471_MP52 (XI0_I1471_bp5 I0_cm107_2 XI0_I1471_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1471_MP51 (XI0_I1471_bp4 I0_pp8_28 XI0_I1471_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP51_1 (XI0_I1471_bp5 I0_pp8_28 XI0_I1471_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP52_1 (XI0_I1471_bsn I0_cm107_2 XI0_I1471_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1471_MP54 (VDD XI0_I1471_bsn I0_cm110_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1471_MP41 (XI0_I1471_bp1 XI0_I1471_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP42 (XI0_I1471_bcon I0_pp8_28 XI0_I1471_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP45 (XI0_I1471_bp2 I0_cm107_2 XI0_I1471_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP43 (VDD XI0_I1471_s1 XI0_I1471_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP44 (XI0_I1471_bp2 I0_pp8_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1471_MP56 (VDD XI0_I1471_bcon I0_cm110_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1471_MP46 (XI0_I1471_bp3 XI0_I1471_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP48 (VDD I0_cm107_2 XI0_I1471_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP50_1 (XI0_I1471_bp4 XI0_I1471_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1471_MP26 (VDD XI0_I1471_asn XI0_I1471_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1471_MP18 (XI0_I1471_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1471_MP21 (XI0_I1471_asn XI0_I1471_acon XI0_I1471_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP24 (XI0_I1471_ap5 I0_pp7_30 XI0_I1471_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1471_MP23 (XI0_I1471_ap4 I0_pp6_32 XI0_I1471_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP22 (VDD VDD XI0_I1471_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP22_1 (XI0_I1471_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP23_1 (XI0_I1471_ap5 I0_pp6_32 XI0_I1471_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1471_MP24_1 (XI0_I1471_asn I0_pp7_30 XI0_I1471_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1471_MP17 (XI0_I1471_acon I0_pp7_30 XI0_I1471_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1471_MP14 (XI0_I1471_ap1 I0_pp6_32 XI0_I1471_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP13 (VDD VDD XI0_I1471_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP15 (XI0_I1471_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP16 (VDD I0_pp6_32 XI0_I1471_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1471_MP28 (I0_cm110_2 XI0_I1471_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1471_MP19 (XI0_I1471_ap3 I0_pp6_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1471_MP20 (VDD I0_pp7_30 XI0_I1471_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1475_MP50 (VDD XI0_I1475_s1 XI0_I1475_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1475_MP47 (XI0_I1475_bp3 I0_pp13_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1475_MP49 (XI0_I1475_bsn XI0_I1475_bcon XI0_I1475_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1475_MP52 (XI0_I1475_bp5 I0_cm111_2 XI0_I1475_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1475_MP51 (XI0_I1475_bp4 I0_pp13_19 XI0_I1475_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP51_1 (XI0_I1475_bp5 I0_pp13_19 XI0_I1475_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP52_1 (XI0_I1475_bsn I0_cm111_2 XI0_I1475_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1475_MP54 (VDD XI0_I1475_bsn I0_cm114_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1475_MP41 (XI0_I1475_bp1 XI0_I1475_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP42 (XI0_I1475_bcon I0_pp13_19 XI0_I1475_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP45 (XI0_I1475_bp2 I0_cm111_2 XI0_I1475_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP43 (VDD XI0_I1475_s1 XI0_I1475_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP44 (XI0_I1475_bp2 I0_pp13_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1475_MP56 (VDD XI0_I1475_bcon I0_cm114_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1475_MP46 (XI0_I1475_bp3 XI0_I1475_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP48 (VDD I0_cm111_2 XI0_I1475_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP50_1 (XI0_I1475_bp4 XI0_I1475_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1475_MP26 (VDD XI0_I1475_asn XI0_I1475_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1475_MP18 (XI0_I1475_ap3 I0_pp10_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1475_MP21 (XI0_I1475_asn XI0_I1475_acon XI0_I1475_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP24 (XI0_I1475_ap5 I0_pp12_21 XI0_I1475_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1475_MP23 (XI0_I1475_ap4 I0_pp11_23 XI0_I1475_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP22 (VDD I0_pp10_25 XI0_I1475_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP22_1 (XI0_I1475_ap4 I0_pp10_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP23_1 (XI0_I1475_ap5 I0_pp11_23 XI0_I1475_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1475_MP24_1 (XI0_I1475_asn I0_pp12_21 XI0_I1475_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1475_MP17 (XI0_I1475_acon I0_pp12_21 XI0_I1475_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1475_MP14 (XI0_I1475_ap1 I0_pp11_23 XI0_I1475_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP13 (VDD I0_pp10_25 XI0_I1475_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP15 (XI0_I1475_ap2 I0_pp10_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP16 (VDD I0_pp11_23 XI0_I1475_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1475_MP28 (I0_cm114_2 XI0_I1475_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1475_MP19 (XI0_I1475_ap3 I0_pp11_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1475_MP20 (VDD I0_pp12_21 XI0_I1475_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1555_MP50 (VDD XI0_I1555_s1 XI0_I1555_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1555_MP47 (XI0_I1555_bp3 I0_cm113_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1555_MP49 (XI0_I1555_bsn XI0_I1555_bcon XI0_I1555_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1555_MP52 (XI0_I1555_bp5 I0_cm193_2 XI0_I1555_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1555_MP51 (XI0_I1555_bp4 I0_cm113_0 XI0_I1555_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP51_1 (XI0_I1555_bp5 I0_cm113_0 XI0_I1555_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP52_1 (XI0_I1555_bsn I0_cm193_2 XI0_I1555_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1555_MP54 (VDD XI0_I1555_bsn I0_cm194_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1555_MP41 (XI0_I1555_bp1 XI0_I1555_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP42 (XI0_I1555_bcon I0_cm113_0 XI0_I1555_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP45 (XI0_I1555_bp2 I0_cm193_2 XI0_I1555_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP43 (VDD XI0_I1555_s1 XI0_I1555_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP44 (XI0_I1555_bp2 I0_cm113_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1555_MP56 (VDD XI0_I1555_bcon I0_cm194_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1555_MP46 (XI0_I1555_bp3 XI0_I1555_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP48 (VDD I0_cm193_2 XI0_I1555_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP50_1 (XI0_I1555_bp4 XI0_I1555_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1555_MP26 (VDD XI0_I1555_asn XI0_I1555_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1555_MP18 (XI0_I1555_ap3 I0_cm110_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1555_MP21 (XI0_I1555_asn XI0_I1555_acon XI0_I1555_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP24 (XI0_I1555_ap5 I0_fa112_1 XI0_I1555_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1555_MP23 (XI0_I1555_ap4 I0_cm111_1 XI0_I1555_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP22 (VDD I0_cm110_1 XI0_I1555_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP22_1 (XI0_I1555_ap4 I0_cm110_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP23_1 (XI0_I1555_ap5 I0_cm111_1 XI0_I1555_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1555_MP24_1 (XI0_I1555_asn I0_fa112_1 XI0_I1555_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1555_MP17 (XI0_I1555_acon I0_fa112_1 XI0_I1555_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1555_MP14 (XI0_I1555_ap1 I0_cm111_1 XI0_I1555_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP13 (VDD I0_cm110_1 XI0_I1555_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP15 (XI0_I1555_ap2 I0_cm110_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP16 (VDD I0_cm111_1 XI0_I1555_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1555_MP28 (I0_cm194_2 XI0_I1555_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1555_MP19 (XI0_I1555_ap3 I0_cm111_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1555_MP20 (VDD I0_fa112_1 XI0_I1555_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1474_MP50 (VDD XI0_I1474_s1 XI0_I1474_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1474_MP47 (XI0_I1474_bp3 I0_pp9_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1474_MP49 (XI0_I1474_bsn XI0_I1474_bcon XI0_I1474_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1474_MP52 (XI0_I1474_bp5 I0_cm110_2 XI0_I1474_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1474_MP51 (XI0_I1474_bp4 I0_pp9_27 XI0_I1474_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP51_1 (XI0_I1474_bp5 I0_pp9_27 XI0_I1474_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP52_1 (XI0_I1474_bsn I0_cm110_2 XI0_I1474_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1474_MP54 (VDD XI0_I1474_bsn I0_cm113_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1474_MP41 (XI0_I1474_bp1 XI0_I1474_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP42 (XI0_I1474_bcon I0_pp9_27 XI0_I1474_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP45 (XI0_I1474_bp2 I0_cm110_2 XI0_I1474_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP43 (VDD XI0_I1474_s1 XI0_I1474_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP44 (XI0_I1474_bp2 I0_pp9_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1474_MP56 (VDD XI0_I1474_bcon I0_cm113_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1474_MP46 (XI0_I1474_bp3 XI0_I1474_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP48 (VDD I0_cm110_2 XI0_I1474_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP50_1 (XI0_I1474_bp4 XI0_I1474_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1474_MP26 (VDD XI0_I1474_asn XI0_I1474_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1474_MP18 (XI0_I1474_ap3 I0_sn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1474_MP21 (XI0_I1474_asn XI0_I1474_acon XI0_I1474_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP24 (XI0_I1474_ap5 I0_pp8_29 XI0_I1474_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1474_MP23 (XI0_I1474_ap4 I0_pp7_31 XI0_I1474_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP22 (VDD I0_sn6 XI0_I1474_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP22_1 (XI0_I1474_ap4 I0_sn6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP23_1 (XI0_I1474_ap5 I0_pp7_31 XI0_I1474_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1474_MP24_1 (XI0_I1474_asn I0_pp8_29 XI0_I1474_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1474_MP17 (XI0_I1474_acon I0_pp8_29 XI0_I1474_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1474_MP14 (XI0_I1474_ap1 I0_pp7_31 XI0_I1474_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP13 (VDD I0_sn6 XI0_I1474_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP15 (XI0_I1474_ap2 I0_sn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP16 (VDD I0_pp7_31 XI0_I1474_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1474_MP28 (I0_cm113_2 XI0_I1474_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1474_MP19 (XI0_I1474_ap3 I0_pp7_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1474_MP20 (VDD I0_pp8_29 XI0_I1474_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1492_MP50 (VDD XI0_I1492_s1 XI0_I1492_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1492_MP47 (XI0_I1492_bp3 I0_pp14_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1492_MP49 (XI0_I1492_bsn XI0_I1492_bcon XI0_I1492_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1492_MP52 (XI0_I1492_bp5 I0_cm130_2 XI0_I1492_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1492_MP51 (XI0_I1492_bp4 I0_pp14_27 XI0_I1492_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP51_1 (XI0_I1492_bp5 I0_pp14_27 XI0_I1492_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP52_1 (XI0_I1492_bsn I0_cm130_2 XI0_I1492_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1492_MP54 (VDD XI0_I1492_bsn I0_cm131_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1492_MP41 (XI0_I1492_bp1 XI0_I1492_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP42 (XI0_I1492_bcon I0_pp14_27 XI0_I1492_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP45 (XI0_I1492_bp2 I0_cm130_2 XI0_I1492_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP43 (VDD XI0_I1492_s1 XI0_I1492_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP44 (XI0_I1492_bp2 I0_pp14_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1492_MP56 (VDD XI0_I1492_bcon I0_cm131_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1492_MP46 (XI0_I1492_bp3 XI0_I1492_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP48 (VDD I0_cm130_2 XI0_I1492_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP50_1 (XI0_I1492_bp4 XI0_I1492_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1492_MP26 (VDD XI0_I1492_asn XI0_I1492_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1492_MP18 (XI0_I1492_ap3 I0_sn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1492_MP21 (XI0_I1492_asn XI0_I1492_acon XI0_I1492_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP24 (XI0_I1492_ap5 I0_pp13_29 XI0_I1492_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1492_MP23 (XI0_I1492_ap4 I0_pp12_31 XI0_I1492_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP22 (VDD I0_sn11 XI0_I1492_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP22_1 (XI0_I1492_ap4 I0_sn11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP23_1 (XI0_I1492_ap5 I0_pp12_31 XI0_I1492_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1492_MP24_1 (XI0_I1492_asn I0_pp13_29 XI0_I1492_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1492_MP17 (XI0_I1492_acon I0_pp13_29 XI0_I1492_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1492_MP14 (XI0_I1492_ap1 I0_pp12_31 XI0_I1492_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP13 (VDD I0_sn11 XI0_I1492_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP15 (XI0_I1492_ap2 I0_sn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP16 (VDD I0_pp12_31 XI0_I1492_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1492_MP28 (I0_cm131_2 XI0_I1492_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1492_MP19 (XI0_I1492_ap3 I0_pp12_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1492_MP20 (VDD I0_pp13_29 XI0_I1492_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1601_MP50 (VDD XI0_I1601_s1 XI0_I1601_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1601_MP47 (XI0_I1601_bp3 I0_pp14_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1601_MP49 (XI0_I1601_bsn XI0_I1601_bcon XI0_I1601_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1601_MP52 (XI0_I1601_bp5 I0_pp15_16 XI0_I1601_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1601_MP51 (XI0_I1601_bp4 I0_pp14_18 XI0_I1601_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP51_1 (XI0_I1601_bp5 I0_pp14_18 XI0_I1601_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP52_1 (XI0_I1601_bsn I0_pp15_16 XI0_I1601_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1601_MP54 (VDD XI0_I1601_bsn I0_cm240_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1601_MP41 (XI0_I1601_bp1 XI0_I1601_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP42 (XI0_I1601_bcon I0_pp14_18 XI0_I1601_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP45 (XI0_I1601_bp2 I0_pp15_16 XI0_I1601_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP43 (VDD XI0_I1601_s1 XI0_I1601_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP44 (XI0_I1601_bp2 I0_pp14_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1601_MP56 (VDD XI0_I1601_bcon I0_cm240_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1601_MP46 (XI0_I1601_bp3 XI0_I1601_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP48 (VDD I0_pp15_16 XI0_I1601_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP50_1 (XI0_I1601_bp4 XI0_I1601_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1601_MP26 (VDD XI0_I1601_asn XI0_I1601_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1601_MP18 (XI0_I1601_ap3 I0_cm194_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1601_MP21 (XI0_I1601_asn XI0_I1601_acon XI0_I1601_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP24 (XI0_I1601_ap5 I0_cm196_0 XI0_I1601_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1601_MP23 (XI0_I1601_ap4 I0_fa195_1 XI0_I1601_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP22 (VDD I0_cm194_1 XI0_I1601_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP22_1 (XI0_I1601_ap4 I0_cm194_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP23_1 (XI0_I1601_ap5 I0_fa195_1 XI0_I1601_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1601_MP24_1 (XI0_I1601_asn I0_cm196_0 XI0_I1601_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1601_MP17 (XI0_I1601_acon I0_cm196_0 XI0_I1601_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1601_MP14 (XI0_I1601_ap1 I0_fa195_1 XI0_I1601_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP13 (VDD I0_cm194_1 XI0_I1601_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP15 (XI0_I1601_ap2 I0_cm194_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP16 (VDD I0_fa195_1 XI0_I1601_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1601_MP28 (I0_cm240_2 XI0_I1601_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1601_MP19 (XI0_I1601_ap3 I0_fa195_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1601_MP20 (VDD I0_cm196_0 XI0_I1601_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1477_MP50 (VDD XI0_I1477_s1 XI0_I1477_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1477_MP47 (XI0_I1477_bp3 I0_pp13_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1477_MP49 (XI0_I1477_bsn XI0_I1477_bcon XI0_I1477_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1477_MP52 (XI0_I1477_bp5 I0_cm114_2 XI0_I1477_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1477_MP51 (XI0_I1477_bp4 I0_pp13_20 XI0_I1477_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP51_1 (XI0_I1477_bp5 I0_pp13_20 XI0_I1477_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP52_1 (XI0_I1477_bsn I0_cm114_2 XI0_I1477_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1477_MP54 (VDD XI0_I1477_bsn I0_cm116_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1477_MP41 (XI0_I1477_bp1 XI0_I1477_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP42 (XI0_I1477_bcon I0_pp13_20 XI0_I1477_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP45 (XI0_I1477_bp2 I0_cm114_2 XI0_I1477_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP43 (VDD XI0_I1477_s1 XI0_I1477_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP44 (XI0_I1477_bp2 I0_pp13_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1477_MP56 (VDD XI0_I1477_bcon I0_cm116_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1477_MP46 (XI0_I1477_bp3 XI0_I1477_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP48 (VDD I0_cm114_2 XI0_I1477_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP50_1 (XI0_I1477_bp4 XI0_I1477_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1477_MP26 (VDD XI0_I1477_asn XI0_I1477_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1477_MP18 (XI0_I1477_ap3 I0_pp10_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1477_MP21 (XI0_I1477_asn XI0_I1477_acon XI0_I1477_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP24 (XI0_I1477_ap5 I0_pp12_22 XI0_I1477_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1477_MP23 (XI0_I1477_ap4 I0_pp11_24 XI0_I1477_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP22 (VDD I0_pp10_26 XI0_I1477_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP22_1 (XI0_I1477_ap4 I0_pp10_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP23_1 (XI0_I1477_ap5 I0_pp11_24 XI0_I1477_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1477_MP24_1 (XI0_I1477_asn I0_pp12_22 XI0_I1477_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1477_MP17 (XI0_I1477_acon I0_pp12_22 XI0_I1477_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1477_MP14 (XI0_I1477_ap1 I0_pp11_24 XI0_I1477_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP13 (VDD I0_pp10_26 XI0_I1477_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP15 (XI0_I1477_ap2 I0_pp10_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP16 (VDD I0_pp11_24 XI0_I1477_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1477_MP28 (I0_cm116_2 XI0_I1477_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1477_MP19 (XI0_I1477_ap3 I0_pp11_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1477_MP20 (VDD I0_pp12_22 XI0_I1477_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1557_MP50 (VDD XI0_I1557_s1 XI0_I1557_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1557_MP47 (XI0_I1557_bp3 I0_cm116_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1557_MP49 (XI0_I1557_bsn XI0_I1557_bcon XI0_I1557_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1557_MP52 (XI0_I1557_bp5 I0_cm194_2 XI0_I1557_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1557_MP51 (XI0_I1557_bp4 I0_cm116_0 XI0_I1557_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP51_1 (XI0_I1557_bp5 I0_cm116_0 XI0_I1557_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP52_1 (XI0_I1557_bsn I0_cm194_2 XI0_I1557_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1557_MP54 (VDD XI0_I1557_bsn I0_cm196_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1557_MP41 (XI0_I1557_bp1 XI0_I1557_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP42 (XI0_I1557_bcon I0_cm116_0 XI0_I1557_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP45 (XI0_I1557_bp2 I0_cm194_2 XI0_I1557_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP43 (VDD XI0_I1557_s1 XI0_I1557_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP44 (XI0_I1557_bp2 I0_cm116_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1557_MP56 (VDD XI0_I1557_bcon I0_cm196_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1557_MP46 (XI0_I1557_bp3 XI0_I1557_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP48 (VDD I0_cm194_2 XI0_I1557_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP50_1 (XI0_I1557_bp4 XI0_I1557_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1557_MP26 (VDD XI0_I1557_asn XI0_I1557_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1557_MP18 (XI0_I1557_ap3 I0_cm113_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1557_MP21 (XI0_I1557_asn XI0_I1557_acon XI0_I1557_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP24 (XI0_I1557_ap5 I0_cm115_0 XI0_I1557_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1557_MP23 (XI0_I1557_ap4 I0_cm114_1 XI0_I1557_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP22 (VDD I0_cm113_1 XI0_I1557_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP22_1 (XI0_I1557_ap4 I0_cm113_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP23_1 (XI0_I1557_ap5 I0_cm114_1 XI0_I1557_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1557_MP24_1 (XI0_I1557_asn I0_cm115_0 XI0_I1557_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1557_MP17 (XI0_I1557_acon I0_cm115_0 XI0_I1557_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1557_MP14 (XI0_I1557_ap1 I0_cm114_1 XI0_I1557_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP13 (VDD I0_cm113_1 XI0_I1557_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP15 (XI0_I1557_ap2 I0_cm113_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP16 (VDD I0_cm114_1 XI0_I1557_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1557_MP28 (I0_cm196_2 XI0_I1557_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1557_MP19 (XI0_I1557_ap3 I0_cm114_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1557_MP20 (VDD I0_cm115_0 XI0_I1557_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1493_MP50 (VDD XI0_I1493_s1 XI0_I1493_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1493_MP47 (XI0_I1493_bp3 I0_pp14_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1493_MP49 (XI0_I1493_bsn XI0_I1493_bcon XI0_I1493_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1493_MP52 (XI0_I1493_bp5 I0_cm131_2 XI0_I1493_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1493_MP51 (XI0_I1493_bp4 I0_pp14_28 XI0_I1493_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP51_1 (XI0_I1493_bp5 I0_pp14_28 XI0_I1493_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP52_1 (XI0_I1493_bsn I0_cm131_2 XI0_I1493_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1493_MP54 (VDD XI0_I1493_bsn I0_cm132_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1493_MP41 (XI0_I1493_bp1 XI0_I1493_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP42 (XI0_I1493_bcon I0_pp14_28 XI0_I1493_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP45 (XI0_I1493_bp2 I0_cm131_2 XI0_I1493_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP43 (VDD XI0_I1493_s1 XI0_I1493_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP44 (XI0_I1493_bp2 I0_pp14_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1493_MP56 (VDD XI0_I1493_bcon I0_cm132_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1493_MP46 (XI0_I1493_bp3 XI0_I1493_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP48 (VDD I0_cm131_2 XI0_I1493_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP50_1 (XI0_I1493_bp4 XI0_I1493_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1493_MP26 (VDD XI0_I1493_asn XI0_I1493_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1493_MP18 (XI0_I1493_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1493_MP21 (XI0_I1493_asn XI0_I1493_acon XI0_I1493_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP24 (XI0_I1493_ap5 I0_pp13_30 XI0_I1493_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1493_MP23 (XI0_I1493_ap4 I0_pp12_32 XI0_I1493_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP22 (VDD VDD XI0_I1493_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP22_1 (XI0_I1493_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP23_1 (XI0_I1493_ap5 I0_pp12_32 XI0_I1493_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1493_MP24_1 (XI0_I1493_asn I0_pp13_30 XI0_I1493_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1493_MP17 (XI0_I1493_acon I0_pp13_30 XI0_I1493_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1493_MP14 (XI0_I1493_ap1 I0_pp12_32 XI0_I1493_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP13 (VDD VDD XI0_I1493_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP15 (XI0_I1493_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP16 (VDD I0_pp12_32 XI0_I1493_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1493_MP28 (I0_cm132_2 XI0_I1493_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1493_MP19 (XI0_I1493_ap3 I0_pp12_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1493_MP20 (VDD I0_pp13_30 XI0_I1493_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1491_MP50 (VDD XI0_I1491_s1 XI0_I1491_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1491_MP47 (XI0_I1491_bp3 I0_pp13_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1491_MP49 (XI0_I1491_bsn XI0_I1491_bcon XI0_I1491_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1491_MP52 (XI0_I1491_bp5 I0_cm129_2 XI0_I1491_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1491_MP51 (XI0_I1491_bp4 I0_pp13_28 XI0_I1491_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP51_1 (XI0_I1491_bp5 I0_pp13_28 XI0_I1491_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP52_1 (XI0_I1491_bsn I0_cm129_2 XI0_I1491_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1491_MP54 (VDD XI0_I1491_bsn I0_cm130_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1491_MP41 (XI0_I1491_bp1 XI0_I1491_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP42 (XI0_I1491_bcon I0_pp13_28 XI0_I1491_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP45 (XI0_I1491_bp2 I0_cm129_2 XI0_I1491_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP43 (VDD XI0_I1491_s1 XI0_I1491_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP44 (XI0_I1491_bp2 I0_pp13_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1491_MP56 (VDD XI0_I1491_bcon I0_cm130_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1491_MP46 (XI0_I1491_bp3 XI0_I1491_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP48 (VDD I0_cm129_2 XI0_I1491_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP50_1 (XI0_I1491_bp4 XI0_I1491_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1491_MP26 (VDD XI0_I1491_asn XI0_I1491_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1491_MP18 (XI0_I1491_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1491_MP21 (XI0_I1491_asn XI0_I1491_acon XI0_I1491_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP24 (XI0_I1491_ap5 I0_pp12_30 XI0_I1491_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1491_MP23 (XI0_I1491_ap4 I0_pp11_32 XI0_I1491_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP22 (VDD VDD XI0_I1491_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP22_1 (XI0_I1491_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP23_1 (XI0_I1491_ap5 I0_pp11_32 XI0_I1491_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1491_MP24_1 (XI0_I1491_asn I0_pp12_30 XI0_I1491_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1491_MP17 (XI0_I1491_acon I0_pp12_30 XI0_I1491_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1491_MP14 (XI0_I1491_ap1 I0_pp11_32 XI0_I1491_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP13 (VDD VDD XI0_I1491_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP15 (XI0_I1491_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP16 (VDD I0_pp11_32 XI0_I1491_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1491_MP28 (I0_cm130_2 XI0_I1491_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1491_MP19 (XI0_I1491_ap3 I0_pp11_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1491_MP20 (VDD I0_pp12_30 XI0_I1491_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1476_MP50 (VDD XI0_I1476_s1 XI0_I1476_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1476_MP47 (XI0_I1476_bp3 I0_pp9_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1476_MP49 (XI0_I1476_bsn XI0_I1476_bcon XI0_I1476_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1476_MP52 (XI0_I1476_bp5 I0_cm113_2 XI0_I1476_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1476_MP51 (XI0_I1476_bp4 I0_pp9_28 XI0_I1476_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP51_1 (XI0_I1476_bp5 I0_pp9_28 XI0_I1476_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP52_1 (XI0_I1476_bsn I0_cm113_2 XI0_I1476_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1476_MP54 (VDD XI0_I1476_bsn I0_cm115_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1476_MP41 (XI0_I1476_bp1 XI0_I1476_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP42 (XI0_I1476_bcon I0_pp9_28 XI0_I1476_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP45 (XI0_I1476_bp2 I0_cm113_2 XI0_I1476_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP43 (VDD XI0_I1476_s1 XI0_I1476_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP44 (XI0_I1476_bp2 I0_pp9_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1476_MP56 (VDD XI0_I1476_bcon I0_cm115_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1476_MP46 (XI0_I1476_bp3 XI0_I1476_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP48 (VDD I0_cm113_2 XI0_I1476_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP50_1 (XI0_I1476_bp4 XI0_I1476_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1476_MP26 (VDD XI0_I1476_asn XI0_I1476_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1476_MP18 (XI0_I1476_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1476_MP21 (XI0_I1476_asn XI0_I1476_acon XI0_I1476_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP24 (XI0_I1476_ap5 I0_pp8_30 XI0_I1476_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1476_MP23 (XI0_I1476_ap4 I0_pp7_32 XI0_I1476_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP22 (VDD VDD XI0_I1476_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP22_1 (XI0_I1476_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP23_1 (XI0_I1476_ap5 I0_pp7_32 XI0_I1476_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1476_MP24_1 (XI0_I1476_asn I0_pp8_30 XI0_I1476_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1476_MP17 (XI0_I1476_acon I0_pp8_30 XI0_I1476_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1476_MP14 (XI0_I1476_ap1 I0_pp7_32 XI0_I1476_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP13 (VDD VDD XI0_I1476_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP15 (XI0_I1476_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP16 (VDD I0_pp7_32 XI0_I1476_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1476_MP28 (I0_cm115_2 XI0_I1476_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1476_MP19 (XI0_I1476_ap3 I0_pp7_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1476_MP20 (VDD I0_pp8_30 XI0_I1476_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1494_MP50 (VDD XI0_I1494_s1 XI0_I1494_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1494_MP47 (XI0_I1494_bp3 I0_pp15_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1494_MP49 (XI0_I1494_bsn XI0_I1494_bcon XI0_I1494_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1494_MP52 (XI0_I1494_bp5 I0_cm132_2 XI0_I1494_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1494_MP51 (XI0_I1494_bp4 I0_pp15_27 XI0_I1494_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP51_1 (XI0_I1494_bp5 I0_pp15_27 XI0_I1494_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP52_1 (XI0_I1494_bsn I0_cm132_2 XI0_I1494_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1494_MP54 (VDD XI0_I1494_bsn I0_cm133_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1494_MP41 (XI0_I1494_bp1 XI0_I1494_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP42 (XI0_I1494_bcon I0_pp15_27 XI0_I1494_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP45 (XI0_I1494_bp2 I0_cm132_2 XI0_I1494_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP43 (VDD XI0_I1494_s1 XI0_I1494_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP44 (XI0_I1494_bp2 I0_pp15_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1494_MP56 (VDD XI0_I1494_bcon I0_cm133_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1494_MP46 (XI0_I1494_bp3 XI0_I1494_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP48 (VDD I0_cm132_2 XI0_I1494_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP50_1 (XI0_I1494_bp4 XI0_I1494_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1494_MP26 (VDD XI0_I1494_asn XI0_I1494_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1494_MP18 (XI0_I1494_ap3 I0_sn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1494_MP21 (XI0_I1494_asn XI0_I1494_acon XI0_I1494_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP24 (XI0_I1494_ap5 I0_pp14_29 XI0_I1494_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1494_MP23 (XI0_I1494_ap4 I0_pp13_31 XI0_I1494_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP22 (VDD I0_sn12 XI0_I1494_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP22_1 (XI0_I1494_ap4 I0_sn12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP23_1 (XI0_I1494_ap5 I0_pp13_31 XI0_I1494_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1494_MP24_1 (XI0_I1494_asn I0_pp14_29 XI0_I1494_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1494_MP17 (XI0_I1494_acon I0_pp14_29 XI0_I1494_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1494_MP14 (XI0_I1494_ap1 I0_pp13_31 XI0_I1494_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP13 (VDD I0_sn12 XI0_I1494_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP15 (XI0_I1494_ap2 I0_sn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP16 (VDD I0_pp13_31 XI0_I1494_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1494_MP28 (I0_cm133_2 XI0_I1494_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1494_MP19 (XI0_I1494_ap3 I0_pp13_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1494_MP20 (VDD I0_pp14_29 XI0_I1494_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1490_MP50 (VDD XI0_I1490_s1 XI0_I1490_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1490_MP47 (XI0_I1490_bp3 I0_pp13_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1490_MP49 (XI0_I1490_bsn XI0_I1490_bcon XI0_I1490_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1490_MP52 (XI0_I1490_bp5 I0_cm127_2 XI0_I1490_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1490_MP51 (XI0_I1490_bp4 I0_pp13_27 XI0_I1490_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP51_1 (XI0_I1490_bp5 I0_pp13_27 XI0_I1490_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP52_1 (XI0_I1490_bsn I0_cm127_2 XI0_I1490_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1490_MP54 (VDD XI0_I1490_bsn I0_cm129_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1490_MP41 (XI0_I1490_bp1 XI0_I1490_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP42 (XI0_I1490_bcon I0_pp13_27 XI0_I1490_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP45 (XI0_I1490_bp2 I0_cm127_2 XI0_I1490_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP43 (VDD XI0_I1490_s1 XI0_I1490_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP44 (XI0_I1490_bp2 I0_pp13_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1490_MP56 (VDD XI0_I1490_bcon I0_cm129_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1490_MP46 (XI0_I1490_bp3 XI0_I1490_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP48 (VDD I0_cm127_2 XI0_I1490_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP50_1 (XI0_I1490_bp4 XI0_I1490_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1490_MP26 (VDD XI0_I1490_asn XI0_I1490_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1490_MP18 (XI0_I1490_ap3 I0_sn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1490_MP21 (XI0_I1490_asn XI0_I1490_acon XI0_I1490_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP24 (XI0_I1490_ap5 I0_pp12_29 XI0_I1490_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1490_MP23 (XI0_I1490_ap4 I0_pp11_31 XI0_I1490_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP22 (VDD I0_sn10 XI0_I1490_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP22_1 (XI0_I1490_ap4 I0_sn10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP23_1 (XI0_I1490_ap5 I0_pp11_31 XI0_I1490_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1490_MP24_1 (XI0_I1490_asn I0_pp12_29 XI0_I1490_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1490_MP17 (XI0_I1490_acon I0_pp12_29 XI0_I1490_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1490_MP14 (XI0_I1490_ap1 I0_pp11_31 XI0_I1490_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP13 (VDD I0_sn10 XI0_I1490_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP15 (XI0_I1490_ap2 I0_sn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP16 (VDD I0_pp11_31 XI0_I1490_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1490_MP28 (I0_cm129_2 XI0_I1490_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1490_MP19 (XI0_I1490_ap3 I0_pp11_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1490_MP20 (VDD I0_pp12_29 XI0_I1490_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1479_MP50 (VDD XI0_I1479_s1 XI0_I1479_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1479_MP47 (XI0_I1479_bp3 I0_pp14_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1479_MP49 (XI0_I1479_bsn XI0_I1479_bcon XI0_I1479_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1479_MP52 (XI0_I1479_bp5 I0_cm116_2 XI0_I1479_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1479_MP51 (XI0_I1479_bp4 I0_pp14_19 XI0_I1479_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP51_1 (XI0_I1479_bp5 I0_pp14_19 XI0_I1479_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP52_1 (XI0_I1479_bsn I0_cm116_2 XI0_I1479_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1479_MP54 (VDD XI0_I1479_bsn I0_cm118_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1479_MP41 (XI0_I1479_bp1 XI0_I1479_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP42 (XI0_I1479_bcon I0_pp14_19 XI0_I1479_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP45 (XI0_I1479_bp2 I0_cm116_2 XI0_I1479_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP43 (VDD XI0_I1479_s1 XI0_I1479_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP44 (XI0_I1479_bp2 I0_pp14_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1479_MP56 (VDD XI0_I1479_bcon I0_cm118_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1479_MP46 (XI0_I1479_bp3 XI0_I1479_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP48 (VDD I0_cm116_2 XI0_I1479_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP50_1 (XI0_I1479_bp4 XI0_I1479_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1479_MP26 (VDD XI0_I1479_asn XI0_I1479_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1479_MP18 (XI0_I1479_ap3 I0_pp11_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1479_MP21 (XI0_I1479_asn XI0_I1479_acon XI0_I1479_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP24 (XI0_I1479_ap5 I0_pp13_21 XI0_I1479_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1479_MP23 (XI0_I1479_ap4 I0_pp12_23 XI0_I1479_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP22 (VDD I0_pp11_25 XI0_I1479_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP22_1 (XI0_I1479_ap4 I0_pp11_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP23_1 (XI0_I1479_ap5 I0_pp12_23 XI0_I1479_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1479_MP24_1 (XI0_I1479_asn I0_pp13_21 XI0_I1479_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1479_MP17 (XI0_I1479_acon I0_pp13_21 XI0_I1479_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1479_MP14 (XI0_I1479_ap1 I0_pp12_23 XI0_I1479_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP13 (VDD I0_pp11_25 XI0_I1479_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP15 (XI0_I1479_ap2 I0_pp11_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP16 (VDD I0_pp12_23 XI0_I1479_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1479_MP28 (I0_cm118_2 XI0_I1479_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1479_MP19 (XI0_I1479_ap3 I0_pp12_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1479_MP20 (VDD I0_pp13_21 XI0_I1479_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1478_MP50 (VDD XI0_I1478_s1 XI0_I1478_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1478_MP47 (XI0_I1478_bp3 I0_pp10_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1478_MP49 (XI0_I1478_bsn XI0_I1478_bcon XI0_I1478_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1478_MP52 (XI0_I1478_bp5 I0_cm115_2 XI0_I1478_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1478_MP51 (XI0_I1478_bp4 I0_pp10_27 XI0_I1478_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP51_1 (XI0_I1478_bp5 I0_pp10_27 XI0_I1478_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP52_1 (XI0_I1478_bsn I0_cm115_2 XI0_I1478_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1478_MP54 (VDD XI0_I1478_bsn I0_cm117_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1478_MP41 (XI0_I1478_bp1 XI0_I1478_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP42 (XI0_I1478_bcon I0_pp10_27 XI0_I1478_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP45 (XI0_I1478_bp2 I0_cm115_2 XI0_I1478_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP43 (VDD XI0_I1478_s1 XI0_I1478_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP44 (XI0_I1478_bp2 I0_pp10_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1478_MP56 (VDD XI0_I1478_bcon I0_cm117_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1478_MP46 (XI0_I1478_bp3 XI0_I1478_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP48 (VDD I0_cm115_2 XI0_I1478_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP50_1 (XI0_I1478_bp4 XI0_I1478_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1478_MP26 (VDD XI0_I1478_asn XI0_I1478_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1478_MP18 (XI0_I1478_ap3 I0_sn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1478_MP21 (XI0_I1478_asn XI0_I1478_acon XI0_I1478_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP24 (XI0_I1478_ap5 I0_pp9_29 XI0_I1478_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1478_MP23 (XI0_I1478_ap4 I0_pp8_31 XI0_I1478_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP22 (VDD I0_sn7 XI0_I1478_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP22_1 (XI0_I1478_ap4 I0_sn7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP23_1 (XI0_I1478_ap5 I0_pp8_31 XI0_I1478_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1478_MP24_1 (XI0_I1478_asn I0_pp9_29 XI0_I1478_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1478_MP17 (XI0_I1478_acon I0_pp9_29 XI0_I1478_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1478_MP14 (XI0_I1478_ap1 I0_pp8_31 XI0_I1478_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP13 (VDD I0_sn7 XI0_I1478_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP15 (XI0_I1478_ap2 I0_sn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP16 (VDD I0_pp8_31 XI0_I1478_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1478_MP28 (I0_cm117_2 XI0_I1478_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1478_MP19 (XI0_I1478_ap3 I0_pp8_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1478_MP20 (VDD I0_pp9_29 XI0_I1478_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1495_MP50 (VDD XI0_I1495_s1 XI0_I1495_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1495_MP47 (XI0_I1495_bp3 I0_pp15_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1495_MP49 (XI0_I1495_bsn XI0_I1495_bcon XI0_I1495_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1495_MP52 (XI0_I1495_bp5 I0_cm133_2 XI0_I1495_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1495_MP51 (XI0_I1495_bp4 I0_pp15_28 XI0_I1495_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP51_1 (XI0_I1495_bp5 I0_pp15_28 XI0_I1495_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP52_1 (XI0_I1495_bsn I0_cm133_2 XI0_I1495_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1495_MP54 (VDD XI0_I1495_bsn I0_cm134_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1495_MP41 (XI0_I1495_bp1 XI0_I1495_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP42 (XI0_I1495_bcon I0_pp15_28 XI0_I1495_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP45 (XI0_I1495_bp2 I0_cm133_2 XI0_I1495_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP43 (VDD XI0_I1495_s1 XI0_I1495_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP44 (XI0_I1495_bp2 I0_pp15_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1495_MP56 (VDD XI0_I1495_bcon I0_cm134_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1495_MP46 (XI0_I1495_bp3 XI0_I1495_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP48 (VDD I0_cm133_2 XI0_I1495_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP50_1 (XI0_I1495_bp4 XI0_I1495_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1495_MP26 (VDD XI0_I1495_asn XI0_I1495_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1495_MP18 (XI0_I1495_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1495_MP21 (XI0_I1495_asn XI0_I1495_acon XI0_I1495_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP24 (XI0_I1495_ap5 I0_pp14_30 XI0_I1495_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1495_MP23 (XI0_I1495_ap4 I0_pp13_32 XI0_I1495_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP22 (VDD VDD XI0_I1495_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP22_1 (XI0_I1495_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP23_1 (XI0_I1495_ap5 I0_pp13_32 XI0_I1495_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1495_MP24_1 (XI0_I1495_asn I0_pp14_30 XI0_I1495_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1495_MP17 (XI0_I1495_acon I0_pp14_30 XI0_I1495_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1495_MP14 (XI0_I1495_ap1 I0_pp13_32 XI0_I1495_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP13 (VDD VDD XI0_I1495_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP15 (XI0_I1495_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP16 (VDD I0_pp13_32 XI0_I1495_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1495_MP28 (I0_cm134_2 XI0_I1495_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1495_MP19 (XI0_I1495_ap3 I0_pp13_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1495_MP20 (VDD I0_pp14_30 XI0_I1495_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1558_MP50 (VDD XI0_I1558_s1 XI0_I1558_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1558_MP47 (XI0_I1558_bp3 I0_cm118_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1558_MP49 (XI0_I1558_bsn XI0_I1558_bcon XI0_I1558_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1558_MP52 (XI0_I1558_bp5 I0_cm196_2 XI0_I1558_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1558_MP51 (XI0_I1558_bp4 I0_cm118_0 XI0_I1558_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP51_1 (XI0_I1558_bp5 I0_cm118_0 XI0_I1558_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP52_1 (XI0_I1558_bsn I0_cm196_2 XI0_I1558_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1558_MP54 (VDD XI0_I1558_bsn I0_cm197_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1558_MP41 (XI0_I1558_bp1 XI0_I1558_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP42 (XI0_I1558_bcon I0_cm118_0 XI0_I1558_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP45 (XI0_I1558_bp2 I0_cm196_2 XI0_I1558_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP43 (VDD XI0_I1558_s1 XI0_I1558_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP44 (XI0_I1558_bp2 I0_cm118_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1558_MP56 (VDD XI0_I1558_bcon I0_cm197_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1558_MP46 (XI0_I1558_bp3 XI0_I1558_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP48 (VDD I0_cm196_2 XI0_I1558_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP50_1 (XI0_I1558_bp4 XI0_I1558_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1558_MP26 (VDD XI0_I1558_asn XI0_I1558_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1558_MP18 (XI0_I1558_ap3 I0_cm115_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1558_MP21 (XI0_I1558_asn XI0_I1558_acon XI0_I1558_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP24 (XI0_I1558_ap5 I0_cm117_0 XI0_I1558_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1558_MP23 (XI0_I1558_ap4 I0_cm116_1 XI0_I1558_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP22 (VDD I0_cm115_1 XI0_I1558_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP22_1 (XI0_I1558_ap4 I0_cm115_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP23_1 (XI0_I1558_ap5 I0_cm116_1 XI0_I1558_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1558_MP24_1 (XI0_I1558_asn I0_cm117_0 XI0_I1558_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1558_MP17 (XI0_I1558_acon I0_cm117_0 XI0_I1558_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1558_MP14 (XI0_I1558_ap1 I0_cm116_1 XI0_I1558_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP13 (VDD I0_cm115_1 XI0_I1558_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP15 (XI0_I1558_ap2 I0_cm115_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP16 (VDD I0_cm116_1 XI0_I1558_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1558_MP28 (I0_cm197_2 XI0_I1558_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1558_MP19 (XI0_I1558_ap3 I0_cm116_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1558_MP20 (VDD I0_cm117_0 XI0_I1558_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1559_MP50 (VDD XI0_I1559_s1 XI0_I1559_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1559_MP47 (XI0_I1559_bp3 I0_cm120_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1559_MP49 (XI0_I1559_bsn XI0_I1559_bcon XI0_I1559_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1559_MP52 (XI0_I1559_bp5 I0_cm197_2 XI0_I1559_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1559_MP51 (XI0_I1559_bp4 I0_cm120_0 XI0_I1559_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP51_1 (XI0_I1559_bp5 I0_cm120_0 XI0_I1559_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP52_1 (XI0_I1559_bsn I0_cm197_2 XI0_I1559_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1559_MP54 (VDD XI0_I1559_bsn I0_cm198_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1559_MP41 (XI0_I1559_bp1 XI0_I1559_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP42 (XI0_I1559_bcon I0_cm120_0 XI0_I1559_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP45 (XI0_I1559_bp2 I0_cm197_2 XI0_I1559_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP43 (VDD XI0_I1559_s1 XI0_I1559_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP44 (XI0_I1559_bp2 I0_cm120_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1559_MP56 (VDD XI0_I1559_bcon I0_cm198_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1559_MP46 (XI0_I1559_bp3 XI0_I1559_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP48 (VDD I0_cm197_2 XI0_I1559_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP50_1 (XI0_I1559_bp4 XI0_I1559_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1559_MP26 (VDD XI0_I1559_asn XI0_I1559_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1559_MP18 (XI0_I1559_ap3 I0_cm117_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.26396p pd=0.91999u ps=2.23999u
    I_MXI0_I1559_MP21 (XI0_I1559_asn XI0_I1559_acon XI0_I1559_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP24 (XI0_I1559_ap5 I0_cm119_0 XI0_I1559_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1559_MP23 (XI0_I1559_ap4 I0_cm118_1 XI0_I1559_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP22 (VDD I0_cm117_1 XI0_I1559_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP22_1 (XI0_I1559_ap4 I0_cm117_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP23_1 (XI0_I1559_ap5 I0_cm118_1 XI0_I1559_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1559_MP24_1 (XI0_I1559_asn I0_cm119_0 XI0_I1559_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1559_MP17 (XI0_I1559_acon I0_cm119_0 XI0_I1559_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1559_MP14 (XI0_I1559_ap1 I0_cm118_1 XI0_I1559_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP13 (VDD I0_cm117_1 XI0_I1559_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP15 (XI0_I1559_ap2 I0_cm117_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP16 (VDD I0_cm118_1 XI0_I1559_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09356p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1559_MP28 (I0_cm198_2 XI0_I1559_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.09356p pd=1.15999u ps=0.91999u
    I_MXI0_I1559_MP19 (XI0_I1559_ap3 I0_cm118_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1559_MP20 (VDD I0_cm119_0 XI0_I1559_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.26396p as=0.10556p pd=2.23999u ps=0.91999u
    I_MXI0_I1565_MP50 (VDD XI0_I1565_s1 XI0_I1565_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.09956p as=0.07916p pd=0.91999u ps=0.79999u
    I_MXI0_I1565_MP47 (XI0_I1565_bp3 I0_pp15_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.23516p as=0.09956p pd=1.45999u ps=0.91999u
    I_MXI0_I1565_MP49 (XI0_I1565_bsn XI0_I1565_bcon XI0_I1565_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.09956p as=0.23516p pd=0.91999u ps=1.45999u
    I_MXI0_I1565_MP52 (XI0_I1565_bp5 I0_cm203_2 XI0_I1565_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.09956p pd=0.79999u ps=0.91999u
    I_MXI0_I1565_MP51 (XI0_I1565_bp4 I0_pp15_24 XI0_I1565_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP51_1 (XI0_I1565_bp5 I0_pp15_24 XI0_I1565_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.07916p as=0.07916p pd=0.79999u ps=0.79999u
    I_MXI0_I1565_MP52_1 (XI0_I1565_bsn I0_cm203_2 XI0_I1565_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.12236p as=0.07916p pd=1.39999u ps=0.79999u
    I_MXI0_I1565_MP54 (VDD XI0_I1565_bsn I0_cm204_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1565_MP41 (XI0_I1565_bp1 XI0_I1565_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP42 (XI0_I1565_bcon I0_pp15_24 XI0_I1565_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP45 (XI0_I1565_bp2 I0_cm203_2 XI0_I1565_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP43 (VDD XI0_I1565_s1 XI0_I1565_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1565_MP44 (XI0_I1565_bp2 I0_pp15_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
