    I_MXI1_I883_MN1 (XI1_I883_Bn I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I883_MN5 (XI1_I883_n2 XI1_I883_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I883_MN4 (I1_b7_31 XI1_I883_An XI1_I883_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I883_MN2 (XI1_I883_n1 I1_dd31_b3_1 I1_b7_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I883_MN3 (VSS I1_qu25_b3_5 XI1_I883_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I883_MN0 (XI1_I883_An I1_dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I885_MN1 (XI1_I885_Bn I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I885_MN5 (XI1_I885_n2 XI1_I885_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I885_MN4 (I1_h7 XI1_I885_An XI1_I885_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I885_MN2 (XI1_I885_n1 I1_p6_31 I1_h7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I885_MN3 (VSS I1_qu25_b3_5 XI1_I885_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I885_MN0 (XI1_I885_An I1_p6_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I874_MN1 (XI1_I874_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I874_MN5 (XI1_I874_n2 XI1_I874_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I874_MN4 (I1_b7_22 XI1_I874_An XI1_I874_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I874_MN2 (XI1_I874_n1 I1_dd22_b3_1 I1_b7_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I874_MN3 (VSS I1_qu25_b3_3 XI1_I874_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I874_MN0 (XI1_I874_An I1_dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I872_MN1 (XI1_I872_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I872_MN5 (XI1_I872_n2 XI1_I872_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I872_MN4 (I1_b7_20 XI1_I872_An XI1_I872_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I872_MN2 (XI1_I872_n1 I1_dd20_b3_1 I1_b7_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I872_MN3 (VSS I1_qu25_b3_3 XI1_I872_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I872_MN0 (XI1_I872_An I1_dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I873_MN1 (XI1_I873_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I873_MN5 (XI1_I873_n2 XI1_I873_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I873_MN4 (I1_b7_21 XI1_I873_An XI1_I873_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I873_MN2 (XI1_I873_n1 I1_dd21_b3_1 I1_b7_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I873_MN3 (VSS I1_qu25_b3_3 XI1_I873_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I873_MN0 (XI1_I873_An I1_dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I870_MN1 (XI1_I870_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I870_MN5 (XI1_I870_n2 XI1_I870_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I870_MN4 (I1_b7_18 XI1_I870_An XI1_I870_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I870_MN2 (XI1_I870_n1 I1_dd18_b3_1 I1_b7_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I870_MN3 (VSS I1_qu25_b3_3 XI1_I870_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I870_MN0 (XI1_I870_An I1_dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I871_MN1 (XI1_I871_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I871_MN5 (XI1_I871_n2 XI1_I871_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I871_MN4 (I1_b7_19 XI1_I871_An XI1_I871_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I871_MN2 (XI1_I871_n1 I1_dd19_b3_1 I1_b7_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I871_MN3 (VSS I1_qu25_b3_3 XI1_I871_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I871_MN0 (XI1_I871_An I1_dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I869_MN1 (XI1_I869_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I869_MN5 (XI1_I869_n2 XI1_I869_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I869_MN4 (I1_b7_17 XI1_I869_An XI1_I869_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I869_MN2 (XI1_I869_n1 I1_dd17_b3_1 I1_b7_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I869_MN3 (VSS I1_qu25_b3_2 XI1_I869_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I869_MN0 (XI1_I869_An I1_dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I867_MN1 (XI1_I867_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I867_MN5 (XI1_I867_n2 XI1_I867_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I867_MN4 (I1_b7_15 XI1_I867_An XI1_I867_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I867_MN2 (XI1_I867_n1 I1_dd15_b3_1 I1_b7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I867_MN3 (VSS I1_qu25_b3_2 XI1_I867_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I867_MN0 (XI1_I867_An I1_dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I822_MN1 (XI1_I822_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I822_MN5 (XI1_I822_n2 XI1_I822_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I822_MN4 (I1_b6_16 XI1_I822_An XI1_I822_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I822_MN2 (XI1_I822_n1 I1_dd16_b3_1 I1_b6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I822_MN3 (VSS I1_qu26_b3_2 XI1_I822_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I822_MN0 (XI1_I822_An I1_dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I820_MN1 (XI1_I820_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I820_MN5 (XI1_I820_n2 XI1_I820_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I820_MN4 (I1_b6_14 XI1_I820_An XI1_I820_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I820_MN2 (XI1_I820_n1 I1_dd14_b3_1 I1_b6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I820_MN3 (VSS I1_qu26_b3_2 XI1_I820_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I820_MN0 (XI1_I820_An I1_dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I821_MN1 (XI1_I821_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I821_MN5 (XI1_I821_n2 XI1_I821_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I821_MN4 (I1_b6_15 XI1_I821_An XI1_I821_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I821_MN2 (XI1_I821_n1 I1_dd15_b3_1 I1_b6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I821_MN3 (VSS I1_qu26_b3_2 XI1_I821_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I821_MN0 (XI1_I821_An I1_dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I819_MN1 (XI1_I819_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I819_MN5 (XI1_I819_n2 XI1_I819_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I819_MN4 (I1_b6_13 XI1_I819_An XI1_I819_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I819_MN2 (XI1_I819_n1 I1_dd13_b3_1 I1_b6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I819_MN3 (VSS I1_qu26_b3_2 XI1_I819_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I819_MN0 (XI1_I819_An I1_dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I818_MN1 (XI1_I818_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I818_MN5 (XI1_I818_n2 XI1_I818_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I818_MN4 (I1_b6_12 XI1_I818_An XI1_I818_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I818_MN2 (XI1_I818_n1 I1_dd12_b3_1 I1_b6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I818_MN3 (VSS I1_qu26_b3_2 XI1_I818_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I818_MN0 (XI1_I818_An I1_dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I207_MN1 (XI1_I838_I207_Bn I1_I838_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I207_MN5 (XI1_I838_I207_n2 XI1_I838_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I207_MN4 (I1_p6_4 XI1_I838_I207_An XI1_I838_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I207_MN2 (XI1_I838_I207_n1 I1_I838_pn4 I1_p6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I207_MN3 (VSS I1_I838_G3_0n XI1_I838_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I207_MN0 (XI1_I838_I207_An I1_I838_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I207_MN1 (XI1_I792_I207_Bn I1_I792_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I207_MN5 (XI1_I792_I207_n2 XI1_I792_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I207_MN4 (I1_p5_4 XI1_I792_I207_An XI1_I792_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I207_MN2 (XI1_I792_I207_n1 I1_I792_pn4 I1_p5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I207_MN3 (VSS I1_I792_G3_0n XI1_I792_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I207_MN0 (XI1_I792_I207_An I1_I792_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I212_MN1 (XI1_I746_I212_Bn I1_I746_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I212_MN5 (XI1_I746_I212_n2 XI1_I746_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I212_MN4 (I1_p4_9 XI1_I746_I212_An XI1_I746_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I212_MN2 (XI1_I746_I212_n1 I1_I746_pn9 I1_p4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I212_MN3 (VSS I1_I746_G8_0n XI1_I746_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I212_MN0 (XI1_I746_I212_An I1_I746_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I214_MN1 (XI1_I746_I214_Bn I1_I746_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I214_MN5 (XI1_I746_I214_n2 XI1_I746_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I214_MN4 (I1_p4_11 XI1_I746_I214_An XI1_I746_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I214_MN2 (XI1_I746_I214_n1 I1_I746_pn11 I1_p4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I214_MN3 (VSS I1_I746_G10_0n XI1_I746_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I214_MN0 (XI1_I746_I214_An I1_I746_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I216_MN1 (XI1_I746_I216_Bn I1_I746_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I216_MN5 (XI1_I746_I216_n2 XI1_I746_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I216_MN4 (I1_p4_13 XI1_I746_I216_An XI1_I746_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I216_MN2 (XI1_I746_I216_n1 I1_I746_pn13 I1_p4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I216_MN3 (VSS I1_I746_G12_0n XI1_I746_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I216_MN0 (XI1_I746_I216_An I1_I746_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I217_MN1 (XI1_I746_I217_Bn I1_I746_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I217_MN5 (XI1_I746_I217_n2 XI1_I746_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I217_MN4 (I1_p4_14 XI1_I746_I217_An XI1_I746_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I217_MN2 (XI1_I746_I217_n1 I1_I746_pn14 I1_p4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I217_MN3 (VSS I1_I746_G13_0n XI1_I746_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I217_MN0 (XI1_I746_I217_An I1_I746_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I219_MN1 (XI1_I746_I219_Bn I1_I746_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I219_MN5 (XI1_I746_I219_n2 XI1_I746_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I219_MN4 (I1_p4_16 XI1_I746_I219_An XI1_I746_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I219_MN2 (XI1_I746_I219_n1 I1_I746_pn16 I1_p4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I219_MN3 (VSS I1_I746_G15_0n XI1_I746_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I219_MN0 (XI1_I746_I219_An I1_I746_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1387_MN1 (XI1_I1387_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1387_MN5 (XI1_I1387_n2 XI1_I1387_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1387_MN4 (I1_b18_29 XI1_I1387_An XI1_I1387_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1387_MN2 (XI1_I1387_n1 I1_dd29_b3_3 I1_b18_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1387_MN3 (VSS I1_qu14_b3_4 XI1_I1387_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1387_MN0 (XI1_I1387_An I1_dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1386_MN1 (XI1_I1386_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1386_MN5 (XI1_I1386_n2 XI1_I1386_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1386_MN4 (I1_b18_28 XI1_I1386_An XI1_I1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1386_MN2 (XI1_I1386_n1 I1_dd28_b3_3 I1_b18_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1386_MN3 (VSS I1_qu14_b3_4 XI1_I1386_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1386_MN0 (XI1_I1386_An I1_dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1383_MN1 (XI1_I1383_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1383_MN5 (XI1_I1383_n2 XI1_I1383_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1383_MN4 (I1_b18_25 XI1_I1383_An XI1_I1383_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1383_MN2 (XI1_I1383_n1 I1_dd25_b3_3 I1_b18_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1383_MN3 (VSS I1_qu14_b3_4 XI1_I1383_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1383_MN0 (XI1_I1383_An I1_dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I215_MN1 (XI1_I1344_I215_Bn I1_I1344_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I215_MN5 (XI1_I1344_I215_n2 XI1_I1344_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I215_MN4 (I1_p17_12 XI1_I1344_I215_An XI1_I1344_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I215_MN2 (XI1_I1344_I215_n1 I1_I1344_pn12 I1_p17_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I215_MN3 (VSS I1_I1344_G11_0n XI1_I1344_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I215_MN0 (XI1_I1344_I215_An I1_I1344_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I214_MN1 (XI1_I1298_I214_Bn I1_I1298_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I214_MN5 (XI1_I1298_I214_n2 XI1_I1298_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I214_MN4 (I1_p16_11 XI1_I1298_I214_An XI1_I1298_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I214_MN2 (XI1_I1298_I214_n1 I1_I1298_pn11 I1_p16_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I214_MN3 (VSS I1_I1298_G10_0n XI1_I1298_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I214_MN0 (XI1_I1298_I214_An I1_I1298_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1283_MN1 (XI1_I1283_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1283_MN5 (XI1_I1283_n2 XI1_I1283_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1283_MN4 (I1_b16_17 XI1_I1283_An XI1_I1283_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1283_MN2 (XI1_I1283_n1 I1_dd17_b3_2 I1_b16_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1283_MN3 (VSS I1_qu16_b3_2 XI1_I1283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1283_MN0 (XI1_I1283_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1282_MN1 (XI1_I1282_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1282_MN5 (XI1_I1282_n2 XI1_I1282_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1282_MN4 (I1_b16_16 XI1_I1282_An XI1_I1282_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1282_MN2 (XI1_I1282_n1 I1_dd16_b3_2 I1_b16_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1282_MN3 (VSS I1_qu16_b3_2 XI1_I1282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1282_MN0 (XI1_I1282_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1281_MN1 (XI1_I1281_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1281_MN5 (XI1_I1281_n2 XI1_I1281_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1281_MN4 (I1_b16_15 XI1_I1281_An XI1_I1281_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1281_MN2 (XI1_I1281_n1 I1_dd15_b3_2 I1_b16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1281_MN3 (VSS I1_qu16_b3_2 XI1_I1281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1281_MN0 (XI1_I1281_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I216_MN1 (XI1_I1252_I216_Bn I1_I1252_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I216_MN5 (XI1_I1252_I216_n2 XI1_I1252_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I216_MN4 (I1_p15_13 XI1_I1252_I216_An XI1_I1252_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I216_MN2 (XI1_I1252_I216_n1 I1_I1252_pn13 I1_p15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I216_MN3 (VSS I1_I1252_G12_0n XI1_I1252_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I216_MN0 (XI1_I1252_I216_An I1_I1252_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I215_MN1 (XI1_I1252_I215_Bn I1_I1252_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I215_MN5 (XI1_I1252_I215_n2 XI1_I1252_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I215_MN4 (I1_p15_12 XI1_I1252_I215_An XI1_I1252_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I215_MN2 (XI1_I1252_I215_n1 I1_I1252_pn12 I1_p15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I215_MN3 (VSS I1_I1252_G11_0n XI1_I1252_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I215_MN0 (XI1_I1252_I215_An I1_I1252_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1235_MN1 (XI1_I1235_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1235_MN5 (XI1_I1235_n2 XI1_I1235_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1235_MN4 (I1_b15_15 XI1_I1235_An XI1_I1235_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1235_MN2 (XI1_I1235_n1 I1_dd15_b3_2 I1_b15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1235_MN3 (VSS I1_qu17_b3_2 XI1_I1235_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1235_MN0 (XI1_I1235_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I216_MN1 (XI1_I1206_I216_Bn I1_I1206_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I216_MN5 (XI1_I1206_I216_n2 XI1_I1206_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I216_MN4 (I1_p14_13 XI1_I1206_I216_An XI1_I1206_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I216_MN2 (XI1_I1206_I216_n1 I1_I1206_pn13 I1_p14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I216_MN3 (VSS I1_I1206_G12_0n XI1_I1206_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I216_MN0 (XI1_I1206_I216_An I1_I1206_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I215_MN1 (XI1_I1206_I215_Bn I1_I1206_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I215_MN5 (XI1_I1206_I215_n2 XI1_I1206_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I215_MN4 (I1_p14_12 XI1_I1206_I215_An XI1_I1206_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I215_MN2 (XI1_I1206_I215_n1 I1_I1206_pn12 I1_p14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I215_MN3 (VSS I1_I1206_G11_0n XI1_I1206_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I215_MN0 (XI1_I1206_I215_An I1_I1206_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I868_MN1 (XI1_I868_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I868_MN5 (XI1_I868_n2 XI1_I868_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I868_MN4 (I1_b7_16 XI1_I868_An XI1_I868_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I868_MN2 (XI1_I868_n1 I1_dd16_b3_1 I1_b7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I868_MN3 (VSS I1_qu25_b3_2 XI1_I868_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I868_MN0 (XI1_I868_An I1_dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I866_MN1 (XI1_I866_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I866_MN5 (XI1_I866_n2 XI1_I866_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I866_MN4 (I1_b7_14 XI1_I866_An XI1_I866_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I866_MN2 (XI1_I866_n1 I1_dd14_b3_1 I1_b7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I866_MN3 (VSS I1_qu25_b3_2 XI1_I866_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I866_MN0 (XI1_I866_An I1_dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I864_MN1 (XI1_I864_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I864_MN5 (XI1_I864_n2 XI1_I864_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I864_MN4 (I1_b7_12 XI1_I864_An XI1_I864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I864_MN2 (XI1_I864_n1 I1_dd12_b3_1 I1_b7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I864_MN3 (VSS I1_qu25_b3_2 XI1_I864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I864_MN0 (XI1_I864_An I1_dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I865_MN1 (XI1_I865_Bn I1_qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I865_MN5 (XI1_I865_n2 XI1_I865_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I865_MN4 (I1_b7_13 XI1_I865_An XI1_I865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I865_MN2 (XI1_I865_n1 I1_dd13_b3_1 I1_b7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I865_MN3 (VSS I1_qu25_b3_2 XI1_I865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I865_MN0 (XI1_I865_An I1_dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I863_MN1 (XI1_I863_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I863_MN5 (XI1_I863_n2 XI1_I863_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I863_MN4 (I1_b7_11 XI1_I863_An XI1_I863_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I863_MN2 (XI1_I863_n1 I1_dd11_b3_1 I1_b7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I863_MN3 (VSS I1_qu25_b3_1 XI1_I863_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I863_MN0 (XI1_I863_An I1_dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I816_MN1 (XI1_I816_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I816_MN5 (XI1_I816_n2 XI1_I816_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I816_MN4 (I1_b6_10 XI1_I816_An XI1_I816_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I816_MN2 (XI1_I816_n1 I1_dd10_b3_1 I1_b6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I816_MN3 (VSS I1_qu26_b3_1 XI1_I816_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I816_MN0 (XI1_I816_An I1_dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I817_MN1 (XI1_I817_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I817_MN5 (XI1_I817_n2 XI1_I817_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I817_MN4 (I1_b6_11 XI1_I817_An XI1_I817_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I817_MN2 (XI1_I817_n1 I1_dd11_b3_1 I1_b6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I817_MN3 (VSS I1_qu26_b3_1 XI1_I817_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I817_MN0 (XI1_I817_An I1_dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I815_MN1 (XI1_I815_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I815_MN5 (XI1_I815_n2 XI1_I815_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I815_MN4 (I1_b6_9 XI1_I815_An XI1_I815_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I815_MN2 (XI1_I815_n1 I1_dd9_b3_1 I1_b6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I815_MN3 (VSS I1_qu26_b3_1 XI1_I815_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I815_MN0 (XI1_I815_An I1_dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I206_MN1 (XI1_I838_I206_Bn I1_I838_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I206_MN5 (XI1_I838_I206_n2 XI1_I838_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I206_MN4 (I1_p6_3 XI1_I838_I206_An XI1_I838_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I206_MN2 (XI1_I838_I206_n1 I1_I838_pn3 I1_p6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I206_MN3 (VSS I1_I838_G2_0n XI1_I838_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I206_MN0 (XI1_I838_I206_An I1_I838_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I206_MN1 (XI1_I792_I206_Bn I1_I792_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I206_MN5 (XI1_I792_I206_n2 XI1_I792_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I206_MN4 (I1_p5_3 XI1_I792_I206_An XI1_I792_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I206_MN2 (XI1_I792_I206_n1 I1_I792_pn3 I1_p5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I206_MN3 (VSS I1_I792_G2_0n XI1_I792_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I206_MN0 (XI1_I792_I206_An I1_I792_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I213_MN1 (XI1_I746_I213_Bn I1_I746_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I213_MN5 (XI1_I746_I213_n2 XI1_I746_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I213_MN4 (I1_p4_10 XI1_I746_I213_An XI1_I746_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I213_MN2 (XI1_I746_I213_n1 I1_I746_pn10 I1_p4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I213_MN3 (VSS I1_I746_G9_0n XI1_I746_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I213_MN0 (XI1_I746_I213_An I1_I746_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I215_MN1 (XI1_I746_I215_Bn I1_I746_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I215_MN5 (XI1_I746_I215_n2 XI1_I746_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I215_MN4 (I1_p4_12 XI1_I746_I215_An XI1_I746_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I215_MN2 (XI1_I746_I215_n1 I1_I746_pn12 I1_p4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I215_MN3 (VSS I1_I746_G11_0n XI1_I746_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I215_MN0 (XI1_I746_I215_An I1_I746_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I745_MN1 (XI1_I745_Bn I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I745_MN5 (XI1_I745_n2 XI1_I745_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I745_MN4 (I1_b4_31 XI1_I745_An XI1_I745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I745_MN2 (XI1_I745_n1 I1_dd31_b3_0 I1_b4_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I745_MN3 (VSS I1_qu28_b3_5 XI1_I745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I745_MN0 (XI1_I745_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1384_MN1 (XI1_I1384_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1384_MN5 (XI1_I1384_n2 XI1_I1384_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1384_MN4 (I1_b18_26 XI1_I1384_An XI1_I1384_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1384_MN2 (XI1_I1384_n1 I1_dd26_b3_3 I1_b18_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1384_MN3 (VSS I1_qu14_b3_4 XI1_I1384_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1384_MN0 (XI1_I1384_An I1_dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1382_MN1 (XI1_I1382_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1382_MN5 (XI1_I1382_n2 XI1_I1382_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1382_MN4 (I1_b18_24 XI1_I1382_An XI1_I1382_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1382_MN2 (XI1_I1382_n1 I1_dd24_b3_3 I1_b18_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1382_MN3 (VSS I1_qu14_b3_4 XI1_I1382_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1382_MN0 (XI1_I1382_An I1_dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1332_MN1 (XI1_I1332_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1332_MN5 (XI1_I1332_n2 XI1_I1332_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1332_MN4 (I1_b17_20 XI1_I1332_An XI1_I1332_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1332_MN2 (XI1_I1332_n1 I1_dd20_b3_3 I1_b17_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1332_MN3 (VSS I1_qu15_b3_3 XI1_I1332_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1332_MN0 (XI1_I1332_An I1_dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1335_MN1 (XI1_I1335_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1335_MN5 (XI1_I1335_n2 XI1_I1335_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1335_MN4 (I1_b17_23 XI1_I1335_An XI1_I1335_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1335_MN2 (XI1_I1335_n1 I1_dd23_b3_3 I1_b17_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1335_MN3 (VSS I1_qu15_b3_3 XI1_I1335_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1335_MN0 (XI1_I1335_An I1_dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1330_MN1 (XI1_I1330_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1330_MN5 (XI1_I1330_n2 XI1_I1330_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1330_MN4 (I1_b17_18 XI1_I1330_An XI1_I1330_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1330_MN2 (XI1_I1330_n1 I1_dd18_b3_3 I1_b17_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1330_MN3 (VSS I1_qu15_b3_3 XI1_I1330_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1330_MN0 (XI1_I1330_An I1_dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I216_MN1 (XI1_I1344_I216_Bn I1_I1344_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I216_MN5 (XI1_I1344_I216_n2 XI1_I1344_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I216_MN4 (I1_p17_13 XI1_I1344_I216_An XI1_I1344_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I216_MN2 (XI1_I1344_I216_n1 I1_I1344_pn13 I1_p17_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I216_MN3 (VSS I1_I1344_G12_0n XI1_I1344_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I216_MN0 (XI1_I1344_I216_An I1_I1344_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I214_MN1 (XI1_I1344_I214_Bn I1_I1344_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I214_MN5 (XI1_I1344_I214_n2 XI1_I1344_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I214_MN4 (I1_p17_11 XI1_I1344_I214_An XI1_I1344_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I214_MN2 (XI1_I1344_I214_n1 I1_I1344_pn11 I1_p17_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I214_MN3 (VSS I1_I1344_G10_0n XI1_I1344_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I214_MN0 (XI1_I1344_I214_An I1_I1344_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I213_MN1 (XI1_I1344_I213_Bn I1_I1344_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I213_MN5 (XI1_I1344_I213_n2 XI1_I1344_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I213_MN4 (I1_p17_10 XI1_I1344_I213_An XI1_I1344_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I213_MN2 (XI1_I1344_I213_n1 I1_I1344_pn10 I1_p17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I213_MN3 (VSS I1_I1344_G9_0n XI1_I1344_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I213_MN0 (XI1_I1344_I213_An I1_I1344_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I213_MN1 (XI1_I1298_I213_Bn I1_I1298_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I213_MN5 (XI1_I1298_I213_n2 XI1_I1298_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I213_MN4 (I1_p16_10 XI1_I1298_I213_An XI1_I1298_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I213_MN2 (XI1_I1298_I213_n1 I1_I1298_pn10 I1_p16_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I213_MN3 (VSS I1_I1298_G9_0n XI1_I1298_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I213_MN0 (XI1_I1298_I213_An I1_I1298_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1278_MN1 (XI1_I1278_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1278_MN5 (XI1_I1278_n2 XI1_I1278_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1278_MN4 (I1_b16_12 XI1_I1278_An XI1_I1278_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1278_MN2 (XI1_I1278_n1 I1_dd12_b3_2 I1_b16_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1278_MN3 (VSS I1_qu16_b3_2 XI1_I1278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1278_MN0 (XI1_I1278_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1280_MN1 (XI1_I1280_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1280_MN5 (XI1_I1280_n2 XI1_I1280_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1280_MN4 (I1_b16_14 XI1_I1280_An XI1_I1280_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1280_MN2 (XI1_I1280_n1 I1_dd14_b3_2 I1_b16_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1280_MN3 (VSS I1_qu16_b3_2 XI1_I1280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1280_MN0 (XI1_I1280_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I214_MN1 (XI1_I1252_I214_Bn I1_I1252_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I214_MN5 (XI1_I1252_I214_n2 XI1_I1252_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I214_MN4 (I1_p15_11 XI1_I1252_I214_An XI1_I1252_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I214_MN2 (XI1_I1252_I214_n1 I1_I1252_pn11 I1_p15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I214_MN3 (VSS I1_I1252_G10_0n XI1_I1252_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I214_MN0 (XI1_I1252_I214_An I1_I1252_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I213_MN1 (XI1_I1252_I213_Bn I1_I1252_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I213_MN5 (XI1_I1252_I213_n2 XI1_I1252_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I213_MN4 (I1_p15_10 XI1_I1252_I213_An XI1_I1252_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I213_MN2 (XI1_I1252_I213_n1 I1_I1252_pn10 I1_p15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I213_MN3 (VSS I1_I1252_G9_0n XI1_I1252_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I213_MN0 (XI1_I1252_I213_An I1_I1252_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1234_MN1 (XI1_I1234_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1234_MN5 (XI1_I1234_n2 XI1_I1234_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1234_MN4 (I1_b15_14 XI1_I1234_An XI1_I1234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1234_MN2 (XI1_I1234_n1 I1_dd14_b3_2 I1_b15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1234_MN3 (VSS I1_qu17_b3_2 XI1_I1234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1234_MN0 (XI1_I1234_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1237_MN1 (XI1_I1237_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1237_MN5 (XI1_I1237_n2 XI1_I1237_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1237_MN4 (I1_b15_17 XI1_I1237_An XI1_I1237_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1237_MN2 (XI1_I1237_n1 I1_dd17_b3_2 I1_b15_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1237_MN3 (VSS I1_qu17_b3_2 XI1_I1237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1237_MN0 (XI1_I1237_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1236_MN1 (XI1_I1236_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1236_MN5 (XI1_I1236_n2 XI1_I1236_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1236_MN4 (I1_b15_16 XI1_I1236_An XI1_I1236_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1236_MN2 (XI1_I1236_n1 I1_dd16_b3_2 I1_b15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1236_MN3 (VSS I1_qu17_b3_2 XI1_I1236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1236_MN0 (XI1_I1236_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1191_MN1 (XI1_I1191_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1191_MN5 (XI1_I1191_n2 XI1_I1191_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1191_MN4 (I1_b14_17 XI1_I1191_An XI1_I1191_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1191_MN2 (XI1_I1191_n1 I1_dd17_b3_2 I1_b14_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1191_MN3 (VSS I1_qu18_b3_2 XI1_I1191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1191_MN0 (XI1_I1191_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1189_MN1 (XI1_I1189_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1189_MN5 (XI1_I1189_n2 XI1_I1189_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1189_MN4 (I1_b14_15 XI1_I1189_An XI1_I1189_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1189_MN2 (XI1_I1189_n1 I1_dd15_b3_2 I1_b14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1189_MN3 (VSS I1_qu18_b3_2 XI1_I1189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1189_MN0 (XI1_I1189_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I214_MN1 (XI1_I1206_I214_Bn I1_I1206_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I214_MN5 (XI1_I1206_I214_n2 XI1_I1206_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I214_MN4 (I1_p14_11 XI1_I1206_I214_An XI1_I1206_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I214_MN2 (XI1_I1206_I214_n1 I1_I1206_pn11 I1_p14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I214_MN3 (VSS I1_I1206_G10_0n XI1_I1206_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I214_MN0 (XI1_I1206_I214_An I1_I1206_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I213_MN1 (XI1_I1206_I213_Bn I1_I1206_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I213_MN5 (XI1_I1206_I213_n2 XI1_I1206_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I213_MN4 (I1_p14_10 XI1_I1206_I213_An XI1_I1206_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I213_MN2 (XI1_I1206_I213_n1 I1_I1206_pn10 I1_p14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I213_MN3 (VSS I1_I1206_G9_0n XI1_I1206_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I213_MN0 (XI1_I1206_I213_An I1_I1206_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I862_MN1 (XI1_I862_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I862_MN5 (XI1_I862_n2 XI1_I862_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I862_MN4 (I1_b7_10 XI1_I862_An XI1_I862_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I862_MN2 (XI1_I862_n1 I1_dd10_b3_1 I1_b7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I862_MN3 (VSS I1_qu25_b3_1 XI1_I862_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I862_MN0 (XI1_I862_An I1_dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I861_MN1 (XI1_I861_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I861_MN5 (XI1_I861_n2 XI1_I861_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I861_MN4 (I1_b7_9 XI1_I861_An XI1_I861_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I861_MN2 (XI1_I861_n1 I1_dd9_b3_1 I1_b7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I861_MN3 (VSS I1_qu25_b3_1 XI1_I861_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I861_MN0 (XI1_I861_An I1_dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I859_MN1 (XI1_I859_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I859_MN5 (XI1_I859_n2 XI1_I859_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I859_MN4 (I1_b7_7 XI1_I859_An XI1_I859_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I859_MN2 (XI1_I859_n1 I1_dd7_b3_1 I1_b7_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I859_MN3 (VSS I1_qu25_b3_1 XI1_I859_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I859_MN0 (XI1_I859_An I1_dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I814_MN1 (XI1_I814_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I814_MN5 (XI1_I814_n2 XI1_I814_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I814_MN4 (I1_b6_8 XI1_I814_An XI1_I814_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I814_MN2 (XI1_I814_n1 I1_dd8_b3_1 I1_b6_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I814_MN3 (VSS I1_qu26_b3_1 XI1_I814_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I814_MN0 (XI1_I814_An I1_dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I813_MN1 (XI1_I813_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I813_MN5 (XI1_I813_n2 XI1_I813_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I813_MN4 (I1_b6_7 XI1_I813_An XI1_I813_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I813_MN2 (XI1_I813_n1 I1_dd7_b3_1 I1_b6_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I813_MN3 (VSS I1_qu26_b3_1 XI1_I813_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I813_MN0 (XI1_I813_An I1_dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I744_MN1 (XI1_I744_Bn I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I744_MN5 (XI1_I744_n2 XI1_I744_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I744_MN4 (I1_b4_30 XI1_I744_An XI1_I744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I744_MN2 (XI1_I744_n1 I1_dd30_b3_0 I1_b4_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I744_MN3 (VSS I1_qu28_b3_5 XI1_I744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I744_MN0 (XI1_I744_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1389_MN1 (XI1_I1389_Bn I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1389_MN5 (XI1_I1389_n2 XI1_I1389_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1389_MN4 (I1_b18_31 XI1_I1389_An XI1_I1389_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1389_MN2 (XI1_I1389_n1 I1_dd31_b3_3 I1_b18_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1389_MN3 (VSS I1_qu14_b3_5 XI1_I1389_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1389_MN0 (XI1_I1389_An I1_dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1391_MN1 (XI1_I1391_Bn I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1391_MN5 (XI1_I1391_n2 XI1_I1391_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1391_MN4 (I1_h18 XI1_I1391_An XI1_I1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1391_MN2 (XI1_I1391_n1 I1_p17_31 I1_h18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1391_MN3 (VSS I1_qu14_b3_5 XI1_I1391_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1391_MN0 (XI1_I1391_An I1_p17_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1380_MN1 (XI1_I1380_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1380_MN5 (XI1_I1380_n2 XI1_I1380_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1380_MN4 (I1_b18_22 XI1_I1380_An XI1_I1380_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1380_MN2 (XI1_I1380_n1 I1_dd22_b3_3 I1_b18_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1380_MN3 (VSS I1_qu14_b3_3 XI1_I1380_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1380_MN0 (XI1_I1380_An I1_dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1334_MN1 (XI1_I1334_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1334_MN5 (XI1_I1334_n2 XI1_I1334_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1334_MN4 (I1_b17_22 XI1_I1334_An XI1_I1334_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1334_MN2 (XI1_I1334_n1 I1_dd22_b3_3 I1_b17_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1334_MN3 (VSS I1_qu15_b3_3 XI1_I1334_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1334_MN0 (XI1_I1334_An I1_dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1333_MN1 (XI1_I1333_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1333_MN5 (XI1_I1333_n2 XI1_I1333_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1333_MN4 (I1_b17_21 XI1_I1333_An XI1_I1333_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1333_MN2 (XI1_I1333_n1 I1_dd21_b3_3 I1_b17_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1333_MN3 (VSS I1_qu15_b3_3 XI1_I1333_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1333_MN0 (XI1_I1333_An I1_dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1331_MN1 (XI1_I1331_Bn I1_qu15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1331_MN5 (XI1_I1331_n2 XI1_I1331_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1331_MN4 (I1_b17_19 XI1_I1331_An XI1_I1331_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1331_MN2 (XI1_I1331_n1 I1_dd19_b3_3 I1_b17_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1331_MN3 (VSS I1_qu15_b3_3 XI1_I1331_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1331_MN0 (XI1_I1331_An I1_dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I212_MN1 (XI1_I1344_I212_Bn I1_I1344_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I212_MN5 (XI1_I1344_I212_n2 XI1_I1344_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I212_MN4 (I1_p17_9 XI1_I1344_I212_An XI1_I1344_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I212_MN2 (XI1_I1344_I212_n1 I1_I1344_pn9 I1_p17_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I212_MN3 (VSS I1_I1344_G8_0n XI1_I1344_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I212_MN0 (XI1_I1344_I212_An I1_I1344_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I212_MN1 (XI1_I1298_I212_Bn I1_I1298_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I212_MN5 (XI1_I1298_I212_n2 XI1_I1298_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I212_MN4 (I1_p16_9 XI1_I1298_I212_An XI1_I1298_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I212_MN2 (XI1_I1298_I212_n1 I1_I1298_pn9 I1_p16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I212_MN3 (VSS I1_I1298_G8_0n XI1_I1298_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I212_MN0 (XI1_I1298_I212_An I1_I1298_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1279_MN1 (XI1_I1279_Bn I1_qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1279_MN5 (XI1_I1279_n2 XI1_I1279_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1279_MN4 (I1_b16_13 XI1_I1279_An XI1_I1279_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1279_MN2 (XI1_I1279_n1 I1_dd13_b3_2 I1_b16_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1279_MN3 (VSS I1_qu16_b3_2 XI1_I1279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1279_MN0 (XI1_I1279_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I212_MN1 (XI1_I1252_I212_Bn I1_I1252_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I212_MN5 (XI1_I1252_I212_n2 XI1_I1252_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I212_MN4 (I1_p15_9 XI1_I1252_I212_An XI1_I1252_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I212_MN2 (XI1_I1252_I212_n1 I1_I1252_pn9 I1_p15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I212_MN3 (VSS I1_I1252_G8_0n XI1_I1252_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I212_MN0 (XI1_I1252_I212_An I1_I1252_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1233_MN1 (XI1_I1233_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1233_MN5 (XI1_I1233_n2 XI1_I1233_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1233_MN4 (I1_b15_13 XI1_I1233_An XI1_I1233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1233_MN2 (XI1_I1233_n1 I1_dd13_b3_2 I1_b15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1233_MN3 (VSS I1_qu17_b3_2 XI1_I1233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1233_MN0 (XI1_I1233_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1232_MN1 (XI1_I1232_Bn I1_qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1232_MN5 (XI1_I1232_n2 XI1_I1232_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1232_MN4 (I1_b15_12 XI1_I1232_An XI1_I1232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1232_MN2 (XI1_I1232_n1 I1_dd12_b3_2 I1_b15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1232_MN3 (VSS I1_qu17_b3_2 XI1_I1232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1232_MN0 (XI1_I1232_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1190_MN1 (XI1_I1190_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1190_MN5 (XI1_I1190_n2 XI1_I1190_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1190_MN4 (I1_b14_16 XI1_I1190_An XI1_I1190_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1190_MN2 (XI1_I1190_n1 I1_dd16_b3_2 I1_b14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1190_MN3 (VSS I1_qu18_b3_2 XI1_I1190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1190_MN0 (XI1_I1190_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1187_MN1 (XI1_I1187_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1187_MN5 (XI1_I1187_n2 XI1_I1187_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1187_MN4 (I1_b14_13 XI1_I1187_An XI1_I1187_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1187_MN2 (XI1_I1187_n1 I1_dd13_b3_2 I1_b14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1187_MN3 (VSS I1_qu18_b3_2 XI1_I1187_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1187_MN0 (XI1_I1187_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1188_MN1 (XI1_I1188_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1188_MN5 (XI1_I1188_n2 XI1_I1188_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1188_MN4 (I1_b14_14 XI1_I1188_An XI1_I1188_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1188_MN2 (XI1_I1188_n1 I1_dd14_b3_2 I1_b14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1188_MN3 (VSS I1_qu18_b3_2 XI1_I1188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1188_MN0 (XI1_I1188_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I212_MN1 (XI1_I1206_I212_Bn I1_I1206_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I212_MN5 (XI1_I1206_I212_n2 XI1_I1206_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I212_MN4 (I1_p14_9 XI1_I1206_I212_An XI1_I1206_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I212_MN2 (XI1_I1206_I212_n1 I1_I1206_pn9 I1_p14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I212_MN3 (VSS I1_I1206_G8_0n XI1_I1206_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I212_MN0 (XI1_I1206_I212_An I1_I1206_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I886_MN1 (XI1_I886_Bn I1_c7_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I886_MN5 (XI1_I886_n2 XI1_I886_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I886_MN4 (I1_p7_32 XI1_I886_An XI1_I886_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I886_MN2 (XI1_I886_n1 I1_h7 I1_p7_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I886_MN3 (VSS I1_c7_o XI1_I886_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I886_MN0 (XI1_I886_An I1_h7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I860_MN1 (XI1_I860_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I860_MN5 (XI1_I860_n2 XI1_I860_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I860_MN4 (I1_b7_8 XI1_I860_An XI1_I860_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I860_MN2 (XI1_I860_n1 I1_dd8_b3_1 I1_b7_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I860_MN3 (VSS I1_qu25_b3_1 XI1_I860_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I860_MN0 (XI1_I860_An I1_dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I858_MN1 (XI1_I858_Bn I1_qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I858_MN5 (XI1_I858_n2 XI1_I858_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I858_MN4 (I1_b7_6 XI1_I858_An XI1_I858_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I858_MN2 (XI1_I858_n1 I1_dd6_b3_1 I1_b7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I858_MN3 (VSS I1_qu25_b3_1 XI1_I858_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I858_MN0 (XI1_I858_An I1_dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I812_MN1 (XI1_I812_Bn I1_qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I812_MN5 (XI1_I812_n2 XI1_I812_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I812_MN4 (I1_b6_6 XI1_I812_An XI1_I812_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I812_MN2 (XI1_I812_n1 I1_dd6_b3_1 I1_b6_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I812_MN3 (VSS I1_qu26_b3_1 XI1_I812_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I812_MN0 (XI1_I812_An I1_dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I811_MN1 (XI1_I811_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I811_MN5 (XI1_I811_n2 XI1_I811_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I811_MN4 (I1_b6_5 XI1_I811_An XI1_I811_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I811_MN2 (XI1_I811_n1 I1_dd5_b3_1 I1_b6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I811_MN3 (VSS I1_qu26_b3_0 XI1_I811_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I811_MN0 (XI1_I811_An I1_dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I206_MN1 (XI1_I746_I206_Bn I1_I746_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I206_MN5 (XI1_I746_I206_n2 XI1_I746_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I206_MN4 (I1_p4_3 XI1_I746_I206_An XI1_I746_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I206_MN2 (XI1_I746_I206_n1 I1_I746_pn3 I1_p4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I206_MN3 (VSS I1_I746_G2_0n XI1_I746_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I206_MN0 (XI1_I746_I206_An I1_I746_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I207_MN1 (XI1_I746_I207_Bn I1_I746_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I207_MN5 (XI1_I746_I207_n2 XI1_I746_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I207_MN4 (I1_p4_4 XI1_I746_I207_An XI1_I746_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I207_MN2 (XI1_I746_I207_n1 I1_I746_pn4 I1_p4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I207_MN3 (VSS I1_I746_G3_0n XI1_I746_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I207_MN0 (XI1_I746_I207_An I1_I746_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I772_MN1 (XI1_I772_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I772_MN5 (XI1_I772_n2 XI1_I772_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I772_MN4 (I1_b5_12 XI1_I772_An XI1_I772_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I772_MN2 (XI1_I772_n1 I1_dd12_b3_0 I1_b5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I772_MN3 (VSS I1_qu27_b3_2 XI1_I772_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I772_MN0 (XI1_I772_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I773_MN1 (XI1_I773_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I773_MN5 (XI1_I773_n2 XI1_I773_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I773_MN4 (I1_b5_13 XI1_I773_An XI1_I773_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I773_MN2 (XI1_I773_n1 I1_dd13_b3_0 I1_b5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I773_MN3 (VSS I1_qu27_b3_2 XI1_I773_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I773_MN0 (XI1_I773_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I774_MN1 (XI1_I774_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I774_MN5 (XI1_I774_n2 XI1_I774_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I774_MN4 (I1_b5_14 XI1_I774_An XI1_I774_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I774_MN2 (XI1_I774_n1 I1_dd14_b3_0 I1_b5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I774_MN3 (VSS I1_qu27_b3_2 XI1_I774_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I774_MN0 (XI1_I774_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I775_MN1 (XI1_I775_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I775_MN5 (XI1_I775_n2 XI1_I775_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I775_MN4 (I1_b5_15 XI1_I775_An XI1_I775_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I775_MN2 (XI1_I775_n1 I1_dd15_b3_0 I1_b5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I775_MN3 (VSS I1_qu27_b3_2 XI1_I775_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I775_MN0 (XI1_I775_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I776_MN1 (XI1_I776_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I776_MN5 (XI1_I776_n2 XI1_I776_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I776_MN4 (I1_b5_16 XI1_I776_An XI1_I776_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I776_MN2 (XI1_I776_n1 I1_dd16_b3_0 I1_b5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I776_MN3 (VSS I1_qu27_b3_2 XI1_I776_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I776_MN0 (XI1_I776_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I777_MN1 (XI1_I777_Bn I1_qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I777_MN5 (XI1_I777_n2 XI1_I777_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I777_MN4 (I1_b5_17 XI1_I777_An XI1_I777_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I777_MN2 (XI1_I777_n1 I1_dd17_b3_0 I1_b5_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I777_MN3 (VSS I1_qu27_b3_2 XI1_I777_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I777_MN0 (XI1_I777_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I728_MN1 (XI1_I728_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I728_MN5 (XI1_I728_n2 XI1_I728_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I728_MN4 (I1_b4_14 XI1_I728_An XI1_I728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I728_MN2 (XI1_I728_n1 I1_dd14_b3_0 I1_b4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I728_MN3 (VSS I1_qu28_b3_2 XI1_I728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I728_MN0 (XI1_I728_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I732_MN1 (XI1_I732_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I732_MN5 (XI1_I732_n2 XI1_I732_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I732_MN4 (I1_b4_18 XI1_I732_An XI1_I732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I732_MN2 (XI1_I732_n1 I1_dd18_b3_0 I1_b4_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I732_MN3 (VSS I1_qu28_b3_3 XI1_I732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I732_MN0 (XI1_I732_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I735_MN1 (XI1_I735_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I735_MN5 (XI1_I735_n2 XI1_I735_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I735_MN4 (I1_b4_21 XI1_I735_An XI1_I735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I735_MN2 (XI1_I735_n1 I1_dd21_b3_0 I1_b4_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I735_MN3 (VSS I1_qu28_b3_3 XI1_I735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I735_MN0 (XI1_I735_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I737_MN1 (XI1_I737_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I737_MN5 (XI1_I737_n2 XI1_I737_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I737_MN4 (I1_b4_23 XI1_I737_An XI1_I737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I737_MN2 (XI1_I737_n1 I1_dd23_b3_0 I1_b4_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I737_MN3 (VSS I1_qu28_b3_3 XI1_I737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I737_MN0 (XI1_I737_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I748_MN1 (XI1_I748_Bn I1_c4_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I748_MN5 (XI1_I748_n2 XI1_I748_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I748_MN4 (I1_p4_32 XI1_I748_An XI1_I748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I748_MN2 (XI1_I748_n1 I1_h4 I1_p4_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I748_MN3 (VSS I1_c4_o XI1_I748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I748_MN0 (XI1_I748_An I1_h4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I747_MN1 (XI1_I747_Bn I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I747_MN5 (XI1_I747_n2 XI1_I747_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I747_MN4 (I1_h4 XI1_I747_An XI1_I747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I747_MN2 (XI1_I747_n1 I1_p3_31 I1_h4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I747_MN3 (VSS I1_qu28_b3_5 XI1_I747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I747_MN0 (XI1_I747_An I1_p3_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1388_MN1 (XI1_I1388_Bn I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1388_MN5 (XI1_I1388_n2 XI1_I1388_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1388_MN4 (I1_b18_30 XI1_I1388_An XI1_I1388_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1388_MN2 (XI1_I1388_n1 I1_dd30_b3_3 I1_b18_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1388_MN3 (VSS I1_qu14_b3_5 XI1_I1388_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1388_MN0 (XI1_I1388_An I1_dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1381_MN1 (XI1_I1381_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1381_MN5 (XI1_I1381_n2 XI1_I1381_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1381_MN4 (I1_b18_23 XI1_I1381_An XI1_I1381_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1381_MN2 (XI1_I1381_n1 I1_dd23_b3_3 I1_b18_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1381_MN3 (VSS I1_qu14_b3_3 XI1_I1381_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1381_MN0 (XI1_I1381_An I1_dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1379_MN1 (XI1_I1379_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1379_MN5 (XI1_I1379_n2 XI1_I1379_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1379_MN4 (I1_b18_21 XI1_I1379_An XI1_I1379_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1379_MN2 (XI1_I1379_n1 I1_dd21_b3_3 I1_b18_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1379_MN3 (VSS I1_qu14_b3_3 XI1_I1379_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1379_MN0 (XI1_I1379_An I1_dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1378_MN1 (XI1_I1378_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1378_MN5 (XI1_I1378_n2 XI1_I1378_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1378_MN4 (I1_b18_20 XI1_I1378_An XI1_I1378_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1378_MN2 (XI1_I1378_n1 I1_dd20_b3_3 I1_b18_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1378_MN3 (VSS I1_qu14_b3_3 XI1_I1378_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1378_MN0 (XI1_I1378_An I1_dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1376_MN1 (XI1_I1376_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1376_MN5 (XI1_I1376_n2 XI1_I1376_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1376_MN4 (I1_b18_18 XI1_I1376_An XI1_I1376_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1376_MN2 (XI1_I1376_n1 I1_dd18_b3_3 I1_b18_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1376_MN3 (VSS I1_qu14_b3_3 XI1_I1376_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1376_MN0 (XI1_I1376_An I1_dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1377_MN1 (XI1_I1377_Bn I1_qu14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1377_MN5 (XI1_I1377_n2 XI1_I1377_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1377_MN4 (I1_b18_19 XI1_I1377_An XI1_I1377_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1377_MN2 (XI1_I1377_n1 I1_dd19_b3_3 I1_b18_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1377_MN3 (VSS I1_qu14_b3_3 XI1_I1377_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1377_MN0 (XI1_I1377_An I1_dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1375_MN1 (XI1_I1375_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1375_MN5 (XI1_I1375_n2 XI1_I1375_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1375_MN4 (I1_b18_17 XI1_I1375_An XI1_I1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1375_MN2 (XI1_I1375_n1 I1_dd17_b3_3 I1_b18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1375_MN3 (VSS I1_qu14_b3_2 XI1_I1375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1375_MN0 (XI1_I1375_An I1_dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1328_MN1 (XI1_I1328_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1328_MN5 (XI1_I1328_n2 XI1_I1328_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1328_MN4 (I1_b17_16 XI1_I1328_An XI1_I1328_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1328_MN2 (XI1_I1328_n1 I1_dd16_b3_3 I1_b17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1328_MN3 (VSS I1_qu15_b3_2 XI1_I1328_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1328_MN0 (XI1_I1328_An I1_dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1329_MN1 (XI1_I1329_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1329_MN5 (XI1_I1329_n2 XI1_I1329_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1329_MN4 (I1_b17_17 XI1_I1329_An XI1_I1329_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1329_MN2 (XI1_I1329_n1 I1_dd17_b3_3 I1_b17_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1329_MN3 (VSS I1_qu15_b3_2 XI1_I1329_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1329_MN0 (XI1_I1329_An I1_dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1327_MN1 (XI1_I1327_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1327_MN5 (XI1_I1327_n2 XI1_I1327_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1327_MN4 (I1_b17_15 XI1_I1327_An XI1_I1327_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1327_MN2 (XI1_I1327_n1 I1_dd15_b3_3 I1_b17_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1327_MN3 (VSS I1_qu15_b3_2 XI1_I1327_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1327_MN0 (XI1_I1327_An I1_dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1276_MN1 (XI1_I1276_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1276_MN5 (XI1_I1276_n2 XI1_I1276_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1276_MN4 (I1_b16_10 XI1_I1276_An XI1_I1276_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1276_MN2 (XI1_I1276_n1 I1_dd10_b3_2 I1_b16_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1276_MN3 (VSS I1_qu16_b3_1 XI1_I1276_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1276_MN0 (XI1_I1276_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1277_MN1 (XI1_I1277_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1277_MN5 (XI1_I1277_n2 XI1_I1277_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1277_MN4 (I1_b16_11 XI1_I1277_An XI1_I1277_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1277_MN2 (XI1_I1277_n1 I1_dd11_b3_2 I1_b16_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1277_MN3 (VSS I1_qu16_b3_1 XI1_I1277_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1277_MN0 (XI1_I1277_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1275_MN1 (XI1_I1275_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1275_MN5 (XI1_I1275_n2 XI1_I1275_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1275_MN4 (I1_b16_9 XI1_I1275_An XI1_I1275_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1275_MN2 (XI1_I1275_n1 I1_dd9_b3_2 I1_b16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1275_MN3 (VSS I1_qu16_b3_1 XI1_I1275_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1275_MN0 (XI1_I1275_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1229_MN1 (XI1_I1229_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1229_MN5 (XI1_I1229_n2 XI1_I1229_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1229_MN4 (I1_b15_9 XI1_I1229_An XI1_I1229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1229_MN2 (XI1_I1229_n1 I1_dd9_b3_2 I1_b15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1229_MN3 (VSS I1_qu17_b3_1 XI1_I1229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1229_MN0 (XI1_I1229_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1231_MN1 (XI1_I1231_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1231_MN5 (XI1_I1231_n2 XI1_I1231_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1231_MN4 (I1_b15_11 XI1_I1231_An XI1_I1231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1231_MN2 (XI1_I1231_n1 I1_dd11_b3_2 I1_b15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1231_MN3 (VSS I1_qu17_b3_1 XI1_I1231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1231_MN0 (XI1_I1231_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1230_MN1 (XI1_I1230_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1230_MN5 (XI1_I1230_n2 XI1_I1230_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1230_MN4 (I1_b15_10 XI1_I1230_An XI1_I1230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1230_MN2 (XI1_I1230_n1 I1_dd10_b3_2 I1_b15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1230_MN3 (VSS I1_qu17_b3_1 XI1_I1230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1230_MN0 (XI1_I1230_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1207_MN1 (XI1_I1207_Bn I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1207_MN5 (XI1_I1207_n2 XI1_I1207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1207_MN4 (I1_h14 XI1_I1207_An XI1_I1207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1207_MN2 (XI1_I1207_n1 I1_p13_31 I1_h14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1207_MN3 (VSS I1_qu18_b3_5 XI1_I1207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1207_MN0 (XI1_I1207_An I1_p13_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1186_MN1 (XI1_I1186_Bn I1_qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1186_MN5 (XI1_I1186_n2 XI1_I1186_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1186_MN4 (I1_b14_12 XI1_I1186_An XI1_I1186_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1186_MN2 (XI1_I1186_n1 I1_dd12_b3_2 I1_b14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1186_MN3 (VSS I1_qu18_b3_2 XI1_I1186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1186_MN0 (XI1_I1186_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1208_MN1 (XI1_I1208_Bn I1_c14_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1208_MN5 (XI1_I1208_n2 XI1_I1208_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1208_MN4 (I1_p14_32 XI1_I1208_An XI1_I1208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1208_MN2 (XI1_I1208_n1 I1_h14 I1_p14_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1208_MN3 (VSS I1_c14_o XI1_I1208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1208_MN0 (XI1_I1208_An I1_h14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I882_MN1 (XI1_I882_Bn I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I882_MN5 (XI1_I882_n2 XI1_I882_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I882_MN4 (I1_b7_30 XI1_I882_An XI1_I882_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I882_MN2 (XI1_I882_n1 I1_dd30_b3_1 I1_b7_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I882_MN3 (VSS I1_qu25_b3_5 XI1_I882_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I882_MN0 (XI1_I882_An I1_dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I219_MN1 (XI1_I884_I219_Bn I1_I884_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I219_MN5 (XI1_I884_I219_n2 XI1_I884_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I219_MN4 (I1_p7_16 XI1_I884_I219_An XI1_I884_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I219_MN2 (XI1_I884_I219_n1 I1_I884_pn16 I1_p7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I219_MN3 (VSS I1_I884_G15_0n XI1_I884_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I219_MN0 (XI1_I884_I219_An I1_I884_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I217_MN1 (XI1_I884_I217_Bn I1_I884_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I217_MN5 (XI1_I884_I217_n2 XI1_I884_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I217_MN4 (I1_p7_14 XI1_I884_I217_An XI1_I884_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I217_MN2 (XI1_I884_I217_n1 I1_I884_pn14 I1_p7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I217_MN3 (VSS I1_I884_G13_0n XI1_I884_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I217_MN0 (XI1_I884_I217_An I1_I884_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I215_MN1 (XI1_I884_I215_Bn I1_I884_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I215_MN5 (XI1_I884_I215_n2 XI1_I884_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I215_MN4 (I1_p7_12 XI1_I884_I215_An XI1_I884_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I215_MN2 (XI1_I884_I215_n1 I1_I884_pn12 I1_p7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I215_MN3 (VSS I1_I884_G11_0n XI1_I884_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I215_MN0 (XI1_I884_I215_An I1_I884_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I857_MN1 (XI1_I857_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I857_MN5 (XI1_I857_n2 XI1_I857_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I857_MN4 (I1_b7_5 XI1_I857_An XI1_I857_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I857_MN2 (XI1_I857_n1 I1_dd5_b3_1 I1_b7_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I857_MN3 (VSS I1_qu25_b3_0 XI1_I857_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I857_MN0 (XI1_I857_An I1_dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I856_MN1 (XI1_I856_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I856_MN5 (XI1_I856_n2 XI1_I856_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I856_MN4 (I1_b7_4 XI1_I856_An XI1_I856_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I856_MN2 (XI1_I856_n1 I1_dd4_b3_1 I1_b7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I856_MN3 (VSS I1_qu25_b3_0 XI1_I856_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I856_MN0 (XI1_I856_An I1_dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I809_MN1 (XI1_I809_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I809_MN5 (XI1_I809_n2 XI1_I809_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I809_MN4 (I1_b6_3 XI1_I809_An XI1_I809_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I809_MN2 (XI1_I809_n1 I1_dd3_b3_1 I1_b6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I809_MN3 (VSS I1_qu26_b3_0 XI1_I809_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I809_MN0 (XI1_I809_An I1_dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I810_MN1 (XI1_I810_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I810_MN5 (XI1_I810_n2 XI1_I810_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I810_MN4 (I1_b6_4 XI1_I810_An XI1_I810_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I810_MN2 (XI1_I810_n1 I1_dd4_b3_1 I1_b6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I810_MN3 (VSS I1_qu26_b3_0 XI1_I810_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I810_MN0 (XI1_I810_An I1_dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I766_MN1 (XI1_I766_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I766_MN5 (XI1_I766_n2 XI1_I766_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I766_MN4 (I1_b5_6 XI1_I766_An XI1_I766_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I766_MN2 (XI1_I766_n1 I1_dd6_b3_0 I1_b5_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I766_MN3 (VSS I1_qu27_b3_1 XI1_I766_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I766_MN0 (XI1_I766_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I769_MN1 (XI1_I769_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I769_MN5 (XI1_I769_n2 XI1_I769_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I769_MN4 (I1_b5_9 XI1_I769_An XI1_I769_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I769_MN2 (XI1_I769_n1 I1_dd9_b3_0 I1_b5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I769_MN3 (VSS I1_qu27_b3_1 XI1_I769_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I769_MN0 (XI1_I769_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I770_MN1 (XI1_I770_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I770_MN5 (XI1_I770_n2 XI1_I770_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I770_MN4 (I1_b5_10 XI1_I770_An XI1_I770_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I770_MN2 (XI1_I770_n1 I1_dd10_b3_0 I1_b5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I770_MN3 (VSS I1_qu27_b3_1 XI1_I770_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I770_MN0 (XI1_I770_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I724_MN1 (XI1_I724_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I724_MN5 (XI1_I724_n2 XI1_I724_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I724_MN4 (I1_b4_10 XI1_I724_An XI1_I724_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I724_MN2 (XI1_I724_n1 I1_dd10_b3_0 I1_b4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I724_MN3 (VSS I1_qu28_b3_1 XI1_I724_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I724_MN0 (XI1_I724_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I727_MN1 (XI1_I727_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I727_MN5 (XI1_I727_n2 XI1_I727_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I727_MN4 (I1_b4_13 XI1_I727_An XI1_I727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I727_MN2 (XI1_I727_n1 I1_dd13_b3_0 I1_b4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I727_MN3 (VSS I1_qu28_b3_2 XI1_I727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I727_MN0 (XI1_I727_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I726_MN1 (XI1_I726_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I726_MN5 (XI1_I726_n2 XI1_I726_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I726_MN4 (I1_b4_12 XI1_I726_An XI1_I726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I726_MN2 (XI1_I726_n1 I1_dd12_b3_0 I1_b4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I726_MN3 (VSS I1_qu28_b3_2 XI1_I726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I726_MN0 (XI1_I726_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I730_MN1 (XI1_I730_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I730_MN5 (XI1_I730_n2 XI1_I730_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I730_MN4 (I1_b4_16 XI1_I730_An XI1_I730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I730_MN2 (XI1_I730_n1 I1_dd16_b3_0 I1_b4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I730_MN3 (VSS I1_qu28_b3_2 XI1_I730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I730_MN0 (XI1_I730_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I731_MN1 (XI1_I731_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I731_MN5 (XI1_I731_n2 XI1_I731_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I731_MN4 (I1_b4_17 XI1_I731_An XI1_I731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I731_MN2 (XI1_I731_n1 I1_dd17_b3_0 I1_b4_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I731_MN3 (VSS I1_qu28_b3_2 XI1_I731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I731_MN0 (XI1_I731_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I219_MN1 (XI1_I700_I219_Bn I1_I700_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I219_MN5 (XI1_I700_I219_n2 XI1_I700_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I219_MN4 (I1_p3_16 XI1_I700_I219_An XI1_I700_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I219_MN2 (XI1_I700_I219_n1 I1_I700_pn16 I1_p3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I219_MN3 (VSS I1_I700_G15_0n XI1_I700_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I219_MN0 (XI1_I700_I219_An I1_I700_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I733_MN1 (XI1_I733_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I733_MN5 (XI1_I733_n2 XI1_I733_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I733_MN4 (I1_b4_19 XI1_I733_An XI1_I733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I733_MN2 (XI1_I733_n1 I1_dd19_b3_0 I1_b4_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I733_MN3 (VSS I1_qu28_b3_3 XI1_I733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I733_MN0 (XI1_I733_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I734_MN1 (XI1_I734_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I734_MN5 (XI1_I734_n2 XI1_I734_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I734_MN4 (I1_b4_20 XI1_I734_An XI1_I734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I734_MN2 (XI1_I734_n1 I1_dd20_b3_0 I1_b4_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I734_MN3 (VSS I1_qu28_b3_3 XI1_I734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I734_MN0 (XI1_I734_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I736_MN1 (XI1_I736_Bn I1_qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I736_MN5 (XI1_I736_n2 XI1_I736_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I736_MN4 (I1_b4_22 XI1_I736_An XI1_I736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I736_MN2 (XI1_I736_n1 I1_dd22_b3_0 I1_b4_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I736_MN3 (VSS I1_qu28_b3_3 XI1_I736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I736_MN0 (XI1_I736_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I702_MN1 (XI1_I702_Bn I1_c3_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I702_MN5 (XI1_I702_n2 XI1_I702_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I702_MN4 (I1_p3_32 XI1_I702_An XI1_I702_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I702_MN2 (XI1_I702_n1 I1_h3 I1_p3_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I702_MN3 (VSS I1_c3_o XI1_I702_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I702_MN0 (XI1_I702_An I1_h3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1374_MN1 (XI1_I1374_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1374_MN5 (XI1_I1374_n2 XI1_I1374_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1374_MN4 (I1_b18_16 XI1_I1374_An XI1_I1374_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1374_MN2 (XI1_I1374_n1 I1_dd16_b3_3 I1_b18_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1374_MN3 (VSS I1_qu14_b3_2 XI1_I1374_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1374_MN0 (XI1_I1374_An I1_dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1373_MN1 (XI1_I1373_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1373_MN5 (XI1_I1373_n2 XI1_I1373_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1373_MN4 (I1_b18_15 XI1_I1373_An XI1_I1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1373_MN2 (XI1_I1373_n1 I1_dd15_b3_3 I1_b18_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1373_MN3 (VSS I1_qu14_b3_2 XI1_I1373_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1373_MN0 (XI1_I1373_An I1_dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1326_MN1 (XI1_I1326_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1326_MN5 (XI1_I1326_n2 XI1_I1326_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1326_MN4 (I1_b17_14 XI1_I1326_An XI1_I1326_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1326_MN2 (XI1_I1326_n1 I1_dd14_b3_3 I1_b17_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1326_MN3 (VSS I1_qu15_b3_2 XI1_I1326_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1326_MN0 (XI1_I1326_An I1_dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1324_MN1 (XI1_I1324_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1324_MN5 (XI1_I1324_n2 XI1_I1324_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1324_MN4 (I1_b17_12 XI1_I1324_An XI1_I1324_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1324_MN2 (XI1_I1324_n1 I1_dd12_b3_3 I1_b17_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1324_MN3 (VSS I1_qu15_b3_2 XI1_I1324_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1324_MN0 (XI1_I1324_An I1_dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1325_MN1 (XI1_I1325_Bn I1_qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1325_MN5 (XI1_I1325_n2 XI1_I1325_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1325_MN4 (I1_b17_13 XI1_I1325_An XI1_I1325_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1325_MN2 (XI1_I1325_n1 I1_dd13_b3_3 I1_b17_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1325_MN3 (VSS I1_qu15_b3_2 XI1_I1325_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1325_MN0 (XI1_I1325_An I1_dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I207_MN1 (XI1_I1298_I207_Bn I1_I1298_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I207_MN5 (XI1_I1298_I207_n2 XI1_I1298_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I207_MN4 (I1_p16_4 XI1_I1298_I207_An XI1_I1298_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I207_MN2 (XI1_I1298_I207_n1 I1_I1298_pn4 I1_p16_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I207_MN3 (VSS I1_I1298_G3_0n XI1_I1298_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I207_MN0 (XI1_I1298_I207_An I1_I1298_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1274_MN1 (XI1_I1274_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1274_MN5 (XI1_I1274_n2 XI1_I1274_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1274_MN4 (I1_b16_8 XI1_I1274_An XI1_I1274_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1274_MN2 (XI1_I1274_n1 I1_dd8_b3_2 I1_b16_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1274_MN3 (VSS I1_qu16_b3_1 XI1_I1274_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1274_MN0 (XI1_I1274_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1273_MN1 (XI1_I1273_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1273_MN5 (XI1_I1273_n2 XI1_I1273_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1273_MN4 (I1_b16_7 XI1_I1273_An XI1_I1273_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1273_MN2 (XI1_I1273_n1 I1_dd7_b3_2 I1_b16_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1273_MN3 (VSS I1_qu16_b3_1 XI1_I1273_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1273_MN0 (XI1_I1273_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1226_MN1 (XI1_I1226_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1226_MN5 (XI1_I1226_n2 XI1_I1226_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1226_MN4 (I1_b15_6 XI1_I1226_An XI1_I1226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1226_MN2 (XI1_I1226_n1 I1_dd6_b3_2 I1_b15_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1226_MN3 (VSS I1_qu17_b3_1 XI1_I1226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1226_MN0 (XI1_I1226_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1228_MN1 (XI1_I1228_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1228_MN5 (XI1_I1228_n2 XI1_I1228_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1228_MN4 (I1_b15_8 XI1_I1228_An XI1_I1228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1228_MN2 (XI1_I1228_n1 I1_dd8_b3_2 I1_b15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1228_MN3 (VSS I1_qu17_b3_1 XI1_I1228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1228_MN0 (XI1_I1228_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1227_MN1 (XI1_I1227_Bn I1_qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1227_MN5 (XI1_I1227_n2 XI1_I1227_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1227_MN4 (I1_b15_7 XI1_I1227_An XI1_I1227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1227_MN2 (XI1_I1227_n1 I1_dd7_b3_2 I1_b15_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1227_MN3 (VSS I1_qu17_b3_1 XI1_I1227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1227_MN0 (XI1_I1227_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I215_MN1 (XI1_I1160_I215_Bn I1_I1160_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I215_MN5 (XI1_I1160_I215_n2 XI1_I1160_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I215_MN4 (I1_p13_12 XI1_I1160_I215_An XI1_I1160_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I215_MN2 (XI1_I1160_I215_n1 I1_I1160_pn12 I1_p13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I215_MN3 (VSS I1_I1160_G11_0n XI1_I1160_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I215_MN0 (XI1_I1160_I215_An I1_I1160_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1185_MN1 (XI1_I1185_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1185_MN5 (XI1_I1185_n2 XI1_I1185_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1185_MN4 (I1_b14_11 XI1_I1185_An XI1_I1185_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1185_MN2 (XI1_I1185_n1 I1_dd11_b3_2 I1_b14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1185_MN3 (VSS I1_qu18_b3_1 XI1_I1185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1185_MN0 (XI1_I1185_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1184_MN1 (XI1_I1184_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1184_MN5 (XI1_I1184_n2 XI1_I1184_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1184_MN4 (I1_b14_10 XI1_I1184_An XI1_I1184_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1184_MN2 (XI1_I1184_n1 I1_dd10_b3_2 I1_b14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1184_MN3 (VSS I1_qu18_b3_1 XI1_I1184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1184_MN0 (XI1_I1184_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1183_MN1 (XI1_I1183_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1183_MN5 (XI1_I1183_n2 XI1_I1183_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1183_MN4 (I1_b14_9 XI1_I1183_An XI1_I1183_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1183_MN2 (XI1_I1183_n1 I1_dd9_b3_2 I1_b14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1183_MN3 (VSS I1_qu18_b3_1 XI1_I1183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1183_MN0 (XI1_I1183_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1182_MN1 (XI1_I1182_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1182_MN5 (XI1_I1182_n2 XI1_I1182_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1182_MN4 (I1_b14_8 XI1_I1182_An XI1_I1182_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1182_MN2 (XI1_I1182_n1 I1_dd8_b3_2 I1_b14_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1182_MN3 (VSS I1_qu18_b3_1 XI1_I1182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1182_MN0 (XI1_I1182_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1180_MN1 (XI1_I1180_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1180_MN5 (XI1_I1180_n2 XI1_I1180_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1180_MN4 (I1_b14_6 XI1_I1180_An XI1_I1180_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1180_MN2 (XI1_I1180_n1 I1_dd6_b3_2 I1_b14_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1180_MN3 (VSS I1_qu18_b3_1 XI1_I1180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1180_MN0 (XI1_I1180_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I207_MN1 (XI1_I1206_I207_Bn I1_I1206_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I207_MN5 (XI1_I1206_I207_n2 XI1_I1206_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I207_MN4 (I1_p14_4 XI1_I1206_I207_An XI1_I1206_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I207_MN2 (XI1_I1206_I207_n1 I1_I1206_pn4 I1_p14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I207_MN3 (VSS I1_I1206_G3_0n XI1_I1206_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I207_MN0 (XI1_I1206_I207_An I1_I1206_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I206_MN1 (XI1_I1206_I206_Bn I1_I1206_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I206_MN5 (XI1_I1206_I206_n2 XI1_I1206_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I206_MN4 (I1_p14_3 XI1_I1206_I206_An XI1_I1206_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I206_MN2 (XI1_I1206_I206_n1 I1_I1206_pn3 I1_p14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I206_MN3 (VSS I1_I1206_G2_0n XI1_I1206_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I206_MN0 (XI1_I1206_I206_An I1_I1206_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I213_MN1 (XI1_I884_I213_Bn I1_I884_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I213_MN5 (XI1_I884_I213_n2 XI1_I884_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I213_MN4 (I1_p7_10 XI1_I884_I213_An XI1_I884_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I213_MN2 (XI1_I884_I213_n1 I1_I884_pn10 I1_p7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I213_MN3 (VSS I1_I884_G9_0n XI1_I884_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I213_MN0 (XI1_I884_I213_An I1_I884_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I207_MN1 (XI1_I884_I207_Bn I1_I884_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I207_MN5 (XI1_I884_I207_n2 XI1_I884_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I207_MN4 (I1_p7_4 XI1_I884_I207_An XI1_I884_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I207_MN2 (XI1_I884_I207_n1 I1_I884_pn4 I1_p7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I207_MN3 (VSS I1_I884_G3_0n XI1_I884_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I207_MN0 (XI1_I884_I207_An I1_I884_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I855_MN1 (XI1_I855_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I855_MN5 (XI1_I855_n2 XI1_I855_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I855_MN4 (I1_b7_3 XI1_I855_An XI1_I855_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I855_MN2 (XI1_I855_n1 I1_dd3_b3_1 I1_b7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I855_MN3 (VSS I1_qu25_b3_0 XI1_I855_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I855_MN0 (XI1_I855_An I1_dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I808_MN1 (XI1_I808_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I808_MN5 (XI1_I808_n2 XI1_I808_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I808_MN4 (I1_b6_2 XI1_I808_An XI1_I808_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I808_MN2 (XI1_I808_n1 I1_dd2_b3_1 I1_b6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I808_MN3 (VSS I1_qu26_b3_0 XI1_I808_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I808_MN0 (XI1_I808_An I1_dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I765_MN1 (XI1_I765_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I765_MN5 (XI1_I765_n2 XI1_I765_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I765_MN4 (I1_b5_5 XI1_I765_An XI1_I765_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I765_MN2 (XI1_I765_n1 I1_dd5_b3_0 I1_b5_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I765_MN3 (VSS I1_qu27_b3_0 XI1_I765_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I765_MN0 (XI1_I765_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I767_MN1 (XI1_I767_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I767_MN5 (XI1_I767_n2 XI1_I767_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I767_MN4 (I1_b5_7 XI1_I767_An XI1_I767_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I767_MN2 (XI1_I767_n1 I1_dd7_b3_0 I1_b5_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I767_MN3 (VSS I1_qu27_b3_1 XI1_I767_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I767_MN0 (XI1_I767_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I768_MN1 (XI1_I768_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I768_MN5 (XI1_I768_n2 XI1_I768_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I768_MN4 (I1_b5_8 XI1_I768_An XI1_I768_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I768_MN2 (XI1_I768_n1 I1_dd8_b3_0 I1_b5_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I768_MN3 (VSS I1_qu27_b3_1 XI1_I768_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I768_MN0 (XI1_I768_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I771_MN1 (XI1_I771_Bn I1_qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I771_MN5 (XI1_I771_n2 XI1_I771_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I771_MN4 (I1_b5_11 XI1_I771_An XI1_I771_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I771_MN2 (XI1_I771_n1 I1_dd11_b3_0 I1_b5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I771_MN3 (VSS I1_qu27_b3_1 XI1_I771_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I771_MN0 (XI1_I771_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I720_MN1 (XI1_I720_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I720_MN5 (XI1_I720_n2 XI1_I720_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I720_MN4 (I1_b4_6 XI1_I720_An XI1_I720_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I720_MN2 (XI1_I720_n1 I1_dd6_b3_0 I1_b4_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I720_MN3 (VSS I1_qu28_b3_1 XI1_I720_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I720_MN0 (XI1_I720_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I722_MN1 (XI1_I722_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I722_MN5 (XI1_I722_n2 XI1_I722_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I722_MN4 (I1_b4_8 XI1_I722_An XI1_I722_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I722_MN2 (XI1_I722_n1 I1_dd8_b3_0 I1_b4_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I722_MN3 (VSS I1_qu28_b3_1 XI1_I722_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I722_MN0 (XI1_I722_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I725_MN1 (XI1_I725_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I725_MN5 (XI1_I725_n2 XI1_I725_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I725_MN4 (I1_b4_11 XI1_I725_An XI1_I725_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I725_MN2 (XI1_I725_n1 I1_dd11_b3_0 I1_b4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I725_MN3 (VSS I1_qu28_b3_1 XI1_I725_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I725_MN0 (XI1_I725_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I723_MN1 (XI1_I723_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I723_MN5 (XI1_I723_n2 XI1_I723_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I723_MN4 (I1_b4_9 XI1_I723_An XI1_I723_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I723_MN2 (XI1_I723_n1 I1_dd9_b3_0 I1_b4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I723_MN3 (VSS I1_qu28_b3_1 XI1_I723_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I723_MN0 (XI1_I723_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I213_MN1 (XI1_I700_I213_Bn I1_I700_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I213_MN5 (XI1_I700_I213_n2 XI1_I700_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I213_MN4 (I1_p3_10 XI1_I700_I213_An XI1_I700_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I213_MN2 (XI1_I700_I213_n1 I1_I700_pn10 I1_p3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I213_MN3 (VSS I1_I700_G9_0n XI1_I700_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I213_MN0 (XI1_I700_I213_An I1_I700_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I215_MN1 (XI1_I700_I215_Bn I1_I700_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I215_MN5 (XI1_I700_I215_n2 XI1_I700_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I215_MN4 (I1_p3_12 XI1_I700_I215_An XI1_I700_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I215_MN2 (XI1_I700_I215_n1 I1_I700_pn12 I1_p3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I215_MN3 (VSS I1_I700_G11_0n XI1_I700_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I215_MN0 (XI1_I700_I215_An I1_I700_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I729_MN1 (XI1_I729_Bn I1_qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I729_MN5 (XI1_I729_n2 XI1_I729_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I729_MN4 (I1_b4_15 XI1_I729_An XI1_I729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I729_MN2 (XI1_I729_n1 I1_dd15_b3_0 I1_b4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I729_MN3 (VSS I1_qu28_b3_2 XI1_I729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I729_MN0 (XI1_I729_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I217_MN1 (XI1_I700_I217_Bn I1_I700_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I217_MN5 (XI1_I700_I217_n2 XI1_I700_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I217_MN4 (I1_p3_14 XI1_I700_I217_An XI1_I700_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I217_MN2 (XI1_I700_I217_n1 I1_I700_pn14 I1_p3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I217_MN3 (VSS I1_I700_G13_0n XI1_I700_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I217_MN0 (XI1_I700_I217_An I1_I700_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1372_MN1 (XI1_I1372_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1372_MN5 (XI1_I1372_n2 XI1_I1372_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1372_MN4 (I1_b18_14 XI1_I1372_An XI1_I1372_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1372_MN2 (XI1_I1372_n1 I1_dd14_b3_3 I1_b18_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1372_MN3 (VSS I1_qu14_b3_2 XI1_I1372_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1372_MN0 (XI1_I1372_An I1_dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1370_MN1 (XI1_I1370_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1370_MN5 (XI1_I1370_n2 XI1_I1370_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1370_MN4 (I1_b18_12 XI1_I1370_An XI1_I1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1370_MN2 (XI1_I1370_n1 I1_dd12_b3_3 I1_b18_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1370_MN3 (VSS I1_qu14_b3_2 XI1_I1370_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1370_MN0 (XI1_I1370_An I1_dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1371_MN1 (XI1_I1371_Bn I1_qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1371_MN5 (XI1_I1371_n2 XI1_I1371_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1371_MN4 (I1_b18_13 XI1_I1371_An XI1_I1371_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1371_MN2 (XI1_I1371_n1 I1_dd13_b3_3 I1_b18_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1371_MN3 (VSS I1_qu14_b3_2 XI1_I1371_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1371_MN0 (XI1_I1371_An I1_dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1368_MN1 (XI1_I1368_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1368_MN5 (XI1_I1368_n2 XI1_I1368_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1368_MN4 (I1_b18_10 XI1_I1368_An XI1_I1368_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1368_MN2 (XI1_I1368_n1 I1_dd10_b3_3 I1_b18_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1368_MN3 (VSS I1_qu14_b3_1 XI1_I1368_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1368_MN0 (XI1_I1368_An I1_dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1322_MN1 (XI1_I1322_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1322_MN5 (XI1_I1322_n2 XI1_I1322_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1322_MN4 (I1_b17_10 XI1_I1322_An XI1_I1322_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1322_MN2 (XI1_I1322_n1 I1_dd10_b3_3 I1_b17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1322_MN3 (VSS I1_qu15_b3_1 XI1_I1322_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1322_MN0 (XI1_I1322_An I1_dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1323_MN1 (XI1_I1323_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1323_MN5 (XI1_I1323_n2 XI1_I1323_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1323_MN4 (I1_b17_11 XI1_I1323_An XI1_I1323_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1323_MN2 (XI1_I1323_n1 I1_dd11_b3_3 I1_b17_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1323_MN3 (VSS I1_qu15_b3_1 XI1_I1323_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1323_MN0 (XI1_I1323_An I1_dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1320_MN1 (XI1_I1320_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1320_MN5 (XI1_I1320_n2 XI1_I1320_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1320_MN4 (I1_b17_8 XI1_I1320_An XI1_I1320_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1320_MN2 (XI1_I1320_n1 I1_dd8_b3_3 I1_b17_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1320_MN3 (VSS I1_qu15_b3_1 XI1_I1320_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1320_MN0 (XI1_I1320_An I1_dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1319_MN1 (XI1_I1319_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1319_MN5 (XI1_I1319_n2 XI1_I1319_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1319_MN4 (I1_b17_7 XI1_I1319_An XI1_I1319_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1319_MN2 (XI1_I1319_n1 I1_dd7_b3_3 I1_b17_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1319_MN3 (VSS I1_qu15_b3_1 XI1_I1319_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1319_MN0 (XI1_I1319_An I1_dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I206_MN1 (XI1_I1298_I206_Bn I1_I1298_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I206_MN5 (XI1_I1298_I206_n2 XI1_I1298_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I206_MN4 (I1_p16_3 XI1_I1298_I206_An XI1_I1298_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I206_MN2 (XI1_I1298_I206_n1 I1_I1298_pn3 I1_p16_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I206_MN3 (VSS I1_I1298_G2_0n XI1_I1298_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I206_MN0 (XI1_I1298_I206_An I1_I1298_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1271_MN1 (XI1_I1271_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1271_MN5 (XI1_I1271_n2 XI1_I1271_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1271_MN4 (I1_b16_5 XI1_I1271_An XI1_I1271_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1271_MN2 (XI1_I1271_n1 I1_dd5_b3_2 I1_b16_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1271_MN3 (VSS I1_qu16_b3_0 XI1_I1271_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1271_MN0 (XI1_I1271_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1272_MN1 (XI1_I1272_Bn I1_qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1272_MN5 (XI1_I1272_n2 XI1_I1272_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1272_MN4 (I1_b16_6 XI1_I1272_An XI1_I1272_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1272_MN2 (XI1_I1272_n1 I1_dd6_b3_2 I1_b16_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1272_MN3 (VSS I1_qu16_b3_1 XI1_I1272_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1272_MN0 (XI1_I1272_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I206_MN1 (XI1_I1252_I206_Bn I1_I1252_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I206_MN5 (XI1_I1252_I206_n2 XI1_I1252_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I206_MN4 (I1_p15_3 XI1_I1252_I206_An XI1_I1252_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I206_MN2 (XI1_I1252_I206_n1 I1_I1252_pn3 I1_p15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I206_MN3 (VSS I1_I1252_G2_0n XI1_I1252_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I206_MN0 (XI1_I1252_I206_An I1_I1252_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I207_MN1 (XI1_I1252_I207_Bn I1_I1252_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I207_MN5 (XI1_I1252_I207_n2 XI1_I1252_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I207_MN4 (I1_p15_4 XI1_I1252_I207_An XI1_I1252_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I207_MN2 (XI1_I1252_I207_n1 I1_I1252_pn4 I1_p15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I207_MN3 (VSS I1_I1252_G3_0n XI1_I1252_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I207_MN0 (XI1_I1252_I207_An I1_I1252_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1225_MN1 (XI1_I1225_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1225_MN5 (XI1_I1225_n2 XI1_I1225_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1225_MN4 (I1_b15_5 XI1_I1225_An XI1_I1225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1225_MN2 (XI1_I1225_n1 I1_dd5_b3_2 I1_b15_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1225_MN3 (VSS I1_qu17_b3_0 XI1_I1225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1225_MN0 (XI1_I1225_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1162_MN1 (XI1_I1162_Bn I1_c13_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1162_MN5 (XI1_I1162_n2 XI1_I1162_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1162_MN4 (I1_p13_32 XI1_I1162_An XI1_I1162_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1162_MN2 (XI1_I1162_n1 I1_h13 I1_p13_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1162_MN3 (VSS I1_c13_o XI1_I1162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1162_MN0 (XI1_I1162_An I1_h13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I219_MN1 (XI1_I1160_I219_Bn I1_I1160_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I219_MN5 (XI1_I1160_I219_n2 XI1_I1160_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I219_MN4 (I1_p13_16 XI1_I1160_I219_An XI1_I1160_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I219_MN2 (XI1_I1160_I219_n1 I1_I1160_pn16 I1_p13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I219_MN3 (VSS I1_I1160_G15_0n XI1_I1160_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I219_MN0 (XI1_I1160_I219_An I1_I1160_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I217_MN1 (XI1_I1160_I217_Bn I1_I1160_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I217_MN5 (XI1_I1160_I217_n2 XI1_I1160_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I217_MN4 (I1_p13_14 XI1_I1160_I217_An XI1_I1160_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I217_MN2 (XI1_I1160_I217_n1 I1_I1160_pn14 I1_p13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I217_MN3 (VSS I1_I1160_G13_0n XI1_I1160_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I217_MN0 (XI1_I1160_I217_An I1_I1160_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I213_MN1 (XI1_I1160_I213_Bn I1_I1160_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I213_MN5 (XI1_I1160_I213_n2 XI1_I1160_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I213_MN4 (I1_p13_10 XI1_I1160_I213_An XI1_I1160_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I213_MN2 (XI1_I1160_I213_n1 I1_I1160_pn10 I1_p13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I213_MN3 (VSS I1_I1160_G9_0n XI1_I1160_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I213_MN0 (XI1_I1160_I213_An I1_I1160_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1181_MN1 (XI1_I1181_Bn I1_qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1181_MN5 (XI1_I1181_n2 XI1_I1181_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1181_MN4 (I1_b14_7 XI1_I1181_An XI1_I1181_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1181_MN2 (XI1_I1181_n1 I1_dd7_b3_2 I1_b14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1181_MN3 (VSS I1_qu18_b3_1 XI1_I1181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1181_MN0 (XI1_I1181_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I918_MN1 (XI1_I918_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I918_MN5 (XI1_I918_n2 XI1_I918_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I918_MN4 (I1_b8_20 XI1_I918_An XI1_I918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I918_MN2 (XI1_I918_n1 I1_dd20_b3_1 I1_b8_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I918_MN3 (VSS I1_qu24_b3_3 XI1_I918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I918_MN0 (XI1_I918_An I1_dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I218_MN1 (XI1_I884_I218_Bn I1_I884_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I218_MN5 (XI1_I884_I218_n2 XI1_I884_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I218_MN4 (I1_p7_15 XI1_I884_I218_An XI1_I884_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I218_MN2 (XI1_I884_I218_n1 I1_I884_pn15 I1_p7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I218_MN3 (VSS I1_I884_G14_0n XI1_I884_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I218_MN0 (XI1_I884_I218_An I1_I884_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I216_MN1 (XI1_I884_I216_Bn I1_I884_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I216_MN5 (XI1_I884_I216_n2 XI1_I884_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I216_MN4 (I1_p7_13 XI1_I884_I216_An XI1_I884_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I216_MN2 (XI1_I884_I216_n1 I1_I884_pn13 I1_p7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I216_MN3 (VSS I1_I884_G12_0n XI1_I884_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I216_MN0 (XI1_I884_I216_An I1_I884_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I214_MN1 (XI1_I884_I214_Bn I1_I884_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I214_MN5 (XI1_I884_I214_n2 XI1_I884_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I214_MN4 (I1_p7_11 XI1_I884_I214_An XI1_I884_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I214_MN2 (XI1_I884_I214_n1 I1_I884_pn11 I1_p7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I214_MN3 (VSS I1_I884_G10_0n XI1_I884_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I214_MN0 (XI1_I884_I214_An I1_I884_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I763_MN1 (XI1_I763_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I763_MN5 (XI1_I763_n2 XI1_I763_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I763_MN4 (I1_b5_3 XI1_I763_An XI1_I763_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I763_MN2 (XI1_I763_n1 I1_dd3_b3_0 I1_b5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I763_MN3 (VSS I1_qu27_b3_0 XI1_I763_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I763_MN0 (XI1_I763_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I762_MN1 (XI1_I762_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I762_MN5 (XI1_I762_n2 XI1_I762_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I762_MN4 (I1_b5_2 XI1_I762_An XI1_I762_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I762_MN2 (XI1_I762_n1 I1_dd2_b3_0 I1_b5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I762_MN3 (VSS I1_qu27_b3_0 XI1_I762_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I762_MN0 (XI1_I762_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I764_MN1 (XI1_I764_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I764_MN5 (XI1_I764_n2 XI1_I764_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I764_MN4 (I1_b5_4 XI1_I764_An XI1_I764_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I764_MN2 (XI1_I764_n1 I1_dd4_b3_0 I1_b5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I764_MN3 (VSS I1_qu27_b3_0 XI1_I764_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I764_MN0 (XI1_I764_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I717_MN1 (XI1_I717_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I717_MN5 (XI1_I717_n2 XI1_I717_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I717_MN4 (I1_b4_3 XI1_I717_An XI1_I717_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I717_MN2 (XI1_I717_n1 I1_dd3_b3_0 I1_b4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I717_MN3 (VSS I1_qu28_b3_0 XI1_I717_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I717_MN0 (XI1_I717_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I207_MN1 (XI1_I700_I207_Bn I1_I700_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I207_MN5 (XI1_I700_I207_n2 XI1_I700_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I207_MN4 (I1_p3_4 XI1_I700_I207_An XI1_I700_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I207_MN2 (XI1_I700_I207_n1 I1_I700_pn4 I1_p3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I207_MN3 (VSS I1_I700_G3_0n XI1_I700_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I207_MN0 (XI1_I700_I207_An I1_I700_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I721_MN1 (XI1_I721_Bn I1_qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I721_MN5 (XI1_I721_n2 XI1_I721_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I721_MN4 (I1_b4_7 XI1_I721_An XI1_I721_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I721_MN2 (XI1_I721_n1 I1_dd7_b3_0 I1_b4_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I721_MN3 (VSS I1_qu28_b3_1 XI1_I721_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I721_MN0 (XI1_I721_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1369_MN1 (XI1_I1369_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1369_MN5 (XI1_I1369_n2 XI1_I1369_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1369_MN4 (I1_b18_11 XI1_I1369_An XI1_I1369_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1369_MN2 (XI1_I1369_n1 I1_dd11_b3_3 I1_b18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1369_MN3 (VSS I1_qu14_b3_1 XI1_I1369_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1369_MN0 (XI1_I1369_An I1_dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1321_MN1 (XI1_I1321_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1321_MN5 (XI1_I1321_n2 XI1_I1321_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1321_MN4 (I1_b17_9 XI1_I1321_An XI1_I1321_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1321_MN2 (XI1_I1321_n1 I1_dd9_b3_3 I1_b17_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1321_MN3 (VSS I1_qu15_b3_1 XI1_I1321_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1321_MN0 (XI1_I1321_An I1_dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1367_MN1 (XI1_I1367_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1367_MN5 (XI1_I1367_n2 XI1_I1367_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1367_MN4 (I1_b18_9 XI1_I1367_An XI1_I1367_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1367_MN2 (XI1_I1367_n1 I1_dd9_b3_3 I1_b18_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1367_MN3 (VSS I1_qu14_b3_1 XI1_I1367_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1367_MN0 (XI1_I1367_An I1_dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1318_MN1 (XI1_I1318_Bn I1_qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1318_MN5 (XI1_I1318_n2 XI1_I1318_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1318_MN4 (I1_b17_6 XI1_I1318_An XI1_I1318_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1318_MN2 (XI1_I1318_n1 I1_dd6_b3_3 I1_b17_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1318_MN3 (VSS I1_qu15_b3_1 XI1_I1318_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1318_MN0 (XI1_I1318_An I1_dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I207_MN1 (XI1_I1344_I207_Bn I1_I1344_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I207_MN5 (XI1_I1344_I207_n2 XI1_I1344_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I207_MN4 (I1_p17_4 XI1_I1344_I207_An XI1_I1344_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I207_MN2 (XI1_I1344_I207_n1 I1_I1344_pn4 I1_p17_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I207_MN3 (VSS I1_I1344_G3_0n XI1_I1344_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I207_MN0 (XI1_I1344_I207_An I1_I1344_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1269_MN1 (XI1_I1269_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1269_MN5 (XI1_I1269_n2 XI1_I1269_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1269_MN4 (I1_b16_3 XI1_I1269_An XI1_I1269_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1269_MN2 (XI1_I1269_n1 I1_dd3_b3_2 I1_b16_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1269_MN3 (VSS I1_qu16_b3_0 XI1_I1269_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1269_MN0 (XI1_I1269_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1270_MN1 (XI1_I1270_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1270_MN5 (XI1_I1270_n2 XI1_I1270_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1270_MN4 (I1_b16_4 XI1_I1270_An XI1_I1270_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1270_MN2 (XI1_I1270_n1 I1_dd4_b3_2 I1_b16_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1270_MN3 (VSS I1_qu16_b3_0 XI1_I1270_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1270_MN0 (XI1_I1270_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1223_MN1 (XI1_I1223_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1223_MN5 (XI1_I1223_n2 XI1_I1223_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1223_MN4 (I1_b15_3 XI1_I1223_An XI1_I1223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1223_MN2 (XI1_I1223_n1 I1_dd3_b3_2 I1_b15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1223_MN3 (VSS I1_qu17_b3_0 XI1_I1223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1223_MN0 (XI1_I1223_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1224_MN1 (XI1_I1224_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1224_MN5 (XI1_I1224_n2 XI1_I1224_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1224_MN4 (I1_b15_4 XI1_I1224_An XI1_I1224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1224_MN2 (XI1_I1224_n1 I1_dd4_b3_2 I1_b15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1224_MN3 (VSS I1_qu17_b3_0 XI1_I1224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1224_MN0 (XI1_I1224_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1179_MN1 (XI1_I1179_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1179_MN5 (XI1_I1179_n2 XI1_I1179_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1179_MN4 (I1_b14_5 XI1_I1179_An XI1_I1179_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1179_MN2 (XI1_I1179_n1 I1_dd5_b3_2 I1_b14_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1179_MN3 (VSS I1_qu18_b3_0 XI1_I1179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1179_MN0 (XI1_I1179_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1178_MN1 (XI1_I1178_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1178_MN5 (XI1_I1178_n2 XI1_I1178_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1178_MN4 (I1_b14_4 XI1_I1178_An XI1_I1178_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1178_MN2 (XI1_I1178_n1 I1_dd4_b3_2 I1_b14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1178_MN3 (VSS I1_qu18_b3_0 XI1_I1178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1178_MN0 (XI1_I1178_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I927_MN1 (XI1_I927_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I927_MN5 (XI1_I927_n2 XI1_I927_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I927_MN4 (I1_b8_29 XI1_I927_An XI1_I927_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I927_MN2 (XI1_I927_n1 I1_dd29_b3_1 I1_b8_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I927_MN3 (VSS I1_qu24_b3_4 XI1_I927_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I927_MN0 (XI1_I927_An I1_dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I925_MN1 (XI1_I925_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I925_MN5 (XI1_I925_n2 XI1_I925_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I925_MN4 (I1_b8_27 XI1_I925_An XI1_I925_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I925_MN2 (XI1_I925_n1 I1_dd27_b3_1 I1_b8_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I925_MN3 (VSS I1_qu24_b3_4 XI1_I925_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I925_MN0 (XI1_I925_An I1_dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I926_MN1 (XI1_I926_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I926_MN5 (XI1_I926_n2 XI1_I926_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I926_MN4 (I1_b8_28 XI1_I926_An XI1_I926_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I926_MN2 (XI1_I926_n1 I1_dd28_b3_1 I1_b8_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I926_MN3 (VSS I1_qu24_b3_4 XI1_I926_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I926_MN0 (XI1_I926_An I1_dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I924_MN1 (XI1_I924_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I924_MN5 (XI1_I924_n2 XI1_I924_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I924_MN4 (I1_b8_26 XI1_I924_An XI1_I924_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I924_MN2 (XI1_I924_n1 I1_dd26_b3_1 I1_b8_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I924_MN3 (VSS I1_qu24_b3_4 XI1_I924_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I924_MN0 (XI1_I924_An I1_dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I923_MN1 (XI1_I923_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I923_MN5 (XI1_I923_n2 XI1_I923_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I923_MN4 (I1_b8_25 XI1_I923_An XI1_I923_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I923_MN2 (XI1_I923_n1 I1_dd25_b3_1 I1_b8_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I923_MN3 (VSS I1_qu24_b3_4 XI1_I923_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I923_MN0 (XI1_I923_An I1_dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I922_MN1 (XI1_I922_Bn I1_qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I922_MN5 (XI1_I922_n2 XI1_I922_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I922_MN4 (I1_b8_24 XI1_I922_An XI1_I922_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I922_MN2 (XI1_I922_n1 I1_dd24_b3_1 I1_b8_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I922_MN3 (VSS I1_qu24_b3_4 XI1_I922_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I922_MN0 (XI1_I922_An I1_dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I921_MN1 (XI1_I921_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I921_MN5 (XI1_I921_n2 XI1_I921_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I921_MN4 (I1_b8_23 XI1_I921_An XI1_I921_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I921_MN2 (XI1_I921_n1 I1_dd23_b3_1 I1_b8_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I921_MN3 (VSS I1_qu24_b3_3 XI1_I921_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I921_MN0 (XI1_I921_An I1_dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I920_MN1 (XI1_I920_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I920_MN5 (XI1_I920_n2 XI1_I920_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I920_MN4 (I1_b8_22 XI1_I920_An XI1_I920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I920_MN2 (XI1_I920_n1 I1_dd22_b3_1 I1_b8_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I920_MN3 (VSS I1_qu24_b3_3 XI1_I920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I920_MN0 (XI1_I920_An I1_dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I919_MN1 (XI1_I919_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I919_MN5 (XI1_I919_n2 XI1_I919_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I919_MN4 (I1_b8_21 XI1_I919_An XI1_I919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I919_MN2 (XI1_I919_n1 I1_dd21_b3_1 I1_b8_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I919_MN3 (VSS I1_qu24_b3_3 XI1_I919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I919_MN0 (XI1_I919_An I1_dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I916_MN1 (XI1_I916_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I916_MN5 (XI1_I916_n2 XI1_I916_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I916_MN4 (I1_b8_18 XI1_I916_An XI1_I916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I916_MN2 (XI1_I916_n1 I1_dd18_b3_1 I1_b8_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I916_MN3 (VSS I1_qu24_b3_3 XI1_I916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I916_MN0 (XI1_I916_An I1_dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I917_MN1 (XI1_I917_Bn I1_qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I917_MN5 (XI1_I917_n2 XI1_I917_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I917_MN4 (I1_b8_19 XI1_I917_An XI1_I917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I917_MN2 (XI1_I917_n1 I1_dd19_b3_1 I1_b8_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I917_MN3 (VSS I1_qu24_b3_3 XI1_I917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I917_MN0 (XI1_I917_An I1_dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I914_MN1 (XI1_I914_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I914_MN5 (XI1_I914_n2 XI1_I914_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I914_MN4 (I1_b8_16 XI1_I914_An XI1_I914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I914_MN2 (XI1_I914_n1 I1_dd16_b3_1 I1_b8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I914_MN3 (VSS I1_qu24_b3_2 XI1_I914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I914_MN0 (XI1_I914_An I1_dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I915_MN1 (XI1_I915_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I915_MN5 (XI1_I915_n2 XI1_I915_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I915_MN4 (I1_b8_17 XI1_I915_An XI1_I915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I915_MN2 (XI1_I915_n1 I1_dd17_b3_1 I1_b8_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I915_MN3 (VSS I1_qu24_b3_2 XI1_I915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I915_MN0 (XI1_I915_An I1_dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I911_MN1 (XI1_I911_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I911_MN5 (XI1_I911_n2 XI1_I911_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I911_MN4 (I1_b8_13 XI1_I911_An XI1_I911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I911_MN2 (XI1_I911_n1 I1_dd13_b3_1 I1_b8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I911_MN3 (VSS I1_qu24_b3_2 XI1_I911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I911_MN0 (XI1_I911_An I1_dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I912_MN1 (XI1_I912_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I912_MN5 (XI1_I912_n2 XI1_I912_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I912_MN4 (I1_b8_14 XI1_I912_An XI1_I912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I912_MN2 (XI1_I912_n1 I1_dd14_b3_1 I1_b8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I912_MN3 (VSS I1_qu24_b3_2 XI1_I912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I912_MN0 (XI1_I912_An I1_dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I910_MN1 (XI1_I910_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I910_MN5 (XI1_I910_n2 XI1_I910_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I910_MN4 (I1_b8_12 XI1_I910_An XI1_I910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I910_MN2 (XI1_I910_n1 I1_dd12_b3_1 I1_b8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I910_MN3 (VSS I1_qu24_b3_2 XI1_I910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I910_MN0 (XI1_I910_An I1_dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I212_MN1 (XI1_I884_I212_Bn I1_I884_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I212_MN5 (XI1_I884_I212_n2 XI1_I884_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I212_MN4 (I1_p7_9 XI1_I884_I212_An XI1_I884_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I212_MN2 (XI1_I884_I212_n1 I1_I884_pn9 I1_p7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I212_MN3 (VSS I1_I884_G8_0n XI1_I884_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I212_MN0 (XI1_I884_I212_An I1_I884_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I908_MN1 (XI1_I908_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I908_MN5 (XI1_I908_n2 XI1_I908_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I908_MN4 (I1_b8_10 XI1_I908_An XI1_I908_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I908_MN2 (XI1_I908_n1 I1_dd10_b3_1 I1_b8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I908_MN3 (VSS I1_qu24_b3_1 XI1_I908_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I908_MN0 (XI1_I908_An I1_dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I905_MN1 (XI1_I905_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I905_MN5 (XI1_I905_n2 XI1_I905_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I905_MN4 (I1_b8_7 XI1_I905_An XI1_I905_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I905_MN2 (XI1_I905_n1 I1_dd7_b3_1 I1_b8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I905_MN3 (VSS I1_qu24_b3_1 XI1_I905_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I905_MN0 (XI1_I905_An I1_dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I854_MN1 (XI1_I854_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I854_MN5 (XI1_I854_n2 XI1_I854_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I854_MN4 (I1_b7_2 XI1_I854_An XI1_I854_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I854_MN2 (XI1_I854_n1 I1_dd2_b3_1 I1_b7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I854_MN3 (VSS I1_qu25_b3_0 XI1_I854_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I854_MN0 (XI1_I854_An I1_dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I206_MN1 (XI1_I884_I206_Bn I1_I884_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I206_MN5 (XI1_I884_I206_n2 XI1_I884_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I884_I206_MN4 (I1_p7_3 XI1_I884_I206_An XI1_I884_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I206_MN2 (XI1_I884_I206_n1 I1_I884_pn3 I1_p7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I884_I206_MN3 (VSS I1_I884_G2_0n XI1_I884_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I884_I206_MN0 (XI1_I884_I206_An I1_I884_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I807_MN1 (XI1_I807_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I807_MN5 (XI1_I807_n2 XI1_I807_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I807_MN4 (I1_b6_1 XI1_I807_An XI1_I807_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I807_MN2 (XI1_I807_n1 I1_dd1_b3_1 I1_b6_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I807_MN3 (VSS I1_qu26_b3_0 XI1_I807_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I807_MN0 (XI1_I807_An I1_dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I716_MN1 (XI1_I716_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I716_MN5 (XI1_I716_n2 XI1_I716_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I716_MN4 (I1_b4_2 XI1_I716_An XI1_I716_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I716_MN2 (XI1_I716_n1 I1_dd2_b3_0 I1_b4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I716_MN3 (VSS I1_qu28_b3_0 XI1_I716_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I716_MN0 (XI1_I716_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I718_MN1 (XI1_I718_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I718_MN5 (XI1_I718_n2 XI1_I718_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I718_MN4 (I1_b4_4 XI1_I718_An XI1_I718_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I718_MN2 (XI1_I718_n1 I1_dd4_b3_0 I1_b4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I718_MN3 (VSS I1_qu28_b3_0 XI1_I718_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I718_MN0 (XI1_I718_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I719_MN1 (XI1_I719_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I719_MN5 (XI1_I719_n2 XI1_I719_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I719_MN4 (I1_b4_5 XI1_I719_An XI1_I719_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I719_MN2 (XI1_I719_n1 I1_dd5_b3_0 I1_b4_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I719_MN3 (VSS I1_qu28_b3_0 XI1_I719_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I719_MN0 (XI1_I719_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I206_MN1 (XI1_I700_I206_Bn I1_I700_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I206_MN5 (XI1_I700_I206_n2 XI1_I700_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I206_MN4 (I1_p3_3 XI1_I700_I206_An XI1_I700_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I206_MN2 (XI1_I700_I206_n1 I1_I700_pn3 I1_p3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I206_MN3 (VSS I1_I700_G2_0n XI1_I700_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I206_MN0 (XI1_I700_I206_An I1_I700_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I212_MN1 (XI1_I700_I212_Bn I1_I700_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I212_MN5 (XI1_I700_I212_n2 XI1_I700_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I212_MN4 (I1_p3_9 XI1_I700_I212_An XI1_I700_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I212_MN2 (XI1_I700_I212_n1 I1_I700_pn9 I1_p3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I212_MN3 (VSS I1_I700_G8_0n XI1_I700_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I212_MN0 (XI1_I700_I212_An I1_I700_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I214_MN1 (XI1_I700_I214_Bn I1_I700_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I214_MN5 (XI1_I700_I214_n2 XI1_I700_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I214_MN4 (I1_p3_11 XI1_I700_I214_An XI1_I700_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I214_MN2 (XI1_I700_I214_n1 I1_I700_pn11 I1_p3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I214_MN3 (VSS I1_I700_G10_0n XI1_I700_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I214_MN0 (XI1_I700_I214_An I1_I700_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I216_MN1 (XI1_I700_I216_Bn I1_I700_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I216_MN5 (XI1_I700_I216_n2 XI1_I700_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I216_MN4 (I1_p3_13 XI1_I700_I216_An XI1_I700_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I216_MN2 (XI1_I700_I216_n1 I1_I700_pn13 I1_p3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I216_MN3 (VSS I1_I700_G12_0n XI1_I700_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I216_MN0 (XI1_I700_I216_An I1_I700_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I218_MN1 (XI1_I700_I218_Bn I1_I700_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I218_MN5 (XI1_I700_I218_n2 XI1_I700_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I700_I218_MN4 (I1_p3_15 XI1_I700_I218_An XI1_I700_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I218_MN2 (XI1_I700_I218_n1 I1_I700_pn15 I1_p3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I700_I218_MN3 (VSS I1_I700_G14_0n XI1_I700_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I700_I218_MN0 (XI1_I700_I218_An I1_I700_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1392_MN1 (XI1_I1392_Bn I1_c18_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1392_MN5 (XI1_I1392_n2 XI1_I1392_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1392_MN4 (I1_p18_32 XI1_I1392_An XI1_I1392_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1392_MN2 (XI1_I1392_n1 I1_h18 I1_p18_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1392_MN3 (VSS I1_c18_o XI1_I1392_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1392_MN0 (XI1_I1392_An I1_h18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1366_MN1 (XI1_I1366_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1366_MN5 (XI1_I1366_n2 XI1_I1366_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1366_MN4 (I1_b18_8 XI1_I1366_An XI1_I1366_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1366_MN2 (XI1_I1366_n1 I1_dd8_b3_3 I1_b18_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1366_MN3 (VSS I1_qu14_b3_1 XI1_I1366_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1366_MN0 (XI1_I1366_An I1_dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1365_MN1 (XI1_I1365_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1365_MN5 (XI1_I1365_n2 XI1_I1365_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1365_MN4 (I1_b18_7 XI1_I1365_An XI1_I1365_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1365_MN2 (XI1_I1365_n1 I1_dd7_b3_3 I1_b18_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1365_MN3 (VSS I1_qu14_b3_1 XI1_I1365_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1365_MN0 (XI1_I1365_An I1_dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I206_MN1 (XI1_I1344_I206_Bn I1_I1344_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I206_MN5 (XI1_I1344_I206_n2 XI1_I1344_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I206_MN4 (I1_p17_3 XI1_I1344_I206_An XI1_I1344_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I206_MN2 (XI1_I1344_I206_n1 I1_I1344_pn3 I1_p17_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I206_MN3 (VSS I1_I1344_G2_0n XI1_I1344_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I206_MN0 (XI1_I1344_I206_An I1_I1344_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1267_MN1 (XI1_I1267_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1267_MN5 (XI1_I1267_n2 XI1_I1267_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1267_MN4 (I1_b16_1 XI1_I1267_An XI1_I1267_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1267_MN2 (XI1_I1267_n1 I1_dd1_b3_2 I1_b16_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1267_MN3 (VSS I1_qu16_b3_0 XI1_I1267_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1267_MN0 (XI1_I1267_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1268_MN1 (XI1_I1268_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1268_MN5 (XI1_I1268_n2 XI1_I1268_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1268_MN4 (I1_b16_2 XI1_I1268_An XI1_I1268_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1268_MN2 (XI1_I1268_n1 I1_dd2_b3_2 I1_b16_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1268_MN3 (VSS I1_qu16_b3_0 XI1_I1268_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1268_MN0 (XI1_I1268_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1221_MN1 (XI1_I1221_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1221_MN5 (XI1_I1221_n2 XI1_I1221_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1221_MN4 (I1_b15_1 XI1_I1221_An XI1_I1221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1221_MN2 (XI1_I1221_n1 I1_dd1_b3_2 I1_b15_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1221_MN3 (VSS I1_qu17_b3_0 XI1_I1221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1221_MN0 (XI1_I1221_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1222_MN1 (XI1_I1222_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1222_MN5 (XI1_I1222_n2 XI1_I1222_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1222_MN4 (I1_b15_2 XI1_I1222_An XI1_I1222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1222_MN2 (XI1_I1222_n1 I1_dd2_b3_2 I1_b15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1222_MN3 (VSS I1_qu17_b3_0 XI1_I1222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1222_MN0 (XI1_I1222_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I216_MN1 (XI1_I1160_I216_Bn I1_I1160_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I216_MN5 (XI1_I1160_I216_n2 XI1_I1160_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I216_MN4 (I1_p13_13 XI1_I1160_I216_An XI1_I1160_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I216_MN2 (XI1_I1160_I216_n1 I1_I1160_pn13 I1_p13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I216_MN3 (VSS I1_I1160_G12_0n XI1_I1160_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I216_MN0 (XI1_I1160_I216_An I1_I1160_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I207_MN1 (XI1_I1160_I207_Bn I1_I1160_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I207_MN5 (XI1_I1160_I207_n2 XI1_I1160_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I207_MN4 (I1_p13_4 XI1_I1160_I207_An XI1_I1160_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I207_MN2 (XI1_I1160_I207_n1 I1_I1160_pn4 I1_p13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I207_MN3 (VSS I1_I1160_G3_0n XI1_I1160_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I207_MN0 (XI1_I1160_I207_An I1_I1160_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1177_MN1 (XI1_I1177_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1177_MN5 (XI1_I1177_n2 XI1_I1177_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1177_MN4 (I1_b14_3 XI1_I1177_An XI1_I1177_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1177_MN2 (XI1_I1177_n1 I1_dd3_b3_2 I1_b14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1177_MN3 (VSS I1_qu18_b3_0 XI1_I1177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1177_MN0 (XI1_I1177_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1176_MN1 (XI1_I1176_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1176_MN5 (XI1_I1176_n2 XI1_I1176_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1176_MN4 (I1_b14_2 XI1_I1176_An XI1_I1176_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1176_MN2 (XI1_I1176_n1 I1_dd2_b3_2 I1_b14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1176_MN3 (VSS I1_qu18_b3_0 XI1_I1176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1176_MN0 (XI1_I1176_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1175_MN1 (XI1_I1175_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1175_MN5 (XI1_I1175_n2 XI1_I1175_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1175_MN4 (I1_b14_1 XI1_I1175_An XI1_I1175_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1175_MN2 (XI1_I1175_n1 I1_dd1_b3_2 I1_b14_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1175_MN3 (VSS I1_qu18_b3_0 XI1_I1175_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1175_MN0 (XI1_I1175_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I931_MN1 (XI1_I931_Bn I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I931_MN5 (XI1_I931_n2 XI1_I931_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I931_MN4 (I1_h8 XI1_I931_An XI1_I931_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I931_MN2 (XI1_I931_n1 I1_p7_31 I1_h8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I931_MN3 (VSS I1_qu24_b3_5 XI1_I931_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I931_MN0 (XI1_I931_An I1_p7_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I913_MN1 (XI1_I913_Bn I1_qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I913_MN5 (XI1_I913_n2 XI1_I913_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I913_MN4 (I1_b8_15 XI1_I913_An XI1_I913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I913_MN2 (XI1_I913_n1 I1_dd15_b3_1 I1_b8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I913_MN3 (VSS I1_qu24_b3_2 XI1_I913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I913_MN0 (XI1_I913_An I1_dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I909_MN1 (XI1_I909_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I909_MN5 (XI1_I909_n2 XI1_I909_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I909_MN4 (I1_b8_11 XI1_I909_An XI1_I909_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I909_MN2 (XI1_I909_n1 I1_dd11_b3_1 I1_b8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I909_MN3 (VSS I1_qu24_b3_1 XI1_I909_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I909_MN0 (XI1_I909_An I1_dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I907_MN1 (XI1_I907_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I907_MN5 (XI1_I907_n2 XI1_I907_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I907_MN4 (I1_b8_9 XI1_I907_An XI1_I907_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I907_MN2 (XI1_I907_n1 I1_dd9_b3_1 I1_b8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I907_MN3 (VSS I1_qu24_b3_1 XI1_I907_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I907_MN0 (XI1_I907_An I1_dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I906_MN1 (XI1_I906_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I906_MN5 (XI1_I906_n2 XI1_I906_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I906_MN4 (I1_b8_8 XI1_I906_An XI1_I906_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I906_MN2 (XI1_I906_n1 I1_dd8_b3_1 I1_b8_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I906_MN3 (VSS I1_qu24_b3_1 XI1_I906_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I906_MN0 (XI1_I906_An I1_dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I904_MN1 (XI1_I904_Bn I1_qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I904_MN5 (XI1_I904_n2 XI1_I904_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I904_MN4 (I1_b8_6 XI1_I904_An XI1_I904_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I904_MN2 (XI1_I904_n1 I1_dd6_b3_1 I1_b8_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I904_MN3 (VSS I1_qu24_b3_1 XI1_I904_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I904_MN0 (XI1_I904_An I1_dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I853_MN1 (XI1_I853_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I853_MN5 (XI1_I853_n2 XI1_I853_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I853_MN4 (I1_b7_1 XI1_I853_An XI1_I853_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I853_MN2 (XI1_I853_n1 I1_dd1_b3_1 I1_b7_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I853_MN3 (VSS I1_qu25_b3_0 XI1_I853_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I853_MN0 (XI1_I853_An I1_dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I761_MN1 (XI1_I761_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I761_MN5 (XI1_I761_n2 XI1_I761_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I761_MN4 (I1_b5_1 XI1_I761_An XI1_I761_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I761_MN2 (XI1_I761_n1 I1_dd1_b3_0 I1_b5_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I761_MN3 (VSS I1_qu27_b3_0 XI1_I761_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I761_MN0 (XI1_I761_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I715_MN1 (XI1_I715_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I715_MN5 (XI1_I715_n2 XI1_I715_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I715_MN4 (I1_b4_1 XI1_I715_An XI1_I715_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I715_MN2 (XI1_I715_n1 I1_dd1_b3_0 I1_b4_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I715_MN3 (VSS I1_qu28_b3_0 XI1_I715_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I715_MN0 (XI1_I715_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I219_MN1 (XI1_I1390_I219_Bn I1_I1390_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I219_MN5 (XI1_I1390_I219_n2 XI1_I1390_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I219_MN4 (I1_p18_16 XI1_I1390_I219_An XI1_I1390_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I219_MN2 (XI1_I1390_I219_n1 I1_I1390_pn16 I1_p18_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I219_MN3 (VSS I1_I1390_G15_0n XI1_I1390_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I219_MN0 (XI1_I1390_I219_An I1_I1390_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I217_MN1 (XI1_I1390_I217_Bn I1_I1390_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I217_MN5 (XI1_I1390_I217_n2 XI1_I1390_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I217_MN4 (I1_p18_14 XI1_I1390_I217_An XI1_I1390_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I217_MN2 (XI1_I1390_I217_n1 I1_I1390_pn14 I1_p18_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I217_MN3 (VSS I1_I1390_G13_0n XI1_I1390_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I217_MN0 (XI1_I1390_I217_An I1_I1390_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I215_MN1 (XI1_I1390_I215_Bn I1_I1390_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I215_MN5 (XI1_I1390_I215_n2 XI1_I1390_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I215_MN4 (I1_p18_12 XI1_I1390_I215_An XI1_I1390_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I215_MN2 (XI1_I1390_I215_n1 I1_I1390_pn12 I1_p18_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I215_MN3 (VSS I1_I1390_G11_0n XI1_I1390_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I215_MN0 (XI1_I1390_I215_An I1_I1390_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1364_MN1 (XI1_I1364_Bn I1_qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1364_MN5 (XI1_I1364_n2 XI1_I1364_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1364_MN4 (I1_b18_6 XI1_I1364_An XI1_I1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1364_MN2 (XI1_I1364_n1 I1_dd6_b3_3 I1_b18_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1364_MN3 (VSS I1_qu14_b3_1 XI1_I1364_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1364_MN0 (XI1_I1364_An I1_dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1317_MN1 (XI1_I1317_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1317_MN5 (XI1_I1317_n2 XI1_I1317_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1317_MN4 (I1_b17_5 XI1_I1317_An XI1_I1317_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1317_MN2 (XI1_I1317_n1 I1_dd5_b3_3 I1_b17_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1317_MN3 (VSS I1_qu15_b3_0 XI1_I1317_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1317_MN0 (XI1_I1317_An I1_dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1363_MN1 (XI1_I1363_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1363_MN5 (XI1_I1363_n2 XI1_I1363_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1363_MN4 (I1_b18_5 XI1_I1363_An XI1_I1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1363_MN2 (XI1_I1363_n1 I1_dd5_b3_3 I1_b18_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1363_MN3 (VSS I1_qu14_b3_0 XI1_I1363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1363_MN0 (XI1_I1363_An I1_dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1316_MN1 (XI1_I1316_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1316_MN5 (XI1_I1316_n2 XI1_I1316_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1316_MN4 (I1_b17_4 XI1_I1316_An XI1_I1316_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1316_MN2 (XI1_I1316_n1 I1_dd4_b3_3 I1_b17_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1316_MN3 (VSS I1_qu15_b3_0 XI1_I1316_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1316_MN0 (XI1_I1316_An I1_dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1315_MN1 (XI1_I1315_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1315_MN5 (XI1_I1315_n2 XI1_I1315_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1315_MN4 (I1_b17_3 XI1_I1315_An XI1_I1315_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1315_MN2 (XI1_I1315_n1 I1_dd3_b3_3 I1_b17_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1315_MN3 (VSS I1_qu15_b3_0 XI1_I1315_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1315_MN0 (XI1_I1315_An I1_dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1266_MN1 (XI1_I1266_Bn I1_qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1266_MN5 (XI1_I1266_n2 XI1_I1266_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1266_MN4 (I1_b16_0 XI1_I1266_An XI1_I1266_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1266_MN2 (XI1_I1266_n1 I1_B_0_b3_2 I1_b16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1266_MN3 (VSS I1_qu16_b3_0 XI1_I1266_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1266_MN0 (XI1_I1266_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1220_MN1 (XI1_I1220_Bn I1_qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1220_MN5 (XI1_I1220_n2 XI1_I1220_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1220_MN4 (I1_b15_0 XI1_I1220_An XI1_I1220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1220_MN2 (XI1_I1220_n1 I1_B_0_b3_2 I1_b15_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1220_MN3 (VSS I1_qu17_b3_0 XI1_I1220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1220_MN0 (XI1_I1220_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1159_MN1 (XI1_I1159_Bn I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1159_MN5 (XI1_I1159_n2 XI1_I1159_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1159_MN4 (I1_b13_31 XI1_I1159_An XI1_I1159_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1159_MN2 (XI1_I1159_n1 I1_dd31_b3_2 I1_b13_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1159_MN3 (VSS I1_qu19_b3_5 XI1_I1159_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1159_MN0 (XI1_I1159_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I218_MN1 (XI1_I1160_I218_Bn I1_I1160_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I218_MN5 (XI1_I1160_I218_n2 XI1_I1160_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I218_MN4 (I1_p13_15 XI1_I1160_I218_An XI1_I1160_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I218_MN2 (XI1_I1160_I218_n1 I1_I1160_pn15 I1_p13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I218_MN3 (VSS I1_I1160_G14_0n XI1_I1160_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I218_MN0 (XI1_I1160_I218_An I1_I1160_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I214_MN1 (XI1_I1160_I214_Bn I1_I1160_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I214_MN5 (XI1_I1160_I214_n2 XI1_I1160_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I214_MN4 (I1_p13_11 XI1_I1160_I214_An XI1_I1160_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I214_MN2 (XI1_I1160_I214_n1 I1_I1160_pn11 I1_p13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I214_MN3 (VSS I1_I1160_G10_0n XI1_I1160_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I214_MN0 (XI1_I1160_I214_An I1_I1160_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I212_MN1 (XI1_I1160_I212_Bn I1_I1160_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I212_MN5 (XI1_I1160_I212_n2 XI1_I1160_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I212_MN4 (I1_p13_9 XI1_I1160_I212_An XI1_I1160_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I212_MN2 (XI1_I1160_I212_n1 I1_I1160_pn9 I1_p13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I212_MN3 (VSS I1_I1160_G8_0n XI1_I1160_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I212_MN0 (XI1_I1160_I212_An I1_I1160_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I206_MN1 (XI1_I1160_I206_Bn I1_I1160_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I206_MN5 (XI1_I1160_I206_n2 XI1_I1160_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1160_I206_MN4 (I1_p13_3 XI1_I1160_I206_An XI1_I1160_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I206_MN2 (XI1_I1160_I206_n1 I1_I1160_pn3 I1_p13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1160_I206_MN3 (VSS I1_I1160_G2_0n XI1_I1160_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1160_I206_MN0 (XI1_I1160_I206_An I1_I1160_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1174_MN1 (XI1_I1174_Bn I1_qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1174_MN5 (XI1_I1174_n2 XI1_I1174_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1174_MN4 (I1_b14_0 XI1_I1174_An XI1_I1174_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1174_MN2 (XI1_I1174_n1 I1_B_0_b3_2 I1_b14_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1174_MN3 (VSS I1_qu18_b3_0 XI1_I1174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1174_MN0 (XI1_I1174_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I806_MN1 (XI1_I806_Bn I1_qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I806_MN5 (XI1_I806_n2 XI1_I806_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I806_MN4 (I1_b6_0 XI1_I806_An XI1_I806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I806_MN2 (XI1_I806_n1 I1_B_0_b3_1 I1_b6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I806_MN3 (VSS I1_qu26_b3_0 XI1_I806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I806_MN0 (XI1_I806_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I760_MN1 (XI1_I760_Bn I1_qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I760_MN5 (XI1_I760_n2 XI1_I760_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I760_MN4 (I1_b5_0 XI1_I760_An XI1_I760_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I760_MN2 (XI1_I760_n1 I1_B_0_b3_1 I1_b5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I760_MN3 (VSS I1_qu27_b3_0 XI1_I760_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I760_MN0 (XI1_I760_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I669_MN1 (XI1_I669_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I669_MN5 (XI1_I669_n2 XI1_I669_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I669_MN4 (I1_b3_1 XI1_I669_An XI1_I669_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I669_MN2 (XI1_I669_n1 I1_dd1_b3_0 I1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I669_MN3 (VSS I1_qu29_b3_0 XI1_I669_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I669_MN0 (XI1_I669_An I1_dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I213_MN1 (XI1_I1390_I213_Bn I1_I1390_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I213_MN5 (XI1_I1390_I213_n2 XI1_I1390_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I213_MN4 (I1_p18_10 XI1_I1390_I213_An XI1_I1390_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I213_MN2 (XI1_I1390_I213_n1 I1_I1390_pn10 I1_p18_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I213_MN3 (VSS I1_I1390_G9_0n XI1_I1390_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I213_MN0 (XI1_I1390_I213_An I1_I1390_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1361_MN1 (XI1_I1361_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1361_MN5 (XI1_I1361_n2 XI1_I1361_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1361_MN4 (I1_b18_3 XI1_I1361_An XI1_I1361_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1361_MN2 (XI1_I1361_n1 I1_dd3_b3_3 I1_b18_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1361_MN3 (VSS I1_qu14_b3_0 XI1_I1361_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1361_MN0 (XI1_I1361_An I1_dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1362_MN1 (XI1_I1362_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1362_MN5 (XI1_I1362_n2 XI1_I1362_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1362_MN4 (I1_b18_4 XI1_I1362_An XI1_I1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1362_MN2 (XI1_I1362_n1 I1_dd4_b3_3 I1_b18_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1362_MN3 (VSS I1_qu14_b3_0 XI1_I1362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1362_MN0 (XI1_I1362_An I1_dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1313_MN1 (XI1_I1313_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1313_MN5 (XI1_I1313_n2 XI1_I1313_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1313_MN4 (I1_b17_1 XI1_I1313_An XI1_I1313_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1313_MN2 (XI1_I1313_n1 I1_dd1_b3_3 I1_b17_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1313_MN3 (VSS I1_qu15_b3_0 XI1_I1313_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1313_MN0 (XI1_I1313_An I1_dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1155_MN1 (XI1_I1155_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1155_MN5 (XI1_I1155_n2 XI1_I1155_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1155_MN4 (I1_b13_27 XI1_I1155_An XI1_I1155_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1155_MN2 (XI1_I1155_n1 I1_dd27_b3_2 I1_b13_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1155_MN3 (VSS I1_qu19_b3_4 XI1_I1155_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1155_MN0 (XI1_I1155_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1157_MN1 (XI1_I1157_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1157_MN5 (XI1_I1157_n2 XI1_I1157_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1157_MN4 (I1_b13_29 XI1_I1157_An XI1_I1157_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1157_MN2 (XI1_I1157_n1 I1_dd29_b3_2 I1_b13_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1157_MN3 (VSS I1_qu19_b3_4 XI1_I1157_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1157_MN0 (XI1_I1157_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I932_MN1 (XI1_I932_Bn I1_c8_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I932_MN5 (XI1_I932_n2 XI1_I932_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I932_MN4 (I1_p8_32 XI1_I932_An XI1_I932_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I932_MN2 (XI1_I932_n1 I1_h8 I1_p8_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I932_MN3 (VSS I1_c8_o XI1_I932_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I932_MN0 (XI1_I932_An I1_h8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I219_MN1 (XI1_I930_I219_Bn I1_I930_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I219_MN5 (XI1_I930_I219_n2 XI1_I930_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I219_MN4 (I1_p8_16 XI1_I930_I219_An XI1_I930_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I219_MN2 (XI1_I930_I219_n1 I1_I930_pn16 I1_p8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I219_MN3 (VSS I1_I930_G15_0n XI1_I930_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I219_MN0 (XI1_I930_I219_An I1_I930_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I852_MN1 (XI1_I852_Bn I1_qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I852_MN5 (XI1_I852_n2 XI1_I852_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I852_MN4 (I1_b7_0 XI1_I852_An XI1_I852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I852_MN2 (XI1_I852_n1 I1_B_0_b3_1 I1_b7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I852_MN3 (VSS I1_qu25_b3_0 XI1_I852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I852_MN0 (XI1_I852_An I1_B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I903_MN1 (XI1_I903_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I903_MN5 (XI1_I903_n2 XI1_I903_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I903_MN4 (I1_b8_5 XI1_I903_An XI1_I903_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I903_MN2 (XI1_I903_n1 I1_dd5_b3_1 I1_b8_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I903_MN3 (VSS I1_qu24_b3_0 XI1_I903_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I903_MN0 (XI1_I903_An I1_dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I714_MN1 (XI1_I714_Bn I1_qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I714_MN5 (XI1_I714_n2 XI1_I714_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I714_MN4 (I1_b4_0 XI1_I714_An XI1_I714_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I714_MN2 (XI1_I714_n1 I1_B_0_b3_0 I1_b4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I714_MN3 (VSS I1_qu28_b3_0 XI1_I714_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I714_MN0 (XI1_I714_An I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I670_MN1 (XI1_I670_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I670_MN5 (XI1_I670_n2 XI1_I670_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I670_MN4 (I1_b3_2 XI1_I670_An XI1_I670_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I670_MN2 (XI1_I670_n1 I1_dd2_b3_0 I1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I670_MN3 (VSS I1_qu29_b3_0 XI1_I670_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I670_MN0 (XI1_I670_An I1_dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I671_MN1 (XI1_I671_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I671_MN5 (XI1_I671_n2 XI1_I671_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I671_MN4 (I1_b3_3 XI1_I671_An XI1_I671_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I671_MN2 (XI1_I671_n1 I1_dd3_b3_0 I1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I671_MN3 (VSS I1_qu29_b3_0 XI1_I671_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I671_MN0 (XI1_I671_An I1_dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I695_MN1 (XI1_I695_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I695_MN5 (XI1_I695_n2 XI1_I695_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I695_MN4 (I1_b3_27 XI1_I695_An XI1_I695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I695_MN2 (XI1_I695_n1 I1_dd27_b3_0 I1_b3_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I695_MN3 (VSS I1_qu29_b3_4 XI1_I695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I695_MN0 (XI1_I695_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I696_MN1 (XI1_I696_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I696_MN5 (XI1_I696_n2 XI1_I696_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I696_MN4 (I1_b3_28 XI1_I696_An XI1_I696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I696_MN2 (XI1_I696_n1 I1_dd28_b3_0 I1_b3_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I696_MN3 (VSS I1_qu29_b3_4 XI1_I696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I696_MN0 (XI1_I696_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I218_MN1 (XI1_I1390_I218_Bn I1_I1390_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I218_MN5 (XI1_I1390_I218_n2 XI1_I1390_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I218_MN4 (I1_p18_15 XI1_I1390_I218_An XI1_I1390_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I218_MN2 (XI1_I1390_I218_n1 I1_I1390_pn15 I1_p18_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I218_MN3 (VSS I1_I1390_G14_0n XI1_I1390_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I218_MN0 (XI1_I1390_I218_An I1_I1390_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I212_MN1 (XI1_I1390_I212_Bn I1_I1390_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I212_MN5 (XI1_I1390_I212_n2 XI1_I1390_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I212_MN4 (I1_p18_9 XI1_I1390_I212_An XI1_I1390_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I212_MN2 (XI1_I1390_I212_n1 I1_I1390_pn9 I1_p18_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I212_MN3 (VSS I1_I1390_G8_0n XI1_I1390_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I212_MN0 (XI1_I1390_I212_An I1_I1390_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1360_MN1 (XI1_I1360_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1360_MN5 (XI1_I1360_n2 XI1_I1360_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1360_MN4 (I1_b18_2 XI1_I1360_An XI1_I1360_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1360_MN2 (XI1_I1360_n1 I1_dd2_b3_3 I1_b18_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1360_MN3 (VSS I1_qu14_b3_0 XI1_I1360_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1360_MN0 (XI1_I1360_An I1_dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1314_MN1 (XI1_I1314_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1314_MN5 (XI1_I1314_n2 XI1_I1314_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1314_MN4 (I1_b17_2 XI1_I1314_An XI1_I1314_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1314_MN2 (XI1_I1314_n1 I1_dd2_b3_3 I1_b17_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1314_MN3 (VSS I1_qu15_b3_0 XI1_I1314_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1314_MN0 (XI1_I1314_An I1_dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1312_MN1 (XI1_I1312_Bn I1_qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1312_MN5 (XI1_I1312_n2 XI1_I1312_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1312_MN4 (I1_b17_0 XI1_I1312_An XI1_I1312_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1312_MN2 (XI1_I1312_n1 I1_B_0_b3_3 I1_b17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1312_MN3 (VSS I1_qu15_b3_0 XI1_I1312_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1312_MN0 (XI1_I1312_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1156_MN1 (XI1_I1156_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1156_MN5 (XI1_I1156_n2 XI1_I1156_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1156_MN4 (I1_b13_28 XI1_I1156_An XI1_I1156_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1156_MN2 (XI1_I1156_n1 I1_dd28_b3_2 I1_b13_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1156_MN3 (VSS I1_qu19_b3_4 XI1_I1156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1156_MN0 (XI1_I1156_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1153_MN1 (XI1_I1153_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1153_MN5 (XI1_I1153_n2 XI1_I1153_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1153_MN4 (I1_b13_25 XI1_I1153_An XI1_I1153_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1153_MN2 (XI1_I1153_n1 I1_dd25_b3_2 I1_b13_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1153_MN3 (VSS I1_qu19_b3_4 XI1_I1153_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1153_MN0 (XI1_I1153_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1158_MN1 (XI1_I1158_Bn I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1158_MN5 (XI1_I1158_n2 XI1_I1158_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1158_MN4 (I1_b13_30 XI1_I1158_An XI1_I1158_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1158_MN2 (XI1_I1158_n1 I1_dd30_b3_2 I1_b13_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1158_MN3 (VSS I1_qu19_b3_5 XI1_I1158_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1158_MN0 (XI1_I1158_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1154_MN1 (XI1_I1154_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1154_MN5 (XI1_I1154_n2 XI1_I1154_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1154_MN4 (I1_b13_26 XI1_I1154_An XI1_I1154_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1154_MN2 (XI1_I1154_n1 I1_dd26_b3_2 I1_b13_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1154_MN3 (VSS I1_qu19_b3_4 XI1_I1154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1154_MN0 (XI1_I1154_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1152_MN1 (XI1_I1152_Bn I1_qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1152_MN5 (XI1_I1152_n2 XI1_I1152_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1152_MN4 (I1_b13_24 XI1_I1152_An XI1_I1152_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1152_MN2 (XI1_I1152_n1 I1_dd24_b3_2 I1_b13_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1152_MN3 (VSS I1_qu19_b3_4 XI1_I1152_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1152_MN0 (XI1_I1152_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1129_MN1 (XI1_I1129_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1129_MN5 (XI1_I1129_n2 XI1_I1129_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1129_MN4 (I1_b13_1 XI1_I1129_An XI1_I1129_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1129_MN2 (XI1_I1129_n1 I1_dd1_b3_2 I1_b13_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1129_MN3 (VSS I1_qu19_b3_0 XI1_I1129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1129_MN0 (XI1_I1129_An I1_dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1128_MN1 (XI1_I1128_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1128_MN5 (XI1_I1128_n2 XI1_I1128_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1128_MN4 (I1_b13_0 XI1_I1128_An XI1_I1128_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1128_MN2 (XI1_I1128_n1 I1_B_0_b3_2 I1_b13_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1128_MN3 (VSS I1_qu19_b3_0 XI1_I1128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1128_MN0 (XI1_I1128_An I1_B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I929_MN1 (XI1_I929_Bn I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I929_MN5 (XI1_I929_n2 XI1_I929_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I929_MN4 (I1_b8_31 XI1_I929_An XI1_I929_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I929_MN2 (XI1_I929_n1 I1_dd31_b3_1 I1_b8_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I929_MN3 (VSS I1_qu24_b3_5 XI1_I929_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I929_MN0 (XI1_I929_An I1_dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I928_MN1 (XI1_I928_Bn I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I928_MN5 (XI1_I928_n2 XI1_I928_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I928_MN4 (I1_b8_30 XI1_I928_An XI1_I928_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I928_MN2 (XI1_I928_n1 I1_dd30_b3_1 I1_b8_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I928_MN3 (VSS I1_qu24_b3_5 XI1_I928_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I928_MN0 (XI1_I928_An I1_dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I217_MN1 (XI1_I930_I217_Bn I1_I930_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I217_MN5 (XI1_I930_I217_n2 XI1_I930_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I217_MN4 (I1_p8_14 XI1_I930_I217_An XI1_I930_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I217_MN2 (XI1_I930_I217_n1 I1_I930_pn14 I1_p8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I217_MN3 (VSS I1_I930_G13_0n XI1_I930_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I217_MN0 (XI1_I930_I217_An I1_I930_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I215_MN1 (XI1_I930_I215_Bn I1_I930_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I215_MN5 (XI1_I930_I215_n2 XI1_I930_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I215_MN4 (I1_p8_12 XI1_I930_I215_An XI1_I930_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I215_MN2 (XI1_I930_I215_n1 I1_I930_pn12 I1_p8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I215_MN3 (VSS I1_I930_G11_0n XI1_I930_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I215_MN0 (XI1_I930_I215_An I1_I930_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I902_MN1 (XI1_I902_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I902_MN5 (XI1_I902_n2 XI1_I902_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I902_MN4 (I1_b8_4 XI1_I902_An XI1_I902_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I902_MN2 (XI1_I902_n1 I1_dd4_b3_1 I1_b8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I902_MN3 (VSS I1_qu24_b3_0 XI1_I902_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I902_MN0 (XI1_I902_An I1_dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I901_MN1 (XI1_I901_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I901_MN5 (XI1_I901_n2 XI1_I901_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I901_MN4 (I1_b8_3 XI1_I901_An XI1_I901_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I901_MN2 (XI1_I901_n1 I1_dd3_b3_1 I1_b8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I901_MN3 (VSS I1_qu24_b3_0 XI1_I901_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I901_MN0 (XI1_I901_An I1_dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I672_MN1 (XI1_I672_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I672_MN5 (XI1_I672_n2 XI1_I672_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I672_MN4 (I1_b3_4 XI1_I672_An XI1_I672_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I672_MN2 (XI1_I672_n1 I1_dd4_b3_0 I1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I672_MN3 (VSS I1_qu29_b3_0 XI1_I672_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I672_MN0 (XI1_I672_An I1_dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I674_MN1 (XI1_I674_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I674_MN5 (XI1_I674_n2 XI1_I674_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I674_MN4 (I1_b3_6 XI1_I674_An XI1_I674_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I674_MN2 (XI1_I674_n1 I1_dd6_b3_0 I1_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I674_MN3 (VSS I1_qu29_b3_1 XI1_I674_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I674_MN0 (XI1_I674_An I1_dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I675_MN1 (XI1_I675_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I675_MN5 (XI1_I675_n2 XI1_I675_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I675_MN4 (I1_b3_7 XI1_I675_An XI1_I675_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I675_MN2 (XI1_I675_n1 I1_dd7_b3_0 I1_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I675_MN3 (VSS I1_qu29_b3_1 XI1_I675_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I675_MN0 (XI1_I675_An I1_dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I676_MN1 (XI1_I676_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I676_MN5 (XI1_I676_n2 XI1_I676_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I676_MN4 (I1_b3_8 XI1_I676_An XI1_I676_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I676_MN2 (XI1_I676_n1 I1_dd8_b3_0 I1_b3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I676_MN3 (VSS I1_qu29_b3_1 XI1_I676_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I676_MN0 (XI1_I676_An I1_dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I677_MN1 (XI1_I677_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I677_MN5 (XI1_I677_n2 XI1_I677_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I677_MN4 (I1_b3_9 XI1_I677_An XI1_I677_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I677_MN2 (XI1_I677_n1 I1_dd9_b3_0 I1_b3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I677_MN3 (VSS I1_qu29_b3_1 XI1_I677_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I677_MN0 (XI1_I677_An I1_dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I679_MN1 (XI1_I679_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I679_MN5 (XI1_I679_n2 XI1_I679_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I679_MN4 (I1_b3_11 XI1_I679_An XI1_I679_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I679_MN2 (XI1_I679_n1 I1_dd11_b3_0 I1_b3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I679_MN3 (VSS I1_qu29_b3_1 XI1_I679_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I679_MN0 (XI1_I679_An I1_dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I680_MN1 (XI1_I680_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I680_MN5 (XI1_I680_n2 XI1_I680_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I680_MN4 (I1_b3_12 XI1_I680_An XI1_I680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I680_MN2 (XI1_I680_n1 I1_dd12_b3_0 I1_b3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I680_MN3 (VSS I1_qu29_b3_2 XI1_I680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I680_MN0 (XI1_I680_An I1_dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I681_MN1 (XI1_I681_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I681_MN5 (XI1_I681_n2 XI1_I681_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I681_MN4 (I1_b3_13 XI1_I681_An XI1_I681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I681_MN2 (XI1_I681_n1 I1_dd13_b3_0 I1_b3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I681_MN3 (VSS I1_qu29_b3_2 XI1_I681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I681_MN0 (XI1_I681_An I1_dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I682_MN1 (XI1_I682_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I682_MN5 (XI1_I682_n2 XI1_I682_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I682_MN4 (I1_b3_14 XI1_I682_An XI1_I682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I682_MN2 (XI1_I682_n1 I1_dd14_b3_0 I1_b3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I682_MN3 (VSS I1_qu29_b3_2 XI1_I682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I682_MN0 (XI1_I682_An I1_dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I683_MN1 (XI1_I683_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I683_MN5 (XI1_I683_n2 XI1_I683_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I683_MN4 (I1_b3_15 XI1_I683_An XI1_I683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I683_MN2 (XI1_I683_n1 I1_dd15_b3_0 I1_b3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I683_MN3 (VSS I1_qu29_b3_2 XI1_I683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I683_MN0 (XI1_I683_An I1_dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I684_MN1 (XI1_I684_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I684_MN5 (XI1_I684_n2 XI1_I684_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I684_MN4 (I1_b3_16 XI1_I684_An XI1_I684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I684_MN2 (XI1_I684_n1 I1_dd16_b3_0 I1_b3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I684_MN3 (VSS I1_qu29_b3_2 XI1_I684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I684_MN0 (XI1_I684_An I1_dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I685_MN1 (XI1_I685_Bn I1_qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I685_MN5 (XI1_I685_n2 XI1_I685_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I685_MN4 (I1_b3_17 XI1_I685_An XI1_I685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I685_MN2 (XI1_I685_n1 I1_dd17_b3_0 I1_b3_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I685_MN3 (VSS I1_qu29_b3_2 XI1_I685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I685_MN0 (XI1_I685_An I1_dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I686_MN1 (XI1_I686_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I686_MN5 (XI1_I686_n2 XI1_I686_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I686_MN4 (I1_b3_18 XI1_I686_An XI1_I686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I686_MN2 (XI1_I686_n1 I1_dd18_b3_0 I1_b3_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I686_MN3 (VSS I1_qu29_b3_3 XI1_I686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I686_MN0 (XI1_I686_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I687_MN1 (XI1_I687_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I687_MN5 (XI1_I687_n2 XI1_I687_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I687_MN4 (I1_b3_19 XI1_I687_An XI1_I687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I687_MN2 (XI1_I687_n1 I1_dd19_b3_0 I1_b3_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I687_MN3 (VSS I1_qu29_b3_3 XI1_I687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I687_MN0 (XI1_I687_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I688_MN1 (XI1_I688_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I688_MN5 (XI1_I688_n2 XI1_I688_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I688_MN4 (I1_b3_20 XI1_I688_An XI1_I688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I688_MN2 (XI1_I688_n1 I1_dd20_b3_0 I1_b3_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I688_MN3 (VSS I1_qu29_b3_3 XI1_I688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I688_MN0 (XI1_I688_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I690_MN1 (XI1_I690_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I690_MN5 (XI1_I690_n2 XI1_I690_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I690_MN4 (I1_b3_22 XI1_I690_An XI1_I690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I690_MN2 (XI1_I690_n1 I1_dd22_b3_0 I1_b3_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I690_MN3 (VSS I1_qu29_b3_3 XI1_I690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I690_MN0 (XI1_I690_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I691_MN1 (XI1_I691_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I691_MN5 (XI1_I691_n2 XI1_I691_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I691_MN4 (I1_b3_23 XI1_I691_An XI1_I691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I691_MN2 (XI1_I691_n1 I1_dd23_b3_0 I1_b3_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I691_MN3 (VSS I1_qu29_b3_3 XI1_I691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I691_MN0 (XI1_I691_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I692_MN1 (XI1_I692_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I692_MN5 (XI1_I692_n2 XI1_I692_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I692_MN4 (I1_b3_24 XI1_I692_An XI1_I692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I692_MN2 (XI1_I692_n1 I1_dd24_b3_0 I1_b3_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I692_MN3 (VSS I1_qu29_b3_4 XI1_I692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I692_MN0 (XI1_I692_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I694_MN1 (XI1_I694_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I694_MN5 (XI1_I694_n2 XI1_I694_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I694_MN4 (I1_b3_26 XI1_I694_An XI1_I694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I694_MN2 (XI1_I694_n1 I1_dd26_b3_0 I1_b3_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I694_MN3 (VSS I1_qu29_b3_4 XI1_I694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I694_MN0 (XI1_I694_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I697_MN1 (XI1_I697_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I697_MN5 (XI1_I697_n2 XI1_I697_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I697_MN4 (I1_b3_29 XI1_I697_An XI1_I697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I697_MN2 (XI1_I697_n1 I1_dd29_b3_0 I1_b3_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I697_MN3 (VSS I1_qu29_b3_4 XI1_I697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I697_MN0 (XI1_I697_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1431_MN1 (XI1_I1431_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1431_MN5 (XI1_I1431_n2 XI1_I1431_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1431_MN4 (I1_b19_27 XI1_I1431_An XI1_I1431_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1431_MN2 (XI1_I1431_n1 I1_dd27_b3_3 I1_b19_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1431_MN3 (VSS I1_qu13_b3_4 XI1_I1431_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1431_MN0 (XI1_I1431_An I1_dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1432_MN1 (XI1_I1432_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1432_MN5 (XI1_I1432_n2 XI1_I1432_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1432_MN4 (I1_b19_28 XI1_I1432_An XI1_I1432_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1432_MN2 (XI1_I1432_n1 I1_dd28_b3_3 I1_b19_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1432_MN3 (VSS I1_qu13_b3_4 XI1_I1432_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1432_MN0 (XI1_I1432_An I1_dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1429_MN1 (XI1_I1429_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1429_MN5 (XI1_I1429_n2 XI1_I1429_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1429_MN4 (I1_b19_25 XI1_I1429_An XI1_I1429_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1429_MN2 (XI1_I1429_n1 I1_dd25_b3_3 I1_b19_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1429_MN3 (VSS I1_qu13_b3_4 XI1_I1429_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1429_MN0 (XI1_I1429_An I1_dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1427_MN1 (XI1_I1427_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1427_MN5 (XI1_I1427_n2 XI1_I1427_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1427_MN4 (I1_b19_23 XI1_I1427_An XI1_I1427_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1427_MN2 (XI1_I1427_n1 I1_dd23_b3_3 I1_b19_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1427_MN3 (VSS I1_qu13_b3_3 XI1_I1427_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1427_MN0 (XI1_I1427_An I1_dd23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1425_MN1 (XI1_I1425_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1425_MN5 (XI1_I1425_n2 XI1_I1425_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1425_MN4 (I1_b19_21 XI1_I1425_An XI1_I1425_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1425_MN2 (XI1_I1425_n1 I1_dd21_b3_3 I1_b19_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1425_MN3 (VSS I1_qu13_b3_3 XI1_I1425_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1425_MN0 (XI1_I1425_An I1_dd21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1423_MN1 (XI1_I1423_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1423_MN5 (XI1_I1423_n2 XI1_I1423_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1423_MN4 (I1_b19_19 XI1_I1423_An XI1_I1423_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1423_MN2 (XI1_I1423_n1 I1_dd19_b3_3 I1_b19_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1423_MN3 (VSS I1_qu13_b3_3 XI1_I1423_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1423_MN0 (XI1_I1423_An I1_dd19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I216_MN1 (XI1_I1390_I216_Bn I1_I1390_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I216_MN5 (XI1_I1390_I216_n2 XI1_I1390_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I216_MN4 (I1_p18_13 XI1_I1390_I216_An XI1_I1390_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I216_MN2 (XI1_I1390_I216_n1 I1_I1390_pn13 I1_p18_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I216_MN3 (VSS I1_I1390_G12_0n XI1_I1390_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I216_MN0 (XI1_I1390_I216_An I1_I1390_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1421_MN1 (XI1_I1421_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1421_MN5 (XI1_I1421_n2 XI1_I1421_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1421_MN4 (I1_b19_17 XI1_I1421_An XI1_I1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1421_MN2 (XI1_I1421_n1 I1_dd17_b3_3 I1_b19_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1421_MN3 (VSS I1_qu13_b3_2 XI1_I1421_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1421_MN0 (XI1_I1421_An I1_dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I214_MN1 (XI1_I1390_I214_Bn I1_I1390_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I214_MN5 (XI1_I1390_I214_n2 XI1_I1390_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I214_MN4 (I1_p18_11 XI1_I1390_I214_An XI1_I1390_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I214_MN2 (XI1_I1390_I214_n1 I1_I1390_pn11 I1_p18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I214_MN3 (VSS I1_I1390_G10_0n XI1_I1390_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I214_MN0 (XI1_I1390_I214_An I1_I1390_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1417_MN1 (XI1_I1417_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1417_MN5 (XI1_I1417_n2 XI1_I1417_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1417_MN4 (I1_b19_13 XI1_I1417_An XI1_I1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1417_MN2 (XI1_I1417_n1 I1_dd13_b3_3 I1_b19_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1417_MN3 (VSS I1_qu13_b3_2 XI1_I1417_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1417_MN0 (XI1_I1417_An I1_dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1415_MN1 (XI1_I1415_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1415_MN5 (XI1_I1415_n2 XI1_I1415_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1415_MN4 (I1_b19_11 XI1_I1415_An XI1_I1415_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1415_MN2 (XI1_I1415_n1 I1_dd11_b3_3 I1_b19_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1415_MN3 (VSS I1_qu13_b3_1 XI1_I1415_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1415_MN0 (XI1_I1415_An I1_dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I207_MN1 (XI1_I1390_I207_Bn I1_I1390_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I207_MN5 (XI1_I1390_I207_n2 XI1_I1390_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I207_MN4 (I1_p18_4 XI1_I1390_I207_An XI1_I1390_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I207_MN2 (XI1_I1390_I207_n1 I1_I1390_pn4 I1_p18_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I207_MN3 (VSS I1_I1390_G3_0n XI1_I1390_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I207_MN0 (XI1_I1390_I207_An I1_I1390_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1110_MN1 (XI1_I1110_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1110_MN5 (XI1_I1110_n2 XI1_I1110_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1110_MN4 (I1_b12_28 XI1_I1110_An XI1_I1110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1110_MN2 (XI1_I1110_n1 I1_dd28_b3_2 I1_b12_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1110_MN3 (VSS I1_qu20_b3_4 XI1_I1110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1110_MN0 (XI1_I1110_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1109_MN1 (XI1_I1109_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1109_MN5 (XI1_I1109_n2 XI1_I1109_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1109_MN4 (I1_b12_27 XI1_I1109_An XI1_I1109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1109_MN2 (XI1_I1109_n1 I1_dd27_b3_2 I1_b12_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1109_MN3 (VSS I1_qu20_b3_4 XI1_I1109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1109_MN0 (XI1_I1109_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1111_MN1 (XI1_I1111_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1111_MN5 (XI1_I1111_n2 XI1_I1111_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1111_MN4 (I1_b12_29 XI1_I1111_An XI1_I1111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1111_MN2 (XI1_I1111_n1 I1_dd29_b3_2 I1_b12_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1111_MN3 (VSS I1_qu20_b3_4 XI1_I1111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1111_MN0 (XI1_I1111_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1151_MN1 (XI1_I1151_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1151_MN5 (XI1_I1151_n2 XI1_I1151_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1151_MN4 (I1_b13_23 XI1_I1151_An XI1_I1151_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1151_MN2 (XI1_I1151_n1 I1_dd23_b3_2 I1_b13_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1151_MN3 (VSS I1_qu19_b3_3 XI1_I1151_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1151_MN0 (XI1_I1151_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1149_MN1 (XI1_I1149_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1149_MN5 (XI1_I1149_n2 XI1_I1149_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1149_MN4 (I1_b13_21 XI1_I1149_An XI1_I1149_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1149_MN2 (XI1_I1149_n1 I1_dd21_b3_2 I1_b13_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1149_MN3 (VSS I1_qu19_b3_3 XI1_I1149_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1149_MN0 (XI1_I1149_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1132_MN1 (XI1_I1132_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1132_MN5 (XI1_I1132_n2 XI1_I1132_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1132_MN4 (I1_b13_4 XI1_I1132_An XI1_I1132_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1132_MN2 (XI1_I1132_n1 I1_dd4_b3_2 I1_b13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1132_MN3 (VSS I1_qu19_b3_0 XI1_I1132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1132_MN0 (XI1_I1132_An I1_dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1065_MN1 (XI1_I1065_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1065_MN5 (XI1_I1065_n2 XI1_I1065_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1065_MN4 (I1_b11_29 XI1_I1065_An XI1_I1065_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1065_MN2 (XI1_I1065_n1 I1_dd29_b3_2 I1_b11_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1065_MN3 (VSS I1_qu21_b3_4 XI1_I1065_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1065_MN0 (XI1_I1065_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1063_MN1 (XI1_I1063_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1063_MN5 (XI1_I1063_n2 XI1_I1063_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1063_MN4 (I1_b11_27 XI1_I1063_An XI1_I1063_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1063_MN2 (XI1_I1063_n1 I1_dd27_b3_2 I1_b11_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1063_MN3 (VSS I1_qu21_b3_4 XI1_I1063_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1063_MN0 (XI1_I1063_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1131_MN1 (XI1_I1131_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1131_MN5 (XI1_I1131_n2 XI1_I1131_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1131_MN4 (I1_b13_3 XI1_I1131_An XI1_I1131_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1131_MN2 (XI1_I1131_n1 I1_dd3_b3_2 I1_b13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1131_MN3 (VSS I1_qu19_b3_0 XI1_I1131_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1131_MN0 (XI1_I1131_An I1_dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1130_MN1 (XI1_I1130_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1130_MN5 (XI1_I1130_n2 XI1_I1130_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1130_MN4 (I1_b13_2 XI1_I1130_An XI1_I1130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1130_MN2 (XI1_I1130_n1 I1_dd2_b3_2 I1_b13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1130_MN3 (VSS I1_qu19_b3_0 XI1_I1130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1130_MN0 (XI1_I1130_An I1_dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I973_MN1 (XI1_I973_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I973_MN5 (XI1_I973_n2 XI1_I973_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I973_MN4 (I1_b9_29 XI1_I973_An XI1_I973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I973_MN2 (XI1_I973_n1 I1_dd29_b3_1 I1_b9_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I973_MN3 (VSS I1_qu23_b3_4 XI1_I973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I973_MN0 (XI1_I973_An I1_dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I971_MN1 (XI1_I971_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I971_MN5 (XI1_I971_n2 XI1_I971_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I971_MN4 (I1_b9_27 XI1_I971_An XI1_I971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I971_MN2 (XI1_I971_n1 I1_dd27_b3_1 I1_b9_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I971_MN3 (VSS I1_qu23_b3_4 XI1_I971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I971_MN0 (XI1_I971_An I1_dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I214_MN1 (XI1_I930_I214_Bn I1_I930_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I214_MN5 (XI1_I930_I214_n2 XI1_I930_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I214_MN4 (I1_p8_11 XI1_I930_I214_An XI1_I930_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I214_MN2 (XI1_I930_I214_n1 I1_I930_pn11 I1_p8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I214_MN3 (VSS I1_I930_G10_0n XI1_I930_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I214_MN0 (XI1_I930_I214_An I1_I930_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I213_MN1 (XI1_I930_I213_Bn I1_I930_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I213_MN5 (XI1_I930_I213_n2 XI1_I930_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I213_MN4 (I1_p8_10 XI1_I930_I213_An XI1_I930_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I213_MN2 (XI1_I930_I213_n1 I1_I930_pn10 I1_p8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I213_MN3 (VSS I1_I930_G9_0n XI1_I930_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I213_MN0 (XI1_I930_I213_An I1_I930_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I207_MN1 (XI1_I930_I207_Bn I1_I930_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I207_MN5 (XI1_I930_I207_n2 XI1_I930_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I207_MN4 (I1_p8_4 XI1_I930_I207_An XI1_I930_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I207_MN2 (XI1_I930_I207_n1 I1_I930_pn4 I1_p8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I207_MN3 (VSS I1_I930_G3_0n XI1_I930_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I207_MN0 (XI1_I930_I207_An I1_I930_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I668_MN1 (XI1_I668_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I668_MN5 (XI1_I668_n2 XI1_I668_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I668_MN4 (I1_b3_0 XI1_I668_An XI1_I668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I668_MN2 (XI1_I668_n1 I1_B_0_b3_0 I1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I668_MN3 (VSS I1_qu29_b3_0 XI1_I668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I668_MN0 (XI1_I668_An I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I673_MN1 (XI1_I673_Bn I1_qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I673_MN5 (XI1_I673_n2 XI1_I673_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I673_MN4 (I1_b3_5 XI1_I673_An XI1_I673_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I673_MN2 (XI1_I673_n1 I1_dd5_b3_0 I1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I673_MN3 (VSS I1_qu29_b3_0 XI1_I673_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I673_MN0 (XI1_I673_An I1_dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I207_MN1 (XI1_I654_I207_Bn I1_I654_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I207_MN5 (XI1_I654_I207_n2 XI1_I654_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I207_MN4 (I1_p2_4 XI1_I654_I207_An XI1_I654_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I207_MN2 (XI1_I654_I207_n1 I1_I654_pn4 I1_p2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I207_MN3 (VSS I1_I654_G3_0n XI1_I654_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I207_MN0 (XI1_I654_I207_An I1_I654_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I678_MN1 (XI1_I678_Bn I1_qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I678_MN5 (XI1_I678_n2 XI1_I678_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I678_MN4 (I1_b3_10 XI1_I678_An XI1_I678_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I678_MN2 (XI1_I678_n1 I1_dd10_b3_0 I1_b3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I678_MN3 (VSS I1_qu29_b3_1 XI1_I678_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I678_MN0 (XI1_I678_An I1_dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I215_MN1 (XI1_I654_I215_Bn I1_I654_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I215_MN5 (XI1_I654_I215_n2 XI1_I654_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I215_MN4 (I1_p2_12 XI1_I654_I215_An XI1_I654_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I215_MN2 (XI1_I654_I215_n1 I1_I654_pn12 I1_p2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I215_MN3 (VSS I1_I654_G11_0n XI1_I654_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I215_MN0 (XI1_I654_I215_An I1_I654_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I217_MN1 (XI1_I654_I217_Bn I1_I654_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I217_MN5 (XI1_I654_I217_n2 XI1_I654_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I217_MN4 (I1_p2_14 XI1_I654_I217_An XI1_I654_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I217_MN2 (XI1_I654_I217_n1 I1_I654_pn14 I1_p2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I217_MN3 (VSS I1_I654_G13_0n XI1_I654_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I217_MN0 (XI1_I654_I217_An I1_I654_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I689_MN1 (XI1_I689_Bn I1_qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I689_MN5 (XI1_I689_n2 XI1_I689_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I689_MN4 (I1_b3_21 XI1_I689_An XI1_I689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I689_MN2 (XI1_I689_n1 I1_dd21_b3_0 I1_b3_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I689_MN3 (VSS I1_qu29_b3_3 XI1_I689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I689_MN0 (XI1_I689_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I693_MN1 (XI1_I693_Bn I1_qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I693_MN5 (XI1_I693_n2 XI1_I693_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I693_MN4 (I1_b3_25 XI1_I693_An XI1_I693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I693_MN2 (XI1_I693_n1 I1_dd25_b3_0 I1_b3_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I693_MN3 (VSS I1_qu29_b3_4 XI1_I693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I693_MN0 (XI1_I693_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I698_MN1 (XI1_I698_Bn I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I698_MN5 (XI1_I698_n2 XI1_I698_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I698_MN4 (I1_b3_30 XI1_I698_An XI1_I698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I698_MN2 (XI1_I698_n1 I1_dd30_b3_0 I1_b3_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I698_MN3 (VSS I1_qu29_b3_5 XI1_I698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I698_MN0 (XI1_I698_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1430_MN1 (XI1_I1430_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1430_MN5 (XI1_I1430_n2 XI1_I1430_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1430_MN4 (I1_b19_26 XI1_I1430_An XI1_I1430_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1430_MN2 (XI1_I1430_n1 I1_dd26_b3_3 I1_b19_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1430_MN3 (VSS I1_qu13_b3_4 XI1_I1430_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1430_MN0 (XI1_I1430_An I1_dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1433_MN1 (XI1_I1433_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1433_MN5 (XI1_I1433_n2 XI1_I1433_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1433_MN4 (I1_b19_29 XI1_I1433_An XI1_I1433_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1433_MN2 (XI1_I1433_n1 I1_dd29_b3_3 I1_b19_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1433_MN3 (VSS I1_qu13_b3_4 XI1_I1433_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1433_MN0 (XI1_I1433_An I1_dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1428_MN1 (XI1_I1428_Bn I1_qu13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1428_MN5 (XI1_I1428_n2 XI1_I1428_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1428_MN4 (I1_b19_24 XI1_I1428_An XI1_I1428_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1428_MN2 (XI1_I1428_n1 I1_dd24_b3_3 I1_b19_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1428_MN3 (VSS I1_qu13_b3_4 XI1_I1428_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1428_MN0 (XI1_I1428_An I1_dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1426_MN1 (XI1_I1426_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1426_MN5 (XI1_I1426_n2 XI1_I1426_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1426_MN4 (I1_b19_22 XI1_I1426_An XI1_I1426_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1426_MN2 (XI1_I1426_n1 I1_dd22_b3_3 I1_b19_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1426_MN3 (VSS I1_qu13_b3_3 XI1_I1426_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1426_MN0 (XI1_I1426_An I1_dd22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1422_MN1 (XI1_I1422_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1422_MN5 (XI1_I1422_n2 XI1_I1422_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1422_MN4 (I1_b19_18 XI1_I1422_An XI1_I1422_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1422_MN2 (XI1_I1422_n1 I1_dd18_b3_3 I1_b19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1422_MN3 (VSS I1_qu13_b3_3 XI1_I1422_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1422_MN0 (XI1_I1422_An I1_dd18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1424_MN1 (XI1_I1424_Bn I1_qu13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1424_MN5 (XI1_I1424_n2 XI1_I1424_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1424_MN4 (I1_b19_20 XI1_I1424_An XI1_I1424_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1424_MN2 (XI1_I1424_n1 I1_dd20_b3_3 I1_b19_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1424_MN3 (VSS I1_qu13_b3_3 XI1_I1424_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1424_MN0 (XI1_I1424_An I1_dd20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1419_MN1 (XI1_I1419_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1419_MN5 (XI1_I1419_n2 XI1_I1419_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1419_MN4 (I1_b19_15 XI1_I1419_An XI1_I1419_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1419_MN2 (XI1_I1419_n1 I1_dd15_b3_3 I1_b19_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1419_MN3 (VSS I1_qu13_b3_2 XI1_I1419_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1419_MN0 (XI1_I1419_An I1_dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1420_MN1 (XI1_I1420_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1420_MN5 (XI1_I1420_n2 XI1_I1420_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1420_MN4 (I1_b19_16 XI1_I1420_An XI1_I1420_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1420_MN2 (XI1_I1420_n1 I1_dd16_b3_3 I1_b19_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1420_MN3 (VSS I1_qu13_b3_2 XI1_I1420_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1420_MN0 (XI1_I1420_An I1_dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1418_MN1 (XI1_I1418_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1418_MN5 (XI1_I1418_n2 XI1_I1418_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1418_MN4 (I1_b19_14 XI1_I1418_An XI1_I1418_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1418_MN2 (XI1_I1418_n1 I1_dd14_b3_3 I1_b19_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1418_MN3 (VSS I1_qu13_b3_2 XI1_I1418_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1418_MN0 (XI1_I1418_An I1_dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1416_MN1 (XI1_I1416_Bn I1_qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1416_MN5 (XI1_I1416_n2 XI1_I1416_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1416_MN4 (I1_b19_12 XI1_I1416_An XI1_I1416_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1416_MN2 (XI1_I1416_n1 I1_dd12_b3_3 I1_b19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1416_MN3 (VSS I1_qu13_b3_2 XI1_I1416_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1416_MN0 (XI1_I1416_An I1_dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1412_MN1 (XI1_I1412_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1412_MN5 (XI1_I1412_n2 XI1_I1412_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1412_MN4 (I1_b19_8 XI1_I1412_An XI1_I1412_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1412_MN2 (XI1_I1412_n1 I1_dd8_b3_3 I1_b19_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1412_MN3 (VSS I1_qu13_b3_1 XI1_I1412_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1412_MN0 (XI1_I1412_An I1_dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1414_MN1 (XI1_I1414_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1414_MN5 (XI1_I1414_n2 XI1_I1414_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1414_MN4 (I1_b19_10 XI1_I1414_An XI1_I1414_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1414_MN2 (XI1_I1414_n1 I1_dd10_b3_3 I1_b19_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1414_MN3 (VSS I1_qu13_b3_1 XI1_I1414_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1414_MN0 (XI1_I1414_An I1_dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1411_MN1 (XI1_I1411_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1411_MN5 (XI1_I1411_n2 XI1_I1411_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1411_MN4 (I1_b19_7 XI1_I1411_An XI1_I1411_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1411_MN2 (XI1_I1411_n1 I1_dd7_b3_3 I1_b19_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1411_MN3 (VSS I1_qu13_b3_1 XI1_I1411_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1411_MN0 (XI1_I1411_An I1_dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1410_MN1 (XI1_I1410_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1410_MN5 (XI1_I1410_n2 XI1_I1410_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1410_MN4 (I1_b19_6 XI1_I1410_An XI1_I1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1410_MN2 (XI1_I1410_n1 I1_dd6_b3_3 I1_b19_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1410_MN3 (VSS I1_qu13_b3_1 XI1_I1410_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1410_MN0 (XI1_I1410_An I1_dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I206_MN1 (XI1_I1390_I206_Bn I1_I1390_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I206_MN5 (XI1_I1390_I206_n2 XI1_I1390_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1390_I206_MN4 (I1_p18_3 XI1_I1390_I206_An XI1_I1390_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I206_MN2 (XI1_I1390_I206_n1 I1_I1390_pn3 I1_p18_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1390_I206_MN3 (VSS I1_I1390_G2_0n XI1_I1390_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1390_I206_MN0 (XI1_I1390_I206_An I1_I1390_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1408_MN1 (XI1_I1408_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1408_MN5 (XI1_I1408_n2 XI1_I1408_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1408_MN4 (I1_b19_4 XI1_I1408_An XI1_I1408_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1408_MN2 (XI1_I1408_n1 I1_dd4_b3_3 I1_b19_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1408_MN3 (VSS I1_qu13_b3_0 XI1_I1408_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1408_MN0 (XI1_I1408_An I1_dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1358_MN1 (XI1_I1358_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1358_MN5 (XI1_I1358_n2 XI1_I1358_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1358_MN4 (I1_b18_0 XI1_I1358_An XI1_I1358_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1358_MN2 (XI1_I1358_n1 I1_B_0_b3_3 I1_b18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1358_MN3 (VSS I1_qu14_b3_0 XI1_I1358_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1358_MN0 (XI1_I1358_An I1_B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1359_MN1 (XI1_I1359_Bn I1_qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1359_MN5 (XI1_I1359_n2 XI1_I1359_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1359_MN4 (I1_b18_1 XI1_I1359_An XI1_I1359_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1359_MN2 (XI1_I1359_n1 I1_dd1_b3_3 I1_b18_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1359_MN3 (VSS I1_qu14_b3_0 XI1_I1359_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1359_MN0 (XI1_I1359_An I1_dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1108_MN1 (XI1_I1108_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1108_MN5 (XI1_I1108_n2 XI1_I1108_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1108_MN4 (I1_b12_26 XI1_I1108_An XI1_I1108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1108_MN2 (XI1_I1108_n1 I1_dd26_b3_2 I1_b12_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1108_MN3 (VSS I1_qu20_b3_4 XI1_I1108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1108_MN0 (XI1_I1108_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1107_MN1 (XI1_I1107_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1107_MN5 (XI1_I1107_n2 XI1_I1107_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1107_MN4 (I1_b12_25 XI1_I1107_An XI1_I1107_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1107_MN2 (XI1_I1107_n1 I1_dd25_b3_2 I1_b12_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1107_MN3 (VSS I1_qu20_b3_4 XI1_I1107_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1107_MN0 (XI1_I1107_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1106_MN1 (XI1_I1106_Bn I1_qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1106_MN5 (XI1_I1106_n2 XI1_I1106_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1106_MN4 (I1_b12_24 XI1_I1106_An XI1_I1106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1106_MN2 (XI1_I1106_n1 I1_dd24_b3_2 I1_b12_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1106_MN3 (VSS I1_qu20_b3_4 XI1_I1106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1106_MN0 (XI1_I1106_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1150_MN1 (XI1_I1150_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1150_MN5 (XI1_I1150_n2 XI1_I1150_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1150_MN4 (I1_b13_22 XI1_I1150_An XI1_I1150_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1150_MN2 (XI1_I1150_n1 I1_dd22_b3_2 I1_b13_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1150_MN3 (VSS I1_qu19_b3_3 XI1_I1150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1150_MN0 (XI1_I1150_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1161_MN1 (XI1_I1161_Bn I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1161_MN5 (XI1_I1161_n2 XI1_I1161_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1161_MN4 (I1_h13 XI1_I1161_An XI1_I1161_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1161_MN2 (XI1_I1161_n1 I1_p12_31 I1_h13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1161_MN3 (VSS I1_qu19_b3_5 XI1_I1161_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1161_MN0 (XI1_I1161_An I1_p12_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1148_MN1 (XI1_I1148_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1148_MN5 (XI1_I1148_n2 XI1_I1148_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1148_MN4 (I1_b13_20 XI1_I1148_An XI1_I1148_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1148_MN2 (XI1_I1148_n1 I1_dd20_b3_2 I1_b13_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1148_MN3 (VSS I1_qu19_b3_3 XI1_I1148_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1148_MN0 (XI1_I1148_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1147_MN1 (XI1_I1147_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1147_MN5 (XI1_I1147_n2 XI1_I1147_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1147_MN4 (I1_b13_19 XI1_I1147_An XI1_I1147_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1147_MN2 (XI1_I1147_n1 I1_dd19_b3_2 I1_b13_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1147_MN3 (VSS I1_qu19_b3_3 XI1_I1147_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1147_MN0 (XI1_I1147_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1146_MN1 (XI1_I1146_Bn I1_qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1146_MN5 (XI1_I1146_n2 XI1_I1146_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1146_MN4 (I1_b13_18 XI1_I1146_An XI1_I1146_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1146_MN2 (XI1_I1146_n1 I1_dd18_b3_2 I1_b13_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1146_MN3 (VSS I1_qu19_b3_3 XI1_I1146_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1146_MN0 (XI1_I1146_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1144_MN1 (XI1_I1144_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1144_MN5 (XI1_I1144_n2 XI1_I1144_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1144_MN4 (I1_b13_16 XI1_I1144_An XI1_I1144_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1144_MN2 (XI1_I1144_n1 I1_dd16_b3_2 I1_b13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1144_MN3 (VSS I1_qu19_b3_2 XI1_I1144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1144_MN0 (XI1_I1144_An I1_dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1138_MN1 (XI1_I1138_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1138_MN5 (XI1_I1138_n2 XI1_I1138_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1138_MN4 (I1_b13_10 XI1_I1138_An XI1_I1138_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1138_MN2 (XI1_I1138_n1 I1_dd10_b3_2 I1_b13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1138_MN3 (VSS I1_qu19_b3_1 XI1_I1138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1138_MN0 (XI1_I1138_An I1_dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1137_MN1 (XI1_I1137_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1137_MN5 (XI1_I1137_n2 XI1_I1137_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1137_MN4 (I1_b13_9 XI1_I1137_An XI1_I1137_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1137_MN2 (XI1_I1137_n1 I1_dd9_b3_2 I1_b13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1137_MN3 (VSS I1_qu19_b3_1 XI1_I1137_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1137_MN0 (XI1_I1137_An I1_dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1134_MN1 (XI1_I1134_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1134_MN5 (XI1_I1134_n2 XI1_I1134_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1134_MN4 (I1_b13_6 XI1_I1134_An XI1_I1134_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1134_MN2 (XI1_I1134_n1 I1_dd6_b3_2 I1_b13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1134_MN3 (VSS I1_qu19_b3_1 XI1_I1134_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1134_MN0 (XI1_I1134_An I1_dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1133_MN1 (XI1_I1133_Bn I1_qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1133_MN5 (XI1_I1133_n2 XI1_I1133_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1133_MN4 (I1_b13_5 XI1_I1133_An XI1_I1133_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1133_MN2 (XI1_I1133_n1 I1_dd5_b3_2 I1_b13_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1133_MN3 (VSS I1_qu19_b3_0 XI1_I1133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1133_MN0 (XI1_I1133_An I1_dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1064_MN1 (XI1_I1064_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1064_MN5 (XI1_I1064_n2 XI1_I1064_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1064_MN4 (I1_b11_28 XI1_I1064_An XI1_I1064_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1064_MN2 (XI1_I1064_n1 I1_dd28_b3_2 I1_b11_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1064_MN3 (VSS I1_qu21_b3_4 XI1_I1064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1064_MN0 (XI1_I1064_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1062_MN1 (XI1_I1062_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1062_MN5 (XI1_I1062_n2 XI1_I1062_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1062_MN4 (I1_b11_26 XI1_I1062_An XI1_I1062_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1062_MN2 (XI1_I1062_n1 I1_dd26_b3_2 I1_b11_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1062_MN3 (VSS I1_qu21_b3_4 XI1_I1062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1062_MN0 (XI1_I1062_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1060_MN1 (XI1_I1060_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1060_MN5 (XI1_I1060_n2 XI1_I1060_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1060_MN4 (I1_b11_24 XI1_I1060_An XI1_I1060_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1060_MN2 (XI1_I1060_n1 I1_dd24_b3_2 I1_b11_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1060_MN3 (VSS I1_qu21_b3_4 XI1_I1060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1060_MN0 (XI1_I1060_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1061_MN1 (XI1_I1061_Bn I1_qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1061_MN5 (XI1_I1061_n2 XI1_I1061_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1061_MN4 (I1_b11_25 XI1_I1061_An XI1_I1061_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1061_MN2 (XI1_I1061_n1 I1_dd25_b3_2 I1_b11_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1061_MN3 (VSS I1_qu21_b3_4 XI1_I1061_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1061_MN0 (XI1_I1061_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1017_MN1 (XI1_I1017_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1017_MN5 (XI1_I1017_n2 XI1_I1017_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1017_MN4 (I1_b10_27 XI1_I1017_An XI1_I1017_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1017_MN2 (XI1_I1017_n1 I1_dd27_b3_1 I1_b10_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1017_MN3 (VSS I1_qu22_b3_4 XI1_I1017_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1017_MN0 (XI1_I1017_An I1_dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1019_MN1 (XI1_I1019_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1019_MN5 (XI1_I1019_n2 XI1_I1019_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1019_MN4 (I1_b10_29 XI1_I1019_An XI1_I1019_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1019_MN2 (XI1_I1019_n1 I1_dd29_b3_1 I1_b10_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1019_MN3 (VSS I1_qu22_b3_4 XI1_I1019_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1019_MN0 (XI1_I1019_An I1_dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I972_MN1 (XI1_I972_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I972_MN5 (XI1_I972_n2 XI1_I972_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I972_MN4 (I1_b9_28 XI1_I972_An XI1_I972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I972_MN2 (XI1_I972_n1 I1_dd28_b3_1 I1_b9_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I972_MN3 (VSS I1_qu23_b3_4 XI1_I972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I972_MN0 (XI1_I972_An I1_dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I968_MN1 (XI1_I968_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I968_MN5 (XI1_I968_n2 XI1_I968_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I968_MN4 (I1_b9_24 XI1_I968_An XI1_I968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I968_MN2 (XI1_I968_n1 I1_dd24_b3_1 I1_b9_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I968_MN3 (VSS I1_qu23_b3_4 XI1_I968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I968_MN0 (XI1_I968_An I1_dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I977_MN1 (XI1_I977_Bn I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I977_MN5 (XI1_I977_n2 XI1_I977_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I977_MN4 (I1_h9 XI1_I977_An XI1_I977_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I977_MN2 (XI1_I977_n1 I1_p8_31 I1_h9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I977_MN3 (VSS I1_qu23_b3_5 XI1_I977_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I977_MN0 (XI1_I977_An I1_p8_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I212_MN1 (XI1_I930_I212_Bn I1_I930_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I212_MN5 (XI1_I930_I212_n2 XI1_I930_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I212_MN4 (I1_p8_9 XI1_I930_I212_An XI1_I930_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I212_MN2 (XI1_I930_I212_n1 I1_I930_pn9 I1_p8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I212_MN3 (VSS I1_I930_G8_0n XI1_I930_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I212_MN0 (XI1_I930_I212_An I1_I930_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I206_MN1 (XI1_I930_I206_Bn I1_I930_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I206_MN5 (XI1_I930_I206_n2 XI1_I930_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I206_MN4 (I1_p8_3 XI1_I930_I206_An XI1_I930_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I206_MN2 (XI1_I930_I206_n1 I1_I930_pn3 I1_p8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I206_MN3 (VSS I1_I930_G2_0n XI1_I930_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I206_MN0 (XI1_I930_I206_An I1_I930_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I206_MN1 (XI1_I654_I206_Bn I1_I654_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I206_MN5 (XI1_I654_I206_n2 XI1_I654_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I206_MN4 (I1_p2_3 XI1_I654_I206_An XI1_I654_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I206_MN2 (XI1_I654_I206_n1 I1_I654_pn3 I1_p2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I206_MN3 (VSS I1_I654_G2_0n XI1_I654_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I206_MN0 (XI1_I654_I206_An I1_I654_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I213_MN1 (XI1_I654_I213_Bn I1_I654_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I213_MN5 (XI1_I654_I213_n2 XI1_I654_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I213_MN4 (I1_p2_10 XI1_I654_I213_An XI1_I654_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I213_MN2 (XI1_I654_I213_n1 I1_I654_pn10 I1_p2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I213_MN3 (VSS I1_I654_G9_0n XI1_I654_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I213_MN0 (XI1_I654_I213_An I1_I654_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I219_MN1 (XI1_I654_I219_Bn I1_I654_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I219_MN5 (XI1_I654_I219_n2 XI1_I654_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I219_MN4 (I1_p2_16 XI1_I654_I219_An XI1_I654_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I219_MN2 (XI1_I654_I219_n1 I1_I654_pn16 I1_p2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I219_MN3 (VSS I1_I654_G15_0n XI1_I654_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I219_MN0 (XI1_I654_I219_An I1_I654_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I656_MN1 (XI1_I656_Bn I1_c2_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I656_MN5 (XI1_I656_n2 XI1_I656_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I656_MN4 (I1_p2_32 XI1_I656_An XI1_I656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I656_MN2 (XI1_I656_n1 I1_h2 I1_p2_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I656_MN3 (VSS I1_c2_o XI1_I656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I656_MN0 (XI1_I656_An I1_h2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I699_MN1 (XI1_I699_Bn I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I699_MN5 (XI1_I699_n2 XI1_I699_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I699_MN4 (I1_b3_31 XI1_I699_An XI1_I699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I699_MN2 (XI1_I699_n1 I1_dd31_b3_0 I1_b3_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I699_MN3 (VSS I1_qu29_b3_5 XI1_I699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I699_MN0 (XI1_I699_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1413_MN1 (XI1_I1413_Bn I1_qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1413_MN5 (XI1_I1413_n2 XI1_I1413_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1413_MN4 (I1_b19_9 XI1_I1413_An XI1_I1413_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1413_MN2 (XI1_I1413_n1 I1_dd9_b3_3 I1_b19_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1413_MN3 (VSS I1_qu13_b3_1 XI1_I1413_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1413_MN0 (XI1_I1413_An I1_dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1409_MN1 (XI1_I1409_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1409_MN5 (XI1_I1409_n2 XI1_I1409_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1409_MN4 (I1_b19_5 XI1_I1409_An XI1_I1409_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1409_MN2 (XI1_I1409_n1 I1_dd5_b3_3 I1_b19_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1409_MN3 (VSS I1_qu13_b3_0 XI1_I1409_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1409_MN0 (XI1_I1409_An I1_dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1407_MN1 (XI1_I1407_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1407_MN5 (XI1_I1407_n2 XI1_I1407_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1407_MN4 (I1_b19_3 XI1_I1407_An XI1_I1407_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1407_MN2 (XI1_I1407_n1 I1_dd3_b3_3 I1_b19_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1407_MN3 (VSS I1_qu13_b3_0 XI1_I1407_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1407_MN0 (XI1_I1407_An I1_dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1113_MN1 (XI1_I1113_Bn I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1113_MN5 (XI1_I1113_n2 XI1_I1113_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1113_MN4 (I1_b12_31 XI1_I1113_An XI1_I1113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1113_MN2 (XI1_I1113_n1 I1_dd31_b3_2 I1_b12_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1113_MN3 (VSS I1_qu20_b3_5 XI1_I1113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1113_MN0 (XI1_I1113_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I218_MN1 (XI1_I1114_I218_Bn I1_I1114_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I218_MN5 (XI1_I1114_I218_n2 XI1_I1114_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1114_I218_MN4 (I1_p12_15 XI1_I1114_I218_An XI1_I1114_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I218_MN2 (XI1_I1114_I218_n1 I1_I1114_pn15 I1_p12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1114_I218_MN3 (VSS I1_I1114_G14_0n XI1_I1114_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1114_I218_MN0 (XI1_I1114_I218_An I1_I1114_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1112_MN1 (XI1_I1112_Bn I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1112_MN5 (XI1_I1112_n2 XI1_I1112_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1112_MN4 (I1_b12_30 XI1_I1112_An XI1_I1112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1112_MN2 (XI1_I1112_n1 I1_dd30_b3_2 I1_b12_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1112_MN3 (VSS I1_qu20_b3_5 XI1_I1112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1112_MN0 (XI1_I1112_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1145_MN1 (XI1_I1145_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1145_MN5 (XI1_I1145_n2 XI1_I1145_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1145_MN4 (I1_b13_17 XI1_I1145_An XI1_I1145_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1145_MN2 (XI1_I1145_n1 I1_dd17_b3_2 I1_b13_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1145_MN3 (VSS I1_qu19_b3_2 XI1_I1145_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1145_MN0 (XI1_I1145_An I1_dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1142_MN1 (XI1_I1142_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1142_MN5 (XI1_I1142_n2 XI1_I1142_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1142_MN4 (I1_b13_14 XI1_I1142_An XI1_I1142_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1142_MN2 (XI1_I1142_n1 I1_dd14_b3_2 I1_b13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1142_MN3 (VSS I1_qu19_b3_2 XI1_I1142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1142_MN0 (XI1_I1142_An I1_dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1141_MN1 (XI1_I1141_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1141_MN5 (XI1_I1141_n2 XI1_I1141_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1141_MN4 (I1_b13_13 XI1_I1141_An XI1_I1141_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1141_MN2 (XI1_I1141_n1 I1_dd13_b3_2 I1_b13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1141_MN3 (VSS I1_qu19_b3_2 XI1_I1141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1141_MN0 (XI1_I1141_An I1_dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1139_MN1 (XI1_I1139_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1139_MN5 (XI1_I1139_n2 XI1_I1139_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1139_MN4 (I1_b13_11 XI1_I1139_An XI1_I1139_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1139_MN2 (XI1_I1139_n1 I1_dd11_b3_2 I1_b13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1139_MN3 (VSS I1_qu19_b3_1 XI1_I1139_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1139_MN0 (XI1_I1139_An I1_dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1135_MN1 (XI1_I1135_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1135_MN5 (XI1_I1135_n2 XI1_I1135_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1135_MN4 (I1_b13_7 XI1_I1135_An XI1_I1135_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1135_MN2 (XI1_I1135_n1 I1_dd7_b3_2 I1_b13_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1135_MN3 (VSS I1_qu19_b3_1 XI1_I1135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1135_MN0 (XI1_I1135_An I1_dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1136_MN1 (XI1_I1136_Bn I1_qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1136_MN5 (XI1_I1136_n2 XI1_I1136_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1136_MN4 (I1_b13_8 XI1_I1136_An XI1_I1136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1136_MN2 (XI1_I1136_n1 I1_dd8_b3_2 I1_b13_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1136_MN3 (VSS I1_qu19_b3_1 XI1_I1136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1136_MN0 (XI1_I1136_An I1_dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1066_MN1 (XI1_I1066_Bn I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1066_MN5 (XI1_I1066_n2 XI1_I1066_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1066_MN4 (I1_b11_30 XI1_I1066_An XI1_I1066_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1066_MN2 (XI1_I1066_n1 I1_dd30_b3_2 I1_b11_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1066_MN3 (VSS I1_qu21_b3_5 XI1_I1066_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1066_MN0 (XI1_I1066_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1016_MN1 (XI1_I1016_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1016_MN5 (XI1_I1016_n2 XI1_I1016_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1016_MN4 (I1_b10_26 XI1_I1016_An XI1_I1016_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1016_MN2 (XI1_I1016_n1 I1_dd26_b3_1 I1_b10_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1016_MN3 (VSS I1_qu22_b3_4 XI1_I1016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1016_MN0 (XI1_I1016_An I1_dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1018_MN1 (XI1_I1018_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1018_MN5 (XI1_I1018_n2 XI1_I1018_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1018_MN4 (I1_b10_28 XI1_I1018_An XI1_I1018_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1018_MN2 (XI1_I1018_n1 I1_dd28_b3_1 I1_b10_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1018_MN3 (VSS I1_qu22_b3_4 XI1_I1018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1018_MN0 (XI1_I1018_An I1_dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I975_MN1 (XI1_I975_Bn I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I975_MN5 (XI1_I975_n2 XI1_I975_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I975_MN4 (I1_b9_31 XI1_I975_An XI1_I975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I975_MN2 (XI1_I975_n1 I1_dd31_b3_1 I1_b9_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I975_MN3 (VSS I1_qu23_b3_5 XI1_I975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I975_MN0 (XI1_I975_An I1_dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1015_MN1 (XI1_I1015_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1015_MN5 (XI1_I1015_n2 XI1_I1015_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1015_MN4 (I1_b10_25 XI1_I1015_An XI1_I1015_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1015_MN2 (XI1_I1015_n1 I1_dd25_b3_1 I1_b10_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1015_MN3 (VSS I1_qu22_b3_4 XI1_I1015_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1015_MN0 (XI1_I1015_An I1_dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I970_MN1 (XI1_I970_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I970_MN5 (XI1_I970_n2 XI1_I970_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I970_MN4 (I1_b9_26 XI1_I970_An XI1_I970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I970_MN2 (XI1_I970_n1 I1_dd26_b3_1 I1_b9_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I970_MN3 (VSS I1_qu23_b3_4 XI1_I970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I970_MN0 (XI1_I970_An I1_dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1014_MN1 (XI1_I1014_Bn I1_qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1014_MN5 (XI1_I1014_n2 XI1_I1014_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1014_MN4 (I1_b10_24 XI1_I1014_An XI1_I1014_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1014_MN2 (XI1_I1014_n1 I1_dd24_b3_1 I1_b10_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1014_MN3 (VSS I1_qu22_b3_4 XI1_I1014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1014_MN0 (XI1_I1014_An I1_dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I969_MN1 (XI1_I969_Bn I1_qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I969_MN5 (XI1_I969_n2 XI1_I969_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I969_MN4 (I1_b9_25 XI1_I969_An XI1_I969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I969_MN2 (XI1_I969_n1 I1_dd25_b3_1 I1_b9_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I969_MN3 (VSS I1_qu23_b3_4 XI1_I969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I969_MN0 (XI1_I969_An I1_dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I967_MN1 (XI1_I967_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I967_MN5 (XI1_I967_n2 XI1_I967_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I967_MN4 (I1_b9_23 XI1_I967_An XI1_I967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I967_MN2 (XI1_I967_n1 I1_dd23_b3_1 I1_b9_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I967_MN3 (VSS I1_qu23_b3_3 XI1_I967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I967_MN0 (XI1_I967_An I1_dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I966_MN1 (XI1_I966_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I966_MN5 (XI1_I966_n2 XI1_I966_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I966_MN4 (I1_b9_22 XI1_I966_An XI1_I966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I966_MN2 (XI1_I966_n1 I1_dd22_b3_1 I1_b9_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I966_MN3 (VSS I1_qu23_b3_3 XI1_I966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I966_MN0 (XI1_I966_An I1_dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I964_MN1 (XI1_I964_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I964_MN5 (XI1_I964_n2 XI1_I964_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I964_MN4 (I1_b9_20 XI1_I964_An XI1_I964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I964_MN2 (XI1_I964_n1 I1_dd20_b3_1 I1_b9_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I964_MN3 (VSS I1_qu23_b3_3 XI1_I964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I964_MN0 (XI1_I964_An I1_dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I963_MN1 (XI1_I963_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I963_MN5 (XI1_I963_n2 XI1_I963_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I963_MN4 (I1_b9_19 XI1_I963_An XI1_I963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I963_MN2 (XI1_I963_n1 I1_dd19_b3_1 I1_b9_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I963_MN3 (VSS I1_qu23_b3_3 XI1_I963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I963_MN0 (XI1_I963_An I1_dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I218_MN1 (XI1_I930_I218_Bn I1_I930_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I218_MN5 (XI1_I930_I218_n2 XI1_I930_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I218_MN4 (I1_p8_15 XI1_I930_I218_An XI1_I930_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I218_MN2 (XI1_I930_I218_n1 I1_I930_pn15 I1_p8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I218_MN3 (VSS I1_I930_G14_0n XI1_I930_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I218_MN0 (XI1_I930_I218_An I1_I930_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I960_MN1 (XI1_I960_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I960_MN5 (XI1_I960_n2 XI1_I960_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I960_MN4 (I1_b9_16 XI1_I960_An XI1_I960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I960_MN2 (XI1_I960_n1 I1_dd16_b3_1 I1_b9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I960_MN3 (VSS I1_qu23_b3_2 XI1_I960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I960_MN0 (XI1_I960_An I1_dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I959_MN1 (XI1_I959_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I959_MN5 (XI1_I959_n2 XI1_I959_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I959_MN4 (I1_b9_15 XI1_I959_An XI1_I959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I959_MN2 (XI1_I959_n1 I1_dd15_b3_1 I1_b9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I959_MN3 (VSS I1_qu23_b3_2 XI1_I959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I959_MN0 (XI1_I959_An I1_dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I961_MN1 (XI1_I961_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I961_MN5 (XI1_I961_n2 XI1_I961_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I961_MN4 (I1_b9_17 XI1_I961_An XI1_I961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I961_MN2 (XI1_I961_n1 I1_dd17_b3_1 I1_b9_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I961_MN3 (VSS I1_qu23_b3_2 XI1_I961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I961_MN0 (XI1_I961_An I1_dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I216_MN1 (XI1_I930_I216_Bn I1_I930_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I216_MN5 (XI1_I930_I216_n2 XI1_I930_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I930_I216_MN4 (I1_p8_13 XI1_I930_I216_An XI1_I930_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I216_MN2 (XI1_I930_I216_n1 I1_I930_pn13 I1_p8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I930_I216_MN3 (VSS I1_I930_G12_0n XI1_I930_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I930_I216_MN0 (XI1_I930_I216_An I1_I930_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I958_MN1 (XI1_I958_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I958_MN5 (XI1_I958_n2 XI1_I958_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I958_MN4 (I1_b9_14 XI1_I958_An XI1_I958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I958_MN2 (XI1_I958_n1 I1_dd14_b3_1 I1_b9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I958_MN3 (VSS I1_qu23_b3_2 XI1_I958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I958_MN0 (XI1_I958_An I1_dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I956_MN1 (XI1_I956_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I956_MN5 (XI1_I956_n2 XI1_I956_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I956_MN4 (I1_b9_12 XI1_I956_An XI1_I956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I956_MN2 (XI1_I956_n1 I1_dd12_b3_1 I1_b9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I956_MN3 (VSS I1_qu23_b3_2 XI1_I956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I956_MN0 (XI1_I956_An I1_dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I953_MN1 (XI1_I953_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I953_MN5 (XI1_I953_n2 XI1_I953_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I953_MN4 (I1_b9_9 XI1_I953_An XI1_I953_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I953_MN2 (XI1_I953_n1 I1_dd9_b3_1 I1_b9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I953_MN3 (VSS I1_qu23_b3_1 XI1_I953_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I953_MN0 (XI1_I953_An I1_dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I900_MN1 (XI1_I900_Bn I1_qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I900_MN5 (XI1_I900_n2 XI1_I900_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I900_MN4 (I1_b8_2 XI1_I900_An XI1_I900_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I900_MN2 (XI1_I900_n1 I1_dd2_b3_1 I1_b8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I900_MN3 (VSS I1_qu24_b3_0 XI1_I900_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I900_MN0 (XI1_I900_An I1_dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I212_MN1 (XI1_I654_I212_Bn I1_I654_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I212_MN5 (XI1_I654_I212_n2 XI1_I654_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I212_MN4 (I1_p2_9 XI1_I654_I212_An XI1_I654_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I212_MN2 (XI1_I654_I212_n1 I1_I654_pn9 I1_p2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I212_MN3 (VSS I1_I654_G8_0n XI1_I654_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I212_MN0 (XI1_I654_I212_An I1_I654_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I214_MN1 (XI1_I654_I214_Bn I1_I654_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I214_MN5 (XI1_I654_I214_n2 XI1_I654_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I214_MN4 (I1_p2_11 XI1_I654_I214_An XI1_I654_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I214_MN2 (XI1_I654_I214_n1 I1_I654_pn11 I1_p2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I214_MN3 (VSS I1_I654_G10_0n XI1_I654_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I214_MN0 (XI1_I654_I214_An I1_I654_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I216_MN1 (XI1_I654_I216_Bn I1_I654_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I216_MN5 (XI1_I654_I216_n2 XI1_I654_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I654_I216_MN4 (I1_p2_13 XI1_I654_I216_An XI1_I654_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I216_MN2 (XI1_I654_I216_n1 I1_I654_pn13 I1_p2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I654_I216_MN3 (VSS I1_I654_G12_0n XI1_I654_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I654_I216_MN0 (XI1_I654_I216_An I1_I654_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I701_MN1 (XI1_I701_Bn I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I701_MN5 (XI1_I701_n2 XI1_I701_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I701_MN4 (I1_h3 XI1_I701_An XI1_I701_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I701_MN2 (XI1_I701_n1 I1_p2_31 I1_h3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I701_MN3 (VSS I1_qu29_b3_5 XI1_I701_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I701_MN0 (XI1_I701_An I1_p2_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1406_MN1 (XI1_I1406_Bn I1_qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1406_MN5 (XI1_I1406_n2 XI1_I1406_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1406_MN4 (I1_b19_2 XI1_I1406_An XI1_I1406_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1406_MN2 (XI1_I1406_n1 I1_dd2_b3_3 I1_b19_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1406_MN3 (VSS I1_qu13_b3_0 XI1_I1406_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1406_MN0 (XI1_I1406_An I1_dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1104_MN1 (XI1_I1104_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1104_MN5 (XI1_I1104_n2 XI1_I1104_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1104_MN4 (I1_b12_22 XI1_I1104_An XI1_I1104_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1104_MN2 (XI1_I1104_n1 I1_dd22_b3_2 I1_b12_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1104_MN3 (VSS I1_qu20_b3_3 XI1_I1104_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1104_MN0 (XI1_I1104_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1103_MN1 (XI1_I1103_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1103_MN5 (XI1_I1103_n2 XI1_I1103_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1103_MN4 (I1_b12_21 XI1_I1103_An XI1_I1103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1103_MN2 (XI1_I1103_n1 I1_dd21_b3_2 I1_b12_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1103_MN3 (VSS I1_qu20_b3_3 XI1_I1103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1103_MN0 (XI1_I1103_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1105_MN1 (XI1_I1105_Bn I1_qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1105_MN5 (XI1_I1105_n2 XI1_I1105_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1105_MN4 (I1_b12_23 XI1_I1105_An XI1_I1105_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1105_MN2 (XI1_I1105_n1 I1_dd23_b3_2 I1_b12_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1105_MN3 (VSS I1_qu20_b3_3 XI1_I1105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1105_MN0 (XI1_I1105_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1116_MN1 (XI1_I1116_Bn I1_c12_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1116_MN5 (XI1_I1116_n2 XI1_I1116_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1116_MN4 (I1_p12_32 XI1_I1116_An XI1_I1116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1116_MN2 (XI1_I1116_n1 I1_h12 I1_p12_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1116_MN3 (VSS I1_c12_o XI1_I1116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1116_MN0 (XI1_I1116_An I1_h12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1115_MN1 (XI1_I1115_Bn I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1115_MN5 (XI1_I1115_n2 XI1_I1115_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1115_MN4 (I1_h12 XI1_I1115_An XI1_I1115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1115_MN2 (XI1_I1115_n1 I1_p11_31 I1_h12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1115_MN3 (VSS I1_qu20_b3_5 XI1_I1115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1115_MN0 (XI1_I1115_An I1_p11_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1143_MN1 (XI1_I1143_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1143_MN5 (XI1_I1143_n2 XI1_I1143_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1143_MN4 (I1_b13_15 XI1_I1143_An XI1_I1143_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1143_MN2 (XI1_I1143_n1 I1_dd15_b3_2 I1_b13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1143_MN3 (VSS I1_qu19_b3_2 XI1_I1143_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1143_MN0 (XI1_I1143_An I1_dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1140_MN1 (XI1_I1140_Bn I1_qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1140_MN5 (XI1_I1140_n2 XI1_I1140_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1140_MN4 (I1_b13_12 XI1_I1140_An XI1_I1140_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1140_MN2 (XI1_I1140_n1 I1_dd12_b3_2 I1_b13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1140_MN3 (VSS I1_qu19_b3_2 XI1_I1140_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1140_MN0 (XI1_I1140_An I1_dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1067_MN1 (XI1_I1067_Bn I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1067_MN5 (XI1_I1067_n2 XI1_I1067_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1067_MN4 (I1_b11_31 XI1_I1067_An XI1_I1067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1067_MN2 (XI1_I1067_n1 I1_dd31_b3_2 I1_b11_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1067_MN3 (VSS I1_qu21_b3_5 XI1_I1067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1067_MN0 (XI1_I1067_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I974_MN1 (XI1_I974_Bn I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I974_MN5 (XI1_I974_n2 XI1_I974_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I974_MN4 (I1_b9_30 XI1_I974_An XI1_I974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I974_MN2 (XI1_I974_n1 I1_dd30_b3_1 I1_b9_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I974_MN3 (VSS I1_qu23_b3_5 XI1_I974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I974_MN0 (XI1_I974_An I1_dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I965_MN1 (XI1_I965_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I965_MN5 (XI1_I965_n2 XI1_I965_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I965_MN4 (I1_b9_21 XI1_I965_An XI1_I965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I965_MN2 (XI1_I965_n1 I1_dd21_b3_1 I1_b9_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I965_MN3 (VSS I1_qu23_b3_3 XI1_I965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I965_MN0 (XI1_I965_An I1_dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I962_MN1 (XI1_I962_Bn I1_qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I962_MN5 (XI1_I962_n2 XI1_I962_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I962_MN4 (I1_b9_18 XI1_I962_An XI1_I962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I962_MN2 (XI1_I962_n1 I1_dd18_b3_1 I1_b9_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I962_MN3 (VSS I1_qu23_b3_3 XI1_I962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I962_MN0 (XI1_I962_An I1_dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I957_MN1 (XI1_I957_Bn I1_qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I957_MN5 (XI1_I957_n2 XI1_I957_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I957_MN4 (I1_b9_13 XI1_I957_An XI1_I957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I957_MN2 (XI1_I957_n1 I1_dd13_b3_1 I1_b9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I957_MN3 (VSS I1_qu23_b3_2 XI1_I957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I957_MN0 (XI1_I957_An I1_dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I954_MN1 (XI1_I954_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I954_MN5 (XI1_I954_n2 XI1_I954_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I954_MN4 (I1_b9_10 XI1_I954_An XI1_I954_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I954_MN2 (XI1_I954_n1 I1_dd10_b3_1 I1_b9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I954_MN3 (VSS I1_qu23_b3_1 XI1_I954_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I954_MN0 (XI1_I954_An I1_dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I955_MN1 (XI1_I955_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I955_MN5 (XI1_I955_n2 XI1_I955_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I955_MN4 (I1_b9_11 XI1_I955_An XI1_I955_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I955_MN2 (XI1_I955_n1 I1_dd11_b3_1 I1_b9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I955_MN3 (VSS I1_qu23_b3_1 XI1_I955_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I955_MN0 (XI1_I955_An I1_dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I951_MN1 (XI1_I951_Bn I1_qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I951_MN5 (XI1_I951_n2 XI1_I951_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I951_MN4 (I1_b9_7 XI1_I951_An XI1_I951_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I951_MN2 (XI1_I951_n1 I1_dd7_b3_1 I1_b9_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I951_MN3 (VSS I1_qu23_b3_1 XI1_I951_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I951_MN0 (XI1_I951_An I1_dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I218_MN1 (XI1_I654_I218_Bn I1_I654_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
