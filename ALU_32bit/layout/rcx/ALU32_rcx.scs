    I_MXI1_I1378_MP0 (VDD I1_dd20_b3_3 XI1_I1378_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1376_MP1 (VDD I1_qu14_b3_3 XI1_I1376_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1376_MP5 (I1_b18_18 XI1_I1376_Bn XI1_I1376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1376_MP4 (XI1_I1376_p1 XI1_I1376_An I1_b18_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1376_MP2 (VDD I1_dd18_b3_3 XI1_I1376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1376_MP3 (XI1_I1376_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1376_MP0 (VDD I1_dd18_b3_3 XI1_I1376_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1377_MP1 (VDD I1_qu14_b3_3 XI1_I1377_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1377_MP5 (I1_b18_19 XI1_I1377_Bn XI1_I1377_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1377_MP4 (XI1_I1377_p1 XI1_I1377_An I1_b18_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1377_MP2 (VDD I1_dd19_b3_3 XI1_I1377_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1377_MP3 (XI1_I1377_p1 I1_qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1377_MP0 (VDD I1_dd19_b3_3 XI1_I1377_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1375_MP1 (VDD I1_qu14_b3_2 XI1_I1375_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1375_MP5 (I1_b18_17 XI1_I1375_Bn XI1_I1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1375_MP4 (XI1_I1375_p1 XI1_I1375_An I1_b18_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1375_MP2 (VDD I1_dd17_b3_3 XI1_I1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1375_MP3 (XI1_I1375_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1375_MP0 (VDD I1_dd17_b3_3 XI1_I1375_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1328_MP1 (VDD I1_qu15_b3_2 XI1_I1328_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1328_MP5 (I1_b17_16 XI1_I1328_Bn XI1_I1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1328_MP4 (XI1_I1328_p1 XI1_I1328_An I1_b17_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1328_MP2 (VDD I1_dd16_b3_3 XI1_I1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1328_MP3 (XI1_I1328_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1328_MP0 (VDD I1_dd16_b3_3 XI1_I1328_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1329_MP1 (VDD I1_qu15_b3_2 XI1_I1329_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1329_MP5 (I1_b17_17 XI1_I1329_Bn XI1_I1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1329_MP4 (XI1_I1329_p1 XI1_I1329_An I1_b17_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1329_MP2 (VDD I1_dd17_b3_3 XI1_I1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1329_MP3 (XI1_I1329_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1329_MP0 (VDD I1_dd17_b3_3 XI1_I1329_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1327_MP1 (VDD I1_qu15_b3_2 XI1_I1327_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1327_MP5 (I1_b17_15 XI1_I1327_Bn XI1_I1327_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1327_MP4 (XI1_I1327_p1 XI1_I1327_An I1_b17_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1327_MP2 (VDD I1_dd15_b3_3 XI1_I1327_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1327_MP3 (XI1_I1327_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1327_MP0 (VDD I1_dd15_b3_3 XI1_I1327_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1276_MP1 (VDD I1_qu16_b3_1 XI1_I1276_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1276_MP5 (I1_b16_10 XI1_I1276_Bn XI1_I1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1276_MP4 (XI1_I1276_p1 XI1_I1276_An I1_b16_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1276_MP2 (VDD I1_dd10_b3_2 XI1_I1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1276_MP3 (XI1_I1276_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1276_MP0 (VDD I1_dd10_b3_2 XI1_I1276_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1277_MP1 (VDD I1_qu16_b3_1 XI1_I1277_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1277_MP5 (I1_b16_11 XI1_I1277_Bn XI1_I1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1277_MP4 (XI1_I1277_p1 XI1_I1277_An I1_b16_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1277_MP2 (VDD I1_dd11_b3_2 XI1_I1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1277_MP3 (XI1_I1277_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1277_MP0 (VDD I1_dd11_b3_2 XI1_I1277_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1275_MP1 (VDD I1_qu16_b3_1 XI1_I1275_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1275_MP5 (I1_b16_9 XI1_I1275_Bn XI1_I1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1275_MP4 (XI1_I1275_p1 XI1_I1275_An I1_b16_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1275_MP2 (VDD I1_dd9_b3_2 XI1_I1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1275_MP3 (XI1_I1275_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1275_MP0 (VDD I1_dd9_b3_2 XI1_I1275_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1229_MP1 (VDD I1_qu17_b3_1 XI1_I1229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1229_MP5 (I1_b15_9 XI1_I1229_Bn XI1_I1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1229_MP4 (XI1_I1229_p1 XI1_I1229_An I1_b15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1229_MP2 (VDD I1_dd9_b3_2 XI1_I1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1229_MP3 (XI1_I1229_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1229_MP0 (VDD I1_dd9_b3_2 XI1_I1229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1231_MP1 (VDD I1_qu17_b3_1 XI1_I1231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1231_MP5 (I1_b15_11 XI1_I1231_Bn XI1_I1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1231_MP4 (XI1_I1231_p1 XI1_I1231_An I1_b15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1231_MP2 (VDD I1_dd11_b3_2 XI1_I1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1231_MP3 (XI1_I1231_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1231_MP0 (VDD I1_dd11_b3_2 XI1_I1231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1230_MP1 (VDD I1_qu17_b3_1 XI1_I1230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1230_MP5 (I1_b15_10 XI1_I1230_Bn XI1_I1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1230_MP4 (XI1_I1230_p1 XI1_I1230_An I1_b15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1230_MP2 (VDD I1_dd10_b3_2 XI1_I1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1230_MP3 (XI1_I1230_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1230_MP0 (VDD I1_dd10_b3_2 XI1_I1230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1207_MP1 (VDD I1_qu18_b3_5 XI1_I1207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1207_MP5 (I1_h14 XI1_I1207_Bn XI1_I1207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1207_MP4 (XI1_I1207_p1 XI1_I1207_An I1_h14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1207_MP2 (VDD I1_p13_31 XI1_I1207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1207_MP3 (XI1_I1207_p1 I1_qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1207_MP0 (VDD I1_p13_31 XI1_I1207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1186_MP1 (VDD I1_qu18_b3_2 XI1_I1186_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1186_MP5 (I1_b14_12 XI1_I1186_Bn XI1_I1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1186_MP4 (XI1_I1186_p1 XI1_I1186_An I1_b14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1186_MP2 (VDD I1_dd12_b3_2 XI1_I1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1186_MP3 (XI1_I1186_p1 I1_qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1186_MP0 (VDD I1_dd12_b3_2 XI1_I1186_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1208_MP1 (VDD I1_c14_o XI1_I1208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1208_MP5 (I1_p14_32 XI1_I1208_Bn XI1_I1208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1208_MP4 (XI1_I1208_p1 XI1_I1208_An I1_p14_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1208_MP2 (VDD I1_h14 XI1_I1208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1208_MP3 (XI1_I1208_p1 I1_c14_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1208_MP0 (VDD I1_h14 XI1_I1208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I882_MP1 (VDD I1_qu25_b3_5 XI1_I882_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I882_MP5 (I1_b7_30 XI1_I882_Bn XI1_I882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I882_MP4 (XI1_I882_p1 XI1_I882_An I1_b7_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I882_MP2 (VDD I1_dd30_b3_1 XI1_I882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I882_MP3 (XI1_I882_p1 I1_qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I882_MP0 (VDD I1_dd30_b3_1 XI1_I882_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I219_MP1 (VDD I1_I884_G15_0n XI1_I884_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I219_MP5 (I1_p7_16 XI1_I884_I219_Bn XI1_I884_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I219_MP4 (XI1_I884_I219_p1 XI1_I884_I219_An I1_p7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I219_MP2 (VDD I1_I884_pn16 XI1_I884_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I219_MP3 (XI1_I884_I219_p1 I1_I884_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I219_MP0 (VDD I1_I884_pn16 XI1_I884_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I217_MP1 (VDD I1_I884_G13_0n XI1_I884_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I217_MP5 (I1_p7_14 XI1_I884_I217_Bn XI1_I884_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I217_MP4 (XI1_I884_I217_p1 XI1_I884_I217_An I1_p7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I217_MP2 (VDD I1_I884_pn14 XI1_I884_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I217_MP3 (XI1_I884_I217_p1 I1_I884_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I217_MP0 (VDD I1_I884_pn14 XI1_I884_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I215_MP1 (VDD I1_I884_G11_0n XI1_I884_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I215_MP5 (I1_p7_12 XI1_I884_I215_Bn XI1_I884_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I215_MP4 (XI1_I884_I215_p1 XI1_I884_I215_An I1_p7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I215_MP2 (VDD I1_I884_pn12 XI1_I884_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I215_MP3 (XI1_I884_I215_p1 I1_I884_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I215_MP0 (VDD I1_I884_pn12 XI1_I884_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I857_MP1 (VDD I1_qu25_b3_0 XI1_I857_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I857_MP5 (I1_b7_5 XI1_I857_Bn XI1_I857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I857_MP4 (XI1_I857_p1 XI1_I857_An I1_b7_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I857_MP2 (VDD I1_dd5_b3_1 XI1_I857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I857_MP3 (XI1_I857_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I857_MP0 (VDD I1_dd5_b3_1 XI1_I857_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I856_MP1 (VDD I1_qu25_b3_0 XI1_I856_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I856_MP5 (I1_b7_4 XI1_I856_Bn XI1_I856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I856_MP4 (XI1_I856_p1 XI1_I856_An I1_b7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I856_MP2 (VDD I1_dd4_b3_1 XI1_I856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I856_MP3 (XI1_I856_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I856_MP0 (VDD I1_dd4_b3_1 XI1_I856_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I809_MP1 (VDD I1_qu26_b3_0 XI1_I809_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I809_MP5 (I1_b6_3 XI1_I809_Bn XI1_I809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I809_MP4 (XI1_I809_p1 XI1_I809_An I1_b6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I809_MP2 (VDD I1_dd3_b3_1 XI1_I809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I809_MP3 (XI1_I809_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I809_MP0 (VDD I1_dd3_b3_1 XI1_I809_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I810_MP1 (VDD I1_qu26_b3_0 XI1_I810_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I810_MP5 (I1_b6_4 XI1_I810_Bn XI1_I810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I810_MP4 (XI1_I810_p1 XI1_I810_An I1_b6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I810_MP2 (VDD I1_dd4_b3_1 XI1_I810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I810_MP3 (XI1_I810_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I810_MP0 (VDD I1_dd4_b3_1 XI1_I810_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I766_MP1 (VDD I1_qu27_b3_1 XI1_I766_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I766_MP5 (I1_b5_6 XI1_I766_Bn XI1_I766_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I766_MP4 (XI1_I766_p1 XI1_I766_An I1_b5_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I766_MP2 (VDD I1_dd6_b3_0 XI1_I766_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I766_MP3 (XI1_I766_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I766_MP0 (VDD I1_dd6_b3_0 XI1_I766_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I769_MP1 (VDD I1_qu27_b3_1 XI1_I769_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I769_MP5 (I1_b5_9 XI1_I769_Bn XI1_I769_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I769_MP4 (XI1_I769_p1 XI1_I769_An I1_b5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I769_MP2 (VDD I1_dd9_b3_0 XI1_I769_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I769_MP3 (XI1_I769_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I769_MP0 (VDD I1_dd9_b3_0 XI1_I769_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I770_MP1 (VDD I1_qu27_b3_1 XI1_I770_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I770_MP5 (I1_b5_10 XI1_I770_Bn XI1_I770_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I770_MP4 (XI1_I770_p1 XI1_I770_An I1_b5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I770_MP2 (VDD I1_dd10_b3_0 XI1_I770_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I770_MP3 (XI1_I770_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I770_MP0 (VDD I1_dd10_b3_0 XI1_I770_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I724_MP1 (VDD I1_qu28_b3_1 XI1_I724_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I724_MP5 (I1_b4_10 XI1_I724_Bn XI1_I724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I724_MP4 (XI1_I724_p1 XI1_I724_An I1_b4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I724_MP2 (VDD I1_dd10_b3_0 XI1_I724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I724_MP3 (XI1_I724_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I724_MP0 (VDD I1_dd10_b3_0 XI1_I724_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I727_MP1 (VDD I1_qu28_b3_2 XI1_I727_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I727_MP5 (I1_b4_13 XI1_I727_Bn XI1_I727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I727_MP4 (XI1_I727_p1 XI1_I727_An I1_b4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I727_MP2 (VDD I1_dd13_b3_0 XI1_I727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I727_MP3 (XI1_I727_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I727_MP0 (VDD I1_dd13_b3_0 XI1_I727_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I726_MP1 (VDD I1_qu28_b3_2 XI1_I726_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I726_MP5 (I1_b4_12 XI1_I726_Bn XI1_I726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I726_MP4 (XI1_I726_p1 XI1_I726_An I1_b4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I726_MP2 (VDD I1_dd12_b3_0 XI1_I726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I726_MP3 (XI1_I726_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I726_MP0 (VDD I1_dd12_b3_0 XI1_I726_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I730_MP1 (VDD I1_qu28_b3_2 XI1_I730_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I730_MP5 (I1_b4_16 XI1_I730_Bn XI1_I730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I730_MP4 (XI1_I730_p1 XI1_I730_An I1_b4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I730_MP2 (VDD I1_dd16_b3_0 XI1_I730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I730_MP3 (XI1_I730_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I730_MP0 (VDD I1_dd16_b3_0 XI1_I730_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I731_MP1 (VDD I1_qu28_b3_2 XI1_I731_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I731_MP5 (I1_b4_17 XI1_I731_Bn XI1_I731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I731_MP4 (XI1_I731_p1 XI1_I731_An I1_b4_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I731_MP2 (VDD I1_dd17_b3_0 XI1_I731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I731_MP3 (XI1_I731_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I731_MP0 (VDD I1_dd17_b3_0 XI1_I731_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I219_MP1 (VDD I1_I700_G15_0n XI1_I700_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I219_MP5 (I1_p3_16 XI1_I700_I219_Bn XI1_I700_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I219_MP4 (XI1_I700_I219_p1 XI1_I700_I219_An I1_p3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I219_MP2 (VDD I1_I700_pn16 XI1_I700_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I219_MP3 (XI1_I700_I219_p1 I1_I700_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I219_MP0 (VDD I1_I700_pn16 XI1_I700_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I733_MP1 (VDD I1_qu28_b3_3 XI1_I733_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I733_MP5 (I1_b4_19 XI1_I733_Bn XI1_I733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I733_MP4 (XI1_I733_p1 XI1_I733_An I1_b4_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I733_MP2 (VDD I1_dd19_b3_0 XI1_I733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I733_MP3 (XI1_I733_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I733_MP0 (VDD I1_dd19_b3_0 XI1_I733_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I734_MP1 (VDD I1_qu28_b3_3 XI1_I734_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I734_MP5 (I1_b4_20 XI1_I734_Bn XI1_I734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I734_MP4 (XI1_I734_p1 XI1_I734_An I1_b4_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I734_MP2 (VDD I1_dd20_b3_0 XI1_I734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I734_MP3 (XI1_I734_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I734_MP0 (VDD I1_dd20_b3_0 XI1_I734_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I736_MP1 (VDD I1_qu28_b3_3 XI1_I736_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I736_MP5 (I1_b4_22 XI1_I736_Bn XI1_I736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I736_MP4 (XI1_I736_p1 XI1_I736_An I1_b4_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I736_MP2 (VDD I1_dd22_b3_0 XI1_I736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I736_MP3 (XI1_I736_p1 I1_qu28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I736_MP0 (VDD I1_dd22_b3_0 XI1_I736_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I702_MP1 (VDD I1_c3_o XI1_I702_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I702_MP5 (I1_p3_32 XI1_I702_Bn XI1_I702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I702_MP4 (XI1_I702_p1 XI1_I702_An I1_p3_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I702_MP2 (VDD I1_h3 XI1_I702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I702_MP3 (XI1_I702_p1 I1_c3_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I702_MP0 (VDD I1_h3 XI1_I702_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1374_MP1 (VDD I1_qu14_b3_2 XI1_I1374_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1374_MP5 (I1_b18_16 XI1_I1374_Bn XI1_I1374_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1374_MP4 (XI1_I1374_p1 XI1_I1374_An I1_b18_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1374_MP2 (VDD I1_dd16_b3_3 XI1_I1374_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1374_MP3 (XI1_I1374_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1374_MP0 (VDD I1_dd16_b3_3 XI1_I1374_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1373_MP1 (VDD I1_qu14_b3_2 XI1_I1373_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1373_MP5 (I1_b18_15 XI1_I1373_Bn XI1_I1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1373_MP4 (XI1_I1373_p1 XI1_I1373_An I1_b18_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1373_MP2 (VDD I1_dd15_b3_3 XI1_I1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1373_MP3 (XI1_I1373_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1373_MP0 (VDD I1_dd15_b3_3 XI1_I1373_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1326_MP1 (VDD I1_qu15_b3_2 XI1_I1326_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1326_MP5 (I1_b17_14 XI1_I1326_Bn XI1_I1326_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1326_MP4 (XI1_I1326_p1 XI1_I1326_An I1_b17_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1326_MP2 (VDD I1_dd14_b3_3 XI1_I1326_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1326_MP3 (XI1_I1326_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1326_MP0 (VDD I1_dd14_b3_3 XI1_I1326_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1324_MP1 (VDD I1_qu15_b3_2 XI1_I1324_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1324_MP5 (I1_b17_12 XI1_I1324_Bn XI1_I1324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1324_MP4 (XI1_I1324_p1 XI1_I1324_An I1_b17_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1324_MP2 (VDD I1_dd12_b3_3 XI1_I1324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1324_MP3 (XI1_I1324_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1324_MP0 (VDD I1_dd12_b3_3 XI1_I1324_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1325_MP1 (VDD I1_qu15_b3_2 XI1_I1325_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1325_MP5 (I1_b17_13 XI1_I1325_Bn XI1_I1325_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1325_MP4 (XI1_I1325_p1 XI1_I1325_An I1_b17_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1325_MP2 (VDD I1_dd13_b3_3 XI1_I1325_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1325_MP3 (XI1_I1325_p1 I1_qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1325_MP0 (VDD I1_dd13_b3_3 XI1_I1325_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I207_MP1 (VDD I1_I1298_G3_0n XI1_I1298_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I207_MP5 (I1_p16_4 XI1_I1298_I207_Bn XI1_I1298_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I207_MP4 (XI1_I1298_I207_p1 XI1_I1298_I207_An I1_p16_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I207_MP2 (VDD I1_I1298_pn4 XI1_I1298_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I207_MP3 (XI1_I1298_I207_p1 I1_I1298_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I207_MP0 (VDD I1_I1298_pn4 XI1_I1298_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1274_MP1 (VDD I1_qu16_b3_1 XI1_I1274_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1274_MP5 (I1_b16_8 XI1_I1274_Bn XI1_I1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1274_MP4 (XI1_I1274_p1 XI1_I1274_An I1_b16_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1274_MP2 (VDD I1_dd8_b3_2 XI1_I1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1274_MP3 (XI1_I1274_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1274_MP0 (VDD I1_dd8_b3_2 XI1_I1274_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1273_MP1 (VDD I1_qu16_b3_1 XI1_I1273_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1273_MP5 (I1_b16_7 XI1_I1273_Bn XI1_I1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1273_MP4 (XI1_I1273_p1 XI1_I1273_An I1_b16_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1273_MP2 (VDD I1_dd7_b3_2 XI1_I1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1273_MP3 (XI1_I1273_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1273_MP0 (VDD I1_dd7_b3_2 XI1_I1273_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1226_MP1 (VDD I1_qu17_b3_1 XI1_I1226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1226_MP5 (I1_b15_6 XI1_I1226_Bn XI1_I1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1226_MP4 (XI1_I1226_p1 XI1_I1226_An I1_b15_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1226_MP2 (VDD I1_dd6_b3_2 XI1_I1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1226_MP3 (XI1_I1226_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1226_MP0 (VDD I1_dd6_b3_2 XI1_I1226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1228_MP1 (VDD I1_qu17_b3_1 XI1_I1228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1228_MP5 (I1_b15_8 XI1_I1228_Bn XI1_I1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1228_MP4 (XI1_I1228_p1 XI1_I1228_An I1_b15_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1228_MP2 (VDD I1_dd8_b3_2 XI1_I1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1228_MP3 (XI1_I1228_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1228_MP0 (VDD I1_dd8_b3_2 XI1_I1228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1227_MP1 (VDD I1_qu17_b3_1 XI1_I1227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1227_MP5 (I1_b15_7 XI1_I1227_Bn XI1_I1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1227_MP4 (XI1_I1227_p1 XI1_I1227_An I1_b15_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1227_MP2 (VDD I1_dd7_b3_2 XI1_I1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1227_MP3 (XI1_I1227_p1 I1_qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1227_MP0 (VDD I1_dd7_b3_2 XI1_I1227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I215_MP1 (VDD I1_I1160_G11_0n XI1_I1160_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I215_MP5 (I1_p13_12 XI1_I1160_I215_Bn XI1_I1160_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I215_MP4 (XI1_I1160_I215_p1 XI1_I1160_I215_An I1_p13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I215_MP2 (VDD I1_I1160_pn12 XI1_I1160_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I215_MP3 (XI1_I1160_I215_p1 I1_I1160_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I215_MP0 (VDD I1_I1160_pn12 XI1_I1160_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1185_MP1 (VDD I1_qu18_b3_1 XI1_I1185_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1185_MP5 (I1_b14_11 XI1_I1185_Bn XI1_I1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1185_MP4 (XI1_I1185_p1 XI1_I1185_An I1_b14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1185_MP2 (VDD I1_dd11_b3_2 XI1_I1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1185_MP3 (XI1_I1185_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1185_MP0 (VDD I1_dd11_b3_2 XI1_I1185_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1184_MP1 (VDD I1_qu18_b3_1 XI1_I1184_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1184_MP5 (I1_b14_10 XI1_I1184_Bn XI1_I1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1184_MP4 (XI1_I1184_p1 XI1_I1184_An I1_b14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1184_MP2 (VDD I1_dd10_b3_2 XI1_I1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1184_MP3 (XI1_I1184_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1184_MP0 (VDD I1_dd10_b3_2 XI1_I1184_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1183_MP1 (VDD I1_qu18_b3_1 XI1_I1183_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1183_MP5 (I1_b14_9 XI1_I1183_Bn XI1_I1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1183_MP4 (XI1_I1183_p1 XI1_I1183_An I1_b14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1183_MP2 (VDD I1_dd9_b3_2 XI1_I1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1183_MP3 (XI1_I1183_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1183_MP0 (VDD I1_dd9_b3_2 XI1_I1183_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1182_MP1 (VDD I1_qu18_b3_1 XI1_I1182_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1182_MP5 (I1_b14_8 XI1_I1182_Bn XI1_I1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1182_MP4 (XI1_I1182_p1 XI1_I1182_An I1_b14_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1182_MP2 (VDD I1_dd8_b3_2 XI1_I1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1182_MP3 (XI1_I1182_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1182_MP0 (VDD I1_dd8_b3_2 XI1_I1182_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1180_MP1 (VDD I1_qu18_b3_1 XI1_I1180_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1180_MP5 (I1_b14_6 XI1_I1180_Bn XI1_I1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1180_MP4 (XI1_I1180_p1 XI1_I1180_An I1_b14_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1180_MP2 (VDD I1_dd6_b3_2 XI1_I1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1180_MP3 (XI1_I1180_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1180_MP0 (VDD I1_dd6_b3_2 XI1_I1180_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I207_MP1 (VDD I1_I1206_G3_0n XI1_I1206_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I207_MP5 (I1_p14_4 XI1_I1206_I207_Bn XI1_I1206_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I207_MP4 (XI1_I1206_I207_p1 XI1_I1206_I207_An I1_p14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I207_MP2 (VDD I1_I1206_pn4 XI1_I1206_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I207_MP3 (XI1_I1206_I207_p1 I1_I1206_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I207_MP0 (VDD I1_I1206_pn4 XI1_I1206_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I206_MP1 (VDD I1_I1206_G2_0n XI1_I1206_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1206_I206_MP5 (I1_p14_3 XI1_I1206_I206_Bn XI1_I1206_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1206_I206_MP4 (XI1_I1206_I206_p1 XI1_I1206_I206_An I1_p14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I206_MP2 (VDD I1_I1206_pn3 XI1_I1206_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1206_I206_MP3 (XI1_I1206_I206_p1 I1_I1206_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1206_I206_MP0 (VDD I1_I1206_pn3 XI1_I1206_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I213_MP1 (VDD I1_I884_G9_0n XI1_I884_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I213_MP5 (I1_p7_10 XI1_I884_I213_Bn XI1_I884_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I213_MP4 (XI1_I884_I213_p1 XI1_I884_I213_An I1_p7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I213_MP2 (VDD I1_I884_pn10 XI1_I884_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I213_MP3 (XI1_I884_I213_p1 I1_I884_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I213_MP0 (VDD I1_I884_pn10 XI1_I884_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I207_MP1 (VDD I1_I884_G3_0n XI1_I884_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I207_MP5 (I1_p7_4 XI1_I884_I207_Bn XI1_I884_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I207_MP4 (XI1_I884_I207_p1 XI1_I884_I207_An I1_p7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I207_MP2 (VDD I1_I884_pn4 XI1_I884_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I207_MP3 (XI1_I884_I207_p1 I1_I884_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I207_MP0 (VDD I1_I884_pn4 XI1_I884_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I855_MP1 (VDD I1_qu25_b3_0 XI1_I855_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I855_MP5 (I1_b7_3 XI1_I855_Bn XI1_I855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I855_MP4 (XI1_I855_p1 XI1_I855_An I1_b7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I855_MP2 (VDD I1_dd3_b3_1 XI1_I855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I855_MP3 (XI1_I855_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I855_MP0 (VDD I1_dd3_b3_1 XI1_I855_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I808_MP1 (VDD I1_qu26_b3_0 XI1_I808_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I808_MP5 (I1_b6_2 XI1_I808_Bn XI1_I808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I808_MP4 (XI1_I808_p1 XI1_I808_An I1_b6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I808_MP2 (VDD I1_dd2_b3_1 XI1_I808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I808_MP3 (XI1_I808_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I808_MP0 (VDD I1_dd2_b3_1 XI1_I808_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I765_MP1 (VDD I1_qu27_b3_0 XI1_I765_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I765_MP5 (I1_b5_5 XI1_I765_Bn XI1_I765_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I765_MP4 (XI1_I765_p1 XI1_I765_An I1_b5_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I765_MP2 (VDD I1_dd5_b3_0 XI1_I765_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I765_MP3 (XI1_I765_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I765_MP0 (VDD I1_dd5_b3_0 XI1_I765_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I767_MP1 (VDD I1_qu27_b3_1 XI1_I767_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I767_MP5 (I1_b5_7 XI1_I767_Bn XI1_I767_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I767_MP4 (XI1_I767_p1 XI1_I767_An I1_b5_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I767_MP2 (VDD I1_dd7_b3_0 XI1_I767_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I767_MP3 (XI1_I767_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I767_MP0 (VDD I1_dd7_b3_0 XI1_I767_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I768_MP1 (VDD I1_qu27_b3_1 XI1_I768_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I768_MP5 (I1_b5_8 XI1_I768_Bn XI1_I768_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I768_MP4 (XI1_I768_p1 XI1_I768_An I1_b5_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I768_MP2 (VDD I1_dd8_b3_0 XI1_I768_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I768_MP3 (XI1_I768_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I768_MP0 (VDD I1_dd8_b3_0 XI1_I768_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I771_MP1 (VDD I1_qu27_b3_1 XI1_I771_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I771_MP5 (I1_b5_11 XI1_I771_Bn XI1_I771_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I771_MP4 (XI1_I771_p1 XI1_I771_An I1_b5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I771_MP2 (VDD I1_dd11_b3_0 XI1_I771_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I771_MP3 (XI1_I771_p1 I1_qu27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I771_MP0 (VDD I1_dd11_b3_0 XI1_I771_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I720_MP1 (VDD I1_qu28_b3_1 XI1_I720_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I720_MP5 (I1_b4_6 XI1_I720_Bn XI1_I720_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I720_MP4 (XI1_I720_p1 XI1_I720_An I1_b4_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I720_MP2 (VDD I1_dd6_b3_0 XI1_I720_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I720_MP3 (XI1_I720_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I720_MP0 (VDD I1_dd6_b3_0 XI1_I720_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I722_MP1 (VDD I1_qu28_b3_1 XI1_I722_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I722_MP5 (I1_b4_8 XI1_I722_Bn XI1_I722_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I722_MP4 (XI1_I722_p1 XI1_I722_An I1_b4_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I722_MP2 (VDD I1_dd8_b3_0 XI1_I722_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I722_MP3 (XI1_I722_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I722_MP0 (VDD I1_dd8_b3_0 XI1_I722_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I725_MP1 (VDD I1_qu28_b3_1 XI1_I725_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I725_MP5 (I1_b4_11 XI1_I725_Bn XI1_I725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I725_MP4 (XI1_I725_p1 XI1_I725_An I1_b4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I725_MP2 (VDD I1_dd11_b3_0 XI1_I725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I725_MP3 (XI1_I725_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I725_MP0 (VDD I1_dd11_b3_0 XI1_I725_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I723_MP1 (VDD I1_qu28_b3_1 XI1_I723_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I723_MP5 (I1_b4_9 XI1_I723_Bn XI1_I723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I723_MP4 (XI1_I723_p1 XI1_I723_An I1_b4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I723_MP2 (VDD I1_dd9_b3_0 XI1_I723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I723_MP3 (XI1_I723_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I723_MP0 (VDD I1_dd9_b3_0 XI1_I723_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I213_MP1 (VDD I1_I700_G9_0n XI1_I700_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I213_MP5 (I1_p3_10 XI1_I700_I213_Bn XI1_I700_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I213_MP4 (XI1_I700_I213_p1 XI1_I700_I213_An I1_p3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I213_MP2 (VDD I1_I700_pn10 XI1_I700_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I213_MP3 (XI1_I700_I213_p1 I1_I700_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I213_MP0 (VDD I1_I700_pn10 XI1_I700_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I215_MP1 (VDD I1_I700_G11_0n XI1_I700_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I215_MP5 (I1_p3_12 XI1_I700_I215_Bn XI1_I700_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I215_MP4 (XI1_I700_I215_p1 XI1_I700_I215_An I1_p3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I215_MP2 (VDD I1_I700_pn12 XI1_I700_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I215_MP3 (XI1_I700_I215_p1 I1_I700_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I215_MP0 (VDD I1_I700_pn12 XI1_I700_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I729_MP1 (VDD I1_qu28_b3_2 XI1_I729_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I729_MP5 (I1_b4_15 XI1_I729_Bn XI1_I729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I729_MP4 (XI1_I729_p1 XI1_I729_An I1_b4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I729_MP2 (VDD I1_dd15_b3_0 XI1_I729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I729_MP3 (XI1_I729_p1 I1_qu28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I729_MP0 (VDD I1_dd15_b3_0 XI1_I729_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I217_MP1 (VDD I1_I700_G13_0n XI1_I700_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I217_MP5 (I1_p3_14 XI1_I700_I217_Bn XI1_I700_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I217_MP4 (XI1_I700_I217_p1 XI1_I700_I217_An I1_p3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I217_MP2 (VDD I1_I700_pn14 XI1_I700_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I217_MP3 (XI1_I700_I217_p1 I1_I700_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I217_MP0 (VDD I1_I700_pn14 XI1_I700_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1372_MP1 (VDD I1_qu14_b3_2 XI1_I1372_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1372_MP5 (I1_b18_14 XI1_I1372_Bn XI1_I1372_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1372_MP4 (XI1_I1372_p1 XI1_I1372_An I1_b18_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1372_MP2 (VDD I1_dd14_b3_3 XI1_I1372_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1372_MP3 (XI1_I1372_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1372_MP0 (VDD I1_dd14_b3_3 XI1_I1372_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1370_MP1 (VDD I1_qu14_b3_2 XI1_I1370_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1370_MP5 (I1_b18_12 XI1_I1370_Bn XI1_I1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1370_MP4 (XI1_I1370_p1 XI1_I1370_An I1_b18_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1370_MP2 (VDD I1_dd12_b3_3 XI1_I1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1370_MP3 (XI1_I1370_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1370_MP0 (VDD I1_dd12_b3_3 XI1_I1370_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1371_MP1 (VDD I1_qu14_b3_2 XI1_I1371_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1371_MP5 (I1_b18_13 XI1_I1371_Bn XI1_I1371_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1371_MP4 (XI1_I1371_p1 XI1_I1371_An I1_b18_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1371_MP2 (VDD I1_dd13_b3_3 XI1_I1371_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1371_MP3 (XI1_I1371_p1 I1_qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1371_MP0 (VDD I1_dd13_b3_3 XI1_I1371_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1368_MP1 (VDD I1_qu14_b3_1 XI1_I1368_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1368_MP5 (I1_b18_10 XI1_I1368_Bn XI1_I1368_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1368_MP4 (XI1_I1368_p1 XI1_I1368_An I1_b18_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1368_MP2 (VDD I1_dd10_b3_3 XI1_I1368_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1368_MP3 (XI1_I1368_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1368_MP0 (VDD I1_dd10_b3_3 XI1_I1368_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1322_MP1 (VDD I1_qu15_b3_1 XI1_I1322_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1322_MP5 (I1_b17_10 XI1_I1322_Bn XI1_I1322_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1322_MP4 (XI1_I1322_p1 XI1_I1322_An I1_b17_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1322_MP2 (VDD I1_dd10_b3_3 XI1_I1322_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1322_MP3 (XI1_I1322_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1322_MP0 (VDD I1_dd10_b3_3 XI1_I1322_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1323_MP1 (VDD I1_qu15_b3_1 XI1_I1323_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1323_MP5 (I1_b17_11 XI1_I1323_Bn XI1_I1323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1323_MP4 (XI1_I1323_p1 XI1_I1323_An I1_b17_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1323_MP2 (VDD I1_dd11_b3_3 XI1_I1323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1323_MP3 (XI1_I1323_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1323_MP0 (VDD I1_dd11_b3_3 XI1_I1323_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1320_MP1 (VDD I1_qu15_b3_1 XI1_I1320_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1320_MP5 (I1_b17_8 XI1_I1320_Bn XI1_I1320_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1320_MP4 (XI1_I1320_p1 XI1_I1320_An I1_b17_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1320_MP2 (VDD I1_dd8_b3_3 XI1_I1320_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1320_MP3 (XI1_I1320_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1320_MP0 (VDD I1_dd8_b3_3 XI1_I1320_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1319_MP1 (VDD I1_qu15_b3_1 XI1_I1319_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1319_MP5 (I1_b17_7 XI1_I1319_Bn XI1_I1319_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1319_MP4 (XI1_I1319_p1 XI1_I1319_An I1_b17_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1319_MP2 (VDD I1_dd7_b3_3 XI1_I1319_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1319_MP3 (XI1_I1319_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1319_MP0 (VDD I1_dd7_b3_3 XI1_I1319_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I206_MP1 (VDD I1_I1298_G2_0n XI1_I1298_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1298_I206_MP5 (I1_p16_3 XI1_I1298_I206_Bn XI1_I1298_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1298_I206_MP4 (XI1_I1298_I206_p1 XI1_I1298_I206_An I1_p16_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I206_MP2 (VDD I1_I1298_pn3 XI1_I1298_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1298_I206_MP3 (XI1_I1298_I206_p1 I1_I1298_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1298_I206_MP0 (VDD I1_I1298_pn3 XI1_I1298_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1271_MP1 (VDD I1_qu16_b3_0 XI1_I1271_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1271_MP5 (I1_b16_5 XI1_I1271_Bn XI1_I1271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1271_MP4 (XI1_I1271_p1 XI1_I1271_An I1_b16_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1271_MP2 (VDD I1_dd5_b3_2 XI1_I1271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1271_MP3 (XI1_I1271_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1271_MP0 (VDD I1_dd5_b3_2 XI1_I1271_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1272_MP1 (VDD I1_qu16_b3_1 XI1_I1272_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1272_MP5 (I1_b16_6 XI1_I1272_Bn XI1_I1272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1272_MP4 (XI1_I1272_p1 XI1_I1272_An I1_b16_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1272_MP2 (VDD I1_dd6_b3_2 XI1_I1272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1272_MP3 (XI1_I1272_p1 I1_qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1272_MP0 (VDD I1_dd6_b3_2 XI1_I1272_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I206_MP1 (VDD I1_I1252_G2_0n XI1_I1252_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I206_MP5 (I1_p15_3 XI1_I1252_I206_Bn XI1_I1252_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I206_MP4 (XI1_I1252_I206_p1 XI1_I1252_I206_An I1_p15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I206_MP2 (VDD I1_I1252_pn3 XI1_I1252_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I206_MP3 (XI1_I1252_I206_p1 I1_I1252_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I206_MP0 (VDD I1_I1252_pn3 XI1_I1252_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I207_MP1 (VDD I1_I1252_G3_0n XI1_I1252_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1252_I207_MP5 (I1_p15_4 XI1_I1252_I207_Bn XI1_I1252_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1252_I207_MP4 (XI1_I1252_I207_p1 XI1_I1252_I207_An I1_p15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I207_MP2 (VDD I1_I1252_pn4 XI1_I1252_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1252_I207_MP3 (XI1_I1252_I207_p1 I1_I1252_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1252_I207_MP0 (VDD I1_I1252_pn4 XI1_I1252_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1225_MP1 (VDD I1_qu17_b3_0 XI1_I1225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1225_MP5 (I1_b15_5 XI1_I1225_Bn XI1_I1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1225_MP4 (XI1_I1225_p1 XI1_I1225_An I1_b15_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1225_MP2 (VDD I1_dd5_b3_2 XI1_I1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1225_MP3 (XI1_I1225_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1225_MP0 (VDD I1_dd5_b3_2 XI1_I1225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1162_MP1 (VDD I1_c13_o XI1_I1162_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1162_MP5 (I1_p13_32 XI1_I1162_Bn XI1_I1162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1162_MP4 (XI1_I1162_p1 XI1_I1162_An I1_p13_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1162_MP2 (VDD I1_h13 XI1_I1162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1162_MP3 (XI1_I1162_p1 I1_c13_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1162_MP0 (VDD I1_h13 XI1_I1162_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I219_MP1 (VDD I1_I1160_G15_0n XI1_I1160_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I219_MP5 (I1_p13_16 XI1_I1160_I219_Bn XI1_I1160_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I219_MP4 (XI1_I1160_I219_p1 XI1_I1160_I219_An I1_p13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I219_MP2 (VDD I1_I1160_pn16 XI1_I1160_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I219_MP3 (XI1_I1160_I219_p1 I1_I1160_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I219_MP0 (VDD I1_I1160_pn16 XI1_I1160_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I217_MP1 (VDD I1_I1160_G13_0n XI1_I1160_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I217_MP5 (I1_p13_14 XI1_I1160_I217_Bn XI1_I1160_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I217_MP4 (XI1_I1160_I217_p1 XI1_I1160_I217_An I1_p13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I217_MP2 (VDD I1_I1160_pn14 XI1_I1160_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I217_MP3 (XI1_I1160_I217_p1 I1_I1160_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I217_MP0 (VDD I1_I1160_pn14 XI1_I1160_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I213_MP1 (VDD I1_I1160_G9_0n XI1_I1160_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I213_MP5 (I1_p13_10 XI1_I1160_I213_Bn XI1_I1160_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I213_MP4 (XI1_I1160_I213_p1 XI1_I1160_I213_An I1_p13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I213_MP2 (VDD I1_I1160_pn10 XI1_I1160_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I213_MP3 (XI1_I1160_I213_p1 I1_I1160_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I213_MP0 (VDD I1_I1160_pn10 XI1_I1160_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1181_MP1 (VDD I1_qu18_b3_1 XI1_I1181_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1181_MP5 (I1_b14_7 XI1_I1181_Bn XI1_I1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1181_MP4 (XI1_I1181_p1 XI1_I1181_An I1_b14_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1181_MP2 (VDD I1_dd7_b3_2 XI1_I1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1181_MP3 (XI1_I1181_p1 I1_qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1181_MP0 (VDD I1_dd7_b3_2 XI1_I1181_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I918_MP1 (VDD I1_qu24_b3_3 XI1_I918_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I918_MP5 (I1_b8_20 XI1_I918_Bn XI1_I918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I918_MP4 (XI1_I918_p1 XI1_I918_An I1_b8_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I918_MP2 (VDD I1_dd20_b3_1 XI1_I918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I918_MP3 (XI1_I918_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I918_MP0 (VDD I1_dd20_b3_1 XI1_I918_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I218_MP1 (VDD I1_I884_G14_0n XI1_I884_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I218_MP5 (I1_p7_15 XI1_I884_I218_Bn XI1_I884_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I218_MP4 (XI1_I884_I218_p1 XI1_I884_I218_An I1_p7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I218_MP2 (VDD I1_I884_pn15 XI1_I884_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I218_MP3 (XI1_I884_I218_p1 I1_I884_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I218_MP0 (VDD I1_I884_pn15 XI1_I884_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I216_MP1 (VDD I1_I884_G12_0n XI1_I884_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I216_MP5 (I1_p7_13 XI1_I884_I216_Bn XI1_I884_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I216_MP4 (XI1_I884_I216_p1 XI1_I884_I216_An I1_p7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I216_MP2 (VDD I1_I884_pn13 XI1_I884_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I216_MP3 (XI1_I884_I216_p1 I1_I884_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I216_MP0 (VDD I1_I884_pn13 XI1_I884_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I214_MP1 (VDD I1_I884_G10_0n XI1_I884_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I214_MP5 (I1_p7_11 XI1_I884_I214_Bn XI1_I884_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I214_MP4 (XI1_I884_I214_p1 XI1_I884_I214_An I1_p7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I214_MP2 (VDD I1_I884_pn11 XI1_I884_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I214_MP3 (XI1_I884_I214_p1 I1_I884_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I214_MP0 (VDD I1_I884_pn11 XI1_I884_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I763_MP1 (VDD I1_qu27_b3_0 XI1_I763_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I763_MP5 (I1_b5_3 XI1_I763_Bn XI1_I763_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I763_MP4 (XI1_I763_p1 XI1_I763_An I1_b5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I763_MP2 (VDD I1_dd3_b3_0 XI1_I763_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I763_MP3 (XI1_I763_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I763_MP0 (VDD I1_dd3_b3_0 XI1_I763_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I762_MP1 (VDD I1_qu27_b3_0 XI1_I762_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I762_MP5 (I1_b5_2 XI1_I762_Bn XI1_I762_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I762_MP4 (XI1_I762_p1 XI1_I762_An I1_b5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I762_MP2 (VDD I1_dd2_b3_0 XI1_I762_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I762_MP3 (XI1_I762_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I762_MP0 (VDD I1_dd2_b3_0 XI1_I762_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I764_MP1 (VDD I1_qu27_b3_0 XI1_I764_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I764_MP5 (I1_b5_4 XI1_I764_Bn XI1_I764_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I764_MP4 (XI1_I764_p1 XI1_I764_An I1_b5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I764_MP2 (VDD I1_dd4_b3_0 XI1_I764_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I764_MP3 (XI1_I764_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I764_MP0 (VDD I1_dd4_b3_0 XI1_I764_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I717_MP1 (VDD I1_qu28_b3_0 XI1_I717_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I717_MP5 (I1_b4_3 XI1_I717_Bn XI1_I717_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I717_MP4 (XI1_I717_p1 XI1_I717_An I1_b4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I717_MP2 (VDD I1_dd3_b3_0 XI1_I717_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I717_MP3 (XI1_I717_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I717_MP0 (VDD I1_dd3_b3_0 XI1_I717_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I207_MP1 (VDD I1_I700_G3_0n XI1_I700_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I207_MP5 (I1_p3_4 XI1_I700_I207_Bn XI1_I700_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I207_MP4 (XI1_I700_I207_p1 XI1_I700_I207_An I1_p3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I207_MP2 (VDD I1_I700_pn4 XI1_I700_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I207_MP3 (XI1_I700_I207_p1 I1_I700_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I207_MP0 (VDD I1_I700_pn4 XI1_I700_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I721_MP1 (VDD I1_qu28_b3_1 XI1_I721_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I721_MP5 (I1_b4_7 XI1_I721_Bn XI1_I721_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I721_MP4 (XI1_I721_p1 XI1_I721_An I1_b4_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I721_MP2 (VDD I1_dd7_b3_0 XI1_I721_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I721_MP3 (XI1_I721_p1 I1_qu28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I721_MP0 (VDD I1_dd7_b3_0 XI1_I721_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1369_MP1 (VDD I1_qu14_b3_1 XI1_I1369_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1369_MP5 (I1_b18_11 XI1_I1369_Bn XI1_I1369_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1369_MP4 (XI1_I1369_p1 XI1_I1369_An I1_b18_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1369_MP2 (VDD I1_dd11_b3_3 XI1_I1369_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1369_MP3 (XI1_I1369_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1369_MP0 (VDD I1_dd11_b3_3 XI1_I1369_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1321_MP1 (VDD I1_qu15_b3_1 XI1_I1321_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1321_MP5 (I1_b17_9 XI1_I1321_Bn XI1_I1321_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1321_MP4 (XI1_I1321_p1 XI1_I1321_An I1_b17_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1321_MP2 (VDD I1_dd9_b3_3 XI1_I1321_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1321_MP3 (XI1_I1321_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1321_MP0 (VDD I1_dd9_b3_3 XI1_I1321_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1367_MP1 (VDD I1_qu14_b3_1 XI1_I1367_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1367_MP5 (I1_b18_9 XI1_I1367_Bn XI1_I1367_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1367_MP4 (XI1_I1367_p1 XI1_I1367_An I1_b18_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1367_MP2 (VDD I1_dd9_b3_3 XI1_I1367_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1367_MP3 (XI1_I1367_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1367_MP0 (VDD I1_dd9_b3_3 XI1_I1367_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1318_MP1 (VDD I1_qu15_b3_1 XI1_I1318_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1318_MP5 (I1_b17_6 XI1_I1318_Bn XI1_I1318_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1318_MP4 (XI1_I1318_p1 XI1_I1318_An I1_b17_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1318_MP2 (VDD I1_dd6_b3_3 XI1_I1318_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1318_MP3 (XI1_I1318_p1 I1_qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1318_MP0 (VDD I1_dd6_b3_3 XI1_I1318_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I207_MP1 (VDD I1_I1344_G3_0n XI1_I1344_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I207_MP5 (I1_p17_4 XI1_I1344_I207_Bn XI1_I1344_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I207_MP4 (XI1_I1344_I207_p1 XI1_I1344_I207_An I1_p17_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I207_MP2 (VDD I1_I1344_pn4 XI1_I1344_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I207_MP3 (XI1_I1344_I207_p1 I1_I1344_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I207_MP0 (VDD I1_I1344_pn4 XI1_I1344_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1269_MP1 (VDD I1_qu16_b3_0 XI1_I1269_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1269_MP5 (I1_b16_3 XI1_I1269_Bn XI1_I1269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1269_MP4 (XI1_I1269_p1 XI1_I1269_An I1_b16_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1269_MP2 (VDD I1_dd3_b3_2 XI1_I1269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1269_MP3 (XI1_I1269_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1269_MP0 (VDD I1_dd3_b3_2 XI1_I1269_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1270_MP1 (VDD I1_qu16_b3_0 XI1_I1270_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1270_MP5 (I1_b16_4 XI1_I1270_Bn XI1_I1270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1270_MP4 (XI1_I1270_p1 XI1_I1270_An I1_b16_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1270_MP2 (VDD I1_dd4_b3_2 XI1_I1270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1270_MP3 (XI1_I1270_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1270_MP0 (VDD I1_dd4_b3_2 XI1_I1270_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1223_MP1 (VDD I1_qu17_b3_0 XI1_I1223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1223_MP5 (I1_b15_3 XI1_I1223_Bn XI1_I1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1223_MP4 (XI1_I1223_p1 XI1_I1223_An I1_b15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1223_MP2 (VDD I1_dd3_b3_2 XI1_I1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1223_MP3 (XI1_I1223_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1223_MP0 (VDD I1_dd3_b3_2 XI1_I1223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1224_MP1 (VDD I1_qu17_b3_0 XI1_I1224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1224_MP5 (I1_b15_4 XI1_I1224_Bn XI1_I1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1224_MP4 (XI1_I1224_p1 XI1_I1224_An I1_b15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1224_MP2 (VDD I1_dd4_b3_2 XI1_I1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1224_MP3 (XI1_I1224_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1224_MP0 (VDD I1_dd4_b3_2 XI1_I1224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1179_MP1 (VDD I1_qu18_b3_0 XI1_I1179_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1179_MP5 (I1_b14_5 XI1_I1179_Bn XI1_I1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1179_MP4 (XI1_I1179_p1 XI1_I1179_An I1_b14_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1179_MP2 (VDD I1_dd5_b3_2 XI1_I1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1179_MP3 (XI1_I1179_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1179_MP0 (VDD I1_dd5_b3_2 XI1_I1179_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1178_MP1 (VDD I1_qu18_b3_0 XI1_I1178_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1178_MP5 (I1_b14_4 XI1_I1178_Bn XI1_I1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1178_MP4 (XI1_I1178_p1 XI1_I1178_An I1_b14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1178_MP2 (VDD I1_dd4_b3_2 XI1_I1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1178_MP3 (XI1_I1178_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1178_MP0 (VDD I1_dd4_b3_2 XI1_I1178_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I927_MP1 (VDD I1_qu24_b3_4 XI1_I927_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I927_MP5 (I1_b8_29 XI1_I927_Bn XI1_I927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I927_MP4 (XI1_I927_p1 XI1_I927_An I1_b8_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I927_MP2 (VDD I1_dd29_b3_1 XI1_I927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I927_MP3 (XI1_I927_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I927_MP0 (VDD I1_dd29_b3_1 XI1_I927_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I925_MP1 (VDD I1_qu24_b3_4 XI1_I925_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I925_MP5 (I1_b8_27 XI1_I925_Bn XI1_I925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I925_MP4 (XI1_I925_p1 XI1_I925_An I1_b8_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I925_MP2 (VDD I1_dd27_b3_1 XI1_I925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I925_MP3 (XI1_I925_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I925_MP0 (VDD I1_dd27_b3_1 XI1_I925_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I926_MP1 (VDD I1_qu24_b3_4 XI1_I926_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I926_MP5 (I1_b8_28 XI1_I926_Bn XI1_I926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I926_MP4 (XI1_I926_p1 XI1_I926_An I1_b8_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I926_MP2 (VDD I1_dd28_b3_1 XI1_I926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I926_MP3 (XI1_I926_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I926_MP0 (VDD I1_dd28_b3_1 XI1_I926_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I924_MP1 (VDD I1_qu24_b3_4 XI1_I924_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I924_MP5 (I1_b8_26 XI1_I924_Bn XI1_I924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I924_MP4 (XI1_I924_p1 XI1_I924_An I1_b8_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I924_MP2 (VDD I1_dd26_b3_1 XI1_I924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I924_MP3 (XI1_I924_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I924_MP0 (VDD I1_dd26_b3_1 XI1_I924_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I923_MP1 (VDD I1_qu24_b3_4 XI1_I923_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I923_MP5 (I1_b8_25 XI1_I923_Bn XI1_I923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I923_MP4 (XI1_I923_p1 XI1_I923_An I1_b8_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I923_MP2 (VDD I1_dd25_b3_1 XI1_I923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I923_MP3 (XI1_I923_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I923_MP0 (VDD I1_dd25_b3_1 XI1_I923_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I922_MP1 (VDD I1_qu24_b3_4 XI1_I922_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I922_MP5 (I1_b8_24 XI1_I922_Bn XI1_I922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I922_MP4 (XI1_I922_p1 XI1_I922_An I1_b8_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I922_MP2 (VDD I1_dd24_b3_1 XI1_I922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I922_MP3 (XI1_I922_p1 I1_qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I922_MP0 (VDD I1_dd24_b3_1 XI1_I922_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I921_MP1 (VDD I1_qu24_b3_3 XI1_I921_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I921_MP5 (I1_b8_23 XI1_I921_Bn XI1_I921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I921_MP4 (XI1_I921_p1 XI1_I921_An I1_b8_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I921_MP2 (VDD I1_dd23_b3_1 XI1_I921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I921_MP3 (XI1_I921_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I921_MP0 (VDD I1_dd23_b3_1 XI1_I921_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I920_MP1 (VDD I1_qu24_b3_3 XI1_I920_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I920_MP5 (I1_b8_22 XI1_I920_Bn XI1_I920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I920_MP4 (XI1_I920_p1 XI1_I920_An I1_b8_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I920_MP2 (VDD I1_dd22_b3_1 XI1_I920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I920_MP3 (XI1_I920_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I920_MP0 (VDD I1_dd22_b3_1 XI1_I920_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I919_MP1 (VDD I1_qu24_b3_3 XI1_I919_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I919_MP5 (I1_b8_21 XI1_I919_Bn XI1_I919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I919_MP4 (XI1_I919_p1 XI1_I919_An I1_b8_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I919_MP2 (VDD I1_dd21_b3_1 XI1_I919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I919_MP3 (XI1_I919_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I919_MP0 (VDD I1_dd21_b3_1 XI1_I919_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I916_MP1 (VDD I1_qu24_b3_3 XI1_I916_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I916_MP5 (I1_b8_18 XI1_I916_Bn XI1_I916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I916_MP4 (XI1_I916_p1 XI1_I916_An I1_b8_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I916_MP2 (VDD I1_dd18_b3_1 XI1_I916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I916_MP3 (XI1_I916_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I916_MP0 (VDD I1_dd18_b3_1 XI1_I916_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I917_MP1 (VDD I1_qu24_b3_3 XI1_I917_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I917_MP5 (I1_b8_19 XI1_I917_Bn XI1_I917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I917_MP4 (XI1_I917_p1 XI1_I917_An I1_b8_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I917_MP2 (VDD I1_dd19_b3_1 XI1_I917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I917_MP3 (XI1_I917_p1 I1_qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I917_MP0 (VDD I1_dd19_b3_1 XI1_I917_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I914_MP1 (VDD I1_qu24_b3_2 XI1_I914_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I914_MP5 (I1_b8_16 XI1_I914_Bn XI1_I914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I914_MP4 (XI1_I914_p1 XI1_I914_An I1_b8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I914_MP2 (VDD I1_dd16_b3_1 XI1_I914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I914_MP3 (XI1_I914_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I914_MP0 (VDD I1_dd16_b3_1 XI1_I914_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I915_MP1 (VDD I1_qu24_b3_2 XI1_I915_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I915_MP5 (I1_b8_17 XI1_I915_Bn XI1_I915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I915_MP4 (XI1_I915_p1 XI1_I915_An I1_b8_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I915_MP2 (VDD I1_dd17_b3_1 XI1_I915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I915_MP3 (XI1_I915_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I915_MP0 (VDD I1_dd17_b3_1 XI1_I915_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I911_MP1 (VDD I1_qu24_b3_2 XI1_I911_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I911_MP5 (I1_b8_13 XI1_I911_Bn XI1_I911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I911_MP4 (XI1_I911_p1 XI1_I911_An I1_b8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I911_MP2 (VDD I1_dd13_b3_1 XI1_I911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I911_MP3 (XI1_I911_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I911_MP0 (VDD I1_dd13_b3_1 XI1_I911_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I912_MP1 (VDD I1_qu24_b3_2 XI1_I912_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I912_MP5 (I1_b8_14 XI1_I912_Bn XI1_I912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I912_MP4 (XI1_I912_p1 XI1_I912_An I1_b8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I912_MP2 (VDD I1_dd14_b3_1 XI1_I912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I912_MP3 (XI1_I912_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I912_MP0 (VDD I1_dd14_b3_1 XI1_I912_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I910_MP1 (VDD I1_qu24_b3_2 XI1_I910_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I910_MP5 (I1_b8_12 XI1_I910_Bn XI1_I910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I910_MP4 (XI1_I910_p1 XI1_I910_An I1_b8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I910_MP2 (VDD I1_dd12_b3_1 XI1_I910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I910_MP3 (XI1_I910_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I910_MP0 (VDD I1_dd12_b3_1 XI1_I910_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I212_MP1 (VDD I1_I884_G8_0n XI1_I884_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I212_MP5 (I1_p7_9 XI1_I884_I212_Bn XI1_I884_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I212_MP4 (XI1_I884_I212_p1 XI1_I884_I212_An I1_p7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I212_MP2 (VDD I1_I884_pn9 XI1_I884_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I212_MP3 (XI1_I884_I212_p1 I1_I884_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I212_MP0 (VDD I1_I884_pn9 XI1_I884_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I908_MP1 (VDD I1_qu24_b3_1 XI1_I908_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I908_MP5 (I1_b8_10 XI1_I908_Bn XI1_I908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I908_MP4 (XI1_I908_p1 XI1_I908_An I1_b8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I908_MP2 (VDD I1_dd10_b3_1 XI1_I908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I908_MP3 (XI1_I908_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I908_MP0 (VDD I1_dd10_b3_1 XI1_I908_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I905_MP1 (VDD I1_qu24_b3_1 XI1_I905_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I905_MP5 (I1_b8_7 XI1_I905_Bn XI1_I905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I905_MP4 (XI1_I905_p1 XI1_I905_An I1_b8_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I905_MP2 (VDD I1_dd7_b3_1 XI1_I905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I905_MP3 (XI1_I905_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I905_MP0 (VDD I1_dd7_b3_1 XI1_I905_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I854_MP1 (VDD I1_qu25_b3_0 XI1_I854_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I854_MP5 (I1_b7_2 XI1_I854_Bn XI1_I854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I854_MP4 (XI1_I854_p1 XI1_I854_An I1_b7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I854_MP2 (VDD I1_dd2_b3_1 XI1_I854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I854_MP3 (XI1_I854_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I854_MP0 (VDD I1_dd2_b3_1 XI1_I854_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I206_MP1 (VDD I1_I884_G2_0n XI1_I884_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I884_I206_MP5 (I1_p7_3 XI1_I884_I206_Bn XI1_I884_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I884_I206_MP4 (XI1_I884_I206_p1 XI1_I884_I206_An I1_p7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I206_MP2 (VDD I1_I884_pn3 XI1_I884_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I884_I206_MP3 (XI1_I884_I206_p1 I1_I884_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I884_I206_MP0 (VDD I1_I884_pn3 XI1_I884_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I807_MP1 (VDD I1_qu26_b3_0 XI1_I807_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I807_MP5 (I1_b6_1 XI1_I807_Bn XI1_I807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I807_MP4 (XI1_I807_p1 XI1_I807_An I1_b6_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I807_MP2 (VDD I1_dd1_b3_1 XI1_I807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I807_MP3 (XI1_I807_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I807_MP0 (VDD I1_dd1_b3_1 XI1_I807_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I716_MP1 (VDD I1_qu28_b3_0 XI1_I716_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I716_MP5 (I1_b4_2 XI1_I716_Bn XI1_I716_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I716_MP4 (XI1_I716_p1 XI1_I716_An I1_b4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I716_MP2 (VDD I1_dd2_b3_0 XI1_I716_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I716_MP3 (XI1_I716_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I716_MP0 (VDD I1_dd2_b3_0 XI1_I716_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I718_MP1 (VDD I1_qu28_b3_0 XI1_I718_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I718_MP5 (I1_b4_4 XI1_I718_Bn XI1_I718_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I718_MP4 (XI1_I718_p1 XI1_I718_An I1_b4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I718_MP2 (VDD I1_dd4_b3_0 XI1_I718_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I718_MP3 (XI1_I718_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I718_MP0 (VDD I1_dd4_b3_0 XI1_I718_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I719_MP1 (VDD I1_qu28_b3_0 XI1_I719_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I719_MP5 (I1_b4_5 XI1_I719_Bn XI1_I719_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I719_MP4 (XI1_I719_p1 XI1_I719_An I1_b4_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I719_MP2 (VDD I1_dd5_b3_0 XI1_I719_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I719_MP3 (XI1_I719_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I719_MP0 (VDD I1_dd5_b3_0 XI1_I719_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I206_MP1 (VDD I1_I700_G2_0n XI1_I700_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I206_MP5 (I1_p3_3 XI1_I700_I206_Bn XI1_I700_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I206_MP4 (XI1_I700_I206_p1 XI1_I700_I206_An I1_p3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I206_MP2 (VDD I1_I700_pn3 XI1_I700_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I206_MP3 (XI1_I700_I206_p1 I1_I700_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I206_MP0 (VDD I1_I700_pn3 XI1_I700_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I212_MP1 (VDD I1_I700_G8_0n XI1_I700_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I212_MP5 (I1_p3_9 XI1_I700_I212_Bn XI1_I700_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I212_MP4 (XI1_I700_I212_p1 XI1_I700_I212_An I1_p3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I212_MP2 (VDD I1_I700_pn9 XI1_I700_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I212_MP3 (XI1_I700_I212_p1 I1_I700_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I212_MP0 (VDD I1_I700_pn9 XI1_I700_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I214_MP1 (VDD I1_I700_G10_0n XI1_I700_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I214_MP5 (I1_p3_11 XI1_I700_I214_Bn XI1_I700_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I214_MP4 (XI1_I700_I214_p1 XI1_I700_I214_An I1_p3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I214_MP2 (VDD I1_I700_pn11 XI1_I700_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I214_MP3 (XI1_I700_I214_p1 I1_I700_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I214_MP0 (VDD I1_I700_pn11 XI1_I700_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I216_MP1 (VDD I1_I700_G12_0n XI1_I700_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I216_MP5 (I1_p3_13 XI1_I700_I216_Bn XI1_I700_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I216_MP4 (XI1_I700_I216_p1 XI1_I700_I216_An I1_p3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I216_MP2 (VDD I1_I700_pn13 XI1_I700_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I216_MP3 (XI1_I700_I216_p1 I1_I700_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I216_MP0 (VDD I1_I700_pn13 XI1_I700_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I218_MP1 (VDD I1_I700_G14_0n XI1_I700_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I700_I218_MP5 (I1_p3_15 XI1_I700_I218_Bn XI1_I700_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I700_I218_MP4 (XI1_I700_I218_p1 XI1_I700_I218_An I1_p3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I218_MP2 (VDD I1_I700_pn15 XI1_I700_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I700_I218_MP3 (XI1_I700_I218_p1 I1_I700_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I700_I218_MP0 (VDD I1_I700_pn15 XI1_I700_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1392_MP1 (VDD I1_c18_o XI1_I1392_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1392_MP5 (I1_p18_32 XI1_I1392_Bn XI1_I1392_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1392_MP4 (XI1_I1392_p1 XI1_I1392_An I1_p18_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1392_MP2 (VDD I1_h18 XI1_I1392_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1392_MP3 (XI1_I1392_p1 I1_c18_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1392_MP0 (VDD I1_h18 XI1_I1392_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1366_MP1 (VDD I1_qu14_b3_1 XI1_I1366_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1366_MP5 (I1_b18_8 XI1_I1366_Bn XI1_I1366_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1366_MP4 (XI1_I1366_p1 XI1_I1366_An I1_b18_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1366_MP2 (VDD I1_dd8_b3_3 XI1_I1366_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1366_MP3 (XI1_I1366_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1366_MP0 (VDD I1_dd8_b3_3 XI1_I1366_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1365_MP1 (VDD I1_qu14_b3_1 XI1_I1365_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1365_MP5 (I1_b18_7 XI1_I1365_Bn XI1_I1365_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1365_MP4 (XI1_I1365_p1 XI1_I1365_An I1_b18_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1365_MP2 (VDD I1_dd7_b3_3 XI1_I1365_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1365_MP3 (XI1_I1365_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1365_MP0 (VDD I1_dd7_b3_3 XI1_I1365_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I206_MP1 (VDD I1_I1344_G2_0n XI1_I1344_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I206_MP5 (I1_p17_3 XI1_I1344_I206_Bn XI1_I1344_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1344_I206_MP4 (XI1_I1344_I206_p1 XI1_I1344_I206_An I1_p17_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I206_MP2 (VDD I1_I1344_pn3 XI1_I1344_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1344_I206_MP3 (XI1_I1344_I206_p1 I1_I1344_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1344_I206_MP0 (VDD I1_I1344_pn3 XI1_I1344_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1267_MP1 (VDD I1_qu16_b3_0 XI1_I1267_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1267_MP5 (I1_b16_1 XI1_I1267_Bn XI1_I1267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1267_MP4 (XI1_I1267_p1 XI1_I1267_An I1_b16_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1267_MP2 (VDD I1_dd1_b3_2 XI1_I1267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1267_MP3 (XI1_I1267_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1267_MP0 (VDD I1_dd1_b3_2 XI1_I1267_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1268_MP1 (VDD I1_qu16_b3_0 XI1_I1268_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1268_MP5 (I1_b16_2 XI1_I1268_Bn XI1_I1268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1268_MP4 (XI1_I1268_p1 XI1_I1268_An I1_b16_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1268_MP2 (VDD I1_dd2_b3_2 XI1_I1268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1268_MP3 (XI1_I1268_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1268_MP0 (VDD I1_dd2_b3_2 XI1_I1268_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1221_MP1 (VDD I1_qu17_b3_0 XI1_I1221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1221_MP5 (I1_b15_1 XI1_I1221_Bn XI1_I1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1221_MP4 (XI1_I1221_p1 XI1_I1221_An I1_b15_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1221_MP2 (VDD I1_dd1_b3_2 XI1_I1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1221_MP3 (XI1_I1221_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1221_MP0 (VDD I1_dd1_b3_2 XI1_I1221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1222_MP1 (VDD I1_qu17_b3_0 XI1_I1222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1222_MP5 (I1_b15_2 XI1_I1222_Bn XI1_I1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1222_MP4 (XI1_I1222_p1 XI1_I1222_An I1_b15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1222_MP2 (VDD I1_dd2_b3_2 XI1_I1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1222_MP3 (XI1_I1222_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1222_MP0 (VDD I1_dd2_b3_2 XI1_I1222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I216_MP1 (VDD I1_I1160_G12_0n XI1_I1160_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I216_MP5 (I1_p13_13 XI1_I1160_I216_Bn XI1_I1160_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I216_MP4 (XI1_I1160_I216_p1 XI1_I1160_I216_An I1_p13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I216_MP2 (VDD I1_I1160_pn13 XI1_I1160_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I216_MP3 (XI1_I1160_I216_p1 I1_I1160_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I216_MP0 (VDD I1_I1160_pn13 XI1_I1160_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I207_MP1 (VDD I1_I1160_G3_0n XI1_I1160_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I207_MP5 (I1_p13_4 XI1_I1160_I207_Bn XI1_I1160_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I207_MP4 (XI1_I1160_I207_p1 XI1_I1160_I207_An I1_p13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I207_MP2 (VDD I1_I1160_pn4 XI1_I1160_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I207_MP3 (XI1_I1160_I207_p1 I1_I1160_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I207_MP0 (VDD I1_I1160_pn4 XI1_I1160_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1177_MP1 (VDD I1_qu18_b3_0 XI1_I1177_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1177_MP5 (I1_b14_3 XI1_I1177_Bn XI1_I1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1177_MP4 (XI1_I1177_p1 XI1_I1177_An I1_b14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1177_MP2 (VDD I1_dd3_b3_2 XI1_I1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1177_MP3 (XI1_I1177_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1177_MP0 (VDD I1_dd3_b3_2 XI1_I1177_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1176_MP1 (VDD I1_qu18_b3_0 XI1_I1176_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1176_MP5 (I1_b14_2 XI1_I1176_Bn XI1_I1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1176_MP4 (XI1_I1176_p1 XI1_I1176_An I1_b14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1176_MP2 (VDD I1_dd2_b3_2 XI1_I1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1176_MP3 (XI1_I1176_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1176_MP0 (VDD I1_dd2_b3_2 XI1_I1176_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1175_MP1 (VDD I1_qu18_b3_0 XI1_I1175_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1175_MP5 (I1_b14_1 XI1_I1175_Bn XI1_I1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1175_MP4 (XI1_I1175_p1 XI1_I1175_An I1_b14_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1175_MP2 (VDD I1_dd1_b3_2 XI1_I1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1175_MP3 (XI1_I1175_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1175_MP0 (VDD I1_dd1_b3_2 XI1_I1175_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I931_MP1 (VDD I1_qu24_b3_5 XI1_I931_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I931_MP5 (I1_h8 XI1_I931_Bn XI1_I931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I931_MP4 (XI1_I931_p1 XI1_I931_An I1_h8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I931_MP2 (VDD I1_p7_31 XI1_I931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I931_MP3 (XI1_I931_p1 I1_qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I931_MP0 (VDD I1_p7_31 XI1_I931_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I913_MP1 (VDD I1_qu24_b3_2 XI1_I913_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I913_MP5 (I1_b8_15 XI1_I913_Bn XI1_I913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I913_MP4 (XI1_I913_p1 XI1_I913_An I1_b8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I913_MP2 (VDD I1_dd15_b3_1 XI1_I913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I913_MP3 (XI1_I913_p1 I1_qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I913_MP0 (VDD I1_dd15_b3_1 XI1_I913_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I909_MP1 (VDD I1_qu24_b3_1 XI1_I909_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I909_MP5 (I1_b8_11 XI1_I909_Bn XI1_I909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I909_MP4 (XI1_I909_p1 XI1_I909_An I1_b8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I909_MP2 (VDD I1_dd11_b3_1 XI1_I909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I909_MP3 (XI1_I909_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I909_MP0 (VDD I1_dd11_b3_1 XI1_I909_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I907_MP1 (VDD I1_qu24_b3_1 XI1_I907_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I907_MP5 (I1_b8_9 XI1_I907_Bn XI1_I907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I907_MP4 (XI1_I907_p1 XI1_I907_An I1_b8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I907_MP2 (VDD I1_dd9_b3_1 XI1_I907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I907_MP3 (XI1_I907_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I907_MP0 (VDD I1_dd9_b3_1 XI1_I907_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I906_MP1 (VDD I1_qu24_b3_1 XI1_I906_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I906_MP5 (I1_b8_8 XI1_I906_Bn XI1_I906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I906_MP4 (XI1_I906_p1 XI1_I906_An I1_b8_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I906_MP2 (VDD I1_dd8_b3_1 XI1_I906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I906_MP3 (XI1_I906_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I906_MP0 (VDD I1_dd8_b3_1 XI1_I906_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I904_MP1 (VDD I1_qu24_b3_1 XI1_I904_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I904_MP5 (I1_b8_6 XI1_I904_Bn XI1_I904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I904_MP4 (XI1_I904_p1 XI1_I904_An I1_b8_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I904_MP2 (VDD I1_dd6_b3_1 XI1_I904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I904_MP3 (XI1_I904_p1 I1_qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I904_MP0 (VDD I1_dd6_b3_1 XI1_I904_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I853_MP1 (VDD I1_qu25_b3_0 XI1_I853_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I853_MP5 (I1_b7_1 XI1_I853_Bn XI1_I853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I853_MP4 (XI1_I853_p1 XI1_I853_An I1_b7_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I853_MP2 (VDD I1_dd1_b3_1 XI1_I853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I853_MP3 (XI1_I853_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I853_MP0 (VDD I1_dd1_b3_1 XI1_I853_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I761_MP1 (VDD I1_qu27_b3_0 XI1_I761_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I761_MP5 (I1_b5_1 XI1_I761_Bn XI1_I761_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I761_MP4 (XI1_I761_p1 XI1_I761_An I1_b5_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I761_MP2 (VDD I1_dd1_b3_0 XI1_I761_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I761_MP3 (XI1_I761_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I761_MP0 (VDD I1_dd1_b3_0 XI1_I761_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I715_MP1 (VDD I1_qu28_b3_0 XI1_I715_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I715_MP5 (I1_b4_1 XI1_I715_Bn XI1_I715_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I715_MP4 (XI1_I715_p1 XI1_I715_An I1_b4_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I715_MP2 (VDD I1_dd1_b3_0 XI1_I715_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I715_MP3 (XI1_I715_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I715_MP0 (VDD I1_dd1_b3_0 XI1_I715_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I219_MP1 (VDD I1_I1390_G15_0n XI1_I1390_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I219_MP5 (I1_p18_16 XI1_I1390_I219_Bn XI1_I1390_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I219_MP4 (XI1_I1390_I219_p1 XI1_I1390_I219_An I1_p18_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I219_MP2 (VDD I1_I1390_pn16 XI1_I1390_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I219_MP3 (XI1_I1390_I219_p1 I1_I1390_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I219_MP0 (VDD I1_I1390_pn16 XI1_I1390_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I217_MP1 (VDD I1_I1390_G13_0n XI1_I1390_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I217_MP5 (I1_p18_14 XI1_I1390_I217_Bn XI1_I1390_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I217_MP4 (XI1_I1390_I217_p1 XI1_I1390_I217_An I1_p18_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I217_MP2 (VDD I1_I1390_pn14 XI1_I1390_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I217_MP3 (XI1_I1390_I217_p1 I1_I1390_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I217_MP0 (VDD I1_I1390_pn14 XI1_I1390_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I215_MP1 (VDD I1_I1390_G11_0n XI1_I1390_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I215_MP5 (I1_p18_12 XI1_I1390_I215_Bn XI1_I1390_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I215_MP4 (XI1_I1390_I215_p1 XI1_I1390_I215_An I1_p18_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I215_MP2 (VDD I1_I1390_pn12 XI1_I1390_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I215_MP3 (XI1_I1390_I215_p1 I1_I1390_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I215_MP0 (VDD I1_I1390_pn12 XI1_I1390_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1364_MP1 (VDD I1_qu14_b3_1 XI1_I1364_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1364_MP5 (I1_b18_6 XI1_I1364_Bn XI1_I1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1364_MP4 (XI1_I1364_p1 XI1_I1364_An I1_b18_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1364_MP2 (VDD I1_dd6_b3_3 XI1_I1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1364_MP3 (XI1_I1364_p1 I1_qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1364_MP0 (VDD I1_dd6_b3_3 XI1_I1364_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1317_MP1 (VDD I1_qu15_b3_0 XI1_I1317_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1317_MP5 (I1_b17_5 XI1_I1317_Bn XI1_I1317_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1317_MP4 (XI1_I1317_p1 XI1_I1317_An I1_b17_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1317_MP2 (VDD I1_dd5_b3_3 XI1_I1317_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1317_MP3 (XI1_I1317_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1317_MP0 (VDD I1_dd5_b3_3 XI1_I1317_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1363_MP1 (VDD I1_qu14_b3_0 XI1_I1363_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1363_MP5 (I1_b18_5 XI1_I1363_Bn XI1_I1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1363_MP4 (XI1_I1363_p1 XI1_I1363_An I1_b18_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1363_MP2 (VDD I1_dd5_b3_3 XI1_I1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1363_MP3 (XI1_I1363_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1363_MP0 (VDD I1_dd5_b3_3 XI1_I1363_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1316_MP1 (VDD I1_qu15_b3_0 XI1_I1316_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1316_MP5 (I1_b17_4 XI1_I1316_Bn XI1_I1316_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1316_MP4 (XI1_I1316_p1 XI1_I1316_An I1_b17_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1316_MP2 (VDD I1_dd4_b3_3 XI1_I1316_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1316_MP3 (XI1_I1316_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1316_MP0 (VDD I1_dd4_b3_3 XI1_I1316_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1315_MP1 (VDD I1_qu15_b3_0 XI1_I1315_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1315_MP5 (I1_b17_3 XI1_I1315_Bn XI1_I1315_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1315_MP4 (XI1_I1315_p1 XI1_I1315_An I1_b17_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1315_MP2 (VDD I1_dd3_b3_3 XI1_I1315_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1315_MP3 (XI1_I1315_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1315_MP0 (VDD I1_dd3_b3_3 XI1_I1315_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1266_MP1 (VDD I1_qu16_b3_0 XI1_I1266_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1266_MP5 (I1_b16_0 XI1_I1266_Bn XI1_I1266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1266_MP4 (XI1_I1266_p1 XI1_I1266_An I1_b16_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1266_MP2 (VDD I1_B_0_b3_2 XI1_I1266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1266_MP3 (XI1_I1266_p1 I1_qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1266_MP0 (VDD I1_B_0_b3_2 XI1_I1266_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1220_MP1 (VDD I1_qu17_b3_0 XI1_I1220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1220_MP5 (I1_b15_0 XI1_I1220_Bn XI1_I1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1220_MP4 (XI1_I1220_p1 XI1_I1220_An I1_b15_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1220_MP2 (VDD I1_B_0_b3_2 XI1_I1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1220_MP3 (XI1_I1220_p1 I1_qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1220_MP0 (VDD I1_B_0_b3_2 XI1_I1220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1159_MP1 (VDD I1_qu19_b3_5 XI1_I1159_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1159_MP5 (I1_b13_31 XI1_I1159_Bn XI1_I1159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1159_MP4 (XI1_I1159_p1 XI1_I1159_An I1_b13_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1159_MP2 (VDD I1_dd31_b3_2 XI1_I1159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1159_MP3 (XI1_I1159_p1 I1_qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1159_MP0 (VDD I1_dd31_b3_2 XI1_I1159_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I218_MP1 (VDD I1_I1160_G14_0n XI1_I1160_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I218_MP5 (I1_p13_15 XI1_I1160_I218_Bn XI1_I1160_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I218_MP4 (XI1_I1160_I218_p1 XI1_I1160_I218_An I1_p13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I218_MP2 (VDD I1_I1160_pn15 XI1_I1160_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I218_MP3 (XI1_I1160_I218_p1 I1_I1160_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I218_MP0 (VDD I1_I1160_pn15 XI1_I1160_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I214_MP1 (VDD I1_I1160_G10_0n XI1_I1160_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I214_MP5 (I1_p13_11 XI1_I1160_I214_Bn XI1_I1160_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I214_MP4 (XI1_I1160_I214_p1 XI1_I1160_I214_An I1_p13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I214_MP2 (VDD I1_I1160_pn11 XI1_I1160_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I214_MP3 (XI1_I1160_I214_p1 I1_I1160_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I214_MP0 (VDD I1_I1160_pn11 XI1_I1160_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I212_MP1 (VDD I1_I1160_G8_0n XI1_I1160_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I212_MP5 (I1_p13_9 XI1_I1160_I212_Bn XI1_I1160_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I212_MP4 (XI1_I1160_I212_p1 XI1_I1160_I212_An I1_p13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I212_MP2 (VDD I1_I1160_pn9 XI1_I1160_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I212_MP3 (XI1_I1160_I212_p1 I1_I1160_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I212_MP0 (VDD I1_I1160_pn9 XI1_I1160_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I206_MP1 (VDD I1_I1160_G2_0n XI1_I1160_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1160_I206_MP5 (I1_p13_3 XI1_I1160_I206_Bn XI1_I1160_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1160_I206_MP4 (XI1_I1160_I206_p1 XI1_I1160_I206_An I1_p13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I206_MP2 (VDD I1_I1160_pn3 XI1_I1160_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1160_I206_MP3 (XI1_I1160_I206_p1 I1_I1160_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1160_I206_MP0 (VDD I1_I1160_pn3 XI1_I1160_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1174_MP1 (VDD I1_qu18_b3_0 XI1_I1174_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1174_MP5 (I1_b14_0 XI1_I1174_Bn XI1_I1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1174_MP4 (XI1_I1174_p1 XI1_I1174_An I1_b14_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1174_MP2 (VDD I1_B_0_b3_2 XI1_I1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1174_MP3 (XI1_I1174_p1 I1_qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1174_MP0 (VDD I1_B_0_b3_2 XI1_I1174_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I806_MP1 (VDD I1_qu26_b3_0 XI1_I806_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I806_MP5 (I1_b6_0 XI1_I806_Bn XI1_I806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I806_MP4 (XI1_I806_p1 XI1_I806_An I1_b6_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I806_MP2 (VDD I1_B_0_b3_1 XI1_I806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I806_MP3 (XI1_I806_p1 I1_qu26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I806_MP0 (VDD I1_B_0_b3_1 XI1_I806_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I760_MP1 (VDD I1_qu27_b3_0 XI1_I760_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I760_MP5 (I1_b5_0 XI1_I760_Bn XI1_I760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I760_MP4 (XI1_I760_p1 XI1_I760_An I1_b5_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I760_MP2 (VDD I1_B_0_b3_1 XI1_I760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I760_MP3 (XI1_I760_p1 I1_qu27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I760_MP0 (VDD I1_B_0_b3_1 XI1_I760_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I669_MP1 (VDD I1_qu29_b3_0 XI1_I669_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I669_MP5 (I1_b3_1 XI1_I669_Bn XI1_I669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I669_MP4 (XI1_I669_p1 XI1_I669_An I1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I669_MP2 (VDD I1_dd1_b3_0 XI1_I669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I669_MP3 (XI1_I669_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I669_MP0 (VDD I1_dd1_b3_0 XI1_I669_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I213_MP1 (VDD I1_I1390_G9_0n XI1_I1390_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I213_MP5 (I1_p18_10 XI1_I1390_I213_Bn XI1_I1390_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I213_MP4 (XI1_I1390_I213_p1 XI1_I1390_I213_An I1_p18_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I213_MP2 (VDD I1_I1390_pn10 XI1_I1390_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I213_MP3 (XI1_I1390_I213_p1 I1_I1390_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I213_MP0 (VDD I1_I1390_pn10 XI1_I1390_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1361_MP1 (VDD I1_qu14_b3_0 XI1_I1361_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1361_MP5 (I1_b18_3 XI1_I1361_Bn XI1_I1361_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1361_MP4 (XI1_I1361_p1 XI1_I1361_An I1_b18_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1361_MP2 (VDD I1_dd3_b3_3 XI1_I1361_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1361_MP3 (XI1_I1361_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1361_MP0 (VDD I1_dd3_b3_3 XI1_I1361_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1362_MP1 (VDD I1_qu14_b3_0 XI1_I1362_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1362_MP5 (I1_b18_4 XI1_I1362_Bn XI1_I1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1362_MP4 (XI1_I1362_p1 XI1_I1362_An I1_b18_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1362_MP2 (VDD I1_dd4_b3_3 XI1_I1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1362_MP3 (XI1_I1362_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1362_MP0 (VDD I1_dd4_b3_3 XI1_I1362_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1313_MP1 (VDD I1_qu15_b3_0 XI1_I1313_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1313_MP5 (I1_b17_1 XI1_I1313_Bn XI1_I1313_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1313_MP4 (XI1_I1313_p1 XI1_I1313_An I1_b17_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1313_MP2 (VDD I1_dd1_b3_3 XI1_I1313_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1313_MP3 (XI1_I1313_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1313_MP0 (VDD I1_dd1_b3_3 XI1_I1313_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1155_MP1 (VDD I1_qu19_b3_4 XI1_I1155_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1155_MP5 (I1_b13_27 XI1_I1155_Bn XI1_I1155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1155_MP4 (XI1_I1155_p1 XI1_I1155_An I1_b13_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1155_MP2 (VDD I1_dd27_b3_2 XI1_I1155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1155_MP3 (XI1_I1155_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1155_MP0 (VDD I1_dd27_b3_2 XI1_I1155_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1157_MP1 (VDD I1_qu19_b3_4 XI1_I1157_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1157_MP5 (I1_b13_29 XI1_I1157_Bn XI1_I1157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1157_MP4 (XI1_I1157_p1 XI1_I1157_An I1_b13_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1157_MP2 (VDD I1_dd29_b3_2 XI1_I1157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1157_MP3 (XI1_I1157_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1157_MP0 (VDD I1_dd29_b3_2 XI1_I1157_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I932_MP1 (VDD I1_c8_o XI1_I932_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I932_MP5 (I1_p8_32 XI1_I932_Bn XI1_I932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I932_MP4 (XI1_I932_p1 XI1_I932_An I1_p8_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I932_MP2 (VDD I1_h8 XI1_I932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I932_MP3 (XI1_I932_p1 I1_c8_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I932_MP0 (VDD I1_h8 XI1_I932_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I219_MP1 (VDD I1_I930_G15_0n XI1_I930_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I219_MP5 (I1_p8_16 XI1_I930_I219_Bn XI1_I930_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I219_MP4 (XI1_I930_I219_p1 XI1_I930_I219_An I1_p8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I219_MP2 (VDD I1_I930_pn16 XI1_I930_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I219_MP3 (XI1_I930_I219_p1 I1_I930_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I219_MP0 (VDD I1_I930_pn16 XI1_I930_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I852_MP1 (VDD I1_qu25_b3_0 XI1_I852_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I852_MP5 (I1_b7_0 XI1_I852_Bn XI1_I852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I852_MP4 (XI1_I852_p1 XI1_I852_An I1_b7_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I852_MP2 (VDD I1_B_0_b3_1 XI1_I852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I852_MP3 (XI1_I852_p1 I1_qu25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I852_MP0 (VDD I1_B_0_b3_1 XI1_I852_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I903_MP1 (VDD I1_qu24_b3_0 XI1_I903_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I903_MP5 (I1_b8_5 XI1_I903_Bn XI1_I903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I903_MP4 (XI1_I903_p1 XI1_I903_An I1_b8_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I903_MP2 (VDD I1_dd5_b3_1 XI1_I903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I903_MP3 (XI1_I903_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I903_MP0 (VDD I1_dd5_b3_1 XI1_I903_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I714_MP1 (VDD I1_qu28_b3_0 XI1_I714_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I714_MP5 (I1_b4_0 XI1_I714_Bn XI1_I714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I714_MP4 (XI1_I714_p1 XI1_I714_An I1_b4_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I714_MP2 (VDD I1_B_0_b3_0 XI1_I714_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I714_MP3 (XI1_I714_p1 I1_qu28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I714_MP0 (VDD I1_B_0_b3_0 XI1_I714_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I670_MP1 (VDD I1_qu29_b3_0 XI1_I670_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I670_MP5 (I1_b3_2 XI1_I670_Bn XI1_I670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I670_MP4 (XI1_I670_p1 XI1_I670_An I1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I670_MP2 (VDD I1_dd2_b3_0 XI1_I670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I670_MP3 (XI1_I670_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I670_MP0 (VDD I1_dd2_b3_0 XI1_I670_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I671_MP1 (VDD I1_qu29_b3_0 XI1_I671_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I671_MP5 (I1_b3_3 XI1_I671_Bn XI1_I671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I671_MP4 (XI1_I671_p1 XI1_I671_An I1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I671_MP2 (VDD I1_dd3_b3_0 XI1_I671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I671_MP3 (XI1_I671_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I671_MP0 (VDD I1_dd3_b3_0 XI1_I671_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I695_MP1 (VDD I1_qu29_b3_4 XI1_I695_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I695_MP5 (I1_b3_27 XI1_I695_Bn XI1_I695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I695_MP4 (XI1_I695_p1 XI1_I695_An I1_b3_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I695_MP2 (VDD I1_dd27_b3_0 XI1_I695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I695_MP3 (XI1_I695_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I695_MP0 (VDD I1_dd27_b3_0 XI1_I695_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I696_MP1 (VDD I1_qu29_b3_4 XI1_I696_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I696_MP5 (I1_b3_28 XI1_I696_Bn XI1_I696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I696_MP4 (XI1_I696_p1 XI1_I696_An I1_b3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I696_MP2 (VDD I1_dd28_b3_0 XI1_I696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I696_MP3 (XI1_I696_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I696_MP0 (VDD I1_dd28_b3_0 XI1_I696_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I218_MP1 (VDD I1_I1390_G14_0n XI1_I1390_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I218_MP5 (I1_p18_15 XI1_I1390_I218_Bn XI1_I1390_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I218_MP4 (XI1_I1390_I218_p1 XI1_I1390_I218_An I1_p18_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I218_MP2 (VDD I1_I1390_pn15 XI1_I1390_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I218_MP3 (XI1_I1390_I218_p1 I1_I1390_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I218_MP0 (VDD I1_I1390_pn15 XI1_I1390_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I212_MP1 (VDD I1_I1390_G8_0n XI1_I1390_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I212_MP5 (I1_p18_9 XI1_I1390_I212_Bn XI1_I1390_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I212_MP4 (XI1_I1390_I212_p1 XI1_I1390_I212_An I1_p18_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I212_MP2 (VDD I1_I1390_pn9 XI1_I1390_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I212_MP3 (XI1_I1390_I212_p1 I1_I1390_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I212_MP0 (VDD I1_I1390_pn9 XI1_I1390_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1360_MP1 (VDD I1_qu14_b3_0 XI1_I1360_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1360_MP5 (I1_b18_2 XI1_I1360_Bn XI1_I1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1360_MP4 (XI1_I1360_p1 XI1_I1360_An I1_b18_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1360_MP2 (VDD I1_dd2_b3_3 XI1_I1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1360_MP3 (XI1_I1360_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1360_MP0 (VDD I1_dd2_b3_3 XI1_I1360_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1314_MP1 (VDD I1_qu15_b3_0 XI1_I1314_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1314_MP5 (I1_b17_2 XI1_I1314_Bn XI1_I1314_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1314_MP4 (XI1_I1314_p1 XI1_I1314_An I1_b17_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1314_MP2 (VDD I1_dd2_b3_3 XI1_I1314_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1314_MP3 (XI1_I1314_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1314_MP0 (VDD I1_dd2_b3_3 XI1_I1314_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1312_MP1 (VDD I1_qu15_b3_0 XI1_I1312_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1312_MP5 (I1_b17_0 XI1_I1312_Bn XI1_I1312_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1312_MP4 (XI1_I1312_p1 XI1_I1312_An I1_b17_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1312_MP2 (VDD I1_B_0_b3_3 XI1_I1312_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1312_MP3 (XI1_I1312_p1 I1_qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1312_MP0 (VDD I1_B_0_b3_3 XI1_I1312_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1156_MP1 (VDD I1_qu19_b3_4 XI1_I1156_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1156_MP5 (I1_b13_28 XI1_I1156_Bn XI1_I1156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1156_MP4 (XI1_I1156_p1 XI1_I1156_An I1_b13_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1156_MP2 (VDD I1_dd28_b3_2 XI1_I1156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1156_MP3 (XI1_I1156_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1156_MP0 (VDD I1_dd28_b3_2 XI1_I1156_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1153_MP1 (VDD I1_qu19_b3_4 XI1_I1153_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1153_MP5 (I1_b13_25 XI1_I1153_Bn XI1_I1153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1153_MP4 (XI1_I1153_p1 XI1_I1153_An I1_b13_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1153_MP2 (VDD I1_dd25_b3_2 XI1_I1153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1153_MP3 (XI1_I1153_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1153_MP0 (VDD I1_dd25_b3_2 XI1_I1153_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1158_MP1 (VDD I1_qu19_b3_5 XI1_I1158_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1158_MP5 (I1_b13_30 XI1_I1158_Bn XI1_I1158_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1158_MP4 (XI1_I1158_p1 XI1_I1158_An I1_b13_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1158_MP2 (VDD I1_dd30_b3_2 XI1_I1158_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1158_MP3 (XI1_I1158_p1 I1_qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1158_MP0 (VDD I1_dd30_b3_2 XI1_I1158_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1154_MP1 (VDD I1_qu19_b3_4 XI1_I1154_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1154_MP5 (I1_b13_26 XI1_I1154_Bn XI1_I1154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1154_MP4 (XI1_I1154_p1 XI1_I1154_An I1_b13_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1154_MP2 (VDD I1_dd26_b3_2 XI1_I1154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1154_MP3 (XI1_I1154_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1154_MP0 (VDD I1_dd26_b3_2 XI1_I1154_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1152_MP1 (VDD I1_qu19_b3_4 XI1_I1152_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1152_MP5 (I1_b13_24 XI1_I1152_Bn XI1_I1152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1152_MP4 (XI1_I1152_p1 XI1_I1152_An I1_b13_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1152_MP2 (VDD I1_dd24_b3_2 XI1_I1152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1152_MP3 (XI1_I1152_p1 I1_qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1152_MP0 (VDD I1_dd24_b3_2 XI1_I1152_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1129_MP1 (VDD I1_qu19_b3_0 XI1_I1129_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1129_MP5 (I1_b13_1 XI1_I1129_Bn XI1_I1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1129_MP4 (XI1_I1129_p1 XI1_I1129_An I1_b13_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1129_MP2 (VDD I1_dd1_b3_2 XI1_I1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1129_MP3 (XI1_I1129_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1129_MP0 (VDD I1_dd1_b3_2 XI1_I1129_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1128_MP1 (VDD I1_qu19_b3_0 XI1_I1128_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1128_MP5 (I1_b13_0 XI1_I1128_Bn XI1_I1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1128_MP4 (XI1_I1128_p1 XI1_I1128_An I1_b13_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1128_MP2 (VDD I1_B_0_b3_2 XI1_I1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1128_MP3 (XI1_I1128_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1128_MP0 (VDD I1_B_0_b3_2 XI1_I1128_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I929_MP1 (VDD I1_qu24_b3_5 XI1_I929_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I929_MP5 (I1_b8_31 XI1_I929_Bn XI1_I929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I929_MP4 (XI1_I929_p1 XI1_I929_An I1_b8_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I929_MP2 (VDD I1_dd31_b3_1 XI1_I929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I929_MP3 (XI1_I929_p1 I1_qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I929_MP0 (VDD I1_dd31_b3_1 XI1_I929_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I928_MP1 (VDD I1_qu24_b3_5 XI1_I928_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I928_MP5 (I1_b8_30 XI1_I928_Bn XI1_I928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I928_MP4 (XI1_I928_p1 XI1_I928_An I1_b8_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I928_MP2 (VDD I1_dd30_b3_1 XI1_I928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I928_MP3 (XI1_I928_p1 I1_qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I928_MP0 (VDD I1_dd30_b3_1 XI1_I928_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I217_MP1 (VDD I1_I930_G13_0n XI1_I930_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I217_MP5 (I1_p8_14 XI1_I930_I217_Bn XI1_I930_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I217_MP4 (XI1_I930_I217_p1 XI1_I930_I217_An I1_p8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I217_MP2 (VDD I1_I930_pn14 XI1_I930_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I217_MP3 (XI1_I930_I217_p1 I1_I930_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I217_MP0 (VDD I1_I930_pn14 XI1_I930_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I215_MP1 (VDD I1_I930_G11_0n XI1_I930_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I215_MP5 (I1_p8_12 XI1_I930_I215_Bn XI1_I930_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I215_MP4 (XI1_I930_I215_p1 XI1_I930_I215_An I1_p8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I215_MP2 (VDD I1_I930_pn12 XI1_I930_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I215_MP3 (XI1_I930_I215_p1 I1_I930_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I215_MP0 (VDD I1_I930_pn12 XI1_I930_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I902_MP1 (VDD I1_qu24_b3_0 XI1_I902_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I902_MP5 (I1_b8_4 XI1_I902_Bn XI1_I902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I902_MP4 (XI1_I902_p1 XI1_I902_An I1_b8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I902_MP2 (VDD I1_dd4_b3_1 XI1_I902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I902_MP3 (XI1_I902_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I902_MP0 (VDD I1_dd4_b3_1 XI1_I902_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I901_MP1 (VDD I1_qu24_b3_0 XI1_I901_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I901_MP5 (I1_b8_3 XI1_I901_Bn XI1_I901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I901_MP4 (XI1_I901_p1 XI1_I901_An I1_b8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I901_MP2 (VDD I1_dd3_b3_1 XI1_I901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I901_MP3 (XI1_I901_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I901_MP0 (VDD I1_dd3_b3_1 XI1_I901_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I672_MP1 (VDD I1_qu29_b3_0 XI1_I672_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I672_MP5 (I1_b3_4 XI1_I672_Bn XI1_I672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I672_MP4 (XI1_I672_p1 XI1_I672_An I1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I672_MP2 (VDD I1_dd4_b3_0 XI1_I672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I672_MP3 (XI1_I672_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I672_MP0 (VDD I1_dd4_b3_0 XI1_I672_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I674_MP1 (VDD I1_qu29_b3_1 XI1_I674_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I674_MP5 (I1_b3_6 XI1_I674_Bn XI1_I674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I674_MP4 (XI1_I674_p1 XI1_I674_An I1_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I674_MP2 (VDD I1_dd6_b3_0 XI1_I674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I674_MP3 (XI1_I674_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I674_MP0 (VDD I1_dd6_b3_0 XI1_I674_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I675_MP1 (VDD I1_qu29_b3_1 XI1_I675_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I675_MP5 (I1_b3_7 XI1_I675_Bn XI1_I675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I675_MP4 (XI1_I675_p1 XI1_I675_An I1_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I675_MP2 (VDD I1_dd7_b3_0 XI1_I675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I675_MP3 (XI1_I675_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I675_MP0 (VDD I1_dd7_b3_0 XI1_I675_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I676_MP1 (VDD I1_qu29_b3_1 XI1_I676_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I676_MP5 (I1_b3_8 XI1_I676_Bn XI1_I676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I676_MP4 (XI1_I676_p1 XI1_I676_An I1_b3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I676_MP2 (VDD I1_dd8_b3_0 XI1_I676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I676_MP3 (XI1_I676_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I676_MP0 (VDD I1_dd8_b3_0 XI1_I676_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I677_MP1 (VDD I1_qu29_b3_1 XI1_I677_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I677_MP5 (I1_b3_9 XI1_I677_Bn XI1_I677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I677_MP4 (XI1_I677_p1 XI1_I677_An I1_b3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I677_MP2 (VDD I1_dd9_b3_0 XI1_I677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I677_MP3 (XI1_I677_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I677_MP0 (VDD I1_dd9_b3_0 XI1_I677_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I679_MP1 (VDD I1_qu29_b3_1 XI1_I679_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I679_MP5 (I1_b3_11 XI1_I679_Bn XI1_I679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I679_MP4 (XI1_I679_p1 XI1_I679_An I1_b3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I679_MP2 (VDD I1_dd11_b3_0 XI1_I679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I679_MP3 (XI1_I679_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I679_MP0 (VDD I1_dd11_b3_0 XI1_I679_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I680_MP1 (VDD I1_qu29_b3_2 XI1_I680_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I680_MP5 (I1_b3_12 XI1_I680_Bn XI1_I680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I680_MP4 (XI1_I680_p1 XI1_I680_An I1_b3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I680_MP2 (VDD I1_dd12_b3_0 XI1_I680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I680_MP3 (XI1_I680_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I680_MP0 (VDD I1_dd12_b3_0 XI1_I680_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I681_MP1 (VDD I1_qu29_b3_2 XI1_I681_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I681_MP5 (I1_b3_13 XI1_I681_Bn XI1_I681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I681_MP4 (XI1_I681_p1 XI1_I681_An I1_b3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I681_MP2 (VDD I1_dd13_b3_0 XI1_I681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I681_MP3 (XI1_I681_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I681_MP0 (VDD I1_dd13_b3_0 XI1_I681_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I682_MP1 (VDD I1_qu29_b3_2 XI1_I682_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I682_MP5 (I1_b3_14 XI1_I682_Bn XI1_I682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I682_MP4 (XI1_I682_p1 XI1_I682_An I1_b3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I682_MP2 (VDD I1_dd14_b3_0 XI1_I682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I682_MP3 (XI1_I682_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I682_MP0 (VDD I1_dd14_b3_0 XI1_I682_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I683_MP1 (VDD I1_qu29_b3_2 XI1_I683_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I683_MP5 (I1_b3_15 XI1_I683_Bn XI1_I683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I683_MP4 (XI1_I683_p1 XI1_I683_An I1_b3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I683_MP2 (VDD I1_dd15_b3_0 XI1_I683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I683_MP3 (XI1_I683_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I683_MP0 (VDD I1_dd15_b3_0 XI1_I683_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I684_MP1 (VDD I1_qu29_b3_2 XI1_I684_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I684_MP5 (I1_b3_16 XI1_I684_Bn XI1_I684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I684_MP4 (XI1_I684_p1 XI1_I684_An I1_b3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I684_MP2 (VDD I1_dd16_b3_0 XI1_I684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I684_MP3 (XI1_I684_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I684_MP0 (VDD I1_dd16_b3_0 XI1_I684_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I685_MP1 (VDD I1_qu29_b3_2 XI1_I685_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I685_MP5 (I1_b3_17 XI1_I685_Bn XI1_I685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I685_MP4 (XI1_I685_p1 XI1_I685_An I1_b3_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I685_MP2 (VDD I1_dd17_b3_0 XI1_I685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I685_MP3 (XI1_I685_p1 I1_qu29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I685_MP0 (VDD I1_dd17_b3_0 XI1_I685_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I686_MP1 (VDD I1_qu29_b3_3 XI1_I686_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I686_MP5 (I1_b3_18 XI1_I686_Bn XI1_I686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I686_MP4 (XI1_I686_p1 XI1_I686_An I1_b3_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I686_MP2 (VDD I1_dd18_b3_0 XI1_I686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I686_MP3 (XI1_I686_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I686_MP0 (VDD I1_dd18_b3_0 XI1_I686_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I687_MP1 (VDD I1_qu29_b3_3 XI1_I687_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I687_MP5 (I1_b3_19 XI1_I687_Bn XI1_I687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I687_MP4 (XI1_I687_p1 XI1_I687_An I1_b3_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I687_MP2 (VDD I1_dd19_b3_0 XI1_I687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I687_MP3 (XI1_I687_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I687_MP0 (VDD I1_dd19_b3_0 XI1_I687_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I688_MP1 (VDD I1_qu29_b3_3 XI1_I688_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I688_MP5 (I1_b3_20 XI1_I688_Bn XI1_I688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I688_MP4 (XI1_I688_p1 XI1_I688_An I1_b3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I688_MP2 (VDD I1_dd20_b3_0 XI1_I688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I688_MP3 (XI1_I688_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I688_MP0 (VDD I1_dd20_b3_0 XI1_I688_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I690_MP1 (VDD I1_qu29_b3_3 XI1_I690_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I690_MP5 (I1_b3_22 XI1_I690_Bn XI1_I690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I690_MP4 (XI1_I690_p1 XI1_I690_An I1_b3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I690_MP2 (VDD I1_dd22_b3_0 XI1_I690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I690_MP3 (XI1_I690_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I690_MP0 (VDD I1_dd22_b3_0 XI1_I690_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I691_MP1 (VDD I1_qu29_b3_3 XI1_I691_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I691_MP5 (I1_b3_23 XI1_I691_Bn XI1_I691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I691_MP4 (XI1_I691_p1 XI1_I691_An I1_b3_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I691_MP2 (VDD I1_dd23_b3_0 XI1_I691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I691_MP3 (XI1_I691_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I691_MP0 (VDD I1_dd23_b3_0 XI1_I691_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I692_MP1 (VDD I1_qu29_b3_4 XI1_I692_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I692_MP5 (I1_b3_24 XI1_I692_Bn XI1_I692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I692_MP4 (XI1_I692_p1 XI1_I692_An I1_b3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I692_MP2 (VDD I1_dd24_b3_0 XI1_I692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I692_MP3 (XI1_I692_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I692_MP0 (VDD I1_dd24_b3_0 XI1_I692_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I694_MP1 (VDD I1_qu29_b3_4 XI1_I694_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I694_MP5 (I1_b3_26 XI1_I694_Bn XI1_I694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I694_MP4 (XI1_I694_p1 XI1_I694_An I1_b3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I694_MP2 (VDD I1_dd26_b3_0 XI1_I694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I694_MP3 (XI1_I694_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I694_MP0 (VDD I1_dd26_b3_0 XI1_I694_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I697_MP1 (VDD I1_qu29_b3_4 XI1_I697_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I697_MP5 (I1_b3_29 XI1_I697_Bn XI1_I697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I697_MP4 (XI1_I697_p1 XI1_I697_An I1_b3_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I697_MP2 (VDD I1_dd29_b3_0 XI1_I697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I697_MP3 (XI1_I697_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I697_MP0 (VDD I1_dd29_b3_0 XI1_I697_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1431_MP1 (VDD I1_qu13_b3_4 XI1_I1431_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1431_MP5 (I1_b19_27 XI1_I1431_Bn XI1_I1431_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1431_MP4 (XI1_I1431_p1 XI1_I1431_An I1_b19_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1431_MP2 (VDD I1_dd27_b3_3 XI1_I1431_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1431_MP3 (XI1_I1431_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1431_MP0 (VDD I1_dd27_b3_3 XI1_I1431_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1432_MP1 (VDD I1_qu13_b3_4 XI1_I1432_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1432_MP5 (I1_b19_28 XI1_I1432_Bn XI1_I1432_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1432_MP4 (XI1_I1432_p1 XI1_I1432_An I1_b19_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1432_MP2 (VDD I1_dd28_b3_3 XI1_I1432_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1432_MP3 (XI1_I1432_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1432_MP0 (VDD I1_dd28_b3_3 XI1_I1432_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1429_MP1 (VDD I1_qu13_b3_4 XI1_I1429_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1429_MP5 (I1_b19_25 XI1_I1429_Bn XI1_I1429_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1429_MP4 (XI1_I1429_p1 XI1_I1429_An I1_b19_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1429_MP2 (VDD I1_dd25_b3_3 XI1_I1429_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1429_MP3 (XI1_I1429_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1429_MP0 (VDD I1_dd25_b3_3 XI1_I1429_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1427_MP1 (VDD I1_qu13_b3_3 XI1_I1427_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1427_MP5 (I1_b19_23 XI1_I1427_Bn XI1_I1427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1427_MP4 (XI1_I1427_p1 XI1_I1427_An I1_b19_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1427_MP2 (VDD I1_dd23_b3_3 XI1_I1427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1427_MP3 (XI1_I1427_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1427_MP0 (VDD I1_dd23_b3_3 XI1_I1427_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1425_MP1 (VDD I1_qu13_b3_3 XI1_I1425_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1425_MP5 (I1_b19_21 XI1_I1425_Bn XI1_I1425_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1425_MP4 (XI1_I1425_p1 XI1_I1425_An I1_b19_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1425_MP2 (VDD I1_dd21_b3_3 XI1_I1425_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1425_MP3 (XI1_I1425_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1425_MP0 (VDD I1_dd21_b3_3 XI1_I1425_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1423_MP1 (VDD I1_qu13_b3_3 XI1_I1423_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1423_MP5 (I1_b19_19 XI1_I1423_Bn XI1_I1423_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1423_MP4 (XI1_I1423_p1 XI1_I1423_An I1_b19_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1423_MP2 (VDD I1_dd19_b3_3 XI1_I1423_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1423_MP3 (XI1_I1423_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1423_MP0 (VDD I1_dd19_b3_3 XI1_I1423_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I216_MP1 (VDD I1_I1390_G12_0n XI1_I1390_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I216_MP5 (I1_p18_13 XI1_I1390_I216_Bn XI1_I1390_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I216_MP4 (XI1_I1390_I216_p1 XI1_I1390_I216_An I1_p18_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I216_MP2 (VDD I1_I1390_pn13 XI1_I1390_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I216_MP3 (XI1_I1390_I216_p1 I1_I1390_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I216_MP0 (VDD I1_I1390_pn13 XI1_I1390_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1421_MP1 (VDD I1_qu13_b3_2 XI1_I1421_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1421_MP5 (I1_b19_17 XI1_I1421_Bn XI1_I1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1421_MP4 (XI1_I1421_p1 XI1_I1421_An I1_b19_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1421_MP2 (VDD I1_dd17_b3_3 XI1_I1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1421_MP3 (XI1_I1421_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1421_MP0 (VDD I1_dd17_b3_3 XI1_I1421_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I214_MP1 (VDD I1_I1390_G10_0n XI1_I1390_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I214_MP5 (I1_p18_11 XI1_I1390_I214_Bn XI1_I1390_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I214_MP4 (XI1_I1390_I214_p1 XI1_I1390_I214_An I1_p18_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I214_MP2 (VDD I1_I1390_pn11 XI1_I1390_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I214_MP3 (XI1_I1390_I214_p1 I1_I1390_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I214_MP0 (VDD I1_I1390_pn11 XI1_I1390_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1417_MP1 (VDD I1_qu13_b3_2 XI1_I1417_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1417_MP5 (I1_b19_13 XI1_I1417_Bn XI1_I1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1417_MP4 (XI1_I1417_p1 XI1_I1417_An I1_b19_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1417_MP2 (VDD I1_dd13_b3_3 XI1_I1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1417_MP3 (XI1_I1417_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1417_MP0 (VDD I1_dd13_b3_3 XI1_I1417_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1415_MP1 (VDD I1_qu13_b3_1 XI1_I1415_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1415_MP5 (I1_b19_11 XI1_I1415_Bn XI1_I1415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1415_MP4 (XI1_I1415_p1 XI1_I1415_An I1_b19_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1415_MP2 (VDD I1_dd11_b3_3 XI1_I1415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1415_MP3 (XI1_I1415_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1415_MP0 (VDD I1_dd11_b3_3 XI1_I1415_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I207_MP1 (VDD I1_I1390_G3_0n XI1_I1390_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I207_MP5 (I1_p18_4 XI1_I1390_I207_Bn XI1_I1390_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I207_MP4 (XI1_I1390_I207_p1 XI1_I1390_I207_An I1_p18_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I207_MP2 (VDD I1_I1390_pn4 XI1_I1390_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I207_MP3 (XI1_I1390_I207_p1 I1_I1390_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I207_MP0 (VDD I1_I1390_pn4 XI1_I1390_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1110_MP1 (VDD I1_qu20_b3_4 XI1_I1110_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1110_MP5 (I1_b12_28 XI1_I1110_Bn XI1_I1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1110_MP4 (XI1_I1110_p1 XI1_I1110_An I1_b12_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1110_MP2 (VDD I1_dd28_b3_2 XI1_I1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1110_MP3 (XI1_I1110_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1110_MP0 (VDD I1_dd28_b3_2 XI1_I1110_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1109_MP1 (VDD I1_qu20_b3_4 XI1_I1109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1109_MP5 (I1_b12_27 XI1_I1109_Bn XI1_I1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1109_MP4 (XI1_I1109_p1 XI1_I1109_An I1_b12_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1109_MP2 (VDD I1_dd27_b3_2 XI1_I1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1109_MP3 (XI1_I1109_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1109_MP0 (VDD I1_dd27_b3_2 XI1_I1109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1111_MP1 (VDD I1_qu20_b3_4 XI1_I1111_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1111_MP5 (I1_b12_29 XI1_I1111_Bn XI1_I1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1111_MP4 (XI1_I1111_p1 XI1_I1111_An I1_b12_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1111_MP2 (VDD I1_dd29_b3_2 XI1_I1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1111_MP3 (XI1_I1111_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1111_MP0 (VDD I1_dd29_b3_2 XI1_I1111_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1151_MP1 (VDD I1_qu19_b3_3 XI1_I1151_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1151_MP5 (I1_b13_23 XI1_I1151_Bn XI1_I1151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1151_MP4 (XI1_I1151_p1 XI1_I1151_An I1_b13_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1151_MP2 (VDD I1_dd23_b3_2 XI1_I1151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1151_MP3 (XI1_I1151_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1151_MP0 (VDD I1_dd23_b3_2 XI1_I1151_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1149_MP1 (VDD I1_qu19_b3_3 XI1_I1149_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1149_MP5 (I1_b13_21 XI1_I1149_Bn XI1_I1149_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1149_MP4 (XI1_I1149_p1 XI1_I1149_An I1_b13_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1149_MP2 (VDD I1_dd21_b3_2 XI1_I1149_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1149_MP3 (XI1_I1149_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1149_MP0 (VDD I1_dd21_b3_2 XI1_I1149_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1132_MP1 (VDD I1_qu19_b3_0 XI1_I1132_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1132_MP5 (I1_b13_4 XI1_I1132_Bn XI1_I1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1132_MP4 (XI1_I1132_p1 XI1_I1132_An I1_b13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1132_MP2 (VDD I1_dd4_b3_2 XI1_I1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1132_MP3 (XI1_I1132_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1132_MP0 (VDD I1_dd4_b3_2 XI1_I1132_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1065_MP1 (VDD I1_qu21_b3_4 XI1_I1065_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1065_MP5 (I1_b11_29 XI1_I1065_Bn XI1_I1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1065_MP4 (XI1_I1065_p1 XI1_I1065_An I1_b11_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1065_MP2 (VDD I1_dd29_b3_2 XI1_I1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1065_MP3 (XI1_I1065_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1065_MP0 (VDD I1_dd29_b3_2 XI1_I1065_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1063_MP1 (VDD I1_qu21_b3_4 XI1_I1063_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1063_MP5 (I1_b11_27 XI1_I1063_Bn XI1_I1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1063_MP4 (XI1_I1063_p1 XI1_I1063_An I1_b11_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1063_MP2 (VDD I1_dd27_b3_2 XI1_I1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1063_MP3 (XI1_I1063_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1063_MP0 (VDD I1_dd27_b3_2 XI1_I1063_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1131_MP1 (VDD I1_qu19_b3_0 XI1_I1131_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1131_MP5 (I1_b13_3 XI1_I1131_Bn XI1_I1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1131_MP4 (XI1_I1131_p1 XI1_I1131_An I1_b13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1131_MP2 (VDD I1_dd3_b3_2 XI1_I1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1131_MP3 (XI1_I1131_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1131_MP0 (VDD I1_dd3_b3_2 XI1_I1131_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1130_MP1 (VDD I1_qu19_b3_0 XI1_I1130_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1130_MP5 (I1_b13_2 XI1_I1130_Bn XI1_I1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1130_MP4 (XI1_I1130_p1 XI1_I1130_An I1_b13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1130_MP2 (VDD I1_dd2_b3_2 XI1_I1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1130_MP3 (XI1_I1130_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1130_MP0 (VDD I1_dd2_b3_2 XI1_I1130_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I973_MP1 (VDD I1_qu23_b3_4 XI1_I973_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I973_MP5 (I1_b9_29 XI1_I973_Bn XI1_I973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I973_MP4 (XI1_I973_p1 XI1_I973_An I1_b9_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I973_MP2 (VDD I1_dd29_b3_1 XI1_I973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I973_MP3 (XI1_I973_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I973_MP0 (VDD I1_dd29_b3_1 XI1_I973_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I971_MP1 (VDD I1_qu23_b3_4 XI1_I971_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I971_MP5 (I1_b9_27 XI1_I971_Bn XI1_I971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I971_MP4 (XI1_I971_p1 XI1_I971_An I1_b9_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I971_MP2 (VDD I1_dd27_b3_1 XI1_I971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I971_MP3 (XI1_I971_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I971_MP0 (VDD I1_dd27_b3_1 XI1_I971_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I214_MP1 (VDD I1_I930_G10_0n XI1_I930_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I214_MP5 (I1_p8_11 XI1_I930_I214_Bn XI1_I930_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I214_MP4 (XI1_I930_I214_p1 XI1_I930_I214_An I1_p8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I214_MP2 (VDD I1_I930_pn11 XI1_I930_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I214_MP3 (XI1_I930_I214_p1 I1_I930_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I214_MP0 (VDD I1_I930_pn11 XI1_I930_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I213_MP1 (VDD I1_I930_G9_0n XI1_I930_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I213_MP5 (I1_p8_10 XI1_I930_I213_Bn XI1_I930_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I213_MP4 (XI1_I930_I213_p1 XI1_I930_I213_An I1_p8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I213_MP2 (VDD I1_I930_pn10 XI1_I930_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I213_MP3 (XI1_I930_I213_p1 I1_I930_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I213_MP0 (VDD I1_I930_pn10 XI1_I930_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I207_MP1 (VDD I1_I930_G3_0n XI1_I930_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I207_MP5 (I1_p8_4 XI1_I930_I207_Bn XI1_I930_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I207_MP4 (XI1_I930_I207_p1 XI1_I930_I207_An I1_p8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I207_MP2 (VDD I1_I930_pn4 XI1_I930_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I207_MP3 (XI1_I930_I207_p1 I1_I930_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I207_MP0 (VDD I1_I930_pn4 XI1_I930_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I668_MP1 (VDD I1_qu29_b3_0 XI1_I668_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I668_MP5 (I1_b3_0 XI1_I668_Bn XI1_I668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I668_MP4 (XI1_I668_p1 XI1_I668_An I1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I668_MP2 (VDD I1_B_0_b3_0 XI1_I668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I668_MP3 (XI1_I668_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I668_MP0 (VDD I1_B_0_b3_0 XI1_I668_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I673_MP1 (VDD I1_qu29_b3_0 XI1_I673_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I673_MP5 (I1_b3_5 XI1_I673_Bn XI1_I673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I673_MP4 (XI1_I673_p1 XI1_I673_An I1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I673_MP2 (VDD I1_dd5_b3_0 XI1_I673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I673_MP3 (XI1_I673_p1 I1_qu29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I673_MP0 (VDD I1_dd5_b3_0 XI1_I673_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I207_MP1 (VDD I1_I654_G3_0n XI1_I654_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I207_MP5 (I1_p2_4 XI1_I654_I207_Bn XI1_I654_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I207_MP4 (XI1_I654_I207_p1 XI1_I654_I207_An I1_p2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I207_MP2 (VDD I1_I654_pn4 XI1_I654_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I207_MP3 (XI1_I654_I207_p1 I1_I654_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I207_MP0 (VDD I1_I654_pn4 XI1_I654_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I678_MP1 (VDD I1_qu29_b3_1 XI1_I678_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I678_MP5 (I1_b3_10 XI1_I678_Bn XI1_I678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I678_MP4 (XI1_I678_p1 XI1_I678_An I1_b3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I678_MP2 (VDD I1_dd10_b3_0 XI1_I678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I678_MP3 (XI1_I678_p1 I1_qu29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I678_MP0 (VDD I1_dd10_b3_0 XI1_I678_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I215_MP1 (VDD I1_I654_G11_0n XI1_I654_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I215_MP5 (I1_p2_12 XI1_I654_I215_Bn XI1_I654_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I215_MP4 (XI1_I654_I215_p1 XI1_I654_I215_An I1_p2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I215_MP2 (VDD I1_I654_pn12 XI1_I654_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I215_MP3 (XI1_I654_I215_p1 I1_I654_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I215_MP0 (VDD I1_I654_pn12 XI1_I654_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I217_MP1 (VDD I1_I654_G13_0n XI1_I654_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I217_MP5 (I1_p2_14 XI1_I654_I217_Bn XI1_I654_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I217_MP4 (XI1_I654_I217_p1 XI1_I654_I217_An I1_p2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I217_MP2 (VDD I1_I654_pn14 XI1_I654_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I217_MP3 (XI1_I654_I217_p1 I1_I654_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I217_MP0 (VDD I1_I654_pn14 XI1_I654_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I689_MP1 (VDD I1_qu29_b3_3 XI1_I689_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I689_MP5 (I1_b3_21 XI1_I689_Bn XI1_I689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I689_MP4 (XI1_I689_p1 XI1_I689_An I1_b3_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I689_MP2 (VDD I1_dd21_b3_0 XI1_I689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I689_MP3 (XI1_I689_p1 I1_qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I689_MP0 (VDD I1_dd21_b3_0 XI1_I689_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I693_MP1 (VDD I1_qu29_b3_4 XI1_I693_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I693_MP5 (I1_b3_25 XI1_I693_Bn XI1_I693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I693_MP4 (XI1_I693_p1 XI1_I693_An I1_b3_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I693_MP2 (VDD I1_dd25_b3_0 XI1_I693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I693_MP3 (XI1_I693_p1 I1_qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I693_MP0 (VDD I1_dd25_b3_0 XI1_I693_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I698_MP1 (VDD I1_qu29_b3_5 XI1_I698_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I698_MP5 (I1_b3_30 XI1_I698_Bn XI1_I698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I698_MP4 (XI1_I698_p1 XI1_I698_An I1_b3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I698_MP2 (VDD I1_dd30_b3_0 XI1_I698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I698_MP3 (XI1_I698_p1 I1_qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I698_MP0 (VDD I1_dd30_b3_0 XI1_I698_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1430_MP1 (VDD I1_qu13_b3_4 XI1_I1430_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1430_MP5 (I1_b19_26 XI1_I1430_Bn XI1_I1430_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1430_MP4 (XI1_I1430_p1 XI1_I1430_An I1_b19_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1430_MP2 (VDD I1_dd26_b3_3 XI1_I1430_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1430_MP3 (XI1_I1430_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1430_MP0 (VDD I1_dd26_b3_3 XI1_I1430_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1433_MP1 (VDD I1_qu13_b3_4 XI1_I1433_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1433_MP5 (I1_b19_29 XI1_I1433_Bn XI1_I1433_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1433_MP4 (XI1_I1433_p1 XI1_I1433_An I1_b19_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1433_MP2 (VDD I1_dd29_b3_3 XI1_I1433_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1433_MP3 (XI1_I1433_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1433_MP0 (VDD I1_dd29_b3_3 XI1_I1433_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1428_MP1 (VDD I1_qu13_b3_4 XI1_I1428_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1428_MP5 (I1_b19_24 XI1_I1428_Bn XI1_I1428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1428_MP4 (XI1_I1428_p1 XI1_I1428_An I1_b19_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1428_MP2 (VDD I1_dd24_b3_3 XI1_I1428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1428_MP3 (XI1_I1428_p1 I1_qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1428_MP0 (VDD I1_dd24_b3_3 XI1_I1428_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1426_MP1 (VDD I1_qu13_b3_3 XI1_I1426_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1426_MP5 (I1_b19_22 XI1_I1426_Bn XI1_I1426_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1426_MP4 (XI1_I1426_p1 XI1_I1426_An I1_b19_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1426_MP2 (VDD I1_dd22_b3_3 XI1_I1426_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1426_MP3 (XI1_I1426_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1426_MP0 (VDD I1_dd22_b3_3 XI1_I1426_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1422_MP1 (VDD I1_qu13_b3_3 XI1_I1422_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1422_MP5 (I1_b19_18 XI1_I1422_Bn XI1_I1422_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1422_MP4 (XI1_I1422_p1 XI1_I1422_An I1_b19_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1422_MP2 (VDD I1_dd18_b3_3 XI1_I1422_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1422_MP3 (XI1_I1422_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1422_MP0 (VDD I1_dd18_b3_3 XI1_I1422_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1424_MP1 (VDD I1_qu13_b3_3 XI1_I1424_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1424_MP5 (I1_b19_20 XI1_I1424_Bn XI1_I1424_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1424_MP4 (XI1_I1424_p1 XI1_I1424_An I1_b19_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1424_MP2 (VDD I1_dd20_b3_3 XI1_I1424_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1424_MP3 (XI1_I1424_p1 I1_qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1424_MP0 (VDD I1_dd20_b3_3 XI1_I1424_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1419_MP1 (VDD I1_qu13_b3_2 XI1_I1419_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1419_MP5 (I1_b19_15 XI1_I1419_Bn XI1_I1419_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1419_MP4 (XI1_I1419_p1 XI1_I1419_An I1_b19_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1419_MP2 (VDD I1_dd15_b3_3 XI1_I1419_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1419_MP3 (XI1_I1419_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1419_MP0 (VDD I1_dd15_b3_3 XI1_I1419_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1420_MP1 (VDD I1_qu13_b3_2 XI1_I1420_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1420_MP5 (I1_b19_16 XI1_I1420_Bn XI1_I1420_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1420_MP4 (XI1_I1420_p1 XI1_I1420_An I1_b19_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1420_MP2 (VDD I1_dd16_b3_3 XI1_I1420_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1420_MP3 (XI1_I1420_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1420_MP0 (VDD I1_dd16_b3_3 XI1_I1420_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1418_MP1 (VDD I1_qu13_b3_2 XI1_I1418_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1418_MP5 (I1_b19_14 XI1_I1418_Bn XI1_I1418_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1418_MP4 (XI1_I1418_p1 XI1_I1418_An I1_b19_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1418_MP2 (VDD I1_dd14_b3_3 XI1_I1418_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1418_MP3 (XI1_I1418_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1418_MP0 (VDD I1_dd14_b3_3 XI1_I1418_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1416_MP1 (VDD I1_qu13_b3_2 XI1_I1416_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1416_MP5 (I1_b19_12 XI1_I1416_Bn XI1_I1416_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1416_MP4 (XI1_I1416_p1 XI1_I1416_An I1_b19_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1416_MP2 (VDD I1_dd12_b3_3 XI1_I1416_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1416_MP3 (XI1_I1416_p1 I1_qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1416_MP0 (VDD I1_dd12_b3_3 XI1_I1416_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1412_MP1 (VDD I1_qu13_b3_1 XI1_I1412_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1412_MP5 (I1_b19_8 XI1_I1412_Bn XI1_I1412_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1412_MP4 (XI1_I1412_p1 XI1_I1412_An I1_b19_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1412_MP2 (VDD I1_dd8_b3_3 XI1_I1412_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1412_MP3 (XI1_I1412_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1412_MP0 (VDD I1_dd8_b3_3 XI1_I1412_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1414_MP1 (VDD I1_qu13_b3_1 XI1_I1414_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1414_MP5 (I1_b19_10 XI1_I1414_Bn XI1_I1414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1414_MP4 (XI1_I1414_p1 XI1_I1414_An I1_b19_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1414_MP2 (VDD I1_dd10_b3_3 XI1_I1414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1414_MP3 (XI1_I1414_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1414_MP0 (VDD I1_dd10_b3_3 XI1_I1414_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1411_MP1 (VDD I1_qu13_b3_1 XI1_I1411_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1411_MP5 (I1_b19_7 XI1_I1411_Bn XI1_I1411_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1411_MP4 (XI1_I1411_p1 XI1_I1411_An I1_b19_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1411_MP2 (VDD I1_dd7_b3_3 XI1_I1411_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1411_MP3 (XI1_I1411_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1411_MP0 (VDD I1_dd7_b3_3 XI1_I1411_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1410_MP1 (VDD I1_qu13_b3_1 XI1_I1410_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1410_MP5 (I1_b19_6 XI1_I1410_Bn XI1_I1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1410_MP4 (XI1_I1410_p1 XI1_I1410_An I1_b19_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1410_MP2 (VDD I1_dd6_b3_3 XI1_I1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1410_MP3 (XI1_I1410_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1410_MP0 (VDD I1_dd6_b3_3 XI1_I1410_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I206_MP1 (VDD I1_I1390_G2_0n XI1_I1390_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1390_I206_MP5 (I1_p18_3 XI1_I1390_I206_Bn XI1_I1390_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1390_I206_MP4 (XI1_I1390_I206_p1 XI1_I1390_I206_An I1_p18_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I206_MP2 (VDD I1_I1390_pn3 XI1_I1390_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1390_I206_MP3 (XI1_I1390_I206_p1 I1_I1390_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1390_I206_MP0 (VDD I1_I1390_pn3 XI1_I1390_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1408_MP1 (VDD I1_qu13_b3_0 XI1_I1408_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1408_MP5 (I1_b19_4 XI1_I1408_Bn XI1_I1408_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1408_MP4 (XI1_I1408_p1 XI1_I1408_An I1_b19_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1408_MP2 (VDD I1_dd4_b3_3 XI1_I1408_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1408_MP3 (XI1_I1408_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1408_MP0 (VDD I1_dd4_b3_3 XI1_I1408_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1358_MP1 (VDD I1_qu14_b3_0 XI1_I1358_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1358_MP5 (I1_b18_0 XI1_I1358_Bn XI1_I1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1358_MP4 (XI1_I1358_p1 XI1_I1358_An I1_b18_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1358_MP2 (VDD I1_B_0_b3_3 XI1_I1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1358_MP3 (XI1_I1358_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1358_MP0 (VDD I1_B_0_b3_3 XI1_I1358_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1359_MP1 (VDD I1_qu14_b3_0 XI1_I1359_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1359_MP5 (I1_b18_1 XI1_I1359_Bn XI1_I1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1359_MP4 (XI1_I1359_p1 XI1_I1359_An I1_b18_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1359_MP2 (VDD I1_dd1_b3_3 XI1_I1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1359_MP3 (XI1_I1359_p1 I1_qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1359_MP0 (VDD I1_dd1_b3_3 XI1_I1359_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1108_MP1 (VDD I1_qu20_b3_4 XI1_I1108_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1108_MP5 (I1_b12_26 XI1_I1108_Bn XI1_I1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1108_MP4 (XI1_I1108_p1 XI1_I1108_An I1_b12_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1108_MP2 (VDD I1_dd26_b3_2 XI1_I1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1108_MP3 (XI1_I1108_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1108_MP0 (VDD I1_dd26_b3_2 XI1_I1108_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1107_MP1 (VDD I1_qu20_b3_4 XI1_I1107_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1107_MP5 (I1_b12_25 XI1_I1107_Bn XI1_I1107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1107_MP4 (XI1_I1107_p1 XI1_I1107_An I1_b12_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1107_MP2 (VDD I1_dd25_b3_2 XI1_I1107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1107_MP3 (XI1_I1107_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1107_MP0 (VDD I1_dd25_b3_2 XI1_I1107_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1106_MP1 (VDD I1_qu20_b3_4 XI1_I1106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1106_MP5 (I1_b12_24 XI1_I1106_Bn XI1_I1106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1106_MP4 (XI1_I1106_p1 XI1_I1106_An I1_b12_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1106_MP2 (VDD I1_dd24_b3_2 XI1_I1106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1106_MP3 (XI1_I1106_p1 I1_qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1106_MP0 (VDD I1_dd24_b3_2 XI1_I1106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1150_MP1 (VDD I1_qu19_b3_3 XI1_I1150_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1150_MP5 (I1_b13_22 XI1_I1150_Bn XI1_I1150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1150_MP4 (XI1_I1150_p1 XI1_I1150_An I1_b13_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1150_MP2 (VDD I1_dd22_b3_2 XI1_I1150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1150_MP3 (XI1_I1150_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1150_MP0 (VDD I1_dd22_b3_2 XI1_I1150_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1161_MP1 (VDD I1_qu19_b3_5 XI1_I1161_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1161_MP5 (I1_h13 XI1_I1161_Bn XI1_I1161_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1161_MP4 (XI1_I1161_p1 XI1_I1161_An I1_h13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1161_MP2 (VDD I1_p12_31 XI1_I1161_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1161_MP3 (XI1_I1161_p1 I1_qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1161_MP0 (VDD I1_p12_31 XI1_I1161_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1148_MP1 (VDD I1_qu19_b3_3 XI1_I1148_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1148_MP5 (I1_b13_20 XI1_I1148_Bn XI1_I1148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1148_MP4 (XI1_I1148_p1 XI1_I1148_An I1_b13_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1148_MP2 (VDD I1_dd20_b3_2 XI1_I1148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1148_MP3 (XI1_I1148_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1148_MP0 (VDD I1_dd20_b3_2 XI1_I1148_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1147_MP1 (VDD I1_qu19_b3_3 XI1_I1147_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1147_MP5 (I1_b13_19 XI1_I1147_Bn XI1_I1147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1147_MP4 (XI1_I1147_p1 XI1_I1147_An I1_b13_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1147_MP2 (VDD I1_dd19_b3_2 XI1_I1147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1147_MP3 (XI1_I1147_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1147_MP0 (VDD I1_dd19_b3_2 XI1_I1147_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1146_MP1 (VDD I1_qu19_b3_3 XI1_I1146_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1146_MP5 (I1_b13_18 XI1_I1146_Bn XI1_I1146_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1146_MP4 (XI1_I1146_p1 XI1_I1146_An I1_b13_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1146_MP2 (VDD I1_dd18_b3_2 XI1_I1146_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1146_MP3 (XI1_I1146_p1 I1_qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1146_MP0 (VDD I1_dd18_b3_2 XI1_I1146_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1144_MP1 (VDD I1_qu19_b3_2 XI1_I1144_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1144_MP5 (I1_b13_16 XI1_I1144_Bn XI1_I1144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1144_MP4 (XI1_I1144_p1 XI1_I1144_An I1_b13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1144_MP2 (VDD I1_dd16_b3_2 XI1_I1144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1144_MP3 (XI1_I1144_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1144_MP0 (VDD I1_dd16_b3_2 XI1_I1144_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1138_MP1 (VDD I1_qu19_b3_1 XI1_I1138_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1138_MP5 (I1_b13_10 XI1_I1138_Bn XI1_I1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1138_MP4 (XI1_I1138_p1 XI1_I1138_An I1_b13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1138_MP2 (VDD I1_dd10_b3_2 XI1_I1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1138_MP3 (XI1_I1138_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1138_MP0 (VDD I1_dd10_b3_2 XI1_I1138_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1137_MP1 (VDD I1_qu19_b3_1 XI1_I1137_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1137_MP5 (I1_b13_9 XI1_I1137_Bn XI1_I1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1137_MP4 (XI1_I1137_p1 XI1_I1137_An I1_b13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1137_MP2 (VDD I1_dd9_b3_2 XI1_I1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1137_MP3 (XI1_I1137_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1137_MP0 (VDD I1_dd9_b3_2 XI1_I1137_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1134_MP1 (VDD I1_qu19_b3_1 XI1_I1134_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1134_MP5 (I1_b13_6 XI1_I1134_Bn XI1_I1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1134_MP4 (XI1_I1134_p1 XI1_I1134_An I1_b13_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1134_MP2 (VDD I1_dd6_b3_2 XI1_I1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1134_MP3 (XI1_I1134_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1134_MP0 (VDD I1_dd6_b3_2 XI1_I1134_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1133_MP1 (VDD I1_qu19_b3_0 XI1_I1133_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1133_MP5 (I1_b13_5 XI1_I1133_Bn XI1_I1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1133_MP4 (XI1_I1133_p1 XI1_I1133_An I1_b13_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1133_MP2 (VDD I1_dd5_b3_2 XI1_I1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1133_MP3 (XI1_I1133_p1 I1_qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1133_MP0 (VDD I1_dd5_b3_2 XI1_I1133_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1064_MP1 (VDD I1_qu21_b3_4 XI1_I1064_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1064_MP5 (I1_b11_28 XI1_I1064_Bn XI1_I1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1064_MP4 (XI1_I1064_p1 XI1_I1064_An I1_b11_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1064_MP2 (VDD I1_dd28_b3_2 XI1_I1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1064_MP3 (XI1_I1064_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1064_MP0 (VDD I1_dd28_b3_2 XI1_I1064_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1062_MP1 (VDD I1_qu21_b3_4 XI1_I1062_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1062_MP5 (I1_b11_26 XI1_I1062_Bn XI1_I1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1062_MP4 (XI1_I1062_p1 XI1_I1062_An I1_b11_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1062_MP2 (VDD I1_dd26_b3_2 XI1_I1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1062_MP3 (XI1_I1062_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1062_MP0 (VDD I1_dd26_b3_2 XI1_I1062_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1060_MP1 (VDD I1_qu21_b3_4 XI1_I1060_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1060_MP5 (I1_b11_24 XI1_I1060_Bn XI1_I1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1060_MP4 (XI1_I1060_p1 XI1_I1060_An I1_b11_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1060_MP2 (VDD I1_dd24_b3_2 XI1_I1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1060_MP3 (XI1_I1060_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1060_MP0 (VDD I1_dd24_b3_2 XI1_I1060_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1061_MP1 (VDD I1_qu21_b3_4 XI1_I1061_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1061_MP5 (I1_b11_25 XI1_I1061_Bn XI1_I1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1061_MP4 (XI1_I1061_p1 XI1_I1061_An I1_b11_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1061_MP2 (VDD I1_dd25_b3_2 XI1_I1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1061_MP3 (XI1_I1061_p1 I1_qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1061_MP0 (VDD I1_dd25_b3_2 XI1_I1061_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1017_MP1 (VDD I1_qu22_b3_4 XI1_I1017_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1017_MP5 (I1_b10_27 XI1_I1017_Bn XI1_I1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1017_MP4 (XI1_I1017_p1 XI1_I1017_An I1_b10_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1017_MP2 (VDD I1_dd27_b3_1 XI1_I1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1017_MP3 (XI1_I1017_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1017_MP0 (VDD I1_dd27_b3_1 XI1_I1017_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1019_MP1 (VDD I1_qu22_b3_4 XI1_I1019_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1019_MP5 (I1_b10_29 XI1_I1019_Bn XI1_I1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1019_MP4 (XI1_I1019_p1 XI1_I1019_An I1_b10_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1019_MP2 (VDD I1_dd29_b3_1 XI1_I1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1019_MP3 (XI1_I1019_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1019_MP0 (VDD I1_dd29_b3_1 XI1_I1019_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I972_MP1 (VDD I1_qu23_b3_4 XI1_I972_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I972_MP5 (I1_b9_28 XI1_I972_Bn XI1_I972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I972_MP4 (XI1_I972_p1 XI1_I972_An I1_b9_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I972_MP2 (VDD I1_dd28_b3_1 XI1_I972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I972_MP3 (XI1_I972_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I972_MP0 (VDD I1_dd28_b3_1 XI1_I972_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I968_MP1 (VDD I1_qu23_b3_4 XI1_I968_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I968_MP5 (I1_b9_24 XI1_I968_Bn XI1_I968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I968_MP4 (XI1_I968_p1 XI1_I968_An I1_b9_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I968_MP2 (VDD I1_dd24_b3_1 XI1_I968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I968_MP3 (XI1_I968_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I968_MP0 (VDD I1_dd24_b3_1 XI1_I968_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I977_MP1 (VDD I1_qu23_b3_5 XI1_I977_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I977_MP5 (I1_h9 XI1_I977_Bn XI1_I977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I977_MP4 (XI1_I977_p1 XI1_I977_An I1_h9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I977_MP2 (VDD I1_p8_31 XI1_I977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I977_MP3 (XI1_I977_p1 I1_qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I977_MP0 (VDD I1_p8_31 XI1_I977_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I212_MP1 (VDD I1_I930_G8_0n XI1_I930_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I212_MP5 (I1_p8_9 XI1_I930_I212_Bn XI1_I930_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I212_MP4 (XI1_I930_I212_p1 XI1_I930_I212_An I1_p8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I212_MP2 (VDD I1_I930_pn9 XI1_I930_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I212_MP3 (XI1_I930_I212_p1 I1_I930_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I212_MP0 (VDD I1_I930_pn9 XI1_I930_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I206_MP1 (VDD I1_I930_G2_0n XI1_I930_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I206_MP5 (I1_p8_3 XI1_I930_I206_Bn XI1_I930_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I206_MP4 (XI1_I930_I206_p1 XI1_I930_I206_An I1_p8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I206_MP2 (VDD I1_I930_pn3 XI1_I930_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I206_MP3 (XI1_I930_I206_p1 I1_I930_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I206_MP0 (VDD I1_I930_pn3 XI1_I930_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I206_MP1 (VDD I1_I654_G2_0n XI1_I654_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I206_MP5 (I1_p2_3 XI1_I654_I206_Bn XI1_I654_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I206_MP4 (XI1_I654_I206_p1 XI1_I654_I206_An I1_p2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I206_MP2 (VDD I1_I654_pn3 XI1_I654_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I206_MP3 (XI1_I654_I206_p1 I1_I654_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I206_MP0 (VDD I1_I654_pn3 XI1_I654_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I213_MP1 (VDD I1_I654_G9_0n XI1_I654_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I213_MP5 (I1_p2_10 XI1_I654_I213_Bn XI1_I654_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I213_MP4 (XI1_I654_I213_p1 XI1_I654_I213_An I1_p2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I213_MP2 (VDD I1_I654_pn10 XI1_I654_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I213_MP3 (XI1_I654_I213_p1 I1_I654_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I213_MP0 (VDD I1_I654_pn10 XI1_I654_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I219_MP1 (VDD I1_I654_G15_0n XI1_I654_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I219_MP5 (I1_p2_16 XI1_I654_I219_Bn XI1_I654_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I219_MP4 (XI1_I654_I219_p1 XI1_I654_I219_An I1_p2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I219_MP2 (VDD I1_I654_pn16 XI1_I654_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I219_MP3 (XI1_I654_I219_p1 I1_I654_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I219_MP0 (VDD I1_I654_pn16 XI1_I654_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I656_MP1 (VDD I1_c2_o XI1_I656_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I656_MP5 (I1_p2_32 XI1_I656_Bn XI1_I656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I656_MP4 (XI1_I656_p1 XI1_I656_An I1_p2_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I656_MP2 (VDD I1_h2 XI1_I656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I656_MP3 (XI1_I656_p1 I1_c2_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I656_MP0 (VDD I1_h2 XI1_I656_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I699_MP1 (VDD I1_qu29_b3_5 XI1_I699_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I699_MP5 (I1_b3_31 XI1_I699_Bn XI1_I699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I699_MP4 (XI1_I699_p1 XI1_I699_An I1_b3_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I699_MP2 (VDD I1_dd31_b3_0 XI1_I699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I699_MP3 (XI1_I699_p1 I1_qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I699_MP0 (VDD I1_dd31_b3_0 XI1_I699_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1413_MP1 (VDD I1_qu13_b3_1 XI1_I1413_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1413_MP5 (I1_b19_9 XI1_I1413_Bn XI1_I1413_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1413_MP4 (XI1_I1413_p1 XI1_I1413_An I1_b19_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1413_MP2 (VDD I1_dd9_b3_3 XI1_I1413_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1413_MP3 (XI1_I1413_p1 I1_qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1413_MP0 (VDD I1_dd9_b3_3 XI1_I1413_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1409_MP1 (VDD I1_qu13_b3_0 XI1_I1409_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1409_MP5 (I1_b19_5 XI1_I1409_Bn XI1_I1409_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1409_MP4 (XI1_I1409_p1 XI1_I1409_An I1_b19_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1409_MP2 (VDD I1_dd5_b3_3 XI1_I1409_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1409_MP3 (XI1_I1409_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1409_MP0 (VDD I1_dd5_b3_3 XI1_I1409_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1407_MP1 (VDD I1_qu13_b3_0 XI1_I1407_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1407_MP5 (I1_b19_3 XI1_I1407_Bn XI1_I1407_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1407_MP4 (XI1_I1407_p1 XI1_I1407_An I1_b19_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1407_MP2 (VDD I1_dd3_b3_3 XI1_I1407_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1407_MP3 (XI1_I1407_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1407_MP0 (VDD I1_dd3_b3_3 XI1_I1407_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1113_MP1 (VDD I1_qu20_b3_5 XI1_I1113_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1113_MP5 (I1_b12_31 XI1_I1113_Bn XI1_I1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1113_MP4 (XI1_I1113_p1 XI1_I1113_An I1_b12_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1113_MP2 (VDD I1_dd31_b3_2 XI1_I1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1113_MP3 (XI1_I1113_p1 I1_qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1113_MP0 (VDD I1_dd31_b3_2 XI1_I1113_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I218_MP1 (VDD I1_I1114_G14_0n XI1_I1114_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I218_MP5 (I1_p12_15 XI1_I1114_I218_Bn XI1_I1114_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I218_MP4 (XI1_I1114_I218_p1 XI1_I1114_I218_An I1_p12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I218_MP2 (VDD I1_I1114_pn15 XI1_I1114_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I218_MP3 (XI1_I1114_I218_p1 I1_I1114_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I218_MP0 (VDD I1_I1114_pn15 XI1_I1114_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1112_MP1 (VDD I1_qu20_b3_5 XI1_I1112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1112_MP5 (I1_b12_30 XI1_I1112_Bn XI1_I1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1112_MP4 (XI1_I1112_p1 XI1_I1112_An I1_b12_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1112_MP2 (VDD I1_dd30_b3_2 XI1_I1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1112_MP3 (XI1_I1112_p1 I1_qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1112_MP0 (VDD I1_dd30_b3_2 XI1_I1112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1145_MP1 (VDD I1_qu19_b3_2 XI1_I1145_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1145_MP5 (I1_b13_17 XI1_I1145_Bn XI1_I1145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1145_MP4 (XI1_I1145_p1 XI1_I1145_An I1_b13_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1145_MP2 (VDD I1_dd17_b3_2 XI1_I1145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1145_MP3 (XI1_I1145_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1145_MP0 (VDD I1_dd17_b3_2 XI1_I1145_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1142_MP1 (VDD I1_qu19_b3_2 XI1_I1142_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1142_MP5 (I1_b13_14 XI1_I1142_Bn XI1_I1142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1142_MP4 (XI1_I1142_p1 XI1_I1142_An I1_b13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1142_MP2 (VDD I1_dd14_b3_2 XI1_I1142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1142_MP3 (XI1_I1142_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1142_MP0 (VDD I1_dd14_b3_2 XI1_I1142_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1141_MP1 (VDD I1_qu19_b3_2 XI1_I1141_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1141_MP5 (I1_b13_13 XI1_I1141_Bn XI1_I1141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1141_MP4 (XI1_I1141_p1 XI1_I1141_An I1_b13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1141_MP2 (VDD I1_dd13_b3_2 XI1_I1141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1141_MP3 (XI1_I1141_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1141_MP0 (VDD I1_dd13_b3_2 XI1_I1141_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1139_MP1 (VDD I1_qu19_b3_1 XI1_I1139_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1139_MP5 (I1_b13_11 XI1_I1139_Bn XI1_I1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1139_MP4 (XI1_I1139_p1 XI1_I1139_An I1_b13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1139_MP2 (VDD I1_dd11_b3_2 XI1_I1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1139_MP3 (XI1_I1139_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1139_MP0 (VDD I1_dd11_b3_2 XI1_I1139_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1135_MP1 (VDD I1_qu19_b3_1 XI1_I1135_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1135_MP5 (I1_b13_7 XI1_I1135_Bn XI1_I1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1135_MP4 (XI1_I1135_p1 XI1_I1135_An I1_b13_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1135_MP2 (VDD I1_dd7_b3_2 XI1_I1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1135_MP3 (XI1_I1135_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1135_MP0 (VDD I1_dd7_b3_2 XI1_I1135_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1136_MP1 (VDD I1_qu19_b3_1 XI1_I1136_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1136_MP5 (I1_b13_8 XI1_I1136_Bn XI1_I1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1136_MP4 (XI1_I1136_p1 XI1_I1136_An I1_b13_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1136_MP2 (VDD I1_dd8_b3_2 XI1_I1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1136_MP3 (XI1_I1136_p1 I1_qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1136_MP0 (VDD I1_dd8_b3_2 XI1_I1136_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1066_MP1 (VDD I1_qu21_b3_5 XI1_I1066_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1066_MP5 (I1_b11_30 XI1_I1066_Bn XI1_I1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1066_MP4 (XI1_I1066_p1 XI1_I1066_An I1_b11_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1066_MP2 (VDD I1_dd30_b3_2 XI1_I1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1066_MP3 (XI1_I1066_p1 I1_qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1066_MP0 (VDD I1_dd30_b3_2 XI1_I1066_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1016_MP1 (VDD I1_qu22_b3_4 XI1_I1016_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1016_MP5 (I1_b10_26 XI1_I1016_Bn XI1_I1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1016_MP4 (XI1_I1016_p1 XI1_I1016_An I1_b10_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1016_MP2 (VDD I1_dd26_b3_1 XI1_I1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1016_MP3 (XI1_I1016_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1016_MP0 (VDD I1_dd26_b3_1 XI1_I1016_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1018_MP1 (VDD I1_qu22_b3_4 XI1_I1018_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1018_MP5 (I1_b10_28 XI1_I1018_Bn XI1_I1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1018_MP4 (XI1_I1018_p1 XI1_I1018_An I1_b10_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1018_MP2 (VDD I1_dd28_b3_1 XI1_I1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1018_MP3 (XI1_I1018_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1018_MP0 (VDD I1_dd28_b3_1 XI1_I1018_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I975_MP1 (VDD I1_qu23_b3_5 XI1_I975_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I975_MP5 (I1_b9_31 XI1_I975_Bn XI1_I975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I975_MP4 (XI1_I975_p1 XI1_I975_An I1_b9_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I975_MP2 (VDD I1_dd31_b3_1 XI1_I975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I975_MP3 (XI1_I975_p1 I1_qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I975_MP0 (VDD I1_dd31_b3_1 XI1_I975_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1015_MP1 (VDD I1_qu22_b3_4 XI1_I1015_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1015_MP5 (I1_b10_25 XI1_I1015_Bn XI1_I1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1015_MP4 (XI1_I1015_p1 XI1_I1015_An I1_b10_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1015_MP2 (VDD I1_dd25_b3_1 XI1_I1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1015_MP3 (XI1_I1015_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1015_MP0 (VDD I1_dd25_b3_1 XI1_I1015_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I970_MP1 (VDD I1_qu23_b3_4 XI1_I970_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I970_MP5 (I1_b9_26 XI1_I970_Bn XI1_I970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I970_MP4 (XI1_I970_p1 XI1_I970_An I1_b9_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I970_MP2 (VDD I1_dd26_b3_1 XI1_I970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I970_MP3 (XI1_I970_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I970_MP0 (VDD I1_dd26_b3_1 XI1_I970_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1014_MP1 (VDD I1_qu22_b3_4 XI1_I1014_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1014_MP5 (I1_b10_24 XI1_I1014_Bn XI1_I1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1014_MP4 (XI1_I1014_p1 XI1_I1014_An I1_b10_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1014_MP2 (VDD I1_dd24_b3_1 XI1_I1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1014_MP3 (XI1_I1014_p1 I1_qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1014_MP0 (VDD I1_dd24_b3_1 XI1_I1014_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I969_MP1 (VDD I1_qu23_b3_4 XI1_I969_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I969_MP5 (I1_b9_25 XI1_I969_Bn XI1_I969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I969_MP4 (XI1_I969_p1 XI1_I969_An I1_b9_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I969_MP2 (VDD I1_dd25_b3_1 XI1_I969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I969_MP3 (XI1_I969_p1 I1_qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I969_MP0 (VDD I1_dd25_b3_1 XI1_I969_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I967_MP1 (VDD I1_qu23_b3_3 XI1_I967_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I967_MP5 (I1_b9_23 XI1_I967_Bn XI1_I967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I967_MP4 (XI1_I967_p1 XI1_I967_An I1_b9_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I967_MP2 (VDD I1_dd23_b3_1 XI1_I967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I967_MP3 (XI1_I967_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I967_MP0 (VDD I1_dd23_b3_1 XI1_I967_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I966_MP1 (VDD I1_qu23_b3_3 XI1_I966_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I966_MP5 (I1_b9_22 XI1_I966_Bn XI1_I966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I966_MP4 (XI1_I966_p1 XI1_I966_An I1_b9_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I966_MP2 (VDD I1_dd22_b3_1 XI1_I966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I966_MP3 (XI1_I966_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I966_MP0 (VDD I1_dd22_b3_1 XI1_I966_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I964_MP1 (VDD I1_qu23_b3_3 XI1_I964_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I964_MP5 (I1_b9_20 XI1_I964_Bn XI1_I964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I964_MP4 (XI1_I964_p1 XI1_I964_An I1_b9_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I964_MP2 (VDD I1_dd20_b3_1 XI1_I964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I964_MP3 (XI1_I964_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I964_MP0 (VDD I1_dd20_b3_1 XI1_I964_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I963_MP1 (VDD I1_qu23_b3_3 XI1_I963_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I963_MP5 (I1_b9_19 XI1_I963_Bn XI1_I963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I963_MP4 (XI1_I963_p1 XI1_I963_An I1_b9_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I963_MP2 (VDD I1_dd19_b3_1 XI1_I963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I963_MP3 (XI1_I963_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I963_MP0 (VDD I1_dd19_b3_1 XI1_I963_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I218_MP1 (VDD I1_I930_G14_0n XI1_I930_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I218_MP5 (I1_p8_15 XI1_I930_I218_Bn XI1_I930_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I218_MP4 (XI1_I930_I218_p1 XI1_I930_I218_An I1_p8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I218_MP2 (VDD I1_I930_pn15 XI1_I930_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I218_MP3 (XI1_I930_I218_p1 I1_I930_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I218_MP0 (VDD I1_I930_pn15 XI1_I930_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I960_MP1 (VDD I1_qu23_b3_2 XI1_I960_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I960_MP5 (I1_b9_16 XI1_I960_Bn XI1_I960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I960_MP4 (XI1_I960_p1 XI1_I960_An I1_b9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I960_MP2 (VDD I1_dd16_b3_1 XI1_I960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I960_MP3 (XI1_I960_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I960_MP0 (VDD I1_dd16_b3_1 XI1_I960_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I959_MP1 (VDD I1_qu23_b3_2 XI1_I959_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I959_MP5 (I1_b9_15 XI1_I959_Bn XI1_I959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I959_MP4 (XI1_I959_p1 XI1_I959_An I1_b9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I959_MP2 (VDD I1_dd15_b3_1 XI1_I959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I959_MP3 (XI1_I959_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I959_MP0 (VDD I1_dd15_b3_1 XI1_I959_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I961_MP1 (VDD I1_qu23_b3_2 XI1_I961_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I961_MP5 (I1_b9_17 XI1_I961_Bn XI1_I961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I961_MP4 (XI1_I961_p1 XI1_I961_An I1_b9_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I961_MP2 (VDD I1_dd17_b3_1 XI1_I961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I961_MP3 (XI1_I961_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I961_MP0 (VDD I1_dd17_b3_1 XI1_I961_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I216_MP1 (VDD I1_I930_G12_0n XI1_I930_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I930_I216_MP5 (I1_p8_13 XI1_I930_I216_Bn XI1_I930_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I930_I216_MP4 (XI1_I930_I216_p1 XI1_I930_I216_An I1_p8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I216_MP2 (VDD I1_I930_pn13 XI1_I930_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I930_I216_MP3 (XI1_I930_I216_p1 I1_I930_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I930_I216_MP0 (VDD I1_I930_pn13 XI1_I930_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I958_MP1 (VDD I1_qu23_b3_2 XI1_I958_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I958_MP5 (I1_b9_14 XI1_I958_Bn XI1_I958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I958_MP4 (XI1_I958_p1 XI1_I958_An I1_b9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I958_MP2 (VDD I1_dd14_b3_1 XI1_I958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I958_MP3 (XI1_I958_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I958_MP0 (VDD I1_dd14_b3_1 XI1_I958_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I956_MP1 (VDD I1_qu23_b3_2 XI1_I956_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I956_MP5 (I1_b9_12 XI1_I956_Bn XI1_I956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I956_MP4 (XI1_I956_p1 XI1_I956_An I1_b9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I956_MP2 (VDD I1_dd12_b3_1 XI1_I956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I956_MP3 (XI1_I956_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I956_MP0 (VDD I1_dd12_b3_1 XI1_I956_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I953_MP1 (VDD I1_qu23_b3_1 XI1_I953_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I953_MP5 (I1_b9_9 XI1_I953_Bn XI1_I953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I953_MP4 (XI1_I953_p1 XI1_I953_An I1_b9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I953_MP2 (VDD I1_dd9_b3_1 XI1_I953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I953_MP3 (XI1_I953_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I953_MP0 (VDD I1_dd9_b3_1 XI1_I953_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I900_MP1 (VDD I1_qu24_b3_0 XI1_I900_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I900_MP5 (I1_b8_2 XI1_I900_Bn XI1_I900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I900_MP4 (XI1_I900_p1 XI1_I900_An I1_b8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I900_MP2 (VDD I1_dd2_b3_1 XI1_I900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I900_MP3 (XI1_I900_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I900_MP0 (VDD I1_dd2_b3_1 XI1_I900_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I212_MP1 (VDD I1_I654_G8_0n XI1_I654_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I212_MP5 (I1_p2_9 XI1_I654_I212_Bn XI1_I654_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I212_MP4 (XI1_I654_I212_p1 XI1_I654_I212_An I1_p2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I212_MP2 (VDD I1_I654_pn9 XI1_I654_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I212_MP3 (XI1_I654_I212_p1 I1_I654_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I212_MP0 (VDD I1_I654_pn9 XI1_I654_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I214_MP1 (VDD I1_I654_G10_0n XI1_I654_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I214_MP5 (I1_p2_11 XI1_I654_I214_Bn XI1_I654_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I214_MP4 (XI1_I654_I214_p1 XI1_I654_I214_An I1_p2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I214_MP2 (VDD I1_I654_pn11 XI1_I654_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I214_MP3 (XI1_I654_I214_p1 I1_I654_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I214_MP0 (VDD I1_I654_pn11 XI1_I654_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I216_MP1 (VDD I1_I654_G12_0n XI1_I654_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I216_MP5 (I1_p2_13 XI1_I654_I216_Bn XI1_I654_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I216_MP4 (XI1_I654_I216_p1 XI1_I654_I216_An I1_p2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I216_MP2 (VDD I1_I654_pn13 XI1_I654_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I216_MP3 (XI1_I654_I216_p1 I1_I654_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I216_MP0 (VDD I1_I654_pn13 XI1_I654_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I701_MP1 (VDD I1_qu29_b3_5 XI1_I701_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I701_MP5 (I1_h3 XI1_I701_Bn XI1_I701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I701_MP4 (XI1_I701_p1 XI1_I701_An I1_h3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I701_MP2 (VDD I1_p2_31 XI1_I701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I701_MP3 (XI1_I701_p1 I1_qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I701_MP0 (VDD I1_p2_31 XI1_I701_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1406_MP1 (VDD I1_qu13_b3_0 XI1_I1406_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1406_MP5 (I1_b19_2 XI1_I1406_Bn XI1_I1406_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1406_MP4 (XI1_I1406_p1 XI1_I1406_An I1_b19_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1406_MP2 (VDD I1_dd2_b3_3 XI1_I1406_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1406_MP3 (XI1_I1406_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1406_MP0 (VDD I1_dd2_b3_3 XI1_I1406_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1104_MP1 (VDD I1_qu20_b3_3 XI1_I1104_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1104_MP5 (I1_b12_22 XI1_I1104_Bn XI1_I1104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1104_MP4 (XI1_I1104_p1 XI1_I1104_An I1_b12_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1104_MP2 (VDD I1_dd22_b3_2 XI1_I1104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1104_MP3 (XI1_I1104_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1104_MP0 (VDD I1_dd22_b3_2 XI1_I1104_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1103_MP1 (VDD I1_qu20_b3_3 XI1_I1103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1103_MP5 (I1_b12_21 XI1_I1103_Bn XI1_I1103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1103_MP4 (XI1_I1103_p1 XI1_I1103_An I1_b12_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1103_MP2 (VDD I1_dd21_b3_2 XI1_I1103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1103_MP3 (XI1_I1103_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1103_MP0 (VDD I1_dd21_b3_2 XI1_I1103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1105_MP1 (VDD I1_qu20_b3_3 XI1_I1105_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1105_MP5 (I1_b12_23 XI1_I1105_Bn XI1_I1105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1105_MP4 (XI1_I1105_p1 XI1_I1105_An I1_b12_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1105_MP2 (VDD I1_dd23_b3_2 XI1_I1105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1105_MP3 (XI1_I1105_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1105_MP0 (VDD I1_dd23_b3_2 XI1_I1105_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1116_MP1 (VDD I1_c12_o XI1_I1116_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1116_MP5 (I1_p12_32 XI1_I1116_Bn XI1_I1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1116_MP4 (XI1_I1116_p1 XI1_I1116_An I1_p12_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1116_MP2 (VDD I1_h12 XI1_I1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1116_MP3 (XI1_I1116_p1 I1_c12_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1116_MP0 (VDD I1_h12 XI1_I1116_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1115_MP1 (VDD I1_qu20_b3_5 XI1_I1115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1115_MP5 (I1_h12 XI1_I1115_Bn XI1_I1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1115_MP4 (XI1_I1115_p1 XI1_I1115_An I1_h12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1115_MP2 (VDD I1_p11_31 XI1_I1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1115_MP3 (XI1_I1115_p1 I1_qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1115_MP0 (VDD I1_p11_31 XI1_I1115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1143_MP1 (VDD I1_qu19_b3_2 XI1_I1143_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1143_MP5 (I1_b13_15 XI1_I1143_Bn XI1_I1143_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1143_MP4 (XI1_I1143_p1 XI1_I1143_An I1_b13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1143_MP2 (VDD I1_dd15_b3_2 XI1_I1143_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1143_MP3 (XI1_I1143_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1143_MP0 (VDD I1_dd15_b3_2 XI1_I1143_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1140_MP1 (VDD I1_qu19_b3_2 XI1_I1140_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1140_MP5 (I1_b13_12 XI1_I1140_Bn XI1_I1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1140_MP4 (XI1_I1140_p1 XI1_I1140_An I1_b13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1140_MP2 (VDD I1_dd12_b3_2 XI1_I1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1140_MP3 (XI1_I1140_p1 I1_qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1140_MP0 (VDD I1_dd12_b3_2 XI1_I1140_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1067_MP1 (VDD I1_qu21_b3_5 XI1_I1067_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1067_MP5 (I1_b11_31 XI1_I1067_Bn XI1_I1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1067_MP4 (XI1_I1067_p1 XI1_I1067_An I1_b11_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1067_MP2 (VDD I1_dd31_b3_2 XI1_I1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1067_MP3 (XI1_I1067_p1 I1_qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1067_MP0 (VDD I1_dd31_b3_2 XI1_I1067_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I974_MP1 (VDD I1_qu23_b3_5 XI1_I974_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I974_MP5 (I1_b9_30 XI1_I974_Bn XI1_I974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I974_MP4 (XI1_I974_p1 XI1_I974_An I1_b9_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I974_MP2 (VDD I1_dd30_b3_1 XI1_I974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I974_MP3 (XI1_I974_p1 I1_qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I974_MP0 (VDD I1_dd30_b3_1 XI1_I974_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I965_MP1 (VDD I1_qu23_b3_3 XI1_I965_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I965_MP5 (I1_b9_21 XI1_I965_Bn XI1_I965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I965_MP4 (XI1_I965_p1 XI1_I965_An I1_b9_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I965_MP2 (VDD I1_dd21_b3_1 XI1_I965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I965_MP3 (XI1_I965_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I965_MP0 (VDD I1_dd21_b3_1 XI1_I965_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I962_MP1 (VDD I1_qu23_b3_3 XI1_I962_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I962_MP5 (I1_b9_18 XI1_I962_Bn XI1_I962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I962_MP4 (XI1_I962_p1 XI1_I962_An I1_b9_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I962_MP2 (VDD I1_dd18_b3_1 XI1_I962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I962_MP3 (XI1_I962_p1 I1_qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I962_MP0 (VDD I1_dd18_b3_1 XI1_I962_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I957_MP1 (VDD I1_qu23_b3_2 XI1_I957_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I957_MP5 (I1_b9_13 XI1_I957_Bn XI1_I957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I957_MP4 (XI1_I957_p1 XI1_I957_An I1_b9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I957_MP2 (VDD I1_dd13_b3_1 XI1_I957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I957_MP3 (XI1_I957_p1 I1_qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I957_MP0 (VDD I1_dd13_b3_1 XI1_I957_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I954_MP1 (VDD I1_qu23_b3_1 XI1_I954_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I954_MP5 (I1_b9_10 XI1_I954_Bn XI1_I954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I954_MP4 (XI1_I954_p1 XI1_I954_An I1_b9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I954_MP2 (VDD I1_dd10_b3_1 XI1_I954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I954_MP3 (XI1_I954_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I954_MP0 (VDD I1_dd10_b3_1 XI1_I954_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I955_MP1 (VDD I1_qu23_b3_1 XI1_I955_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I955_MP5 (I1_b9_11 XI1_I955_Bn XI1_I955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I955_MP4 (XI1_I955_p1 XI1_I955_An I1_b9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I955_MP2 (VDD I1_dd11_b3_1 XI1_I955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I955_MP3 (XI1_I955_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I955_MP0 (VDD I1_dd11_b3_1 XI1_I955_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I951_MP1 (VDD I1_qu23_b3_1 XI1_I951_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I951_MP5 (I1_b9_7 XI1_I951_Bn XI1_I951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I951_MP4 (XI1_I951_p1 XI1_I951_An I1_b9_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I951_MP2 (VDD I1_dd7_b3_1 XI1_I951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I951_MP3 (XI1_I951_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I951_MP0 (VDD I1_dd7_b3_1 XI1_I951_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I218_MP1 (VDD I1_I654_G14_0n XI1_I654_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I654_I218_MP5 (I1_p2_15 XI1_I654_I218_Bn XI1_I654_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I654_I218_MP4 (XI1_I654_I218_p1 XI1_I654_I218_An I1_p2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I218_MP2 (VDD I1_I654_pn15 XI1_I654_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I654_I218_MP3 (XI1_I654_I218_p1 I1_I654_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I654_I218_MP0 (VDD I1_I654_pn15 XI1_I654_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I218_MP1 (VDD I1_I1436_G14_0n XI1_I1436_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I218_MP5 (I1_p19_15 XI1_I1436_I218_Bn XI1_I1436_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I218_MP4 (XI1_I1436_I218_p1 XI1_I1436_I218_An I1_p19_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I218_MP2 (VDD I1_I1436_pn15 XI1_I1436_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I218_MP3 (XI1_I1436_I218_p1 I1_I1436_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I218_MP0 (VDD I1_I1436_pn15 XI1_I1436_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1405_MP1 (VDD I1_qu13_b3_0 XI1_I1405_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1405_MP5 (I1_b19_1 XI1_I1405_Bn XI1_I1405_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1405_MP4 (XI1_I1405_p1 XI1_I1405_An I1_b19_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1405_MP2 (VDD I1_dd1_b3_3 XI1_I1405_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1405_MP3 (XI1_I1405_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1405_MP0 (VDD I1_dd1_b3_3 XI1_I1405_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I219_MP1 (VDD I1_I1114_G15_0n XI1_I1114_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I219_MP5 (I1_p12_16 XI1_I1114_I219_Bn XI1_I1114_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I219_MP4 (XI1_I1114_I219_p1 XI1_I1114_I219_An I1_p12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I219_MP2 (VDD I1_I1114_pn16 XI1_I1114_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I219_MP3 (XI1_I1114_I219_p1 I1_I1114_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I219_MP0 (VDD I1_I1114_pn16 XI1_I1114_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1102_MP1 (VDD I1_qu20_b3_3 XI1_I1102_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1102_MP5 (I1_b12_20 XI1_I1102_Bn XI1_I1102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1102_MP4 (XI1_I1102_p1 XI1_I1102_An I1_b12_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1102_MP2 (VDD I1_dd20_b3_2 XI1_I1102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1102_MP3 (XI1_I1102_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1102_MP0 (VDD I1_dd20_b3_2 XI1_I1102_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1101_MP1 (VDD I1_qu20_b3_3 XI1_I1101_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1101_MP5 (I1_b12_19 XI1_I1101_Bn XI1_I1101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1101_MP4 (XI1_I1101_p1 XI1_I1101_An I1_b12_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1101_MP2 (VDD I1_dd19_b3_2 XI1_I1101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1101_MP3 (XI1_I1101_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1101_MP0 (VDD I1_dd19_b3_2 XI1_I1101_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1070_MP1 (VDD I1_c11_o XI1_I1070_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1070_MP5 (I1_p11_32 XI1_I1070_Bn XI1_I1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1070_MP4 (XI1_I1070_p1 XI1_I1070_An I1_p11_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1070_MP2 (VDD I1_h11 XI1_I1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1070_MP3 (XI1_I1070_p1 I1_c11_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1070_MP0 (VDD I1_h11 XI1_I1070_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1069_MP1 (VDD I1_qu21_b3_5 XI1_I1069_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1069_MP5 (I1_h11 XI1_I1069_Bn XI1_I1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1069_MP4 (XI1_I1069_p1 XI1_I1069_An I1_h11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1069_MP2 (VDD I1_p10_31 XI1_I1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1069_MP3 (XI1_I1069_p1 I1_qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1069_MP0 (VDD I1_p10_31 XI1_I1069_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1020_MP1 (VDD I1_qu22_b3_5 XI1_I1020_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1020_MP5 (I1_b10_30 XI1_I1020_Bn XI1_I1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1020_MP4 (XI1_I1020_p1 XI1_I1020_An I1_b10_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1020_MP2 (VDD I1_dd30_b3_1 XI1_I1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1020_MP3 (XI1_I1020_p1 I1_qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1020_MP0 (VDD I1_dd30_b3_1 XI1_I1020_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1021_MP1 (VDD I1_qu22_b3_5 XI1_I1021_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1021_MP5 (I1_b10_31 XI1_I1021_Bn XI1_I1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1021_MP4 (XI1_I1021_p1 XI1_I1021_An I1_b10_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1021_MP2 (VDD I1_dd31_b3_1 XI1_I1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1021_MP3 (XI1_I1021_p1 I1_qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1021_MP0 (VDD I1_dd31_b3_1 XI1_I1021_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I952_MP1 (VDD I1_qu23_b3_1 XI1_I952_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I952_MP5 (I1_b9_8 XI1_I952_Bn XI1_I952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I952_MP4 (XI1_I952_p1 XI1_I952_An I1_b9_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I952_MP2 (VDD I1_dd8_b3_1 XI1_I952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I952_MP3 (XI1_I952_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I952_MP0 (VDD I1_dd8_b3_1 XI1_I952_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I950_MP1 (VDD I1_qu23_b3_1 XI1_I950_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I950_MP5 (I1_b9_6 XI1_I950_Bn XI1_I950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I950_MP4 (XI1_I950_p1 XI1_I950_An I1_b9_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I950_MP2 (VDD I1_dd6_b3_1 XI1_I950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I950_MP3 (XI1_I950_p1 I1_qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I950_MP0 (VDD I1_dd6_b3_1 XI1_I950_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I623_MP1 (VDD I1_qu30_b3_0 XI1_I623_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I623_MP5 (I1_b2_1 XI1_I623_Bn XI1_I623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I623_MP4 (XI1_I623_p1 XI1_I623_An I1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I623_MP2 (VDD I1_dd1_b3_0 XI1_I623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I623_MP3 (XI1_I623_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I623_MP0 (VDD I1_dd1_b3_0 XI1_I623_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I624_MP1 (VDD I1_qu30_b3_0 XI1_I624_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I624_MP5 (I1_b2_2 XI1_I624_Bn XI1_I624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I624_MP4 (XI1_I624_p1 XI1_I624_An I1_b2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I624_MP2 (VDD I1_dd2_b3_0 XI1_I624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I624_MP3 (XI1_I624_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I624_MP0 (VDD I1_dd2_b3_0 XI1_I624_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I625_MP1 (VDD I1_qu30_b3_0 XI1_I625_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I625_MP5 (I1_b2_3 XI1_I625_Bn XI1_I625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I625_MP4 (XI1_I625_p1 XI1_I625_An I1_b2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I625_MP2 (VDD I1_dd3_b3_0 XI1_I625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I625_MP3 (XI1_I625_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I625_MP0 (VDD I1_dd3_b3_0 XI1_I625_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1434_MP1 (VDD I1_qu13_b3_5 XI1_I1434_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1434_MP5 (I1_b19_30 XI1_I1434_Bn XI1_I1434_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1434_MP4 (XI1_I1434_p1 XI1_I1434_An I1_b19_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1434_MP2 (VDD I1_dd30_b3_3 XI1_I1434_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1434_MP3 (XI1_I1434_p1 I1_qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1434_MP0 (VDD I1_dd30_b3_3 XI1_I1434_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I216_MP1 (VDD I1_I1436_G12_0n XI1_I1436_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I216_MP5 (I1_p19_13 XI1_I1436_I216_Bn XI1_I1436_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I216_MP4 (XI1_I1436_I216_p1 XI1_I1436_I216_An I1_p19_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I216_MP2 (VDD I1_I1436_pn13 XI1_I1436_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I216_MP3 (XI1_I1436_I216_p1 I1_I1436_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I216_MP0 (VDD I1_I1436_pn13 XI1_I1436_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I214_MP1 (VDD I1_I1436_G10_0n XI1_I1436_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I214_MP5 (I1_p19_11 XI1_I1436_I214_Bn XI1_I1436_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I214_MP4 (XI1_I1436_I214_p1 XI1_I1436_I214_An I1_p19_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I214_MP2 (VDD I1_I1436_pn11 XI1_I1436_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I214_MP3 (XI1_I1436_I214_p1 I1_I1436_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I214_MP0 (VDD I1_I1436_pn11 XI1_I1436_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I212_MP1 (VDD I1_I1436_G8_0n XI1_I1436_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I212_MP5 (I1_p19_9 XI1_I1436_I212_Bn XI1_I1436_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I212_MP4 (XI1_I1436_I212_p1 XI1_I1436_I212_An I1_p19_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I212_MP2 (VDD I1_I1436_pn9 XI1_I1436_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I212_MP3 (XI1_I1436_I212_p1 I1_I1436_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I212_MP0 (VDD I1_I1436_pn9 XI1_I1436_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1100_MP1 (VDD I1_qu20_b3_3 XI1_I1100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1100_MP5 (I1_b12_18 XI1_I1100_Bn XI1_I1100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1100_MP4 (XI1_I1100_p1 XI1_I1100_An I1_b12_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1100_MP2 (VDD I1_dd18_b3_2 XI1_I1100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1100_MP3 (XI1_I1100_p1 I1_qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1100_MP0 (VDD I1_dd18_b3_2 XI1_I1100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1059_MP1 (VDD I1_qu21_b3_3 XI1_I1059_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1059_MP5 (I1_b11_23 XI1_I1059_Bn XI1_I1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1059_MP4 (XI1_I1059_p1 XI1_I1059_An I1_b11_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1059_MP2 (VDD I1_dd23_b3_2 XI1_I1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1059_MP3 (XI1_I1059_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1059_MP0 (VDD I1_dd23_b3_2 XI1_I1059_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I978_MP1 (VDD I1_c9_o XI1_I978_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I978_MP5 (I1_p9_32 XI1_I978_Bn XI1_I978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I978_MP4 (XI1_I978_p1 XI1_I978_An I1_p9_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I978_MP2 (VDD I1_h9 XI1_I978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I978_MP3 (XI1_I978_p1 I1_c9_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I978_MP0 (VDD I1_h9 XI1_I978_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I899_MP1 (VDD I1_qu24_b3_0 XI1_I899_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I899_MP5 (I1_b8_1 XI1_I899_Bn XI1_I899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I899_MP4 (XI1_I899_p1 XI1_I899_An I1_b8_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I899_MP2 (VDD I1_dd1_b3_1 XI1_I899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I899_MP3 (XI1_I899_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I899_MP0 (VDD I1_dd1_b3_1 XI1_I899_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I622_MP1 (VDD I1_qu30_b3_0 XI1_I622_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I622_MP5 (I1_b2_0 XI1_I622_Bn XI1_I622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I622_MP4 (XI1_I622_p1 XI1_I622_An I1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I622_MP2 (VDD I1_B_0_b3_0 XI1_I622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I622_MP3 (XI1_I622_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I622_MP0 (VDD I1_B_0_b3_0 XI1_I622_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I626_MP1 (VDD I1_qu30_b3_0 XI1_I626_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I626_MP5 (I1_b2_4 XI1_I626_Bn XI1_I626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I626_MP4 (XI1_I626_p1 XI1_I626_An I1_b2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I626_MP2 (VDD I1_dd4_b3_0 XI1_I626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I626_MP3 (XI1_I626_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I626_MP0 (VDD I1_dd4_b3_0 XI1_I626_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I627_MP1 (VDD I1_qu30_b3_0 XI1_I627_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I627_MP5 (I1_b2_5 XI1_I627_Bn XI1_I627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I627_MP4 (XI1_I627_p1 XI1_I627_An I1_b2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I627_MP2 (VDD I1_dd5_b3_0 XI1_I627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I627_MP3 (XI1_I627_p1 I1_qu30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I627_MP0 (VDD I1_dd5_b3_0 XI1_I627_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I650_MP1 (VDD I1_qu30_b3_4 XI1_I650_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I650_MP5 (I1_b2_28 XI1_I650_Bn XI1_I650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I650_MP4 (XI1_I650_p1 XI1_I650_An I1_b2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I650_MP2 (VDD I1_dd28_b3_0 XI1_I650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I650_MP3 (XI1_I650_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I650_MP0 (VDD I1_dd28_b3_0 XI1_I650_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I651_MP1 (VDD I1_qu30_b3_4 XI1_I651_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I651_MP5 (I1_b2_29 XI1_I651_Bn XI1_I651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I651_MP4 (XI1_I651_p1 XI1_I651_An I1_b2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I651_MP2 (VDD I1_dd29_b3_0 XI1_I651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I651_MP3 (XI1_I651_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I651_MP0 (VDD I1_dd29_b3_0 XI1_I651_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I217_MP1 (VDD I1_I1436_G13_0n XI1_I1436_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I217_MP5 (I1_p19_14 XI1_I1436_I217_Bn XI1_I1436_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I217_MP4 (XI1_I1436_I217_p1 XI1_I1436_I217_An I1_p19_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I217_MP2 (VDD I1_I1436_pn14 XI1_I1436_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I217_MP3 (XI1_I1436_I217_p1 I1_I1436_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I217_MP0 (VDD I1_I1436_pn14 XI1_I1436_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I206_MP1 (VDD I1_I1436_G2_0n XI1_I1436_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I206_MP5 (I1_p19_3 XI1_I1436_I206_Bn XI1_I1436_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I206_MP4 (XI1_I1436_I206_p1 XI1_I1436_I206_An I1_p19_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I206_MP2 (VDD I1_I1436_pn3 XI1_I1436_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I206_MP3 (XI1_I1436_I206_p1 I1_I1436_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I206_MP0 (VDD I1_I1436_pn3 XI1_I1436_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1404_MP1 (VDD I1_qu13_b3_0 XI1_I1404_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1404_MP5 (I1_b19_0 XI1_I1404_Bn XI1_I1404_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1404_MP4 (XI1_I1404_p1 XI1_I1404_An I1_b19_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1404_MP2 (VDD I1_B_0_b3_3 XI1_I1404_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1404_MP3 (XI1_I1404_p1 I1_qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1404_MP0 (VDD I1_B_0_b3_3 XI1_I1404_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I217_MP1 (VDD I1_I1114_G13_0n XI1_I1114_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I217_MP5 (I1_p12_14 XI1_I1114_I217_Bn XI1_I1114_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I217_MP4 (XI1_I1114_I217_p1 XI1_I1114_I217_An I1_p12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I217_MP2 (VDD I1_I1114_pn14 XI1_I1114_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I217_MP3 (XI1_I1114_I217_p1 I1_I1114_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I217_MP0 (VDD I1_I1114_pn14 XI1_I1114_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I219_MP1 (VDD I1_I1068_G15_0n XI1_I1068_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I219_MP5 (I1_p11_16 XI1_I1068_I219_Bn XI1_I1068_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I219_MP4 (XI1_I1068_I219_p1 XI1_I1068_I219_An I1_p11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I219_MP2 (VDD I1_I1068_pn16 XI1_I1068_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I219_MP3 (XI1_I1068_I219_p1 I1_I1068_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I219_MP0 (VDD I1_I1068_pn16 XI1_I1068_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1058_MP1 (VDD I1_qu21_b3_3 XI1_I1058_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1058_MP5 (I1_b11_22 XI1_I1058_Bn XI1_I1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1058_MP4 (XI1_I1058_p1 XI1_I1058_An I1_b11_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1058_MP2 (VDD I1_dd22_b3_2 XI1_I1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1058_MP3 (XI1_I1058_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1058_MP0 (VDD I1_dd22_b3_2 XI1_I1058_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1057_MP1 (VDD I1_qu21_b3_3 XI1_I1057_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1057_MP5 (I1_b11_21 XI1_I1057_Bn XI1_I1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1057_MP4 (XI1_I1057_p1 XI1_I1057_An I1_b11_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1057_MP2 (VDD I1_dd21_b3_2 XI1_I1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1057_MP3 (XI1_I1057_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1057_MP0 (VDD I1_dd21_b3_2 XI1_I1057_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1013_MP1 (VDD I1_qu22_b3_3 XI1_I1013_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1013_MP5 (I1_b10_23 XI1_I1013_Bn XI1_I1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1013_MP4 (XI1_I1013_p1 XI1_I1013_An I1_b10_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1013_MP2 (VDD I1_dd23_b3_1 XI1_I1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1013_MP3 (XI1_I1013_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1013_MP0 (VDD I1_dd23_b3_1 XI1_I1013_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I219_MP1 (VDD I1_I976_G15_0n XI1_I976_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I219_MP5 (I1_p9_16 XI1_I976_I219_Bn XI1_I976_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I219_MP4 (XI1_I976_I219_p1 XI1_I976_I219_An I1_p9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I219_MP2 (VDD I1_I976_pn16 XI1_I976_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I219_MP3 (XI1_I976_I219_p1 I1_I976_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I219_MP0 (VDD I1_I976_pn16 XI1_I976_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I217_MP1 (VDD I1_I976_G13_0n XI1_I976_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I217_MP5 (I1_p9_14 XI1_I976_I217_Bn XI1_I976_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I217_MP4 (XI1_I976_I217_p1 XI1_I976_I217_An I1_p9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I217_MP2 (VDD I1_I976_pn14 XI1_I976_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I217_MP3 (XI1_I976_I217_p1 I1_I976_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I217_MP0 (VDD I1_I976_pn14 XI1_I976_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I898_MP1 (VDD I1_qu24_b3_0 XI1_I898_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I898_MP5 (I1_b8_0 XI1_I898_Bn XI1_I898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I898_MP4 (XI1_I898_p1 XI1_I898_An I1_b8_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I898_MP2 (VDD I1_B_0_b3_1 XI1_I898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I898_MP3 (XI1_I898_p1 I1_qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I898_MP0 (VDD I1_B_0_b3_1 XI1_I898_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I949_MP1 (VDD I1_qu23_b3_0 XI1_I949_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I949_MP5 (I1_b9_5 XI1_I949_Bn XI1_I949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I949_MP4 (XI1_I949_p1 XI1_I949_An I1_b9_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I949_MP2 (VDD I1_dd5_b3_1 XI1_I949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I949_MP3 (XI1_I949_p1 I1_qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I949_MP0 (VDD I1_dd5_b3_1 XI1_I949_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I629_MP1 (VDD I1_qu30_b3_1 XI1_I629_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I629_MP5 (I1_b2_7 XI1_I629_Bn XI1_I629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I629_MP4 (XI1_I629_p1 XI1_I629_An I1_b2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I629_MP2 (VDD I1_dd7_b3_0 XI1_I629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I629_MP3 (XI1_I629_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I629_MP0 (VDD I1_dd7_b3_0 XI1_I629_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I630_MP1 (VDD I1_qu30_b3_1 XI1_I630_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I630_MP5 (I1_b2_8 XI1_I630_Bn XI1_I630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I630_MP4 (XI1_I630_p1 XI1_I630_An I1_b2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I630_MP2 (VDD I1_dd8_b3_0 XI1_I630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I630_MP3 (XI1_I630_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I630_MP0 (VDD I1_dd8_b3_0 XI1_I630_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I631_MP1 (VDD I1_qu30_b3_1 XI1_I631_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I631_MP5 (I1_b2_9 XI1_I631_Bn XI1_I631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I631_MP4 (XI1_I631_p1 XI1_I631_An I1_b2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I631_MP2 (VDD I1_dd9_b3_0 XI1_I631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I631_MP3 (XI1_I631_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I631_MP0 (VDD I1_dd9_b3_0 XI1_I631_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I633_MP1 (VDD I1_qu30_b3_1 XI1_I633_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I633_MP5 (I1_b2_11 XI1_I633_Bn XI1_I633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I633_MP4 (XI1_I633_p1 XI1_I633_An I1_b2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I633_MP2 (VDD I1_dd11_b3_0 XI1_I633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I633_MP3 (XI1_I633_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I633_MP0 (VDD I1_dd11_b3_0 XI1_I633_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I635_MP1 (VDD I1_qu30_b3_2 XI1_I635_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I635_MP5 (I1_b2_13 XI1_I635_Bn XI1_I635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I635_MP4 (XI1_I635_p1 XI1_I635_An I1_b2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I635_MP2 (VDD I1_dd13_b3_0 XI1_I635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I635_MP3 (XI1_I635_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I635_MP0 (VDD I1_dd13_b3_0 XI1_I635_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I638_MP1 (VDD I1_qu30_b3_2 XI1_I638_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I638_MP5 (I1_b2_16 XI1_I638_Bn XI1_I638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I638_MP4 (XI1_I638_p1 XI1_I638_An I1_b2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I638_MP2 (VDD I1_dd16_b3_0 XI1_I638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I638_MP3 (XI1_I638_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I638_MP0 (VDD I1_dd16_b3_0 XI1_I638_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I641_MP1 (VDD I1_qu30_b3_3 XI1_I641_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I641_MP5 (I1_b2_19 XI1_I641_Bn XI1_I641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I641_MP4 (XI1_I641_p1 XI1_I641_An I1_b2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I641_MP2 (VDD I1_dd19_b3_0 XI1_I641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I641_MP3 (XI1_I641_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I641_MP0 (VDD I1_dd19_b3_0 XI1_I641_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I644_MP1 (VDD I1_qu30_b3_3 XI1_I644_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I644_MP5 (I1_b2_22 XI1_I644_Bn XI1_I644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I644_MP4 (XI1_I644_p1 XI1_I644_An I1_b2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I644_MP2 (VDD I1_dd22_b3_0 XI1_I644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I644_MP3 (XI1_I644_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I644_MP0 (VDD I1_dd22_b3_0 XI1_I644_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I646_MP1 (VDD I1_qu30_b3_4 XI1_I646_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I646_MP5 (I1_b2_24 XI1_I646_Bn XI1_I646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I646_MP4 (XI1_I646_p1 XI1_I646_An I1_b2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I646_MP2 (VDD I1_dd24_b3_0 XI1_I646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I646_MP3 (XI1_I646_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I646_MP0 (VDD I1_dd24_b3_0 XI1_I646_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I648_MP1 (VDD I1_qu30_b3_4 XI1_I648_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I648_MP5 (I1_b2_26 XI1_I648_Bn XI1_I648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I648_MP4 (XI1_I648_p1 XI1_I648_An I1_b2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I648_MP2 (VDD I1_dd26_b3_0 XI1_I648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I648_MP3 (XI1_I648_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I648_MP0 (VDD I1_dd26_b3_0 XI1_I648_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I649_MP1 (VDD I1_qu30_b3_4 XI1_I649_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I649_MP5 (I1_b2_27 XI1_I649_Bn XI1_I649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I649_MP4 (XI1_I649_p1 XI1_I649_An I1_b2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I649_MP2 (VDD I1_dd27_b3_0 XI1_I649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I649_MP3 (XI1_I649_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I649_MP0 (VDD I1_dd27_b3_0 XI1_I649_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I647_MP1 (VDD I1_qu30_b3_4 XI1_I647_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I647_MP5 (I1_b2_25 XI1_I647_Bn XI1_I647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I647_MP4 (XI1_I647_p1 XI1_I647_An I1_b2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I647_MP2 (VDD I1_dd25_b3_0 XI1_I647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I647_MP3 (XI1_I647_p1 I1_qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I647_MP0 (VDD I1_dd25_b3_0 XI1_I647_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I652_MP1 (VDD I1_qu30_b3_5 XI1_I652_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I652_MP5 (I1_b2_30 XI1_I652_Bn XI1_I652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I652_MP4 (XI1_I652_p1 XI1_I652_An I1_b2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I652_MP2 (VDD I1_dd30_b3_0 XI1_I652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I652_MP3 (XI1_I652_p1 I1_qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I652_MP0 (VDD I1_dd30_b3_0 XI1_I652_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1435_MP1 (VDD I1_qu13_b3_5 XI1_I1435_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1435_MP5 (I1_b19_31 XI1_I1435_Bn XI1_I1435_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1435_MP4 (XI1_I1435_p1 XI1_I1435_An I1_b19_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1435_MP2 (VDD I1_dd31_b3_3 XI1_I1435_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1435_MP3 (XI1_I1435_p1 I1_qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1435_MP0 (VDD I1_dd31_b3_3 XI1_I1435_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I219_MP1 (VDD I1_I1436_G15_0n XI1_I1436_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I219_MP5 (I1_p19_16 XI1_I1436_I219_Bn XI1_I1436_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I219_MP4 (XI1_I1436_I219_p1 XI1_I1436_I219_An I1_p19_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I219_MP2 (VDD I1_I1436_pn16 XI1_I1436_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I219_MP3 (XI1_I1436_I219_p1 I1_I1436_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I219_MP0 (VDD I1_I1436_pn16 XI1_I1436_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1466_MP1 (VDD I1_qu12_b3_2 XI1_I1466_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1466_MP5 (I1_b20_16 XI1_I1466_Bn XI1_I1466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1466_MP4 (XI1_I1466_p1 XI1_I1466_An I1_b20_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1466_MP2 (VDD I1_dd16_b3_3 XI1_I1466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1466_MP3 (XI1_I1466_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1466_MP0 (VDD I1_dd16_b3_3 XI1_I1466_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1464_MP1 (VDD I1_qu12_b3_2 XI1_I1464_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1464_MP5 (I1_b20_14 XI1_I1464_Bn XI1_I1464_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1464_MP4 (XI1_I1464_p1 XI1_I1464_An I1_b20_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1464_MP2 (VDD I1_dd14_b3_3 XI1_I1464_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1464_MP3 (XI1_I1464_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1464_MP0 (VDD I1_dd14_b3_3 XI1_I1464_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I215_MP1 (VDD I1_I1436_G11_0n XI1_I1436_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I215_MP5 (I1_p19_12 XI1_I1436_I215_Bn XI1_I1436_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I215_MP4 (XI1_I1436_I215_p1 XI1_I1436_I215_An I1_p19_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I215_MP2 (VDD I1_I1436_pn12 XI1_I1436_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I215_MP3 (XI1_I1436_I215_p1 I1_I1436_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I215_MP0 (VDD I1_I1436_pn12 XI1_I1436_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I213_MP1 (VDD I1_I1436_G9_0n XI1_I1436_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I213_MP5 (I1_p19_10 XI1_I1436_I213_Bn XI1_I1436_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I213_MP4 (XI1_I1436_I213_p1 XI1_I1436_I213_An I1_p19_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I213_MP2 (VDD I1_I1436_pn10 XI1_I1436_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I213_MP3 (XI1_I1436_I213_p1 I1_I1436_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I213_MP0 (VDD I1_I1436_pn10 XI1_I1436_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1456_MP1 (VDD I1_qu12_b3_1 XI1_I1456_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1456_MP5 (I1_b20_6 XI1_I1456_Bn XI1_I1456_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1456_MP4 (XI1_I1456_p1 XI1_I1456_An I1_b20_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1456_MP2 (VDD I1_dd6_b3_3 XI1_I1456_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1456_MP3 (XI1_I1456_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1456_MP0 (VDD I1_dd6_b3_3 XI1_I1456_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1458_MP1 (VDD I1_qu12_b3_1 XI1_I1458_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1458_MP5 (I1_b20_8 XI1_I1458_Bn XI1_I1458_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1458_MP4 (XI1_I1458_p1 XI1_I1458_An I1_b20_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1458_MP2 (VDD I1_dd8_b3_3 XI1_I1458_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1458_MP3 (XI1_I1458_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1458_MP0 (VDD I1_dd8_b3_3 XI1_I1458_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I207_MP1 (VDD I1_I1436_G3_0n XI1_I1436_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1436_I207_MP5 (I1_p19_4 XI1_I1436_I207_Bn XI1_I1436_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1436_I207_MP4 (XI1_I1436_I207_p1 XI1_I1436_I207_An I1_p19_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I207_MP2 (VDD I1_I1436_pn4 XI1_I1436_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1436_I207_MP3 (XI1_I1436_I207_p1 I1_I1436_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1436_I207_MP0 (VDD I1_I1436_pn4 XI1_I1436_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I214_MP1 (VDD I1_I1114_G10_0n XI1_I1114_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I214_MP5 (I1_p12_11 XI1_I1114_I214_Bn XI1_I1114_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I214_MP4 (XI1_I1114_I214_p1 XI1_I1114_I214_An I1_p12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I214_MP2 (VDD I1_I1114_pn11 XI1_I1114_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I214_MP3 (XI1_I1114_I214_p1 I1_I1114_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I214_MP0 (VDD I1_I1114_pn11 XI1_I1114_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1098_MP1 (VDD I1_qu20_b3_2 XI1_I1098_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1098_MP5 (I1_b12_16 XI1_I1098_Bn XI1_I1098_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1098_MP4 (XI1_I1098_p1 XI1_I1098_An I1_b12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1098_MP2 (VDD I1_dd16_b3_2 XI1_I1098_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1098_MP3 (XI1_I1098_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1098_MP0 (VDD I1_dd16_b3_2 XI1_I1098_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1099_MP1 (VDD I1_qu20_b3_2 XI1_I1099_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1099_MP5 (I1_b12_17 XI1_I1099_Bn XI1_I1099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1099_MP4 (XI1_I1099_p1 XI1_I1099_An I1_b12_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1099_MP2 (VDD I1_dd17_b3_2 XI1_I1099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1099_MP3 (XI1_I1099_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1099_MP0 (VDD I1_dd17_b3_2 XI1_I1099_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I218_MP1 (VDD I1_I1068_G14_0n XI1_I1068_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I218_MP5 (I1_p11_15 XI1_I1068_I218_Bn XI1_I1068_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I218_MP4 (XI1_I1068_I218_p1 XI1_I1068_I218_An I1_p11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I218_MP2 (VDD I1_I1068_pn15 XI1_I1068_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I218_MP3 (XI1_I1068_I218_p1 I1_I1068_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I218_MP0 (VDD I1_I1068_pn15 XI1_I1068_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1055_MP1 (VDD I1_qu21_b3_3 XI1_I1055_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1055_MP5 (I1_b11_19 XI1_I1055_Bn XI1_I1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1055_MP4 (XI1_I1055_p1 XI1_I1055_An I1_b11_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1055_MP2 (VDD I1_dd19_b3_2 XI1_I1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1055_MP3 (XI1_I1055_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1055_MP0 (VDD I1_dd19_b3_2 XI1_I1055_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1056_MP1 (VDD I1_qu21_b3_3 XI1_I1056_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1056_MP5 (I1_b11_20 XI1_I1056_Bn XI1_I1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1056_MP4 (XI1_I1056_p1 XI1_I1056_An I1_b11_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1056_MP2 (VDD I1_dd20_b3_2 XI1_I1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1056_MP3 (XI1_I1056_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1056_MP0 (VDD I1_dd20_b3_2 XI1_I1056_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1012_MP1 (VDD I1_qu22_b3_3 XI1_I1012_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1012_MP5 (I1_b10_22 XI1_I1012_Bn XI1_I1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1012_MP4 (XI1_I1012_p1 XI1_I1012_An I1_b10_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1012_MP2 (VDD I1_dd22_b3_1 XI1_I1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1012_MP3 (XI1_I1012_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1012_MP0 (VDD I1_dd22_b3_1 XI1_I1012_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1011_MP1 (VDD I1_qu22_b3_3 XI1_I1011_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1011_MP5 (I1_b10_21 XI1_I1011_Bn XI1_I1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1011_MP4 (XI1_I1011_p1 XI1_I1011_An I1_b10_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1011_MP2 (VDD I1_dd21_b3_1 XI1_I1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1011_MP3 (XI1_I1011_p1 I1_qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1011_MP0 (VDD I1_dd21_b3_1 XI1_I1011_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I213_MP1 (VDD I1_I976_G9_0n XI1_I976_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I976_I213_MP5 (I1_p9_10 XI1_I976_I213_Bn XI1_I976_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I976_I213_MP4 (XI1_I976_I213_p1 XI1_I976_I213_An I1_p9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I213_MP2 (VDD I1_I976_pn10 XI1_I976_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I976_I213_MP3 (XI1_I976_I213_p1 I1_I976_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I976_I213_MP0 (VDD I1_I976_pn10 XI1_I976_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I206_MP1 (VDD I1_I608_G2_0n XI1_I608_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I206_MP5 (I1_p1_3 XI1_I608_I206_Bn XI1_I608_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I206_MP4 (XI1_I608_I206_p1 XI1_I608_I206_An I1_p1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I206_MP2 (VDD I1_I608_pn3 XI1_I608_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I206_MP3 (XI1_I608_I206_p1 I1_I608_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I206_MP0 (VDD I1_I608_pn3 XI1_I608_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I628_MP1 (VDD I1_qu30_b3_1 XI1_I628_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I628_MP5 (I1_b2_6 XI1_I628_Bn XI1_I628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I628_MP4 (XI1_I628_p1 XI1_I628_An I1_b2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I628_MP2 (VDD I1_dd6_b3_0 XI1_I628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I628_MP3 (XI1_I628_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I628_MP0 (VDD I1_dd6_b3_0 XI1_I628_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I632_MP1 (VDD I1_qu30_b3_1 XI1_I632_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I632_MP5 (I1_b2_10 XI1_I632_Bn XI1_I632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I632_MP4 (XI1_I632_p1 XI1_I632_An I1_b2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I632_MP2 (VDD I1_dd10_b3_0 XI1_I632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I632_MP3 (XI1_I632_p1 I1_qu30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I632_MP0 (VDD I1_dd10_b3_0 XI1_I632_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I212_MP1 (VDD I1_I608_G8_0n XI1_I608_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I212_MP5 (I1_p1_9 XI1_I608_I212_Bn XI1_I608_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I212_MP4 (XI1_I608_I212_p1 XI1_I608_I212_An I1_p1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I212_MP2 (VDD I1_I608_pn9 XI1_I608_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I212_MP3 (XI1_I608_I212_p1 I1_I608_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I212_MP0 (VDD I1_I608_pn9 XI1_I608_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I214_MP1 (VDD I1_I608_G10_0n XI1_I608_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I214_MP5 (I1_p1_11 XI1_I608_I214_Bn XI1_I608_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I214_MP4 (XI1_I608_I214_p1 XI1_I608_I214_An I1_p1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I214_MP2 (VDD I1_I608_pn11 XI1_I608_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I214_MP3 (XI1_I608_I214_p1 I1_I608_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I214_MP0 (VDD I1_I608_pn11 XI1_I608_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I634_MP1 (VDD I1_qu30_b3_2 XI1_I634_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I634_MP5 (I1_b2_12 XI1_I634_Bn XI1_I634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I634_MP4 (XI1_I634_p1 XI1_I634_An I1_b2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I634_MP2 (VDD I1_dd12_b3_0 XI1_I634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I634_MP3 (XI1_I634_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I634_MP0 (VDD I1_dd12_b3_0 XI1_I634_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I216_MP1 (VDD I1_I608_G12_0n XI1_I608_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I216_MP5 (I1_p1_13 XI1_I608_I216_Bn XI1_I608_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I216_MP4 (XI1_I608_I216_p1 XI1_I608_I216_An I1_p1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I216_MP2 (VDD I1_I608_pn13 XI1_I608_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I216_MP3 (XI1_I608_I216_p1 I1_I608_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I216_MP0 (VDD I1_I608_pn13 XI1_I608_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I636_MP1 (VDD I1_qu30_b3_2 XI1_I636_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I636_MP5 (I1_b2_14 XI1_I636_Bn XI1_I636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I636_MP4 (XI1_I636_p1 XI1_I636_An I1_b2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I636_MP2 (VDD I1_dd14_b3_0 XI1_I636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I636_MP3 (XI1_I636_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I636_MP0 (VDD I1_dd14_b3_0 XI1_I636_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I637_MP1 (VDD I1_qu30_b3_2 XI1_I637_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I637_MP5 (I1_b2_15 XI1_I637_Bn XI1_I637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I637_MP4 (XI1_I637_p1 XI1_I637_An I1_b2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I637_MP2 (VDD I1_dd15_b3_0 XI1_I637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I637_MP3 (XI1_I637_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I637_MP0 (VDD I1_dd15_b3_0 XI1_I637_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I639_MP1 (VDD I1_qu30_b3_2 XI1_I639_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I639_MP5 (I1_b2_17 XI1_I639_Bn XI1_I639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I639_MP4 (XI1_I639_p1 XI1_I639_An I1_b2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I639_MP2 (VDD I1_dd17_b3_0 XI1_I639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I639_MP3 (XI1_I639_p1 I1_qu30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I639_MP0 (VDD I1_dd17_b3_0 XI1_I639_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I218_MP1 (VDD I1_I608_G14_0n XI1_I608_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I608_I218_MP5 (I1_p1_15 XI1_I608_I218_Bn XI1_I608_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I608_I218_MP4 (XI1_I608_I218_p1 XI1_I608_I218_An I1_p1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I218_MP2 (VDD I1_I608_pn15 XI1_I608_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I608_I218_MP3 (XI1_I608_I218_p1 I1_I608_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I608_I218_MP0 (VDD I1_I608_pn15 XI1_I608_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I640_MP1 (VDD I1_qu30_b3_3 XI1_I640_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I640_MP5 (I1_b2_18 XI1_I640_Bn XI1_I640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I640_MP4 (XI1_I640_p1 XI1_I640_An I1_b2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I640_MP2 (VDD I1_dd18_b3_0 XI1_I640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I640_MP3 (XI1_I640_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I640_MP0 (VDD I1_dd18_b3_0 XI1_I640_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I643_MP1 (VDD I1_qu30_b3_3 XI1_I643_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I643_MP5 (I1_b2_21 XI1_I643_Bn XI1_I643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I643_MP4 (XI1_I643_p1 XI1_I643_An I1_b2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I643_MP2 (VDD I1_dd21_b3_0 XI1_I643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I643_MP3 (XI1_I643_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I643_MP0 (VDD I1_dd21_b3_0 XI1_I643_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I642_MP1 (VDD I1_qu30_b3_3 XI1_I642_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I642_MP5 (I1_b2_20 XI1_I642_Bn XI1_I642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I642_MP4 (XI1_I642_p1 XI1_I642_An I1_b2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I642_MP2 (VDD I1_dd20_b3_0 XI1_I642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I642_MP3 (XI1_I642_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I642_MP0 (VDD I1_dd20_b3_0 XI1_I642_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I645_MP1 (VDD I1_qu30_b3_3 XI1_I645_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I645_MP5 (I1_b2_23 XI1_I645_Bn XI1_I645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I645_MP4 (XI1_I645_p1 XI1_I645_An I1_b2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I645_MP2 (VDD I1_dd23_b3_0 XI1_I645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I645_MP3 (XI1_I645_p1 I1_qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I645_MP0 (VDD I1_dd23_b3_0 XI1_I645_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I655_MP1 (VDD I1_qu30_b3_5 XI1_I655_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I655_MP5 (I1_h2 XI1_I655_Bn XI1_I655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I655_MP4 (XI1_I655_p1 XI1_I655_An I1_h2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I655_MP2 (VDD I1_p1_31 XI1_I655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I655_MP3 (XI1_I655_p1 I1_qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I655_MP0 (VDD I1_p1_31 XI1_I655_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I653_MP1 (VDD I1_qu30_b3_5 XI1_I653_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I653_MP5 (I1_b2_31 XI1_I653_Bn XI1_I653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I653_MP4 (XI1_I653_p1 XI1_I653_An I1_b2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I653_MP2 (VDD I1_dd31_b3_0 XI1_I653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I653_MP3 (XI1_I653_p1 I1_qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I653_MP0 (VDD I1_dd31_b3_0 XI1_I653_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1437_MP1 (VDD I1_qu13_b3_5 XI1_I1437_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1437_MP5 (I1_h19 XI1_I1437_Bn XI1_I1437_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1437_MP4 (XI1_I1437_p1 XI1_I1437_An I1_h19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1437_MP2 (VDD I1_p18_31 XI1_I1437_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1437_MP3 (XI1_I1437_p1 I1_qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1437_MP0 (VDD I1_p18_31 XI1_I1437_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1438_MP1 (VDD I1_c19_o XI1_I1438_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1438_MP5 (I1_p19_32 XI1_I1438_Bn XI1_I1438_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1438_MP4 (XI1_I1438_p1 XI1_I1438_An I1_p19_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1438_MP2 (VDD I1_h19 XI1_I1438_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1438_MP3 (XI1_I1438_p1 I1_c19_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1438_MP0 (VDD I1_h19 XI1_I1438_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1473_MP1 (VDD I1_qu12_b3_3 XI1_I1473_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1473_MP5 (I1_b20_23 XI1_I1473_Bn XI1_I1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1473_MP4 (XI1_I1473_p1 XI1_I1473_An I1_b20_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1473_MP2 (VDD I1_dd23_b3_3 XI1_I1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1473_MP3 (XI1_I1473_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1473_MP0 (VDD I1_dd23_b3_3 XI1_I1473_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1472_MP1 (VDD I1_qu12_b3_3 XI1_I1472_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1472_MP5 (I1_b20_22 XI1_I1472_Bn XI1_I1472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1472_MP4 (XI1_I1472_p1 XI1_I1472_An I1_b20_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1472_MP2 (VDD I1_dd22_b3_3 XI1_I1472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1472_MP3 (XI1_I1472_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1472_MP0 (VDD I1_dd22_b3_3 XI1_I1472_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1471_MP1 (VDD I1_qu12_b3_3 XI1_I1471_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1471_MP5 (I1_b20_21 XI1_I1471_Bn XI1_I1471_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1471_MP4 (XI1_I1471_p1 XI1_I1471_An I1_b20_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1471_MP2 (VDD I1_dd21_b3_3 XI1_I1471_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1471_MP3 (XI1_I1471_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1471_MP0 (VDD I1_dd21_b3_3 XI1_I1471_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1470_MP1 (VDD I1_qu12_b3_3 XI1_I1470_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1470_MP5 (I1_b20_20 XI1_I1470_Bn XI1_I1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1470_MP4 (XI1_I1470_p1 XI1_I1470_An I1_b20_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1470_MP2 (VDD I1_dd20_b3_3 XI1_I1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1470_MP3 (XI1_I1470_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1470_MP0 (VDD I1_dd20_b3_3 XI1_I1470_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1469_MP1 (VDD I1_qu12_b3_3 XI1_I1469_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1469_MP5 (I1_b20_19 XI1_I1469_Bn XI1_I1469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1469_MP4 (XI1_I1469_p1 XI1_I1469_An I1_b20_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1469_MP2 (VDD I1_dd19_b3_3 XI1_I1469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1469_MP3 (XI1_I1469_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1469_MP0 (VDD I1_dd19_b3_3 XI1_I1469_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1468_MP1 (VDD I1_qu12_b3_3 XI1_I1468_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1468_MP5 (I1_b20_18 XI1_I1468_Bn XI1_I1468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1468_MP4 (XI1_I1468_p1 XI1_I1468_An I1_b20_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1468_MP2 (VDD I1_dd18_b3_3 XI1_I1468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1468_MP3 (XI1_I1468_p1 I1_qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1468_MP0 (VDD I1_dd18_b3_3 XI1_I1468_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1467_MP1 (VDD I1_qu12_b3_2 XI1_I1467_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1467_MP5 (I1_b20_17 XI1_I1467_Bn XI1_I1467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1467_MP4 (XI1_I1467_p1 XI1_I1467_An I1_b20_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1467_MP2 (VDD I1_dd17_b3_3 XI1_I1467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1467_MP3 (XI1_I1467_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1467_MP0 (VDD I1_dd17_b3_3 XI1_I1467_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1463_MP1 (VDD I1_qu12_b3_2 XI1_I1463_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1463_MP5 (I1_b20_13 XI1_I1463_Bn XI1_I1463_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1463_MP4 (XI1_I1463_p1 XI1_I1463_An I1_b20_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1463_MP2 (VDD I1_dd13_b3_3 XI1_I1463_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1463_MP3 (XI1_I1463_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1463_MP0 (VDD I1_dd13_b3_3 XI1_I1463_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1462_MP1 (VDD I1_qu12_b3_2 XI1_I1462_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1462_MP5 (I1_b20_12 XI1_I1462_Bn XI1_I1462_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1462_MP4 (XI1_I1462_p1 XI1_I1462_An I1_b20_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1462_MP2 (VDD I1_dd12_b3_3 XI1_I1462_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1462_MP3 (XI1_I1462_p1 I1_qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1462_MP0 (VDD I1_dd12_b3_3 XI1_I1462_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1460_MP1 (VDD I1_qu12_b3_1 XI1_I1460_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1460_MP5 (I1_b20_10 XI1_I1460_Bn XI1_I1460_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1460_MP4 (XI1_I1460_p1 XI1_I1460_An I1_b20_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1460_MP2 (VDD I1_dd10_b3_3 XI1_I1460_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1460_MP3 (XI1_I1460_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1460_MP0 (VDD I1_dd10_b3_3 XI1_I1460_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1459_MP1 (VDD I1_qu12_b3_1 XI1_I1459_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1459_MP5 (I1_b20_9 XI1_I1459_Bn XI1_I1459_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1459_MP4 (XI1_I1459_p1 XI1_I1459_An I1_b20_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1459_MP2 (VDD I1_dd9_b3_3 XI1_I1459_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1459_MP3 (XI1_I1459_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1459_MP0 (VDD I1_dd9_b3_3 XI1_I1459_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1461_MP1 (VDD I1_qu12_b3_1 XI1_I1461_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1461_MP5 (I1_b20_11 XI1_I1461_Bn XI1_I1461_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1461_MP4 (XI1_I1461_p1 XI1_I1461_An I1_b20_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1461_MP2 (VDD I1_dd11_b3_3 XI1_I1461_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1461_MP3 (XI1_I1461_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1461_MP0 (VDD I1_dd11_b3_3 XI1_I1461_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1457_MP1 (VDD I1_qu12_b3_1 XI1_I1457_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1457_MP5 (I1_b20_7 XI1_I1457_Bn XI1_I1457_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1457_MP4 (XI1_I1457_p1 XI1_I1457_An I1_b20_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1457_MP2 (VDD I1_dd7_b3_3 XI1_I1457_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1457_MP3 (XI1_I1457_p1 I1_qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1457_MP0 (VDD I1_dd7_b3_3 XI1_I1457_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1455_MP1 (VDD I1_qu12_b3_0 XI1_I1455_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1455_MP5 (I1_b20_5 XI1_I1455_Bn XI1_I1455_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1455_MP4 (XI1_I1455_p1 XI1_I1455_An I1_b20_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1455_MP2 (VDD I1_dd5_b3_3 XI1_I1455_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1455_MP3 (XI1_I1455_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1455_MP0 (VDD I1_dd5_b3_3 XI1_I1455_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1454_MP1 (VDD I1_qu12_b3_0 XI1_I1454_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1454_MP5 (I1_b20_4 XI1_I1454_Bn XI1_I1454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1454_MP4 (XI1_I1454_p1 XI1_I1454_An I1_b20_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1454_MP2 (VDD I1_dd4_b3_3 XI1_I1454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1454_MP3 (XI1_I1454_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1454_MP0 (VDD I1_dd4_b3_3 XI1_I1454_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1453_MP1 (VDD I1_qu12_b3_0 XI1_I1453_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1453_MP5 (I1_b20_3 XI1_I1453_Bn XI1_I1453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1453_MP4 (XI1_I1453_p1 XI1_I1453_An I1_b20_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1453_MP2 (VDD I1_dd3_b3_3 XI1_I1453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1453_MP3 (XI1_I1453_p1 I1_qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1453_MP0 (VDD I1_dd3_b3_3 XI1_I1453_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I216_MP1 (VDD I1_I1114_G12_0n XI1_I1114_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I216_MP5 (I1_p12_13 XI1_I1114_I216_Bn XI1_I1114_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I216_MP4 (XI1_I1114_I216_p1 XI1_I1114_I216_An I1_p12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I216_MP2 (VDD I1_I1114_pn13 XI1_I1114_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I216_MP3 (XI1_I1114_I216_p1 I1_I1114_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I216_MP0 (VDD I1_I1114_pn13 XI1_I1114_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I215_MP1 (VDD I1_I1114_G11_0n XI1_I1114_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1114_I215_MP5 (I1_p12_12 XI1_I1114_I215_Bn XI1_I1114_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1114_I215_MP4 (XI1_I1114_I215_p1 XI1_I1114_I215_An I1_p12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I215_MP2 (VDD I1_I1114_pn12 XI1_I1114_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1114_I215_MP3 (XI1_I1114_I215_p1 I1_I1114_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1114_I215_MP0 (VDD I1_I1114_pn12 XI1_I1114_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1097_MP1 (VDD I1_qu20_b3_2 XI1_I1097_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1097_MP5 (I1_b12_15 XI1_I1097_Bn XI1_I1097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1097_MP4 (XI1_I1097_p1 XI1_I1097_An I1_b12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1097_MP2 (VDD I1_dd15_b3_2 XI1_I1097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1097_MP3 (XI1_I1097_p1 I1_qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1097_MP0 (VDD I1_dd15_b3_2 XI1_I1097_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I217_MP1 (VDD I1_I1068_G13_0n XI1_I1068_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1068_I217_MP5 (I1_p11_14 XI1_I1068_I217_Bn XI1_I1068_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1068_I217_MP4 (XI1_I1068_I217_p1 XI1_I1068_I217_An I1_p11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I217_MP2 (VDD I1_I1068_pn14 XI1_I1068_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1068_I217_MP3 (XI1_I1068_I217_p1 I1_I1068_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1068_I217_MP0 (VDD I1_I1068_pn14 XI1_I1068_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1054_MP1 (VDD I1_qu21_b3_3 XI1_I1054_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1054_MP5 (I1_b11_18 XI1_I1054_Bn XI1_I1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1054_MP4 (XI1_I1054_p1 XI1_I1054_An I1_b11_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1054_MP2 (VDD I1_dd18_b3_2 XI1_I1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1054_MP3 (XI1_I1054_p1 I1_qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1054_MP0 (VDD I1_dd18_b3_2 XI1_I1054_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1023_MP1 (VDD I1_qu22_b3_5 XI1_I1023_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1023_MP5 (I1_h10 XI1_I1023_Bn XI1_I1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI1_I1023_MP4 (XI1_I1023_p1 XI1_I1023_An I1_h10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1023_MP2 (VDD I1_p9_31 XI1_I1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI1_I1023_MP3 (XI1_I1023_p1 I1_qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1023_MP0 (VDD I1_p9_31 XI1_I1023_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1010_MP1 (VDD I1_qu22_b3_3 XI1_I1010_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1010_MP5 (I1_b10_20 XI1_I1010_Bn XI1_I1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
