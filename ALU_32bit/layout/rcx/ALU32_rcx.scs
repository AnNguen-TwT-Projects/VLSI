    I_MXI2_I1_I42_I222_MP1 (VDD I2_I1_I42_G18_0 XI2_I1_I42_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I222_MP5 (I2_S_19 I2_I1_I42_G18_0 XI2_I1_I42_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I222_MP4 (XI2_I1_I42_I222_p1 XI2_I1_I42_I222_An I2_S_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I222_MP2 (VDD I2_I1_I42_pn19 XI2_I1_I42_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I222_MP3 (XI2_I1_I42_I222_p1 XI2_I1_I42_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I222_MP0 (VDD I2_I1_I42_pn19 XI2_I1_I42_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I225_MP1 (VDD I2_I1_I42_G21_0 XI2_I1_I42_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I225_MP5 (I2_S_22 I2_I1_I42_G21_0 XI2_I1_I42_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I225_MP4 (XI2_I1_I42_I225_p1 XI2_I1_I42_I225_An I2_S_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I225_MP2 (VDD I2_I1_I42_pn22 XI2_I1_I42_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I225_MP3 (XI2_I1_I42_I225_p1 XI2_I1_I42_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I225_MP0 (VDD I2_I1_I42_pn22 XI2_I1_I42_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I54_MP1 (VDD I2_I1_bx22 XI2_I1_I42_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I54_MP5 (I2_I1_I42_pn22 I2_I1_bx22 XI2_I1_I42_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I54_MP4 (XI2_I1_I42_I54_p1 XI2_I1_I42_I54_An I2_I1_I42_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I54_MP2 (VDD A_22 XI2_I1_I42_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I54_MP3 (XI2_I1_I42_I54_p1 XI2_I1_I42_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I54_MP0 (VDD A_22 XI2_I1_I42_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I56_MP1 (VDD I2_I1_bx24 XI2_I1_I42_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I56_MP5 (I2_I1_I42_pn24 I2_I1_bx24 XI2_I1_I42_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I56_MP4 (XI2_I1_I42_I56_p1 XI2_I1_I42_I56_An I2_I1_I42_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I56_MP2 (VDD A_24 XI2_I1_I42_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I56_MP3 (XI2_I1_I42_I56_p1 XI2_I1_I42_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I56_MP0 (VDD A_24 XI2_I1_I42_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I57_MP1 (VDD I2_I1_bx25 XI2_I1_I42_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I57_MP5 (I2_I1_I42_pn25 I2_I1_bx25 XI2_I1_I42_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I57_MP4 (XI2_I1_I42_I57_p1 XI2_I1_I42_I57_An I2_I1_I42_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I57_MP2 (VDD A_25 XI2_I1_I42_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I57_MP3 (XI2_I1_I42_I57_p1 XI2_I1_I42_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I57_MP0 (VDD A_25 XI2_I1_I42_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I233_MP1 (VDD I1_I1712_G29_0 XI1_I1712_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I233_MP5 (I1_p25_30 I1_I1712_G29_0 XI1_I1712_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I233_MP4 (XI1_I1712_I233_p1 XI1_I1712_I233_An I1_p25_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I233_MP2 (VDD I1_I1712_pn30 XI1_I1712_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I233_MP3 (XI1_I1712_I233_p1 XI1_I1712_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I233_MP0 (VDD I1_I1712_pn30 XI1_I1712_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I229_MP1 (VDD I1_I1712_G25_0 XI1_I1712_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I229_MP5 (I1_p25_26 I1_I1712_G25_0 XI1_I1712_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I229_MP4 (XI1_I1712_I229_p1 XI1_I1712_I229_An I1_p25_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I229_MP2 (VDD I1_I1712_pn26 XI1_I1712_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I229_MP3 (XI1_I1712_I229_p1 XI1_I1712_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I229_MP0 (VDD I1_I1712_pn26 XI1_I1712_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I209_MP1 (VDD I1_I1712_G5_0 XI1_I1712_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I209_MP5 (I1_p25_6 I1_I1712_G5_0 XI1_I1712_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I209_MP4 (XI1_I1712_I209_p1 XI1_I1712_I209_An I1_p25_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I209_MP2 (VDD I1_I1712_pn6 XI1_I1712_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I209_MP3 (XI1_I1712_I209_p1 XI1_I1712_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I209_MP0 (VDD I1_I1712_pn6 XI1_I1712_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I36_MP1 (VDD I1_b25_4 XI1_I1712_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I36_MP5 (I1_I1712_pn4 I1_b25_4 XI1_I1712_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I36_MP4 (XI1_I1712_I36_p1 XI1_I1712_I36_An I1_I1712_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I36_MP2 (VDD I1_p24_3 XI1_I1712_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I36_MP3 (XI1_I1712_I36_p1 XI1_I1712_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I36_MP0 (VDD I1_p24_3 XI1_I1712_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I233_MP1 (VDD I1_I1528_G29_0 XI1_I1528_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I233_MP5 (I1_p21_30 I1_I1528_G29_0 XI1_I1528_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I233_MP4 (XI1_I1528_I233_p1 XI1_I1528_I233_An I1_p21_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I233_MP2 (VDD I1_I1528_pn30 XI1_I1528_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I233_MP3 (XI1_I1528_I233_p1 XI1_I1528_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I233_MP0 (VDD I1_I1528_pn30 XI1_I1528_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I225_MP1 (VDD I1_I1528_G21_0 XI1_I1528_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1528_I225_MP5 (I1_p21_22 I1_I1528_G21_0 XI1_I1528_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1528_I225_MP4 (XI1_I1528_I225_p1 XI1_I1528_I225_An I1_p21_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I225_MP2 (VDD I1_I1528_pn22 XI1_I1528_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1528_I225_MP3 (XI1_I1528_I225_p1 XI1_I1528_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I225_MP0 (VDD I1_I1528_pn22 XI1_I1528_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I63_MP1 (VDD I1_b22_31 XI1_I1574_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I63_MP5 (I1_I1574_pn31 I1_b22_31 XI1_I1574_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I63_MP4 (XI1_I1574_I63_p1 XI1_I1574_I63_An I1_I1574_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I63_MP2 (VDD I1_p21_30 XI1_I1574_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I63_MP3 (XI1_I1574_I63_p1 XI1_I1574_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I63_MP0 (VDD I1_p21_30 XI1_I1574_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I61_MP1 (VDD I1_b22_29 XI1_I1574_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I61_MP5 (I1_I1574_pn29 I1_b22_29 XI1_I1574_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I61_MP4 (XI1_I1574_I61_p1 XI1_I1574_I61_An I1_I1574_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I61_MP2 (VDD I1_p21_28 XI1_I1574_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I61_MP3 (XI1_I1574_I61_p1 XI1_I1574_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I61_MP0 (VDD I1_p21_28 XI1_I1574_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I48_MP1 (VDD I1_b22_16 XI1_I1574_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I48_MP5 (I1_I1574_pn16 I1_b22_16 XI1_I1574_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I48_MP4 (XI1_I1574_I48_p1 XI1_I1574_I48_An I1_I1574_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I48_MP2 (VDD I1_p21_15 XI1_I1574_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I48_MP3 (XI1_I1574_I48_p1 XI1_I1574_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I48_MP0 (VDD I1_p21_15 XI1_I1574_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I47_MP1 (VDD I1_b22_15 XI1_I1574_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I47_MP5 (I1_I1574_pn15 I1_b22_15 XI1_I1574_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I47_MP4 (XI1_I1574_I47_p1 XI1_I1574_I47_An I1_I1574_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I47_MP2 (VDD I1_p21_14 XI1_I1574_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I47_MP3 (XI1_I1574_I47_p1 XI1_I1574_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I47_MP0 (VDD I1_p21_14 XI1_I1574_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I209_MP1 (VDD I1_I1574_G5_0 XI1_I1574_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I209_MP5 (I1_p22_6 I1_I1574_G5_0 XI1_I1574_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I209_MP4 (XI1_I1574_I209_p1 XI1_I1574_I209_An I1_p22_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I209_MP2 (VDD I1_I1574_pn6 XI1_I1574_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I209_MP3 (XI1_I1574_I209_p1 XI1_I1574_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I209_MP0 (VDD I1_I1574_pn6 XI1_I1574_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I64_MP1 (VDD I1_nakn10 XI1_I64_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I64_MP5 (I1_aa10 I1_nakn10 XI1_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I64_MP4 (XI1_I64_p1 XI1_I64_An I1_aa10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I64_MP2 (VDD A_10 XI1_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I64_MP3 (XI1_I64_p1 XI1_I64_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I64_MP0 (VDD A_10 XI1_I64_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I45_MP1 (VDD I2_I1_bx13 XI2_I1_I42_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I45_MP5 (I2_I1_I42_pn13 I2_I1_bx13 XI2_I1_I42_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I45_MP4 (XI2_I1_I42_I45_p1 XI2_I1_I42_I45_An I2_I1_I42_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I45_MP2 (VDD A_13 XI2_I1_I42_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I45_MP3 (XI2_I1_I42_I45_p1 XI2_I1_I42_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I45_MP0 (VDD A_13 XI2_I1_I42_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I228_MP1 (VDD I2_I1_I42_G24_0 XI2_I1_I42_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I228_MP5 (I2_S_25 I2_I1_I42_G24_0 XI2_I1_I42_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I228_MP4 (XI2_I1_I42_I228_p1 XI2_I1_I42_I228_An I2_S_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I228_MP2 (VDD I2_I1_I42_pn25 XI2_I1_I42_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I228_MP3 (XI2_I1_I42_I228_p1 XI2_I1_I42_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I228_MP0 (VDD I2_I1_I42_pn25 XI2_I1_I42_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I58_MP1 (VDD I2_I1_bx26 XI2_I1_I42_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I58_MP5 (I2_I1_I42_pn26 I2_I1_bx26 XI2_I1_I42_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I58_MP4 (XI2_I1_I42_I58_p1 XI2_I1_I42_I58_An I2_I1_I42_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I58_MP2 (VDD A_26 XI2_I1_I42_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I58_MP3 (XI2_I1_I42_I58_p1 XI2_I1_I42_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I58_MP0 (VDD A_26 XI2_I1_I42_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I59_MP1 (VDD I2_I1_bx27 XI2_I1_I42_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I59_MP5 (I2_I1_I42_pn27 I2_I1_bx27 XI2_I1_I42_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I59_MP4 (XI2_I1_I42_I59_p1 XI2_I1_I42_I59_An I2_I1_I42_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I59_MP2 (VDD A_27 XI2_I1_I42_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I59_MP3 (XI2_I1_I42_I59_p1 XI2_I1_I42_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I59_MP0 (VDD A_27 XI2_I1_I42_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I232_MP1 (VDD I2_I1_I42_G28_0 XI2_I1_I42_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I232_MP5 (I2_S_29 I2_I1_I42_G28_0 XI2_I1_I42_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I232_MP4 (XI2_I1_I42_I232_p1 XI2_I1_I42_I232_An I2_S_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I232_MP2 (VDD I2_I1_I42_pn29 XI2_I1_I42_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I232_MP3 (XI2_I1_I42_I232_p1 XI2_I1_I42_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I232_MP0 (VDD I2_I1_I42_pn29 XI2_I1_I42_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I56_MP1 (VDD I1_b0_24 XI1_I562_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I56_MP5 (I1_I562_pn24 I1_b0_24 XI1_I562_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I56_MP4 (XI1_I562_I56_p1 XI1_I562_I56_An I1_I562_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I56_MP2 (VDD VSS XI1_I562_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I56_MP3 (XI1_I562_I56_p1 XI1_I562_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I56_MP0 (VDD VSS XI1_I562_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I60_MP1 (VDD I1_b25_28 XI1_I1712_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I60_MP5 (I1_I1712_pn28 I1_b25_28 XI1_I1712_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I60_MP4 (XI1_I1712_I60_p1 XI1_I1712_I60_An I1_I1712_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I60_MP2 (VDD I1_p24_27 XI1_I1712_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I60_MP3 (XI1_I1712_I60_p1 XI1_I1712_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I60_MP0 (VDD I1_p24_27 XI1_I1712_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I232_MP1 (VDD I1_I1712_G28_0 XI1_I1712_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I232_MP5 (I1_p25_29 I1_I1712_G28_0 XI1_I1712_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I232_MP4 (XI1_I1712_I232_p1 XI1_I1712_I232_An I1_p25_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I232_MP2 (VDD I1_I1712_pn29 XI1_I1712_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I232_MP3 (XI1_I1712_I232_p1 XI1_I1712_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I232_MP0 (VDD I1_I1712_pn29 XI1_I1712_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I227_MP1 (VDD I1_I1712_G23_0 XI1_I1712_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I227_MP5 (I1_p25_24 I1_I1712_G23_0 XI1_I1712_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I227_MP4 (XI1_I1712_I227_p1 XI1_I1712_I227_An I1_p25_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I227_MP2 (VDD I1_I1712_pn24 XI1_I1712_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I227_MP3 (XI1_I1712_I227_p1 XI1_I1712_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I227_MP0 (VDD I1_I1712_pn24 XI1_I1712_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I211_MP1 (VDD I1_I1712_G7_0 XI1_I1712_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I211_MP5 (I1_p25_8 I1_I1712_G7_0 XI1_I1712_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I211_MP4 (XI1_I1712_I211_p1 XI1_I1712_I211_An I1_p25_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I211_MP2 (VDD I1_I1712_pn8 XI1_I1712_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I211_MP3 (XI1_I1712_I211_p1 XI1_I1712_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I211_MP0 (VDD I1_I1712_pn8 XI1_I1712_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I208_MP1 (VDD I1_I1712_G4_0 XI1_I1712_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I208_MP5 (I1_p25_5 I1_I1712_G4_0 XI1_I1712_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I208_MP4 (XI1_I1712_I208_p1 XI1_I1712_I208_An I1_p25_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I208_MP2 (VDD I1_I1712_pn5 XI1_I1712_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I208_MP3 (XI1_I1712_I208_p1 XI1_I1712_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I208_MP0 (VDD I1_I1712_pn5 XI1_I1712_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I35_MP1 (VDD I1_b25_3 XI1_I1712_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I35_MP5 (I1_I1712_pn3 I1_b25_3 XI1_I1712_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I35_MP4 (XI1_I1712_I35_p1 XI1_I1712_I35_An I1_I1712_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I35_MP2 (VDD I1_p24_2 XI1_I1712_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I35_MP3 (XI1_I1712_I35_p1 XI1_I1712_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I35_MP0 (VDD I1_p24_2 XI1_I1712_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I37_MP1 (VDD I1_b25_5 XI1_I1712_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I37_MP5 (I1_I1712_pn5 I1_b25_5 XI1_I1712_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I37_MP4 (XI1_I1712_I37_p1 XI1_I1712_I37_An I1_I1712_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I37_MP2 (VDD I1_p24_4 XI1_I1712_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I37_MP3 (XI1_I1712_I37_p1 XI1_I1712_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I37_MP0 (VDD I1_p24_4 XI1_I1712_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I62_MP1 (VDD I1_b22_30 XI1_I1574_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I62_MP5 (I1_I1574_pn30 I1_b22_30 XI1_I1574_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I62_MP4 (XI1_I1574_I62_p1 XI1_I1574_I62_An I1_I1574_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I62_MP2 (VDD I1_p21_29 XI1_I1574_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I62_MP3 (XI1_I1574_I62_p1 XI1_I1574_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I62_MP0 (VDD I1_p21_29 XI1_I1574_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I60_MP1 (VDD I1_b22_28 XI1_I1574_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I60_MP5 (I1_I1574_pn28 I1_b22_28 XI1_I1574_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I60_MP4 (XI1_I1574_I60_p1 XI1_I1574_I60_An I1_I1574_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I60_MP2 (VDD I1_p21_27 XI1_I1574_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I60_MP3 (XI1_I1574_I60_p1 XI1_I1574_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I60_MP0 (VDD I1_p21_27 XI1_I1574_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I231_MP1 (VDD I1_I1574_G27_0 XI1_I1574_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I231_MP5 (I1_p22_28 I1_I1574_G27_0 XI1_I1574_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I231_MP4 (XI1_I1574_I231_p1 XI1_I1574_I231_An I1_p22_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I231_MP2 (VDD I1_I1574_pn28 XI1_I1574_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I231_MP3 (XI1_I1574_I231_p1 XI1_I1574_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I231_MP0 (VDD I1_I1574_pn28 XI1_I1574_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I50_MP1 (VDD I1_b22_18 XI1_I1574_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I50_MP5 (I1_I1574_pn18 I1_b22_18 XI1_I1574_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I50_MP4 (XI1_I1574_I50_p1 XI1_I1574_I50_An I1_I1574_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I50_MP2 (VDD I1_p21_17 XI1_I1574_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I50_MP3 (XI1_I1574_I50_p1 XI1_I1574_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I50_MP0 (VDD I1_p21_17 XI1_I1574_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I233_MP1 (VDD I1_I1574_G29_0 XI1_I1574_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I233_MP5 (I1_p22_30 I1_I1574_G29_0 XI1_I1574_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I233_MP4 (XI1_I1574_I233_p1 XI1_I1574_I233_An I1_p22_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I233_MP2 (VDD I1_I1574_pn30 XI1_I1574_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I233_MP3 (XI1_I1574_I233_p1 XI1_I1574_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I233_MP0 (VDD I1_I1574_pn30 XI1_I1574_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I49_MP1 (VDD I1_b22_17 XI1_I1574_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I49_MP5 (I1_I1574_pn17 I1_b22_17 XI1_I1574_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I49_MP4 (XI1_I1574_I49_p1 XI1_I1574_I49_An I1_I1574_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I49_MP2 (VDD I1_p21_16 XI1_I1574_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I49_MP3 (XI1_I1574_I49_p1 XI1_I1574_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I49_MP0 (VDD I1_p21_16 XI1_I1574_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I229_MP1 (VDD I1_I1574_G25_0 XI1_I1574_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I229_MP5 (I1_p22_26 I1_I1574_G25_0 XI1_I1574_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I229_MP4 (XI1_I1574_I229_p1 XI1_I1574_I229_An I1_p22_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I229_MP2 (VDD I1_I1574_pn26 XI1_I1574_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I229_MP3 (XI1_I1574_I229_p1 XI1_I1574_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I229_MP0 (VDD I1_I1574_pn26 XI1_I1574_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I34_MP1 (VDD I1_b22_2 XI1_I1574_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I34_MP5 (I1_I1574_pn2 I1_b22_2 XI1_I1574_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I34_MP4 (XI1_I1574_I34_p1 XI1_I1574_I34_An I1_I1574_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I34_MP2 (VDD I1_p21_1 XI1_I1574_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I34_MP3 (XI1_I1574_I34_p1 XI1_I1574_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I34_MP0 (VDD I1_p21_1 XI1_I1574_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I44_MP1 (VDD I2_I1_bx12 XI2_I1_I42_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I44_MP5 (I2_I1_I42_pn12 I2_I1_bx12 XI2_I1_I42_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I44_MP4 (XI2_I1_I42_I44_p1 XI2_I1_I42_I44_An I2_I1_I42_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I44_MP2 (VDD A_12 XI2_I1_I42_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I44_MP3 (XI2_I1_I42_I44_p1 XI2_I1_I42_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I44_MP0 (VDD A_12 XI2_I1_I42_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I227_MP1 (VDD I2_I1_I42_G23_0 XI2_I1_I42_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I227_MP5 (I2_S_24 I2_I1_I42_G23_0 XI2_I1_I42_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I227_MP4 (XI2_I1_I42_I227_p1 XI2_I1_I42_I227_An I2_S_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I227_MP2 (VDD I2_I1_I42_pn24 XI2_I1_I42_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I227_MP3 (XI2_I1_I42_I227_p1 XI2_I1_I42_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I227_MP0 (VDD I2_I1_I42_pn24 XI2_I1_I42_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I229_MP1 (VDD I2_I1_I42_G25_0 XI2_I1_I42_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I229_MP5 (I2_S_26 I2_I1_I42_G25_0 XI2_I1_I42_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I229_MP4 (XI2_I1_I42_I229_p1 XI2_I1_I42_I229_An I2_S_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I229_MP2 (VDD I2_I1_I42_pn26 XI2_I1_I42_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I229_MP3 (XI2_I1_I42_I229_p1 XI2_I1_I42_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I229_MP0 (VDD I2_I1_I42_pn26 XI2_I1_I42_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I231_MP1 (VDD I2_I1_I42_G27_0 XI2_I1_I42_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I231_MP5 (I2_S_28 I2_I1_I42_G27_0 XI2_I1_I42_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I231_MP4 (XI2_I1_I42_I231_p1 XI2_I1_I42_I231_An I2_S_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I231_MP2 (VDD I2_I1_I42_pn28 XI2_I1_I42_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I231_MP3 (XI2_I1_I42_I231_p1 XI2_I1_I42_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I231_MP0 (VDD I2_I1_I42_pn28 XI2_I1_I42_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I60_MP1 (VDD I2_I1_bx28 XI2_I1_I42_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I60_MP5 (I2_I1_I42_pn28 I2_I1_bx28 XI2_I1_I42_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I60_MP4 (XI2_I1_I42_I60_p1 XI2_I1_I42_I60_An I2_I1_I42_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I60_MP2 (VDD A_28 XI2_I1_I42_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I60_MP3 (XI2_I1_I42_I60_p1 XI2_I1_I42_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I60_MP0 (VDD A_28 XI2_I1_I42_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I230_MP1 (VDD I2_I1_I42_G26_0 XI2_I1_I42_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I230_MP5 (I2_S_27 I2_I1_I42_G26_0 XI2_I1_I42_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I230_MP4 (XI2_I1_I42_I230_p1 XI2_I1_I42_I230_An I2_S_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I230_MP2 (VDD I2_I1_I42_pn27 XI2_I1_I42_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I230_MP3 (XI2_I1_I42_I230_p1 XI2_I1_I42_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I230_MP0 (VDD I2_I1_I42_pn27 XI2_I1_I42_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I61_MP1 (VDD I2_I1_bx29 XI2_I1_I42_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I61_MP5 (I2_I1_I42_pn29 I2_I1_bx29 XI2_I1_I42_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I61_MP4 (XI2_I1_I42_I61_p1 XI2_I1_I42_I61_An I2_I1_I42_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I61_MP2 (VDD A_29 XI2_I1_I42_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I61_MP3 (XI2_I1_I42_I61_p1 XI2_I1_I42_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I61_MP0 (VDD A_29 XI2_I1_I42_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I227_MP1 (VDD I1_I562_G23_0 XI1_I562_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I562_I227_MP5 (I1_p0_24 I1_I562_G23_0 XI1_I562_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I562_I227_MP4 (XI1_I562_I227_p1 XI1_I562_I227_An I1_p0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I227_MP2 (VDD I1_I562_pn24 XI1_I562_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I562_I227_MP3 (XI1_I562_I227_p1 XI1_I562_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I227_MP0 (VDD I1_I562_pn24 XI1_I562_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I59_MP1 (VDD I1_b25_27 XI1_I1712_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I59_MP5 (I1_I1712_pn27 I1_b25_27 XI1_I1712_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I59_MP4 (XI1_I1712_I59_p1 XI1_I1712_I59_An I1_I1712_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I59_MP2 (VDD I1_p24_26 XI1_I1712_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I59_MP3 (XI1_I1712_I59_p1 XI1_I1712_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I59_MP0 (VDD I1_p24_26 XI1_I1712_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I205_MP1 (VDD I1_I1712_G1_0 XI1_I1712_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I205_MP5 (I1_p25_2 I1_I1712_G1_0 XI1_I1712_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I205_MP4 (XI1_I1712_I205_p1 XI1_I1712_I205_An I1_p25_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I205_MP2 (VDD I1_I1712_pn2 XI1_I1712_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I205_MP3 (XI1_I1712_I205_p1 XI1_I1712_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I205_MP0 (VDD I1_I1712_pn2 XI1_I1712_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I34_MP1 (VDD I1_b25_2 XI1_I1712_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I34_MP5 (I1_I1712_pn2 I1_b25_2 XI1_I1712_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I34_MP4 (XI1_I1712_I34_p1 XI1_I1712_I34_An I1_I1712_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I34_MP2 (VDD I1_p24_1 XI1_I1712_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I34_MP3 (XI1_I1712_I34_p1 XI1_I1712_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I34_MP0 (VDD I1_p24_1 XI1_I1712_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I59_MP1 (VDD I1_b22_27 XI1_I1574_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I59_MP5 (I1_I1574_pn27 I1_b22_27 XI1_I1574_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I59_MP4 (XI1_I1574_I59_p1 XI1_I1574_I59_An I1_I1574_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I59_MP2 (VDD I1_p21_26 XI1_I1574_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I59_MP3 (XI1_I1574_I59_p1 XI1_I1574_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I59_MP0 (VDD I1_p21_26 XI1_I1574_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I57_MP1 (VDD I1_b22_25 XI1_I1574_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I57_MP5 (I1_I1574_pn25 I1_b22_25 XI1_I1574_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I57_MP4 (XI1_I1574_I57_p1 XI1_I1574_I57_An I1_I1574_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I57_MP2 (VDD I1_p21_24 XI1_I1574_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I57_MP3 (XI1_I1574_I57_p1 XI1_I1574_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I57_MP0 (VDD I1_p21_24 XI1_I1574_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I58_MP1 (VDD I1_b22_26 XI1_I1574_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I58_MP5 (I1_I1574_pn26 I1_b22_26 XI1_I1574_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I58_MP4 (XI1_I1574_I58_p1 XI1_I1574_I58_An I1_I1574_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I58_MP2 (VDD I1_p21_25 XI1_I1574_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I58_MP3 (XI1_I1574_I58_p1 XI1_I1574_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I58_MP0 (VDD I1_p21_25 XI1_I1574_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I232_MP1 (VDD I1_I1574_G28_0 XI1_I1574_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I232_MP5 (I1_p22_29 I1_I1574_G28_0 XI1_I1574_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I232_MP4 (XI1_I1574_I232_p1 XI1_I1574_I232_An I1_p22_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I232_MP2 (VDD I1_I1574_pn29 XI1_I1574_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I232_MP3 (XI1_I1574_I232_p1 XI1_I1574_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I232_MP0 (VDD I1_I1574_pn29 XI1_I1574_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I221_MP1 (VDD I1_I1574_G17_0 XI1_I1574_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I221_MP5 (I1_p22_18 I1_I1574_G17_0 XI1_I1574_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I221_MP4 (XI1_I1574_I221_p1 XI1_I1574_I221_An I1_p22_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I221_MP2 (VDD I1_I1574_pn18 XI1_I1574_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I221_MP3 (XI1_I1574_I221_p1 XI1_I1574_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I221_MP0 (VDD I1_I1574_pn18 XI1_I1574_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I43_MP1 (VDD I2_I1_bx11 XI2_I1_I42_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I43_MP5 (I2_I1_I42_pn11 I2_I1_bx11 XI2_I1_I42_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I43_MP4 (XI2_I1_I42_I43_p1 XI2_I1_I42_I43_An I2_I1_I42_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I43_MP2 (VDD A_11 XI2_I1_I42_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I43_MP3 (XI2_I1_I42_I43_p1 XI2_I1_I42_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I43_MP0 (VDD A_11 XI2_I1_I42_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I62_MP1 (VDD I2_I1_bx30 XI2_I1_I42_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I62_MP5 (I2_I1_I42_pn30 I2_I1_bx30 XI2_I1_I42_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I62_MP4 (XI2_I1_I42_I62_p1 XI2_I1_I42_I62_An I2_I1_I42_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I62_MP2 (VDD A_30 XI2_I1_I42_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I62_MP3 (XI2_I1_I42_I62_p1 XI2_I1_I42_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I62_MP0 (VDD A_30 XI2_I1_I42_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I234_MP1 (VDD I2_CM XI2_I1_I42_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I234_MP5 (I2_S_31 I2_CM XI2_I1_I42_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I234_MP4 (XI2_I1_I42_I234_p1 XI2_I1_I42_I234_An I2_S_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I234_MP2 (VDD I2_I1_I42_pn31 XI2_I1_I42_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I234_MP3 (XI2_I1_I42_I234_p1 XI2_I1_I42_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I234_MP0 (VDD I2_I1_I42_pn31 XI2_I1_I42_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I61_MP1 (VDD I1_b25_29 XI1_I1712_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I61_MP5 (I1_I1712_pn29 I1_b25_29 XI1_I1712_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I61_MP4 (XI1_I1712_I61_p1 XI1_I1712_I61_An I1_I1712_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I61_MP2 (VDD I1_p24_28 XI1_I1712_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I61_MP3 (XI1_I1712_I61_p1 XI1_I1712_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I61_MP0 (VDD I1_p24_28 XI1_I1712_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I230_MP1 (VDD I1_I1712_G26_0 XI1_I1712_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I230_MP5 (I1_p25_27 I1_I1712_G26_0 XI1_I1712_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I230_MP4 (XI1_I1712_I230_p1 XI1_I1712_I230_An I1_p25_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I230_MP2 (VDD I1_I1712_pn27 XI1_I1712_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I230_MP3 (XI1_I1712_I230_p1 XI1_I1712_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I230_MP0 (VDD I1_I1712_pn27 XI1_I1712_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I56_MP1 (VDD I1_b25_24 XI1_I1712_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I56_MP5 (I1_I1712_pn24 I1_b25_24 XI1_I1712_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I56_MP4 (XI1_I1712_I56_p1 XI1_I1712_I56_An I1_I1712_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I56_MP2 (VDD I1_p24_23 XI1_I1712_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I56_MP3 (XI1_I1712_I56_p1 XI1_I1712_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I56_MP0 (VDD I1_p24_23 XI1_I1712_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I38_MP1 (VDD I1_b25_6 XI1_I1712_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I38_MP5 (I1_I1712_pn6 I1_b25_6 XI1_I1712_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I38_MP4 (XI1_I1712_I38_p1 XI1_I1712_I38_An I1_I1712_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I38_MP2 (VDD I1_p24_5 XI1_I1712_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I38_MP3 (XI1_I1712_I38_p1 XI1_I1712_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I38_MP0 (VDD I1_p24_5 XI1_I1712_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I33_MP1 (VDD I1_b25_1 XI1_I1712_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I33_MP5 (I1_I1712_pn1 I1_b25_1 XI1_I1712_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I33_MP4 (XI1_I1712_I33_p1 XI1_I1712_I33_An I1_I1712_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I33_MP2 (VDD I1_p24_0 XI1_I1712_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I33_MP3 (XI1_I1712_I33_p1 XI1_I1712_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I33_MP0 (VDD I1_p24_0 XI1_I1712_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I204_MP1 (VDD I1_I1666_G0_0 XI1_I1666_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I204_MP5 (I1_p24_1 I1_I1666_G0_0 XI1_I1666_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I204_MP4 (XI1_I1666_I204_p1 XI1_I1666_I204_An I1_p24_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I204_MP2 (VDD I1_I1666_pn1 XI1_I1666_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I204_MP3 (XI1_I1666_I204_p1 XI1_I1666_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I204_MP0 (VDD I1_I1666_pn1 XI1_I1666_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I32_MP1 (VDD I1_b24_0 XI1_I1666_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I32_MP5 (I1_I1666_pn0 I1_b24_0 XI1_I1666_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I32_MP4 (XI1_I1666_I32_p1 XI1_I1666_I32_An I1_I1666_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I32_MP2 (VDD I1_aa7 XI1_I1666_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I32_MP3 (XI1_I1666_I32_p1 XI1_I1666_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I32_MP0 (VDD I1_aa7 XI1_I1666_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I203_MP1 (VDD I1_qu8_b3_5 XI1_I1666_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I203_MP5 (I1_p24_0 I1_qu8_b3_5 XI1_I1666_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I203_MP4 (XI1_I1666_I203_p1 XI1_I1666_I203_An I1_p24_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I203_MP2 (VDD I1_I1666_pn0 XI1_I1666_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I203_MP3 (XI1_I1666_I203_p1 XI1_I1666_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I203_MP0 (VDD I1_I1666_pn0 XI1_I1666_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I56_MP1 (VDD I1_b22_24 XI1_I1574_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I56_MP5 (I1_I1574_pn24 I1_b22_24 XI1_I1574_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I56_MP4 (XI1_I1574_I56_p1 XI1_I1574_I56_An I1_I1574_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I56_MP2 (VDD I1_p21_23 XI1_I1574_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I56_MP3 (XI1_I1574_I56_p1 XI1_I1574_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I56_MP0 (VDD I1_p21_23 XI1_I1574_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I227_MP1 (VDD I1_I1574_G23_0 XI1_I1574_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I227_MP5 (I1_p22_24 I1_I1574_G23_0 XI1_I1574_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I227_MP4 (XI1_I1574_I227_p1 XI1_I1574_I227_An I1_p22_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I227_MP2 (VDD I1_I1574_pn24 XI1_I1574_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I227_MP3 (XI1_I1574_I227_p1 XI1_I1574_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I227_MP0 (VDD I1_I1574_pn24 XI1_I1574_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I225_MP1 (VDD I1_I1574_G21_0 XI1_I1574_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I225_MP5 (I1_p22_22 I1_I1574_G21_0 XI1_I1574_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I225_MP4 (XI1_I1574_I225_p1 XI1_I1574_I225_An I1_p22_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I225_MP2 (VDD I1_I1574_pn22 XI1_I1574_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I225_MP3 (XI1_I1574_I225_p1 XI1_I1574_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I225_MP0 (VDD I1_I1574_pn22 XI1_I1574_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I228_MP1 (VDD I1_I1574_G24_0 XI1_I1574_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I228_MP5 (I1_p22_25 I1_I1574_G24_0 XI1_I1574_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I228_MP4 (XI1_I1574_I228_p1 XI1_I1574_I228_An I1_p22_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I228_MP2 (VDD I1_I1574_pn25 XI1_I1574_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I228_MP3 (XI1_I1574_I228_p1 XI1_I1574_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I228_MP0 (VDD I1_I1574_pn25 XI1_I1574_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I220_MP1 (VDD I1_I1574_G16_0 XI1_I1574_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I220_MP5 (I1_p22_17 I1_I1574_G16_0 XI1_I1574_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I220_MP4 (XI1_I1574_I220_p1 XI1_I1574_I220_An I1_p22_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I220_MP2 (VDD I1_I1574_pn17 XI1_I1574_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I220_MP3 (XI1_I1574_I220_p1 XI1_I1574_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I220_MP0 (VDD I1_I1574_pn17 XI1_I1574_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I208_MP1 (VDD I1_I1574_G4_0 XI1_I1574_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I208_MP5 (I1_p22_5 I1_I1574_G4_0 XI1_I1574_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I208_MP4 (XI1_I1574_I208_p1 XI1_I1574_I208_An I1_p22_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I208_MP2 (VDD I1_I1574_pn5 XI1_I1574_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I208_MP3 (XI1_I1574_I208_p1 XI1_I1574_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I208_MP0 (VDD I1_I1574_pn5 XI1_I1574_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I205_MP1 (VDD I1_I1574_G1_0 XI1_I1574_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I205_MP5 (I1_p22_2 I1_I1574_G1_0 XI1_I1574_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I205_MP4 (XI1_I1574_I205_p1 XI1_I1574_I205_An I1_p22_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I205_MP2 (VDD I1_I1574_pn2 XI1_I1574_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I205_MP3 (XI1_I1574_I205_p1 XI1_I1574_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I205_MP0 (VDD I1_I1574_pn2 XI1_I1574_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I33_MP1 (VDD I1_b22_1 XI1_I1574_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I33_MP5 (I1_I1574_pn1 I1_b22_1 XI1_I1574_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I33_MP4 (XI1_I1574_I33_p1 XI1_I1574_I33_An I1_I1574_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I33_MP2 (VDD I1_p21_0 XI1_I1574_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I33_MP3 (XI1_I1574_I33_p1 XI1_I1574_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I33_MP0 (VDD I1_p21_0 XI1_I1574_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I233_MP1 (VDD I2_I1_I42_G29_0 XI2_I1_I42_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I233_MP5 (I2_S_30 I2_I1_I42_G29_0 XI2_I1_I42_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I233_MP4 (XI2_I1_I42_I233_p1 XI2_I1_I42_I233_An I2_S_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I233_MP2 (VDD I2_I1_I42_pn30 XI2_I1_I42_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I233_MP3 (XI2_I1_I42_I233_p1 XI2_I1_I42_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I233_MP0 (VDD I2_I1_I42_pn30 XI2_I1_I42_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I63_MP1 (VDD I2_I1_bx31 XI2_I1_I42_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I63_MP5 (I2_I1_I42_pn31 I2_I1_bx31 XI2_I1_I42_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I63_MP4 (XI2_I1_I42_I63_p1 XI2_I1_I42_I63_An I2_I1_I42_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I63_MP2 (VDD A_31 XI2_I1_I42_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I63_MP3 (XI2_I1_I42_I63_p1 XI2_I1_I42_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I63_MP0 (VDD A_31 XI2_I1_I42_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I62_MP1 (VDD I1_b25_30 XI1_I1712_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I62_MP5 (I1_I1712_pn30 I1_b25_30 XI1_I1712_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I62_MP4 (XI1_I1712_I62_p1 XI1_I1712_I62_An I1_I1712_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I62_MP2 (VDD I1_p24_29 XI1_I1712_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I62_MP3 (XI1_I1712_I62_p1 XI1_I1712_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I62_MP0 (VDD I1_p24_29 XI1_I1712_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I58_MP1 (VDD I1_b25_26 XI1_I1712_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I58_MP5 (I1_I1712_pn26 I1_b25_26 XI1_I1712_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I58_MP4 (XI1_I1712_I58_p1 XI1_I1712_I58_An I1_I1712_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I58_MP2 (VDD I1_p24_25 XI1_I1712_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I58_MP3 (XI1_I1712_I58_p1 XI1_I1712_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I58_MP0 (VDD I1_p24_25 XI1_I1712_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I210_MP1 (VDD I1_I1712_G6_0 XI1_I1712_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I210_MP5 (I1_p25_7 I1_I1712_G6_0 XI1_I1712_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I210_MP4 (XI1_I1712_I210_p1 XI1_I1712_I210_An I1_p25_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I210_MP2 (VDD I1_I1712_pn7 XI1_I1712_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I210_MP3 (XI1_I1712_I210_p1 XI1_I1712_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I210_MP0 (VDD I1_I1712_pn7 XI1_I1712_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I39_MP1 (VDD I1_b25_7 XI1_I1712_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I39_MP5 (I1_I1712_pn7 I1_b25_7 XI1_I1712_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I39_MP4 (XI1_I1712_I39_p1 XI1_I1712_I39_An I1_I1712_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I39_MP2 (VDD I1_p24_6 XI1_I1712_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I39_MP3 (XI1_I1712_I39_p1 XI1_I1712_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I39_MP0 (VDD I1_p24_6 XI1_I1712_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I40_MP1 (VDD I1_b25_8 XI1_I1712_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I40_MP5 (I1_I1712_pn8 I1_b25_8 XI1_I1712_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I40_MP4 (XI1_I1712_I40_p1 XI1_I1712_I40_An I1_I1712_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I40_MP2 (VDD I1_p24_7 XI1_I1712_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I40_MP3 (XI1_I1712_I40_p1 XI1_I1712_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I40_MP0 (VDD I1_p24_7 XI1_I1712_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I204_MP1 (VDD I1_I1712_G0_0 XI1_I1712_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I204_MP5 (I1_p25_1 I1_I1712_G0_0 XI1_I1712_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I204_MP4 (XI1_I1712_I204_p1 XI1_I1712_I204_An I1_p25_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I204_MP2 (VDD I1_I1712_pn1 XI1_I1712_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I204_MP3 (XI1_I1712_I204_p1 XI1_I1712_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I204_MP0 (VDD I1_I1712_pn1 XI1_I1712_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I205_MP1 (VDD I1_I1666_G1_0 XI1_I1666_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I205_MP5 (I1_p24_2 I1_I1666_G1_0 XI1_I1666_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I205_MP4 (XI1_I1666_I205_p1 XI1_I1666_I205_An I1_p24_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I205_MP2 (VDD I1_I1666_pn2 XI1_I1666_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I205_MP3 (XI1_I1666_I205_p1 XI1_I1666_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I205_MP0 (VDD I1_I1666_pn2 XI1_I1666_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I33_MP1 (VDD I1_b24_1 XI1_I1666_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I33_MP5 (I1_I1666_pn1 I1_b24_1 XI1_I1666_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I33_MP4 (XI1_I1666_I33_p1 XI1_I1666_I33_An I1_I1666_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I33_MP2 (VDD I1_p23_0 XI1_I1666_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I33_MP3 (XI1_I1666_I33_p1 XI1_I1666_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I33_MP0 (VDD I1_p23_0 XI1_I1666_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I55_MP1 (VDD I1_b22_23 XI1_I1574_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I55_MP5 (I1_I1574_pn23 I1_b22_23 XI1_I1574_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I55_MP4 (XI1_I1574_I55_p1 XI1_I1574_I55_An I1_I1574_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I55_MP2 (VDD I1_p21_22 XI1_I1574_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I55_MP3 (XI1_I1574_I55_p1 XI1_I1574_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I55_MP0 (VDD I1_p21_22 XI1_I1574_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I53_MP1 (VDD I1_b22_21 XI1_I1574_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I53_MP5 (I1_I1574_pn21 I1_b22_21 XI1_I1574_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I53_MP4 (XI1_I1574_I53_p1 XI1_I1574_I53_An I1_I1574_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I53_MP2 (VDD I1_p21_20 XI1_I1574_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I53_MP3 (XI1_I1574_I53_p1 XI1_I1574_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I53_MP0 (VDD I1_p21_20 XI1_I1574_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I54_MP1 (VDD I1_b22_22 XI1_I1574_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I54_MP5 (I1_I1574_pn22 I1_b22_22 XI1_I1574_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I54_MP4 (XI1_I1574_I54_p1 XI1_I1574_I54_An I1_I1574_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I54_MP2 (VDD I1_p21_21 XI1_I1574_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I54_MP3 (XI1_I1574_I54_p1 XI1_I1574_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I54_MP0 (VDD I1_p21_21 XI1_I1574_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I224_MP1 (VDD I1_I1574_G20_0 XI1_I1574_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I224_MP5 (I1_p22_21 I1_I1574_G20_0 XI1_I1574_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I224_MP4 (XI1_I1574_I224_p1 XI1_I1574_I224_An I1_p22_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I224_MP2 (VDD I1_I1574_pn21 XI1_I1574_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I224_MP3 (XI1_I1574_I224_p1 XI1_I1574_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I224_MP0 (VDD I1_I1574_pn21 XI1_I1574_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I210_MP1 (VDD I1_I1574_G6_0 XI1_I1574_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I210_MP5 (I1_p22_7 I1_I1574_G6_0 XI1_I1574_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I210_MP4 (XI1_I1574_I210_p1 XI1_I1574_I210_An I1_p22_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I210_MP2 (VDD I1_I1574_pn7 XI1_I1574_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I210_MP3 (XI1_I1574_I210_p1 XI1_I1574_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I210_MP0 (VDD I1_I1574_pn7 XI1_I1574_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I36_MP1 (VDD I1_b23_4 XI1_I1620_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I36_MP5 (I1_I1620_pn4 I1_b23_4 XI1_I1620_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I36_MP4 (XI1_I1620_I36_p1 XI1_I1620_I36_An I1_I1620_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I36_MP2 (VDD I1_p22_3 XI1_I1620_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I36_MP3 (XI1_I1620_I36_p1 XI1_I1620_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I36_MP0 (VDD I1_p22_3 XI1_I1620_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I204_MP1 (VDD I1_I1574_G0_0 XI1_I1574_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I204_MP5 (I1_p22_1 I1_I1574_G0_0 XI1_I1574_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I204_MP4 (XI1_I1574_I204_p1 XI1_I1574_I204_An I1_p22_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I204_MP2 (VDD I1_I1574_pn1 XI1_I1574_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I204_MP3 (XI1_I1574_I204_p1 XI1_I1574_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I204_MP0 (VDD I1_I1574_pn1 XI1_I1574_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I42_MP1 (VDD I2_I1_bx10 XI2_I1_I42_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I42_MP5 (I2_I1_I42_pn10 I2_I1_bx10 XI2_I1_I42_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I42_MP4 (XI2_I1_I42_I42_p1 XI2_I1_I42_I42_An I2_I1_I42_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I42_MP2 (VDD A_10 XI2_I1_I42_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I42_MP3 (XI2_I1_I42_I42_p1 XI2_I1_I42_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I42_MP0 (VDD A_10 XI2_I1_I42_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I63_MP1 (VDD I1_b25_31 XI1_I1712_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I63_MP5 (I1_I1712_pn31 I1_b25_31 XI1_I1712_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I63_MP4 (XI1_I1712_I63_p1 XI1_I1712_I63_An I1_I1712_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I63_MP2 (VDD I1_p24_30 XI1_I1712_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I63_MP3 (XI1_I1712_I63_p1 XI1_I1712_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I63_MP0 (VDD I1_p24_30 XI1_I1712_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I234_MP1 (VDD I1_c25_m XI1_I1712_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I234_MP5 (I1_p25_31 I1_c25_m XI1_I1712_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I234_MP4 (XI1_I1712_I234_p1 XI1_I1712_I234_An I1_p25_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I234_MP2 (VDD I1_I1712_pn31 XI1_I1712_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I234_MP3 (XI1_I1712_I234_p1 XI1_I1712_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I234_MP0 (VDD I1_I1712_pn31 XI1_I1712_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I57_MP1 (VDD I1_b25_25 XI1_I1712_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I57_MP5 (I1_I1712_pn25 I1_b25_25 XI1_I1712_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I57_MP4 (XI1_I1712_I57_p1 XI1_I1712_I57_An I1_I1712_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I57_MP2 (VDD I1_p24_24 XI1_I1712_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I57_MP3 (XI1_I1712_I57_p1 XI1_I1712_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I57_MP0 (VDD I1_p24_24 XI1_I1712_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I228_MP1 (VDD I1_I1712_G24_0 XI1_I1712_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I228_MP5 (I1_p25_25 I1_I1712_G24_0 XI1_I1712_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I228_MP4 (XI1_I1712_I228_p1 XI1_I1712_I228_An I1_p25_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I228_MP2 (VDD I1_I1712_pn25 XI1_I1712_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I228_MP3 (XI1_I1712_I228_p1 XI1_I1712_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I228_MP0 (VDD I1_I1712_pn25 XI1_I1712_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I225_MP1 (VDD I1_I1712_G21_0 XI1_I1712_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I225_MP5 (I1_p25_22 I1_I1712_G21_0 XI1_I1712_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I225_MP4 (XI1_I1712_I225_p1 XI1_I1712_I225_An I1_p25_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I225_MP2 (VDD I1_I1712_pn22 XI1_I1712_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I225_MP3 (XI1_I1712_I225_p1 XI1_I1712_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I225_MP0 (VDD I1_I1712_pn22 XI1_I1712_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I54_MP1 (VDD I1_b25_22 XI1_I1712_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I54_MP5 (I1_I1712_pn22 I1_b25_22 XI1_I1712_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I54_MP4 (XI1_I1712_I54_p1 XI1_I1712_I54_An I1_I1712_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I54_MP2 (VDD I1_p24_21 XI1_I1712_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I54_MP3 (XI1_I1712_I54_p1 XI1_I1712_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I54_MP0 (VDD I1_p24_21 XI1_I1712_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I223_MP1 (VDD I1_I1712_G19_0 XI1_I1712_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I223_MP5 (I1_p25_20 I1_I1712_G19_0 XI1_I1712_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I223_MP4 (XI1_I1712_I223_p1 XI1_I1712_I223_An I1_p25_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I223_MP2 (VDD I1_I1712_pn20 XI1_I1712_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I223_MP3 (XI1_I1712_I223_p1 XI1_I1712_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I223_MP0 (VDD I1_I1712_pn20 XI1_I1712_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I222_MP1 (VDD I1_I1712_G18_0 XI1_I1712_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I222_MP5 (I1_p25_19 I1_I1712_G18_0 XI1_I1712_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I222_MP4 (XI1_I1712_I222_p1 XI1_I1712_I222_An I1_p25_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I222_MP2 (VDD I1_I1712_pn19 XI1_I1712_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I222_MP3 (XI1_I1712_I222_p1 XI1_I1712_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I222_MP0 (VDD I1_I1712_pn19 XI1_I1712_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I221_MP1 (VDD I1_I1712_G17_0 XI1_I1712_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I221_MP5 (I1_p25_18 I1_I1712_G17_0 XI1_I1712_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I221_MP4 (XI1_I1712_I221_p1 XI1_I1712_I221_An I1_p25_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I221_MP2 (VDD I1_I1712_pn18 XI1_I1712_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I221_MP3 (XI1_I1712_I221_p1 XI1_I1712_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I221_MP0 (VDD I1_I1712_pn18 XI1_I1712_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I42_MP1 (VDD I1_b25_10 XI1_I1712_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I42_MP5 (I1_I1712_pn10 I1_b25_10 XI1_I1712_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I42_MP4 (XI1_I1712_I42_p1 XI1_I1712_I42_An I1_I1712_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I42_MP2 (VDD I1_p24_9 XI1_I1712_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I42_MP3 (XI1_I1712_I42_p1 XI1_I1712_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I42_MP0 (VDD I1_p24_9 XI1_I1712_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I41_MP1 (VDD I1_b25_9 XI1_I1712_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I41_MP5 (I1_I1712_pn9 I1_b25_9 XI1_I1712_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I41_MP4 (XI1_I1712_I41_p1 XI1_I1712_I41_An I1_I1712_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I41_MP2 (VDD I1_p24_8 XI1_I1712_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I41_MP3 (XI1_I1712_I41_p1 XI1_I1712_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I41_MP0 (VDD I1_p24_8 XI1_I1712_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I203_MP1 (VDD I1_qu7_b3_5 XI1_I1712_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I203_MP5 (I1_p25_0 I1_qu7_b3_5 XI1_I1712_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I203_MP4 (XI1_I1712_I203_p1 XI1_I1712_I203_An I1_p25_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I203_MP2 (VDD I1_I1712_pn0 XI1_I1712_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I203_MP3 (XI1_I1712_I203_p1 XI1_I1712_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I203_MP0 (VDD I1_I1712_pn0 XI1_I1712_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I32_MP1 (VDD I1_b25_0 XI1_I1712_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I32_MP5 (I1_I1712_pn0 I1_b25_0 XI1_I1712_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I32_MP4 (XI1_I1712_I32_p1 XI1_I1712_I32_An I1_I1712_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I32_MP2 (VDD I1_aa6 XI1_I1712_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I32_MP3 (XI1_I1712_I32_p1 XI1_I1712_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I32_MP0 (VDD I1_aa6 XI1_I1712_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I34_MP1 (VDD I1_b24_2 XI1_I1666_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I34_MP5 (I1_I1666_pn2 I1_b24_2 XI1_I1666_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I34_MP4 (XI1_I1666_I34_p1 XI1_I1666_I34_An I1_I1666_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I34_MP2 (VDD I1_p23_1 XI1_I1666_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I34_MP3 (XI1_I1666_I34_p1 XI1_I1666_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I34_MP0 (VDD I1_p23_1 XI1_I1666_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I35_MP1 (VDD I1_b24_3 XI1_I1666_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I35_MP5 (I1_I1666_pn3 I1_b24_3 XI1_I1666_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I35_MP4 (XI1_I1666_I35_p1 XI1_I1666_I35_An I1_I1666_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I35_MP2 (VDD I1_p23_2 XI1_I1666_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I35_MP3 (XI1_I1666_I35_p1 XI1_I1666_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I35_MP0 (VDD I1_p23_2 XI1_I1666_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I36_MP1 (VDD I1_b24_4 XI1_I1666_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I36_MP5 (I1_I1666_pn4 I1_b24_4 XI1_I1666_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I36_MP4 (XI1_I1666_I36_p1 XI1_I1666_I36_An I1_I1666_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I36_MP2 (VDD I1_p23_3 XI1_I1666_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I36_MP3 (XI1_I1666_I36_p1 XI1_I1666_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I36_MP0 (VDD I1_p23_3 XI1_I1666_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I52_MP1 (VDD I1_b22_20 XI1_I1574_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I52_MP5 (I1_I1574_pn20 I1_b22_20 XI1_I1574_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I52_MP4 (XI1_I1574_I52_p1 XI1_I1574_I52_An I1_I1574_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I52_MP2 (VDD I1_p21_19 XI1_I1574_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I52_MP3 (XI1_I1574_I52_p1 XI1_I1574_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I52_MP0 (VDD I1_p21_19 XI1_I1574_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I230_MP1 (VDD I1_I1574_G26_0 XI1_I1574_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I230_MP5 (I1_p22_27 I1_I1574_G26_0 XI1_I1574_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I230_MP4 (XI1_I1574_I230_p1 XI1_I1574_I230_An I1_p22_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I230_MP2 (VDD I1_I1574_pn27 XI1_I1574_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I230_MP3 (XI1_I1574_I230_p1 XI1_I1574_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I230_MP0 (VDD I1_I1574_pn27 XI1_I1574_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I51_MP1 (VDD I1_b22_19 XI1_I1574_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I51_MP5 (I1_I1574_pn19 I1_b22_19 XI1_I1574_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I51_MP4 (XI1_I1574_I51_p1 XI1_I1574_I51_An I1_I1574_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I51_MP2 (VDD I1_p21_18 XI1_I1574_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I51_MP3 (XI1_I1574_I51_p1 XI1_I1574_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I51_MP0 (VDD I1_p21_18 XI1_I1574_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I223_MP1 (VDD I1_I1574_G19_0 XI1_I1574_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I223_MP5 (I1_p22_20 I1_I1574_G19_0 XI1_I1574_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I223_MP4 (XI1_I1574_I223_p1 XI1_I1574_I223_An I1_p22_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I223_MP2 (VDD I1_I1574_pn20 XI1_I1574_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I223_MP3 (XI1_I1574_I223_p1 XI1_I1574_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I223_MP0 (VDD I1_I1574_pn20 XI1_I1574_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I222_MP1 (VDD I1_I1574_G18_0 XI1_I1574_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I222_MP5 (I1_p22_19 I1_I1574_G18_0 XI1_I1574_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I222_MP4 (XI1_I1574_I222_p1 XI1_I1574_I222_An I1_p22_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I222_MP2 (VDD I1_I1574_pn19 XI1_I1574_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I222_MP3 (XI1_I1574_I222_p1 XI1_I1574_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I222_MP0 (VDD I1_I1574_pn19 XI1_I1574_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I234_MP1 (VDD I1_c22_m XI1_I1574_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I234_MP5 (I1_p22_31 I1_c22_m XI1_I1574_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I234_MP4 (XI1_I1574_I234_p1 XI1_I1574_I234_An I1_p22_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I234_MP2 (VDD I1_I1574_pn31 XI1_I1574_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I234_MP3 (XI1_I1574_I234_p1 XI1_I1574_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I234_MP0 (VDD I1_I1574_pn31 XI1_I1574_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I32_MP1 (VDD I1_b22_0 XI1_I1574_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I32_MP5 (I1_I1574_pn0 I1_b22_0 XI1_I1574_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I32_MP4 (XI1_I1574_I32_p1 XI1_I1574_I32_An I1_I1574_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I32_MP2 (VDD I1_aa9 XI1_I1574_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I32_MP3 (XI1_I1574_I32_p1 XI1_I1574_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I32_MP0 (VDD I1_aa9 XI1_I1574_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I61_MP1 (VDD I1_nakn9 XI1_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I61_MP5 (I1_aa9 I1_nakn9 XI1_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I61_MP4 (XI1_I61_p1 XI1_I61_An I1_aa9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I61_MP2 (VDD A_9 XI1_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I61_MP3 (XI1_I61_p1 XI1_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I61_MP0 (VDD A_9 XI1_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I41_MP1 (VDD I2_I1_bx9 XI2_I1_I42_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I41_MP5 (I2_I1_I42_pn9 I2_I1_bx9 XI2_I1_I42_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I41_MP4 (XI2_I1_I42_I41_p1 XI2_I1_I42_I41_An I2_I1_I42_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I41_MP2 (VDD A_9 XI2_I1_I42_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I41_MP3 (XI2_I1_I42_I41_p1 XI2_I1_I42_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I41_MP0 (VDD A_9 XI2_I1_I42_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I40_MP1 (VDD I2_I1_bx8 XI2_I1_I42_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I40_MP5 (I2_I1_I42_pn8 I2_I1_bx8 XI2_I1_I42_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I40_MP4 (XI2_I1_I42_I40_p1 XI2_I1_I42_I40_An I2_I1_I42_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I40_MP2 (VDD A_8 XI2_I1_I42_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I40_MP3 (XI2_I1_I42_I40_p1 XI2_I1_I42_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I40_MP0 (VDD A_8 XI2_I1_I42_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I211_MP1 (VDD I2_I1_I42_G7_0 XI2_I1_I42_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I211_MP5 (I2_S_8 I2_I1_I42_G7_0 XI2_I1_I42_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I211_MP4 (XI2_I1_I42_I211_p1 XI2_I1_I42_I211_An I2_S_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I211_MP2 (VDD I2_I1_I42_pn8 XI2_I1_I42_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I211_MP3 (XI2_I1_I42_I211_p1 XI2_I1_I42_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I211_MP0 (VDD I2_I1_I42_pn8 XI2_I1_I42_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I59_MP1 (VDD I1_b26_27 XI1_I1758_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I59_MP5 (I1_I1758_pn27 I1_b26_27 XI1_I1758_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I59_MP4 (XI1_I1758_I59_p1 XI1_I1758_I59_An I1_I1758_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I59_MP2 (VDD I1_p25_26 XI1_I1758_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I59_MP3 (XI1_I1758_I59_p1 XI1_I1758_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I59_MP0 (VDD I1_p25_26 XI1_I1758_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I226_MP1 (VDD I1_I1712_G22_0 XI1_I1712_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I226_MP5 (I1_p25_23 I1_I1712_G22_0 XI1_I1712_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I226_MP4 (XI1_I1712_I226_p1 XI1_I1712_I226_An I1_p25_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I226_MP2 (VDD I1_I1712_pn23 XI1_I1712_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I226_MP3 (XI1_I1712_I226_p1 XI1_I1712_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I226_MP0 (VDD I1_I1712_pn23 XI1_I1712_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I52_MP1 (VDD I1_b25_20 XI1_I1712_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I52_MP5 (I1_I1712_pn20 I1_b25_20 XI1_I1712_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I52_MP4 (XI1_I1712_I52_p1 XI1_I1712_I52_An I1_I1712_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I52_MP2 (VDD I1_p24_19 XI1_I1712_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I52_MP3 (XI1_I1712_I52_p1 XI1_I1712_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I52_MP0 (VDD I1_p24_19 XI1_I1712_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I224_MP1 (VDD I1_I1712_G20_0 XI1_I1712_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I224_MP5 (I1_p25_21 I1_I1712_G20_0 XI1_I1712_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I224_MP4 (XI1_I1712_I224_p1 XI1_I1712_I224_An I1_p25_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I224_MP2 (VDD I1_I1712_pn21 XI1_I1712_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I224_MP3 (XI1_I1712_I224_p1 XI1_I1712_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I224_MP0 (VDD I1_I1712_pn21 XI1_I1712_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I50_MP1 (VDD I1_b25_18 XI1_I1712_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I50_MP5 (I1_I1712_pn18 I1_b25_18 XI1_I1712_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I50_MP4 (XI1_I1712_I50_p1 XI1_I1712_I50_An I1_I1712_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I50_MP2 (VDD I1_p24_17 XI1_I1712_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I50_MP3 (XI1_I1712_I50_p1 XI1_I1712_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I50_MP0 (VDD I1_p24_17 XI1_I1712_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I47_MP1 (VDD I1_b25_15 XI1_I1712_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I47_MP5 (I1_I1712_pn15 I1_b25_15 XI1_I1712_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I47_MP4 (XI1_I1712_I47_p1 XI1_I1712_I47_An I1_I1712_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I47_MP2 (VDD I1_p24_14 XI1_I1712_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I47_MP3 (XI1_I1712_I47_p1 XI1_I1712_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I47_MP0 (VDD I1_p24_14 XI1_I1712_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I44_MP1 (VDD I1_b25_12 XI1_I1712_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I44_MP5 (I1_I1712_pn12 I1_b25_12 XI1_I1712_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I44_MP4 (XI1_I1712_I44_p1 XI1_I1712_I44_An I1_I1712_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I44_MP2 (VDD I1_p24_11 XI1_I1712_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I44_MP3 (XI1_I1712_I44_p1 XI1_I1712_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I44_MP0 (VDD I1_p24_11 XI1_I1712_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I43_MP1 (VDD I1_b25_11 XI1_I1712_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I43_MP5 (I1_I1712_pn11 I1_b25_11 XI1_I1712_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I43_MP4 (XI1_I1712_I43_p1 XI1_I1712_I43_An I1_I1712_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I43_MP2 (VDD I1_p24_10 XI1_I1712_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I43_MP3 (XI1_I1712_I43_p1 XI1_I1712_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I43_MP0 (VDD I1_p24_10 XI1_I1712_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I208_MP1 (VDD I1_I1666_G4_0 XI1_I1666_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I208_MP5 (I1_p24_5 I1_I1666_G4_0 XI1_I1666_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I208_MP4 (XI1_I1666_I208_p1 XI1_I1666_I208_An I1_p24_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I208_MP2 (VDD I1_I1666_pn5 XI1_I1666_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I208_MP3 (XI1_I1666_I208_p1 XI1_I1666_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I208_MP0 (VDD I1_I1666_pn5 XI1_I1666_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I220_MP1 (VDD I1_I1666_G16_0 XI1_I1666_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I220_MP5 (I1_p24_17 I1_I1666_G16_0 XI1_I1666_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I220_MP4 (XI1_I1666_I220_p1 XI1_I1666_I220_An I1_p24_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I220_MP2 (VDD I1_I1666_pn17 XI1_I1666_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I220_MP3 (XI1_I1666_I220_p1 XI1_I1666_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I220_MP0 (VDD I1_I1666_pn17 XI1_I1666_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I209_MP1 (VDD I1_I1666_G5_0 XI1_I1666_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I209_MP5 (I1_p24_6 I1_I1666_G5_0 XI1_I1666_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I209_MP4 (XI1_I1666_I209_p1 XI1_I1666_I209_An I1_p24_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I209_MP2 (VDD I1_I1666_pn6 XI1_I1666_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I209_MP3 (XI1_I1666_I209_p1 XI1_I1666_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I209_MP0 (VDD I1_I1666_pn6 XI1_I1666_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I37_MP1 (VDD I1_b24_5 XI1_I1666_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I37_MP5 (I1_I1666_pn5 I1_b24_5 XI1_I1666_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I37_MP4 (XI1_I1666_I37_p1 XI1_I1666_I37_An I1_I1666_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I37_MP2 (VDD I1_p23_4 XI1_I1666_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I37_MP3 (XI1_I1666_I37_p1 XI1_I1666_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I37_MP0 (VDD I1_p23_4 XI1_I1666_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I38_MP1 (VDD I1_b24_6 XI1_I1666_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I38_MP5 (I1_I1666_pn6 I1_b24_6 XI1_I1666_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I38_MP4 (XI1_I1666_I38_p1 XI1_I1666_I38_An I1_I1666_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I38_MP2 (VDD I1_p23_5 XI1_I1666_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I38_MP3 (XI1_I1666_I38_p1 XI1_I1666_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I38_MP0 (VDD I1_p23_5 XI1_I1666_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I226_MP1 (VDD I1_I1574_G22_0 XI1_I1574_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I226_MP5 (I1_p22_23 I1_I1574_G22_0 XI1_I1574_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I226_MP4 (XI1_I1574_I226_p1 XI1_I1574_I226_An I1_p22_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I226_MP2 (VDD I1_I1574_pn23 XI1_I1574_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I226_MP3 (XI1_I1574_I226_p1 XI1_I1574_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I226_MP0 (VDD I1_I1574_pn23 XI1_I1574_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I40_MP1 (VDD I1_b23_8 XI1_I1620_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I40_MP5 (I1_I1620_pn8 I1_b23_8 XI1_I1620_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I40_MP4 (XI1_I1620_I40_p1 XI1_I1620_I40_An I1_I1620_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I40_MP2 (VDD I1_p22_7 XI1_I1620_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I40_MP3 (XI1_I1620_I40_p1 XI1_I1620_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I40_MP0 (VDD I1_p22_7 XI1_I1620_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I37_MP1 (VDD I1_b23_5 XI1_I1620_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I37_MP5 (I1_I1620_pn5 I1_b23_5 XI1_I1620_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I37_MP4 (XI1_I1620_I37_p1 XI1_I1620_I37_An I1_I1620_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I37_MP2 (VDD I1_p22_4 XI1_I1620_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I37_MP3 (XI1_I1620_I37_p1 XI1_I1620_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I37_MP0 (VDD I1_p22_4 XI1_I1620_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I52_MP1 (VDD I1_nakn6 XI1_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I52_MP5 (I1_aa6 I1_nakn6 XI1_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I52_MP4 (XI1_I52_p1 XI1_I52_An I1_aa6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I52_MP2 (VDD A_6 XI1_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I52_MP3 (XI1_I52_p1 XI1_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I52_MP0 (VDD A_6 XI1_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I35_MP1 (VDD I1_b23_3 XI1_I1620_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I35_MP5 (I1_I1620_pn3 I1_b23_3 XI1_I1620_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I35_MP4 (XI1_I1620_I35_p1 XI1_I1620_I35_An I1_I1620_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I35_MP2 (VDD I1_p22_2 XI1_I1620_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I35_MP3 (XI1_I1620_I35_p1 XI1_I1620_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I35_MP0 (VDD I1_p22_2 XI1_I1620_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I203_MP1 (VDD I1_qu10_b3_5 XI1_I1574_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1574_I203_MP5 (I1_p22_0 I1_qu10_b3_5 XI1_I1574_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1574_I203_MP4 (XI1_I1574_I203_p1 XI1_I1574_I203_An I1_p22_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I203_MP2 (VDD I1_I1574_pn0 XI1_I1574_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1574_I203_MP3 (XI1_I1574_I203_p1 XI1_I1574_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I203_MP0 (VDD I1_I1574_pn0 XI1_I1574_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I55_MP1 (VDD I1_nakn7 XI1_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I55_MP5 (I1_aa7 I1_nakn7 XI1_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I55_MP4 (XI1_I55_p1 XI1_I55_An I1_aa7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I55_MP2 (VDD A_7 XI1_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I55_MP3 (XI1_I55_p1 XI1_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I55_MP0 (VDD A_7 XI1_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I39_MP1 (VDD I2_I1_bx7 XI2_I1_I42_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I39_MP5 (I2_I1_I42_pn7 I2_I1_bx7 XI2_I1_I42_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I39_MP4 (XI2_I1_I42_I39_p1 XI2_I1_I42_I39_An I2_I1_I42_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I39_MP2 (VDD A_7 XI2_I1_I42_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I39_MP3 (XI2_I1_I42_I39_p1 XI2_I1_I42_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I39_MP0 (VDD A_7 XI2_I1_I42_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I210_MP1 (VDD I2_I1_I42_G6_0 XI2_I1_I42_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I210_MP5 (I2_S_7 I2_I1_I42_G6_0 XI2_I1_I42_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I210_MP4 (XI2_I1_I42_I210_p1 XI2_I1_I42_I210_An I2_S_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I210_MP2 (VDD I2_I1_I42_pn7 XI2_I1_I42_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I210_MP3 (XI2_I1_I42_I210_p1 XI2_I1_I42_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I210_MP0 (VDD I2_I1_I42_pn7 XI2_I1_I42_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I61_MP1 (VDD I1_b26_29 XI1_I1758_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I61_MP5 (I1_I1758_pn29 I1_b26_29 XI1_I1758_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I61_MP4 (XI1_I1758_I61_p1 XI1_I1758_I61_An I1_I1758_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I61_MP2 (VDD I1_p25_28 XI1_I1758_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I61_MP3 (XI1_I1758_I61_p1 XI1_I1758_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I61_MP0 (VDD I1_p25_28 XI1_I1758_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I60_MP1 (VDD I1_b26_28 XI1_I1758_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I60_MP5 (I1_I1758_pn28 I1_b26_28 XI1_I1758_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I60_MP4 (XI1_I1758_I60_p1 XI1_I1758_I60_An I1_I1758_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I60_MP2 (VDD I1_p25_27 XI1_I1758_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I60_MP3 (XI1_I1758_I60_p1 XI1_I1758_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I60_MP0 (VDD I1_p25_27 XI1_I1758_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I57_MP1 (VDD I1_b26_25 XI1_I1758_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I57_MP5 (I1_I1758_pn25 I1_b26_25 XI1_I1758_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I57_MP4 (XI1_I1758_I57_p1 XI1_I1758_I57_An I1_I1758_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I57_MP2 (VDD I1_p25_24 XI1_I1758_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I57_MP3 (XI1_I1758_I57_p1 XI1_I1758_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I57_MP0 (VDD I1_p25_24 XI1_I1758_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I53_MP1 (VDD I1_b25_21 XI1_I1712_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I53_MP5 (I1_I1712_pn21 I1_b25_21 XI1_I1712_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I53_MP4 (XI1_I1712_I53_p1 XI1_I1712_I53_An I1_I1712_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I53_MP2 (VDD I1_p24_20 XI1_I1712_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I53_MP3 (XI1_I1712_I53_p1 XI1_I1712_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I53_MP0 (VDD I1_p24_20 XI1_I1712_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I55_MP1 (VDD I1_b25_23 XI1_I1712_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I55_MP5 (I1_I1712_pn23 I1_b25_23 XI1_I1712_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I55_MP4 (XI1_I1712_I55_p1 XI1_I1712_I55_An I1_I1712_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I55_MP2 (VDD I1_p24_22 XI1_I1712_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I55_MP3 (XI1_I1712_I55_p1 XI1_I1712_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I55_MP0 (VDD I1_p24_22 XI1_I1712_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I51_MP1 (VDD I1_b25_19 XI1_I1712_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I51_MP5 (I1_I1712_pn19 I1_b25_19 XI1_I1712_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I51_MP4 (XI1_I1712_I51_p1 XI1_I1712_I51_An I1_I1712_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I51_MP2 (VDD I1_p24_18 XI1_I1712_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I51_MP3 (XI1_I1712_I51_p1 XI1_I1712_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I51_MP0 (VDD I1_p24_18 XI1_I1712_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I48_MP1 (VDD I1_b25_16 XI1_I1712_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I48_MP5 (I1_I1712_pn16 I1_b25_16 XI1_I1712_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I48_MP4 (XI1_I1712_I48_p1 XI1_I1712_I48_An I1_I1712_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I48_MP2 (VDD I1_p24_15 XI1_I1712_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I48_MP3 (XI1_I1712_I48_p1 XI1_I1712_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I48_MP0 (VDD I1_p24_15 XI1_I1712_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I46_MP1 (VDD I1_b25_14 XI1_I1712_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I46_MP5 (I1_I1712_pn14 I1_b25_14 XI1_I1712_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I46_MP4 (XI1_I1712_I46_p1 XI1_I1712_I46_An I1_I1712_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I46_MP2 (VDD I1_p24_13 XI1_I1712_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I46_MP3 (XI1_I1712_I46_p1 XI1_I1712_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I46_MP0 (VDD I1_p24_13 XI1_I1712_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I45_MP1 (VDD I1_b25_13 XI1_I1712_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I45_MP5 (I1_I1712_pn13 I1_b25_13 XI1_I1712_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I45_MP4 (XI1_I1712_I45_p1 XI1_I1712_I45_An I1_I1712_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I45_MP2 (VDD I1_p24_12 XI1_I1712_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I45_MP3 (XI1_I1712_I45_p1 XI1_I1712_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I45_MP0 (VDD I1_p24_12 XI1_I1712_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I210_MP1 (VDD I1_I1666_G6_0 XI1_I1666_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I210_MP5 (I1_p24_7 I1_I1666_G6_0 XI1_I1666_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I210_MP4 (XI1_I1666_I210_p1 XI1_I1666_I210_An I1_p24_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I210_MP2 (VDD I1_I1666_pn7 XI1_I1666_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I210_MP3 (XI1_I1666_I210_p1 XI1_I1666_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I210_MP0 (VDD I1_I1666_pn7 XI1_I1666_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I222_MP1 (VDD I1_I1666_G18_0 XI1_I1666_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I222_MP5 (I1_p24_19 I1_I1666_G18_0 XI1_I1666_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I222_MP4 (XI1_I1666_I222_p1 XI1_I1666_I222_An I1_p24_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I222_MP2 (VDD I1_I1666_pn19 XI1_I1666_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I222_MP3 (XI1_I1666_I222_p1 XI1_I1666_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I222_MP0 (VDD I1_I1666_pn19 XI1_I1666_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I211_MP1 (VDD I1_I1666_G7_0 XI1_I1666_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I211_MP5 (I1_p24_8 I1_I1666_G7_0 XI1_I1666_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I211_MP4 (XI1_I1666_I211_p1 XI1_I1666_I211_An I1_p24_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I211_MP2 (VDD I1_I1666_pn8 XI1_I1666_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I211_MP3 (XI1_I1666_I211_p1 XI1_I1666_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I211_MP0 (VDD I1_I1666_pn8 XI1_I1666_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I39_MP1 (VDD I1_b24_7 XI1_I1666_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I39_MP5 (I1_I1666_pn7 I1_b24_7 XI1_I1666_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I39_MP4 (XI1_I1666_I39_p1 XI1_I1666_I39_An I1_I1666_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I39_MP2 (VDD I1_p23_6 XI1_I1666_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I39_MP3 (XI1_I1666_I39_p1 XI1_I1666_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I39_MP0 (VDD I1_p23_6 XI1_I1666_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I40_MP1 (VDD I1_b24_8 XI1_I1666_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I40_MP5 (I1_I1666_pn8 I1_b24_8 XI1_I1666_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I40_MP4 (XI1_I1666_I40_p1 XI1_I1666_I40_An I1_I1666_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I40_MP2 (VDD I1_p23_7 XI1_I1666_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I40_MP3 (XI1_I1666_I40_p1 XI1_I1666_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I40_MP0 (VDD I1_p23_7 XI1_I1666_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I203_MP1 (VDD I1_qu9_b3_5 XI1_I1620_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I203_MP5 (I1_p23_0 I1_qu9_b3_5 XI1_I1620_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I203_MP4 (XI1_I1620_I203_p1 XI1_I1620_I203_An I1_p23_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I203_MP2 (VDD I1_I1620_pn0 XI1_I1620_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I203_MP3 (XI1_I1620_I203_p1 XI1_I1620_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I203_MP0 (VDD I1_I1620_pn0 XI1_I1620_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I210_MP1 (VDD I1_I1620_G6_0 XI1_I1620_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I210_MP5 (I1_p23_7 I1_I1620_G6_0 XI1_I1620_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I210_MP4 (XI1_I1620_I210_p1 XI1_I1620_I210_An I1_p23_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I210_MP2 (VDD I1_I1620_pn7 XI1_I1620_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I210_MP3 (XI1_I1620_I210_p1 XI1_I1620_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I210_MP0 (VDD I1_I1620_pn7 XI1_I1620_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I41_MP1 (VDD I1_b23_9 XI1_I1620_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I41_MP5 (I1_I1620_pn9 I1_b23_9 XI1_I1620_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I41_MP4 (XI1_I1620_I41_p1 XI1_I1620_I41_An I1_I1620_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I41_MP2 (VDD I1_p22_8 XI1_I1620_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I41_MP3 (XI1_I1620_I41_p1 XI1_I1620_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I41_MP0 (VDD I1_p22_8 XI1_I1620_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I39_MP1 (VDD I1_b23_7 XI1_I1620_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I39_MP5 (I1_I1620_pn7 I1_b23_7 XI1_I1620_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I39_MP4 (XI1_I1620_I39_p1 XI1_I1620_I39_An I1_I1620_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I39_MP2 (VDD I1_p22_6 XI1_I1620_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I39_MP3 (XI1_I1620_I39_p1 XI1_I1620_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I39_MP0 (VDD I1_p22_6 XI1_I1620_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I208_MP1 (VDD I1_I1620_G4_0 XI1_I1620_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I208_MP5 (I1_p23_5 I1_I1620_G4_0 XI1_I1620_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I208_MP4 (XI1_I1620_I208_p1 XI1_I1620_I208_An I1_p23_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I208_MP2 (VDD I1_I1620_pn5 XI1_I1620_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I208_MP3 (XI1_I1620_I208_p1 XI1_I1620_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I208_MP0 (VDD I1_I1620_pn5 XI1_I1620_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I34_MP1 (VDD I1_b23_2 XI1_I1620_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I34_MP5 (I1_I1620_pn2 I1_b23_2 XI1_I1620_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I34_MP4 (XI1_I1620_I34_p1 XI1_I1620_I34_An I1_I1620_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I34_MP2 (VDD I1_p22_1 XI1_I1620_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I34_MP3 (XI1_I1620_I34_p1 XI1_I1620_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I34_MP0 (VDD I1_p22_1 XI1_I1620_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I204_MP1 (VDD I1_I1620_G0_0 XI1_I1620_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I204_MP5 (I1_p23_1 I1_I1620_G0_0 XI1_I1620_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I204_MP4 (XI1_I1620_I204_p1 XI1_I1620_I204_An I1_p23_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I204_MP2 (VDD I1_I1620_pn1 XI1_I1620_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I204_MP3 (XI1_I1620_I204_p1 XI1_I1620_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I204_MP0 (VDD I1_I1620_pn1 XI1_I1620_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I32_MP1 (VDD I1_b23_0 XI1_I1620_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I32_MP5 (I1_I1620_pn0 I1_b23_0 XI1_I1620_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I32_MP4 (XI1_I1620_I32_p1 XI1_I1620_I32_An I1_I1620_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I32_MP2 (VDD I1_aa8 XI1_I1620_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I32_MP3 (XI1_I1620_I32_p1 XI1_I1620_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I32_MP0 (VDD I1_aa8 XI1_I1620_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I58_MP1 (VDD I1_nakn8 XI1_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I58_MP5 (I1_aa8 I1_nakn8 XI1_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I58_MP4 (XI1_I58_p1 XI1_I58_An I1_aa8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I58_MP2 (VDD A_8 XI1_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I58_MP3 (XI1_I58_p1 XI1_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I58_MP0 (VDD A_8 XI1_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I38_MP1 (VDD I2_I1_bx6 XI2_I1_I42_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I38_MP5 (I2_I1_I42_pn6 I2_I1_bx6 XI2_I1_I42_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I38_MP4 (XI2_I1_I42_I38_p1 XI2_I1_I42_I38_An I2_I1_I42_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I38_MP2 (VDD A_6 XI2_I1_I42_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I38_MP3 (XI2_I1_I42_I38_p1 XI2_I1_I42_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I38_MP0 (VDD A_6 XI2_I1_I42_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I209_MP1 (VDD I2_I1_I42_G5_0 XI2_I1_I42_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I209_MP5 (I2_S_6 I2_I1_I42_G5_0 XI2_I1_I42_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I209_MP4 (XI2_I1_I42_I209_p1 XI2_I1_I42_I209_An I2_S_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I209_MP2 (VDD I2_I1_I42_pn6 XI2_I1_I42_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I209_MP3 (XI2_I1_I42_I209_p1 XI2_I1_I42_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I209_MP0 (VDD I2_I1_I42_pn6 XI2_I1_I42_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I208_MP1 (VDD I2_I1_I42_G4_0 XI2_I1_I42_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I208_MP5 (I2_S_5 I2_I1_I42_G4_0 XI2_I1_I42_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I208_MP4 (XI2_I1_I42_I208_p1 XI2_I1_I42_I208_An I2_S_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I208_MP2 (VDD I2_I1_I42_pn5 XI2_I1_I42_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I208_MP3 (XI2_I1_I42_I208_p1 XI2_I1_I42_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I208_MP0 (VDD I2_I1_I42_pn5 XI2_I1_I42_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I56_MP1 (VDD I1_b26_24 XI1_I1758_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I56_MP5 (I1_I1758_pn24 I1_b26_24 XI1_I1758_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I56_MP4 (XI1_I1758_I56_p1 XI1_I1758_I56_An I1_I1758_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I56_MP2 (VDD I1_p25_23 XI1_I1758_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I56_MP3 (XI1_I1758_I56_p1 XI1_I1758_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I56_MP0 (VDD I1_p25_23 XI1_I1758_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I53_MP1 (VDD I1_b26_21 XI1_I1758_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I53_MP5 (I1_I1758_pn21 I1_b26_21 XI1_I1758_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I53_MP4 (XI1_I1758_I53_p1 XI1_I1758_I53_An I1_I1758_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I53_MP2 (VDD I1_p25_20 XI1_I1758_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I53_MP3 (XI1_I1758_I53_p1 XI1_I1758_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I53_MP0 (VDD I1_p25_20 XI1_I1758_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I220_MP1 (VDD I1_I1712_G16_0 XI1_I1712_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I220_MP5 (I1_p25_17 I1_I1712_G16_0 XI1_I1712_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I220_MP4 (XI1_I1712_I220_p1 XI1_I1712_I220_An I1_p25_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I220_MP2 (VDD I1_I1712_pn17 XI1_I1712_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I220_MP3 (XI1_I1712_I220_p1 XI1_I1712_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I220_MP0 (VDD I1_I1712_pn17 XI1_I1712_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I47_MP1 (VDD I1_b26_15 XI1_I1758_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I47_MP5 (I1_I1758_pn15 I1_b26_15 XI1_I1758_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I47_MP4 (XI1_I1758_I47_p1 XI1_I1758_I47_An I1_I1758_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I47_MP2 (VDD I1_p25_14 XI1_I1758_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I47_MP3 (XI1_I1758_I47_p1 XI1_I1758_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I47_MP0 (VDD I1_p25_14 XI1_I1758_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I49_MP1 (VDD I1_b25_17 XI1_I1712_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1712_I49_MP5 (I1_I1712_pn17 I1_b25_17 XI1_I1712_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1712_I49_MP4 (XI1_I1712_I49_p1 XI1_I1712_I49_An I1_I1712_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I49_MP2 (VDD I1_p24_16 XI1_I1712_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1712_I49_MP3 (XI1_I1712_I49_p1 XI1_I1712_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I49_MP0 (VDD I1_p24_16 XI1_I1712_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I228_MP1 (VDD I1_I1666_G24_0 XI1_I1666_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I228_MP5 (I1_p24_25 I1_I1666_G24_0 XI1_I1666_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I228_MP4 (XI1_I1666_I228_p1 XI1_I1666_I228_An I1_p24_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I228_MP2 (VDD I1_I1666_pn25 XI1_I1666_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I228_MP3 (XI1_I1666_I228_p1 XI1_I1666_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I228_MP0 (VDD I1_I1666_pn25 XI1_I1666_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I221_MP1 (VDD I1_I1666_G17_0 XI1_I1666_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I221_MP5 (I1_p24_18 I1_I1666_G17_0 XI1_I1666_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I221_MP4 (XI1_I1666_I221_p1 XI1_I1666_I221_An I1_p24_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I221_MP2 (VDD I1_I1666_pn18 XI1_I1666_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I221_MP3 (XI1_I1666_I221_p1 XI1_I1666_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I221_MP0 (VDD I1_I1666_pn18 XI1_I1666_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I43_MP1 (VDD I1_b24_11 XI1_I1666_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I43_MP5 (I1_I1666_pn11 I1_b24_11 XI1_I1666_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I43_MP4 (XI1_I1666_I43_p1 XI1_I1666_I43_An I1_I1666_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I43_MP2 (VDD I1_p23_10 XI1_I1666_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I43_MP3 (XI1_I1666_I43_p1 XI1_I1666_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I43_MP0 (VDD I1_p23_10 XI1_I1666_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I42_MP1 (VDD I1_b24_10 XI1_I1666_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I42_MP5 (I1_I1666_pn10 I1_b24_10 XI1_I1666_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I42_MP4 (XI1_I1666_I42_p1 XI1_I1666_I42_An I1_I1666_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I42_MP2 (VDD I1_p23_9 XI1_I1666_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I42_MP3 (XI1_I1666_I42_p1 XI1_I1666_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I42_MP0 (VDD I1_p23_9 XI1_I1666_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I41_MP1 (VDD I1_b24_9 XI1_I1666_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I41_MP5 (I1_I1666_pn9 I1_b24_9 XI1_I1666_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I41_MP4 (XI1_I1666_I41_p1 XI1_I1666_I41_An I1_I1666_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I41_MP2 (VDD I1_p23_8 XI1_I1666_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I41_MP3 (XI1_I1666_I41_p1 XI1_I1666_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I41_MP0 (VDD I1_p23_8 XI1_I1666_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I45_MP1 (VDD I1_b23_13 XI1_I1620_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I45_MP5 (I1_I1620_pn13 I1_b23_13 XI1_I1620_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I45_MP4 (XI1_I1620_I45_p1 XI1_I1620_I45_An I1_I1620_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I45_MP2 (VDD I1_p22_12 XI1_I1620_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I45_MP3 (XI1_I1620_I45_p1 XI1_I1620_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I45_MP0 (VDD I1_p22_12 XI1_I1620_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I46_MP1 (VDD I1_b23_14 XI1_I1620_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I46_MP5 (I1_I1620_pn14 I1_b23_14 XI1_I1620_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I46_MP4 (XI1_I1620_I46_p1 XI1_I1620_I46_An I1_I1620_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I46_MP2 (VDD I1_p22_13 XI1_I1620_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I46_MP3 (XI1_I1620_I46_p1 XI1_I1620_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I46_MP0 (VDD I1_p22_13 XI1_I1620_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I44_MP1 (VDD I1_b23_12 XI1_I1620_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I44_MP5 (I1_I1620_pn12 I1_b23_12 XI1_I1620_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I44_MP4 (XI1_I1620_I44_p1 XI1_I1620_I44_An I1_I1620_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I44_MP2 (VDD I1_p22_11 XI1_I1620_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I44_MP3 (XI1_I1620_I44_p1 XI1_I1620_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I44_MP0 (VDD I1_p22_11 XI1_I1620_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I43_MP1 (VDD I1_b23_11 XI1_I1620_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I43_MP5 (I1_I1620_pn11 I1_b23_11 XI1_I1620_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I43_MP4 (XI1_I1620_I43_p1 XI1_I1620_I43_An I1_I1620_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I43_MP2 (VDD I1_p22_10 XI1_I1620_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I43_MP3 (XI1_I1620_I43_p1 XI1_I1620_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I43_MP0 (VDD I1_p22_10 XI1_I1620_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I42_MP1 (VDD I1_b23_10 XI1_I1620_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I42_MP5 (I1_I1620_pn10 I1_b23_10 XI1_I1620_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I42_MP4 (XI1_I1620_I42_p1 XI1_I1620_I42_An I1_I1620_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I42_MP2 (VDD I1_p22_9 XI1_I1620_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I42_MP3 (XI1_I1620_I42_p1 XI1_I1620_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I42_MP0 (VDD I1_p22_9 XI1_I1620_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I38_MP1 (VDD I1_b23_6 XI1_I1620_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I38_MP5 (I1_I1620_pn6 I1_b23_6 XI1_I1620_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I38_MP4 (XI1_I1620_I38_p1 XI1_I1620_I38_An I1_I1620_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I38_MP2 (VDD I1_p22_5 XI1_I1620_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I38_MP3 (XI1_I1620_I38_p1 XI1_I1620_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I38_MP0 (VDD I1_p22_5 XI1_I1620_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I205_MP1 (VDD I1_I1620_G1_0 XI1_I1620_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I205_MP5 (I1_p23_2 I1_I1620_G1_0 XI1_I1620_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I205_MP4 (XI1_I1620_I205_p1 XI1_I1620_I205_An I1_p23_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I205_MP2 (VDD I1_I1620_pn2 XI1_I1620_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I205_MP3 (XI1_I1620_I205_p1 XI1_I1620_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I205_MP0 (VDD I1_I1620_pn2 XI1_I1620_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I33_MP1 (VDD I1_b23_1 XI1_I1620_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I33_MP5 (I1_I1620_pn1 I1_b23_1 XI1_I1620_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I33_MP4 (XI1_I1620_I33_p1 XI1_I1620_I33_An I1_I1620_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I33_MP2 (VDD I1_p22_0 XI1_I1620_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I33_MP3 (XI1_I1620_I33_p1 XI1_I1620_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I33_MP0 (VDD I1_p22_0 XI1_I1620_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I37_MP1 (VDD I2_I1_bx5 XI2_I1_I42_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I37_MP5 (I2_I1_I42_pn5 I2_I1_bx5 XI2_I1_I42_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I37_MP4 (XI2_I1_I42_I37_p1 XI2_I1_I42_I37_An I2_I1_I42_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I37_MP2 (VDD A_5 XI2_I1_I42_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I37_MP3 (XI2_I1_I42_I37_p1 XI2_I1_I42_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I37_MP0 (VDD A_5 XI2_I1_I42_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I58_MP1 (VDD I1_b26_26 XI1_I1758_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I58_MP5 (I1_I1758_pn26 I1_b26_26 XI1_I1758_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I58_MP4 (XI1_I1758_I58_p1 XI1_I1758_I58_An I1_I1758_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I58_MP2 (VDD I1_p25_25 XI1_I1758_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I58_MP3 (XI1_I1758_I58_p1 XI1_I1758_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I58_MP0 (VDD I1_p25_25 XI1_I1758_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I55_MP1 (VDD I1_b26_23 XI1_I1758_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I55_MP5 (I1_I1758_pn23 I1_b26_23 XI1_I1758_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I55_MP4 (XI1_I1758_I55_p1 XI1_I1758_I55_An I1_I1758_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I55_MP2 (VDD I1_p25_22 XI1_I1758_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I55_MP3 (XI1_I1758_I55_p1 XI1_I1758_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I55_MP0 (VDD I1_p25_22 XI1_I1758_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I50_MP1 (VDD I1_b26_18 XI1_I1758_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I50_MP5 (I1_I1758_pn18 I1_b26_18 XI1_I1758_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I50_MP4 (XI1_I1758_I50_p1 XI1_I1758_I50_An I1_I1758_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I50_MP2 (VDD I1_p25_17 XI1_I1758_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I50_MP3 (XI1_I1758_I50_p1 XI1_I1758_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I50_MP0 (VDD I1_p25_17 XI1_I1758_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I49_MP1 (VDD I1_b26_17 XI1_I1758_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I49_MP5 (I1_I1758_pn17 I1_b26_17 XI1_I1758_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I49_MP4 (XI1_I1758_I49_p1 XI1_I1758_I49_An I1_I1758_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I49_MP2 (VDD I1_p25_16 XI1_I1758_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I49_MP3 (XI1_I1758_I49_p1 XI1_I1758_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I49_MP0 (VDD I1_p25_16 XI1_I1758_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I48_MP1 (VDD I1_b26_16 XI1_I1758_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I48_MP5 (I1_I1758_pn16 I1_b26_16 XI1_I1758_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I48_MP4 (XI1_I1758_I48_p1 XI1_I1758_I48_An I1_I1758_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I48_MP2 (VDD I1_p25_15 XI1_I1758_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I48_MP3 (XI1_I1758_I48_p1 XI1_I1758_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I48_MP0 (VDD I1_p25_15 XI1_I1758_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I45_MP1 (VDD I1_b26_13 XI1_I1758_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I45_MP5 (I1_I1758_pn13 I1_b26_13 XI1_I1758_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I45_MP4 (XI1_I1758_I45_p1 XI1_I1758_I45_An I1_I1758_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I45_MP2 (VDD I1_p25_12 XI1_I1758_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I45_MP3 (XI1_I1758_I45_p1 XI1_I1758_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I45_MP0 (VDD I1_p25_12 XI1_I1758_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I224_MP1 (VDD I1_I1666_G20_0 XI1_I1666_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I224_MP5 (I1_p24_21 I1_I1666_G20_0 XI1_I1666_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I224_MP4 (XI1_I1666_I224_p1 XI1_I1666_I224_An I1_p24_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I224_MP2 (VDD I1_I1666_pn21 XI1_I1666_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I224_MP3 (XI1_I1666_I224_p1 XI1_I1666_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I224_MP0 (VDD I1_I1666_pn21 XI1_I1666_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I230_MP1 (VDD I1_I1666_G26_0 XI1_I1666_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I230_MP5 (I1_p24_27 I1_I1666_G26_0 XI1_I1666_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I230_MP4 (XI1_I1666_I230_p1 XI1_I1666_I230_An I1_p24_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I230_MP2 (VDD I1_I1666_pn27 XI1_I1666_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I230_MP3 (XI1_I1666_I230_p1 XI1_I1666_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I230_MP0 (VDD I1_I1666_pn27 XI1_I1666_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I223_MP1 (VDD I1_I1666_G19_0 XI1_I1666_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I223_MP5 (I1_p24_20 I1_I1666_G19_0 XI1_I1666_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I223_MP4 (XI1_I1666_I223_p1 XI1_I1666_I223_An I1_p24_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I223_MP2 (VDD I1_I1666_pn20 XI1_I1666_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I223_MP3 (XI1_I1666_I223_p1 XI1_I1666_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I223_MP0 (VDD I1_I1666_pn20 XI1_I1666_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I44_MP1 (VDD I1_b24_12 XI1_I1666_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I44_MP5 (I1_I1666_pn12 I1_b24_12 XI1_I1666_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I44_MP4 (XI1_I1666_I44_p1 XI1_I1666_I44_An I1_I1666_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I44_MP2 (VDD I1_p23_11 XI1_I1666_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I44_MP3 (XI1_I1666_I44_p1 XI1_I1666_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I44_MP0 (VDD I1_p23_11 XI1_I1666_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I48_MP1 (VDD I1_b23_16 XI1_I1620_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I48_MP5 (I1_I1620_pn16 I1_b23_16 XI1_I1620_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I48_MP4 (XI1_I1620_I48_p1 XI1_I1620_I48_An I1_I1620_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I48_MP2 (VDD I1_p22_15 XI1_I1620_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I48_MP3 (XI1_I1620_I48_p1 XI1_I1620_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I48_MP0 (VDD I1_p22_15 XI1_I1620_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I211_MP1 (VDD I1_I1620_G7_0 XI1_I1620_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I211_MP5 (I1_p23_8 I1_I1620_G7_0 XI1_I1620_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I211_MP4 (XI1_I1620_I211_p1 XI1_I1620_I211_An I1_p23_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I211_MP2 (VDD I1_I1620_pn8 XI1_I1620_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I211_MP3 (XI1_I1620_I211_p1 XI1_I1620_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I211_MP0 (VDD I1_I1620_pn8 XI1_I1620_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I209_MP1 (VDD I1_I1620_G5_0 XI1_I1620_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I209_MP5 (I1_p23_6 I1_I1620_G5_0 XI1_I1620_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I209_MP4 (XI1_I1620_I209_p1 XI1_I1620_I209_An I1_p23_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I209_MP2 (VDD I1_I1620_pn6 XI1_I1620_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I209_MP3 (XI1_I1620_I209_p1 XI1_I1620_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I209_MP0 (VDD I1_I1620_pn6 XI1_I1620_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I36_MP1 (VDD I2_I1_bx4 XI2_I1_I42_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I36_MP5 (I2_I1_I42_pn4 I2_I1_bx4 XI2_I1_I42_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I36_MP4 (XI2_I1_I42_I36_p1 XI2_I1_I42_I36_An I2_I1_I42_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I36_MP2 (VDD A_4 XI2_I1_I42_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I36_MP3 (XI2_I1_I42_I36_p1 XI2_I1_I42_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I36_MP0 (VDD A_4 XI2_I1_I42_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I35_MP1 (VDD I2_I1_bx3 XI2_I1_I42_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I35_MP5 (I2_I1_I42_pn3 I2_I1_bx3 XI2_I1_I42_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I35_MP4 (XI2_I1_I42_I35_p1 XI2_I1_I42_I35_An I2_I1_I42_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I35_MP2 (VDD A_3 XI2_I1_I42_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I35_MP3 (XI2_I1_I42_I35_p1 XI2_I1_I42_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I35_MP0 (VDD A_3 XI2_I1_I42_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I63_MP1 (VDD I1_b26_31 XI1_I1758_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I63_MP5 (I1_I1758_pn31 I1_b26_31 XI1_I1758_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I63_MP4 (XI1_I1758_I63_p1 XI1_I1758_I63_An I1_I1758_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I63_MP2 (VDD I1_p25_30 XI1_I1758_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I63_MP3 (XI1_I1758_I63_p1 XI1_I1758_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I63_MP0 (VDD I1_p25_30 XI1_I1758_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I62_MP1 (VDD I1_b26_30 XI1_I1758_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I62_MP5 (I1_I1758_pn30 I1_b26_30 XI1_I1758_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I62_MP4 (XI1_I1758_I62_p1 XI1_I1758_I62_An I1_I1758_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I62_MP2 (VDD I1_p25_29 XI1_I1758_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I62_MP3 (XI1_I1758_I62_p1 XI1_I1758_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I62_MP0 (VDD I1_p25_29 XI1_I1758_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I54_MP1 (VDD I1_b26_22 XI1_I1758_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I54_MP5 (I1_I1758_pn22 I1_b26_22 XI1_I1758_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I54_MP4 (XI1_I1758_I54_p1 XI1_I1758_I54_An I1_I1758_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I54_MP2 (VDD I1_p25_21 XI1_I1758_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I54_MP3 (XI1_I1758_I54_p1 XI1_I1758_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I54_MP0 (VDD I1_p25_21 XI1_I1758_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I52_MP1 (VDD I1_b26_20 XI1_I1758_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I52_MP5 (I1_I1758_pn20 I1_b26_20 XI1_I1758_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I52_MP4 (XI1_I1758_I52_p1 XI1_I1758_I52_An I1_I1758_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I52_MP2 (VDD I1_p25_19 XI1_I1758_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I52_MP3 (XI1_I1758_I52_p1 XI1_I1758_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I52_MP0 (VDD I1_p25_19 XI1_I1758_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I51_MP1 (VDD I1_b26_19 XI1_I1758_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I51_MP5 (I1_I1758_pn19 I1_b26_19 XI1_I1758_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I51_MP4 (XI1_I1758_I51_p1 XI1_I1758_I51_An I1_I1758_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I51_MP2 (VDD I1_p25_18 XI1_I1758_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I51_MP3 (XI1_I1758_I51_p1 XI1_I1758_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I51_MP0 (VDD I1_p25_18 XI1_I1758_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I46_MP1 (VDD I1_b26_14 XI1_I1758_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I46_MP5 (I1_I1758_pn14 I1_b26_14 XI1_I1758_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I46_MP4 (XI1_I1758_I46_p1 XI1_I1758_I46_An I1_I1758_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I46_MP2 (VDD I1_p25_13 XI1_I1758_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I46_MP3 (XI1_I1758_I46_p1 XI1_I1758_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I46_MP0 (VDD I1_p25_13 XI1_I1758_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I43_MP1 (VDD I1_b26_11 XI1_I1758_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I43_MP5 (I1_I1758_pn11 I1_b26_11 XI1_I1758_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I43_MP4 (XI1_I1758_I43_p1 XI1_I1758_I43_An I1_I1758_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I43_MP2 (VDD I1_p25_10 XI1_I1758_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I43_MP3 (XI1_I1758_I43_p1 XI1_I1758_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I43_MP0 (VDD I1_p25_10 XI1_I1758_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I44_MP1 (VDD I1_b26_12 XI1_I1758_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I44_MP5 (I1_I1758_pn12 I1_b26_12 XI1_I1758_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I44_MP4 (XI1_I1758_I44_p1 XI1_I1758_I44_An I1_I1758_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I44_MP2 (VDD I1_p25_11 XI1_I1758_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I44_MP3 (XI1_I1758_I44_p1 XI1_I1758_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I44_MP0 (VDD I1_p25_11 XI1_I1758_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I229_MP1 (VDD I1_I1666_G25_0 XI1_I1666_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I229_MP5 (I1_p24_26 I1_I1666_G25_0 XI1_I1666_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I229_MP4 (XI1_I1666_I229_p1 XI1_I1666_I229_An I1_p24_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I229_MP2 (VDD I1_I1666_pn26 XI1_I1666_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I229_MP3 (XI1_I1666_I229_p1 XI1_I1666_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I229_MP0 (VDD I1_I1666_pn26 XI1_I1666_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I46_MP1 (VDD I1_b24_14 XI1_I1666_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I46_MP5 (I1_I1666_pn14 I1_b24_14 XI1_I1666_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I46_MP4 (XI1_I1666_I46_p1 XI1_I1666_I46_An I1_I1666_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I46_MP2 (VDD I1_p23_13 XI1_I1666_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I46_MP3 (XI1_I1666_I46_p1 XI1_I1666_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I46_MP0 (VDD I1_p23_13 XI1_I1666_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I45_MP1 (VDD I1_b24_13 XI1_I1666_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I45_MP5 (I1_I1666_pn13 I1_b24_13 XI1_I1666_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I45_MP4 (XI1_I1666_I45_p1 XI1_I1666_I45_An I1_I1666_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I45_MP2 (VDD I1_p23_12 XI1_I1666_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I45_MP3 (XI1_I1666_I45_p1 XI1_I1666_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I45_MP0 (VDD I1_p23_12 XI1_I1666_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I49_MP1 (VDD I1_b23_17 XI1_I1620_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I49_MP5 (I1_I1620_pn17 I1_b23_17 XI1_I1620_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I49_MP4 (XI1_I1620_I49_p1 XI1_I1620_I49_An I1_I1620_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I49_MP2 (VDD I1_p22_16 XI1_I1620_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I49_MP3 (XI1_I1620_I49_p1 XI1_I1620_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I49_MP0 (VDD I1_p22_16 XI1_I1620_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I47_MP1 (VDD I1_b23_15 XI1_I1620_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I47_MP5 (I1_I1620_pn15 I1_b23_15 XI1_I1620_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I47_MP4 (XI1_I1620_I47_p1 XI1_I1620_I47_An I1_I1620_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I47_MP2 (VDD I1_p22_14 XI1_I1620_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I47_MP3 (XI1_I1620_I47_p1 XI1_I1620_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I47_MP0 (VDD I1_p22_14 XI1_I1620_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I34_MP1 (VDD I2_I1_bx2 XI2_I1_I42_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I34_MP5 (I2_I1_I42_pn2 I2_I1_bx2 XI2_I1_I42_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I34_MP4 (XI2_I1_I42_I34_p1 XI2_I1_I42_I34_An I2_I1_I42_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I34_MP2 (VDD A_2 XI2_I1_I42_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I34_MP3 (XI2_I1_I42_I34_p1 XI2_I1_I42_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I34_MP0 (VDD A_2 XI2_I1_I42_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I205_MP1 (VDD I2_I1_I42_G1_0 XI2_I1_I42_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I205_MP5 (I2_S_2 I2_I1_I42_G1_0 XI2_I1_I42_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I205_MP4 (XI2_I1_I42_I205_p1 XI2_I1_I42_I205_An I2_S_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I205_MP2 (VDD I2_I1_I42_pn2 XI2_I1_I42_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I205_MP3 (XI2_I1_I42_I205_p1 XI2_I1_I42_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I205_MP0 (VDD I2_I1_I42_pn2 XI2_I1_I42_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I42_MP1 (VDD I1_b26_10 XI1_I1758_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I42_MP5 (I1_I1758_pn10 I1_b26_10 XI1_I1758_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I42_MP4 (XI1_I1758_I42_p1 XI1_I1758_I42_An I1_I1758_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I42_MP2 (VDD I1_p25_9 XI1_I1758_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I42_MP3 (XI1_I1758_I42_p1 XI1_I1758_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I42_MP0 (VDD I1_p25_9 XI1_I1758_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I40_MP1 (VDD I1_b26_8 XI1_I1758_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I40_MP5 (I1_I1758_pn8 I1_b26_8 XI1_I1758_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I40_MP4 (XI1_I1758_I40_p1 XI1_I1758_I40_An I1_I1758_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I40_MP2 (VDD I1_p25_7 XI1_I1758_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I40_MP3 (XI1_I1758_I40_p1 XI1_I1758_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I40_MP0 (VDD I1_p25_7 XI1_I1758_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I232_MP1 (VDD I1_I1666_G28_0 XI1_I1666_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I232_MP5 (I1_p24_29 I1_I1666_G28_0 XI1_I1666_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I232_MP4 (XI1_I1666_I232_p1 XI1_I1666_I232_An I1_p24_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I232_MP2 (VDD I1_I1666_pn29 XI1_I1666_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I232_MP3 (XI1_I1666_I232_p1 XI1_I1666_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I232_MP0 (VDD I1_I1666_pn29 XI1_I1666_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I225_MP1 (VDD I1_I1666_G21_0 XI1_I1666_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I225_MP5 (I1_p24_22 I1_I1666_G21_0 XI1_I1666_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I225_MP4 (XI1_I1666_I225_p1 XI1_I1666_I225_An I1_p24_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I225_MP2 (VDD I1_I1666_pn22 XI1_I1666_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I225_MP3 (XI1_I1666_I225_p1 XI1_I1666_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I225_MP0 (VDD I1_I1666_pn22 XI1_I1666_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I47_MP1 (VDD I1_b24_15 XI1_I1666_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I47_MP5 (I1_I1666_pn15 I1_b24_15 XI1_I1666_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I47_MP4 (XI1_I1666_I47_p1 XI1_I1666_I47_An I1_I1666_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I47_MP2 (VDD I1_p23_14 XI1_I1666_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I47_MP3 (XI1_I1666_I47_p1 XI1_I1666_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I47_MP0 (VDD I1_p23_14 XI1_I1666_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I48_MP1 (VDD I1_b24_16 XI1_I1666_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I48_MP5 (I1_I1666_pn16 I1_b24_16 XI1_I1666_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I48_MP4 (XI1_I1666_I48_p1 XI1_I1666_I48_An I1_I1666_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I48_MP2 (VDD I1_p23_15 XI1_I1666_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I48_MP3 (XI1_I1666_I48_p1 XI1_I1666_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I48_MP0 (VDD I1_p23_15 XI1_I1666_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I204_MP1 (VDD I2_I1_I42_G0_0 XI2_I1_I42_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I204_MP5 (I2_S_1 I2_I1_I42_G0_0 XI2_I1_I42_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I204_MP4 (XI2_I1_I42_I204_p1 XI2_I1_I42_I204_An I2_S_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I204_MP2 (VDD I2_I1_I42_pn1 XI2_I1_I42_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I204_MP3 (XI2_I1_I42_I204_p1 XI2_I1_I42_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I204_MP0 (VDD I2_I1_I42_pn1 XI2_I1_I42_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I33_MP1 (VDD I2_I1_bx1 XI2_I1_I42_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I33_MP5 (I2_I1_I42_pn1 I2_I1_bx1 XI2_I1_I42_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I33_MP4 (XI2_I1_I42_I33_p1 XI2_I1_I42_I33_An I2_I1_I42_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I33_MP2 (VDD A_1 XI2_I1_I42_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I33_MP3 (XI2_I1_I42_I33_p1 XI2_I1_I42_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I33_MP0 (VDD A_1 XI2_I1_I42_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I41_MP1 (VDD I1_b26_9 XI1_I1758_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I41_MP5 (I1_I1758_pn9 I1_b26_9 XI1_I1758_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I41_MP4 (XI1_I1758_I41_p1 XI1_I1758_I41_An I1_I1758_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I41_MP2 (VDD I1_p25_8 XI1_I1758_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I41_MP3 (XI1_I1758_I41_p1 XI1_I1758_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I41_MP0 (VDD I1_p25_8 XI1_I1758_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I39_MP1 (VDD I1_b26_7 XI1_I1758_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I39_MP5 (I1_I1758_pn7 I1_b26_7 XI1_I1758_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I39_MP4 (XI1_I1758_I39_p1 XI1_I1758_I39_An I1_I1758_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I39_MP2 (VDD I1_p25_6 XI1_I1758_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I39_MP3 (XI1_I1758_I39_p1 XI1_I1758_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I39_MP0 (VDD I1_p25_6 XI1_I1758_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I231_MP1 (VDD I1_I1666_G27_0 XI1_I1666_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I231_MP5 (I1_p24_28 I1_I1666_G27_0 XI1_I1666_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I231_MP4 (XI1_I1666_I231_p1 XI1_I1666_I231_An I1_p24_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I231_MP2 (VDD I1_I1666_pn28 XI1_I1666_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I231_MP3 (XI1_I1666_I231_p1 XI1_I1666_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I231_MP0 (VDD I1_I1666_pn28 XI1_I1666_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I50_MP1 (VDD I1_b24_18 XI1_I1666_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I50_MP5 (I1_I1666_pn18 I1_b24_18 XI1_I1666_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I50_MP4 (XI1_I1666_I50_p1 XI1_I1666_I50_An I1_I1666_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I50_MP2 (VDD I1_p23_17 XI1_I1666_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I50_MP3 (XI1_I1666_I50_p1 XI1_I1666_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I50_MP0 (VDD I1_p23_17 XI1_I1666_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I220_MP1 (VDD I1_I1620_G16_0 XI1_I1620_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I220_MP5 (I1_p23_17 I1_I1620_G16_0 XI1_I1620_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I220_MP4 (XI1_I1620_I220_p1 XI1_I1620_I220_An I1_p23_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I220_MP2 (VDD I1_I1620_pn17 XI1_I1620_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I220_MP3 (XI1_I1620_I220_p1 XI1_I1620_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I220_MP0 (VDD I1_I1620_pn17 XI1_I1620_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2106_MP1 (VDD I1_nqkn10 XI1_I2106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2106_MP5 (DIVQ_10 I1_nqkn10 XI1_I2106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2106_MP4 (XI1_I2106_p1 XI1_I2106_An DIVQ_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2106_MP2 (VDD I1_qu10_b3_5 XI1_I2106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2106_MP3 (XI1_I2106_p1 XI1_I2106_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2106_MP0 (VDD I1_qu10_b3_5 XI1_I2106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I32_MP1 (VDD I2_I1_bx0 XI2_I1_I42_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I32_MP5 (I2_I1_I42_pn0 I2_I1_bx0 XI2_I1_I42_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I32_MP4 (XI2_I1_I42_I32_p1 XI2_I1_I42_I32_An I2_I1_I42_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I32_MP2 (VDD A_0 XI2_I1_I42_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I32_MP3 (XI2_I1_I42_I32_p1 XI2_I1_I42_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I32_MP0 (VDD A_0 XI2_I1_I42_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I233_MP1 (VDD I1_I1758_G29_0 XI1_I1758_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I233_MP5 (I1_p26_30 I1_I1758_G29_0 XI1_I1758_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I233_MP4 (XI1_I1758_I233_p1 XI1_I1758_I233_An I1_p26_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I233_MP2 (VDD I1_I1758_pn30 XI1_I1758_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I233_MP3 (XI1_I1758_I233_p1 XI1_I1758_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I233_MP0 (VDD I1_I1758_pn30 XI1_I1758_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I229_MP1 (VDD I1_I1758_G25_0 XI1_I1758_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I229_MP5 (I1_p26_26 I1_I1758_G25_0 XI1_I1758_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I229_MP4 (XI1_I1758_I229_p1 XI1_I1758_I229_An I1_p26_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I229_MP2 (VDD I1_I1758_pn26 XI1_I1758_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I229_MP3 (XI1_I1758_I229_p1 XI1_I1758_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I229_MP0 (VDD I1_I1758_pn26 XI1_I1758_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I227_MP1 (VDD I1_I1758_G23_0 XI1_I1758_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I227_MP5 (I1_p26_24 I1_I1758_G23_0 XI1_I1758_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I227_MP4 (XI1_I1758_I227_p1 XI1_I1758_I227_An I1_p26_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I227_MP2 (VDD I1_I1758_pn24 XI1_I1758_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I227_MP3 (XI1_I1758_I227_p1 XI1_I1758_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I227_MP0 (VDD I1_I1758_pn24 XI1_I1758_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I38_MP1 (VDD I1_b26_6 XI1_I1758_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I38_MP5 (I1_I1758_pn6 I1_b26_6 XI1_I1758_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I38_MP4 (XI1_I1758_I38_p1 XI1_I1758_I38_An I1_I1758_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I38_MP2 (VDD I1_p25_5 XI1_I1758_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I38_MP3 (XI1_I1758_I38_p1 XI1_I1758_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I38_MP0 (VDD I1_p25_5 XI1_I1758_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I226_MP1 (VDD I1_I1666_G22_0 XI1_I1666_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I226_MP5 (I1_p24_23 I1_I1666_G22_0 XI1_I1666_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I226_MP4 (XI1_I1666_I226_p1 XI1_I1666_I226_An I1_p24_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I226_MP2 (VDD I1_I1666_pn23 XI1_I1666_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I226_MP3 (XI1_I1666_I226_p1 XI1_I1666_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I226_MP0 (VDD I1_I1666_pn23 XI1_I1666_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I227_MP1 (VDD I1_I1666_G23_0 XI1_I1666_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I227_MP5 (I1_p24_24 I1_I1666_G23_0 XI1_I1666_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I227_MP4 (XI1_I1666_I227_p1 XI1_I1666_I227_An I1_p24_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I227_MP2 (VDD I1_I1666_pn24 XI1_I1666_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I227_MP3 (XI1_I1666_I227_p1 XI1_I1666_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I227_MP0 (VDD I1_I1666_pn24 XI1_I1666_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I233_MP1 (VDD I1_I1666_G29_0 XI1_I1666_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I233_MP5 (I1_p24_30 I1_I1666_G29_0 XI1_I1666_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I233_MP4 (XI1_I1666_I233_p1 XI1_I1666_I233_An I1_p24_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I233_MP2 (VDD I1_I1666_pn30 XI1_I1666_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I233_MP3 (XI1_I1666_I233_p1 XI1_I1666_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I233_MP0 (VDD I1_I1666_pn30 XI1_I1666_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I52_MP1 (VDD I1_b24_20 XI1_I1666_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I52_MP5 (I1_I1666_pn20 I1_b24_20 XI1_I1666_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I52_MP4 (XI1_I1666_I52_p1 XI1_I1666_I52_An I1_I1666_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I52_MP2 (VDD I1_p23_19 XI1_I1666_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I52_MP3 (XI1_I1666_I52_p1 XI1_I1666_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I52_MP0 (VDD I1_p23_19 XI1_I1666_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I51_MP1 (VDD I1_b24_19 XI1_I1666_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I51_MP5 (I1_I1666_pn19 I1_b24_19 XI1_I1666_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I51_MP4 (XI1_I1666_I51_p1 XI1_I1666_I51_An I1_I1666_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I51_MP2 (VDD I1_p23_18 XI1_I1666_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I51_MP3 (XI1_I1666_I51_p1 XI1_I1666_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I51_MP0 (VDD I1_p23_18 XI1_I1666_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I49_MP1 (VDD I1_b24_17 XI1_I1666_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I49_MP5 (I1_I1666_pn17 I1_b24_17 XI1_I1666_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I49_MP4 (XI1_I1666_I49_p1 XI1_I1666_I49_An I1_I1666_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I49_MP2 (VDD I1_p23_16 XI1_I1666_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I49_MP3 (XI1_I1666_I49_p1 XI1_I1666_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I49_MP0 (VDD I1_p23_16 XI1_I1666_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I222_MP1 (VDD I1_I1620_G18_0 XI1_I1620_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I222_MP5 (I1_p23_19 I1_I1620_G18_0 XI1_I1620_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I222_MP4 (XI1_I1620_I222_p1 XI1_I1620_I222_An I1_p23_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I222_MP2 (VDD I1_I1620_pn19 XI1_I1620_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I222_MP3 (XI1_I1620_I222_p1 XI1_I1620_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I222_MP0 (VDD I1_I1620_pn19 XI1_I1620_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I221_MP1 (VDD I1_I1620_G17_0 XI1_I1620_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I221_MP5 (I1_p23_18 I1_I1620_G17_0 XI1_I1620_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I221_MP4 (XI1_I1620_I221_p1 XI1_I1620_I221_An I1_p23_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I221_MP2 (VDD I1_I1620_pn18 XI1_I1620_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I221_MP3 (XI1_I1620_I221_p1 XI1_I1620_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I221_MP0 (VDD I1_I1620_pn18 XI1_I1620_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I203_MP1 (VDD I2_I1_SUB_b3_5 XI2_I1_I42_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I203_MP5 (I2_S_0 I2_I1_SUB_b3_5 XI2_I1_I42_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I203_MP4 (XI2_I1_I42_I203_p1 XI2_I1_I42_I203_An I2_S_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I203_MP2 (VDD I2_I1_I42_pn0 XI2_I1_I42_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I203_MP3 (XI2_I1_I42_I203_p1 XI2_I1_I42_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I203_MP0 (VDD I2_I1_I42_pn0 XI2_I1_I42_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I231_MP1 (VDD I1_I1758_G27_0 XI1_I1758_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I231_MP5 (I1_p26_28 I1_I1758_G27_0 XI1_I1758_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I231_MP4 (XI1_I1758_I231_p1 XI1_I1758_I231_An I1_p26_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I231_MP2 (VDD I1_I1758_pn28 XI1_I1758_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I231_MP3 (XI1_I1758_I231_p1 XI1_I1758_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I231_MP0 (VDD I1_I1758_pn28 XI1_I1758_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I225_MP1 (VDD I1_I1758_G21_0 XI1_I1758_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I225_MP5 (I1_p26_22 I1_I1758_G21_0 XI1_I1758_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I225_MP4 (XI1_I1758_I225_p1 XI1_I1758_I225_An I1_p26_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I225_MP2 (VDD I1_I1758_pn22 XI1_I1758_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I225_MP3 (XI1_I1758_I225_p1 XI1_I1758_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I225_MP0 (VDD I1_I1758_pn22 XI1_I1758_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I223_MP1 (VDD I1_I1758_G19_0 XI1_I1758_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I223_MP5 (I1_p26_20 I1_I1758_G19_0 XI1_I1758_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I223_MP4 (XI1_I1758_I223_p1 XI1_I1758_I223_An I1_p26_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I223_MP2 (VDD I1_I1758_pn20 XI1_I1758_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I223_MP3 (XI1_I1758_I223_p1 XI1_I1758_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I223_MP0 (VDD I1_I1758_pn20 XI1_I1758_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I234_MP1 (VDD I1_c24_m XI1_I1666_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I234_MP5 (I1_p24_31 I1_c24_m XI1_I1666_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I234_MP4 (XI1_I1666_I234_p1 XI1_I1666_I234_An I1_p24_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I234_MP2 (VDD I1_I1666_pn31 XI1_I1666_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I234_MP3 (XI1_I1666_I234_p1 XI1_I1666_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I234_MP0 (VDD I1_I1666_pn31 XI1_I1666_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I37_MP1 (VDD I1_b26_5 XI1_I1758_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I37_MP5 (I1_I1758_pn5 I1_b26_5 XI1_I1758_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I37_MP4 (XI1_I1758_I37_p1 XI1_I1758_I37_An I1_I1758_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I37_MP2 (VDD I1_p25_4 XI1_I1758_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I37_MP3 (XI1_I1758_I37_p1 XI1_I1758_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I37_MP0 (VDD I1_p25_4 XI1_I1758_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I54_MP1 (VDD I1_b24_22 XI1_I1666_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I54_MP5 (I1_I1666_pn22 I1_b24_22 XI1_I1666_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I54_MP4 (XI1_I1666_I54_p1 XI1_I1666_I54_An I1_I1666_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I54_MP2 (VDD I1_p23_21 XI1_I1666_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I54_MP3 (XI1_I1666_I54_p1 XI1_I1666_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I54_MP0 (VDD I1_p23_21 XI1_I1666_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I53_MP1 (VDD I1_b24_21 XI1_I1666_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I53_MP5 (I1_I1666_pn21 I1_b24_21 XI1_I1666_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I53_MP4 (XI1_I1666_I53_p1 XI1_I1666_I53_An I1_I1666_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I53_MP2 (VDD I1_p23_20 XI1_I1666_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I53_MP3 (XI1_I1666_I53_p1 XI1_I1666_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I53_MP0 (VDD I1_p23_20 XI1_I1666_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I52_MP1 (VDD I1_b23_20 XI1_I1620_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I52_MP5 (I1_I1620_pn20 I1_b23_20 XI1_I1620_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I52_MP4 (XI1_I1620_I52_p1 XI1_I1620_I52_An I1_I1620_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I52_MP2 (VDD I1_p22_19 XI1_I1620_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I52_MP3 (XI1_I1620_I52_p1 XI1_I1620_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I52_MP0 (VDD I1_p22_19 XI1_I1620_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I51_MP1 (VDD I1_b23_19 XI1_I1620_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I51_MP5 (I1_I1620_pn19 I1_b23_19 XI1_I1620_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I51_MP4 (XI1_I1620_I51_p1 XI1_I1620_I51_An I1_I1620_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I51_MP2 (VDD I1_p22_18 XI1_I1620_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I51_MP3 (XI1_I1620_I51_p1 XI1_I1620_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I51_MP0 (VDD I1_p22_18 XI1_I1620_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I50_MP1 (VDD I1_b23_18 XI1_I1620_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I50_MP5 (I1_I1620_pn18 I1_b23_18 XI1_I1620_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I50_MP4 (XI1_I1620_I50_p1 XI1_I1620_I50_An I1_I1620_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I50_MP2 (VDD I1_p22_17 XI1_I1620_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I50_MP3 (XI1_I1620_I50_p1 XI1_I1620_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I50_MP0 (VDD I1_p22_17 XI1_I1620_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2103_MP1 (VDD I1_nqkn9 XI1_I2103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2103_MP5 (DIVQ_9 I1_nqkn9 XI1_I2103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2103_MP4 (XI1_I2103_p1 XI1_I2103_An DIVQ_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2103_MP2 (VDD I1_qu9_b3_5 XI1_I2103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2103_MP3 (XI1_I2103_p1 XI1_I2103_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2103_MP0 (VDD I1_qu9_b3_5 XI1_I2103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2097_MP1 (VDD I1_nqkn7 XI1_I2097_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2097_MP5 (DIVQ_7 I1_nqkn7 XI1_I2097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2097_MP4 (XI1_I2097_p1 XI1_I2097_An DIVQ_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2097_MP2 (VDD I1_qu7_b3_5 XI1_I2097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2097_MP3 (XI1_I2097_p1 XI1_I2097_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2097_MP0 (VDD I1_qu7_b3_5 XI1_I2097_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I221_MP1 (VDD I1_I1758_G17_0 XI1_I1758_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I221_MP5 (I1_p26_18 I1_I1758_G17_0 XI1_I1758_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I221_MP4 (XI1_I1758_I221_p1 XI1_I1758_I221_An I1_p26_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I221_MP2 (VDD I1_I1758_pn18 XI1_I1758_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I221_MP3 (XI1_I1758_I221_p1 XI1_I1758_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I221_MP0 (VDD I1_I1758_pn18 XI1_I1758_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I211_MP1 (VDD I1_I1758_G7_0 XI1_I1758_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I211_MP5 (I1_p26_8 I1_I1758_G7_0 XI1_I1758_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I211_MP4 (XI1_I1758_I211_p1 XI1_I1758_I211_An I1_p26_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I211_MP2 (VDD I1_I1758_pn8 XI1_I1758_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I211_MP3 (XI1_I1758_I211_p1 XI1_I1758_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I211_MP0 (VDD I1_I1758_pn8 XI1_I1758_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I36_MP1 (VDD I1_b26_4 XI1_I1758_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I36_MP5 (I1_I1758_pn4 I1_b26_4 XI1_I1758_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I36_MP4 (XI1_I1758_I36_p1 XI1_I1758_I36_An I1_I1758_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I36_MP2 (VDD I1_p25_3 XI1_I1758_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I36_MP3 (XI1_I1758_I36_p1 XI1_I1758_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I36_MP0 (VDD I1_p25_3 XI1_I1758_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I55_MP1 (VDD I1_b24_23 XI1_I1666_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I55_MP5 (I1_I1666_pn23 I1_b24_23 XI1_I1666_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I55_MP4 (XI1_I1666_I55_p1 XI1_I1666_I55_An I1_I1666_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I55_MP2 (VDD I1_p23_22 XI1_I1666_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I55_MP3 (XI1_I1666_I55_p1 XI1_I1666_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I55_MP0 (VDD I1_p23_22 XI1_I1666_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I53_MP1 (VDD I1_b23_21 XI1_I1620_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I53_MP5 (I1_I1620_pn21 I1_b23_21 XI1_I1620_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I53_MP4 (XI1_I1620_I53_p1 XI1_I1620_I53_An I1_I1620_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I53_MP2 (VDD I1_p22_20 XI1_I1620_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I53_MP3 (XI1_I1620_I53_p1 XI1_I1620_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I53_MP0 (VDD I1_p22_20 XI1_I1620_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I224_MP1 (VDD I1_I1620_G20_0 XI1_I1620_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I224_MP5 (I1_p23_21 I1_I1620_G20_0 XI1_I1620_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I224_MP4 (XI1_I1620_I224_p1 XI1_I1620_I224_An I1_p23_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I224_MP2 (VDD I1_I1620_pn21 XI1_I1620_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I224_MP3 (XI1_I1620_I224_p1 XI1_I1620_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I224_MP0 (VDD I1_I1620_pn21 XI1_I1620_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I223_MP1 (VDD I1_I1620_G19_0 XI1_I1620_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I223_MP5 (I1_p23_20 I1_I1620_G19_0 XI1_I1620_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I223_MP4 (XI1_I1620_I223_p1 XI1_I1620_I223_An I1_p23_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I223_MP2 (VDD I1_I1620_pn20 XI1_I1620_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I223_MP3 (XI1_I1620_I223_p1 XI1_I1620_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I223_MP0 (VDD I1_I1620_pn20 XI1_I1620_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2100_MP1 (VDD I1_nqkn8 XI1_I2100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2100_MP5 (DIVQ_8 I1_nqkn8 XI1_I2100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2100_MP4 (XI1_I2100_p1 XI1_I2100_An DIVQ_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2100_MP2 (VDD I1_qu8_b3_5 XI1_I2100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2100_MP3 (XI1_I2100_p1 XI1_I2100_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2100_MP0 (VDD I1_qu8_b3_5 XI1_I2100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I234_MP1 (VDD I1_c26_m XI1_I1758_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I234_MP5 (I1_p26_31 I1_c26_m XI1_I1758_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I234_MP4 (XI1_I1758_I234_p1 XI1_I1758_I234_An I1_p26_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I234_MP2 (VDD I1_I1758_pn31 XI1_I1758_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I234_MP3 (XI1_I1758_I234_p1 XI1_I1758_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I234_MP0 (VDD I1_I1758_pn31 XI1_I1758_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I232_MP1 (VDD I1_I1758_G28_0 XI1_I1758_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I232_MP5 (I1_p26_29 I1_I1758_G28_0 XI1_I1758_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I232_MP4 (XI1_I1758_I232_p1 XI1_I1758_I232_An I1_p26_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I232_MP2 (VDD I1_I1758_pn29 XI1_I1758_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I232_MP3 (XI1_I1758_I232_p1 XI1_I1758_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I232_MP0 (VDD I1_I1758_pn29 XI1_I1758_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I209_MP1 (VDD I1_I1758_G5_0 XI1_I1758_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I209_MP5 (I1_p26_6 I1_I1758_G5_0 XI1_I1758_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I209_MP4 (XI1_I1758_I209_p1 XI1_I1758_I209_An I1_p26_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I209_MP2 (VDD I1_I1758_pn6 XI1_I1758_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I209_MP3 (XI1_I1758_I209_p1 XI1_I1758_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I209_MP0 (VDD I1_I1758_pn6 XI1_I1758_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I210_MP1 (VDD I1_I1758_G6_0 XI1_I1758_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I210_MP5 (I1_p26_7 I1_I1758_G6_0 XI1_I1758_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I210_MP4 (XI1_I1758_I210_p1 XI1_I1758_I210_An I1_p26_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I210_MP2 (VDD I1_I1758_pn7 XI1_I1758_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I210_MP3 (XI1_I1758_I210_p1 XI1_I1758_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I210_MP0 (VDD I1_I1758_pn7 XI1_I1758_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I35_MP1 (VDD I1_b26_3 XI1_I1758_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I35_MP5 (I1_I1758_pn3 I1_b26_3 XI1_I1758_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I35_MP4 (XI1_I1758_I35_p1 XI1_I1758_I35_An I1_I1758_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I35_MP2 (VDD I1_p25_2 XI1_I1758_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I35_MP3 (XI1_I1758_I35_p1 XI1_I1758_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I35_MP0 (VDD I1_p25_2 XI1_I1758_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I56_MP1 (VDD I1_b24_24 XI1_I1666_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I56_MP5 (I1_I1666_pn24 I1_b24_24 XI1_I1666_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I56_MP4 (XI1_I1666_I56_p1 XI1_I1666_I56_An I1_I1666_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I56_MP2 (VDD I1_p23_23 XI1_I1666_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I56_MP3 (XI1_I1666_I56_p1 XI1_I1666_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I56_MP0 (VDD I1_p23_23 XI1_I1666_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I234_MP1 (VDD I1_c23_m XI1_I1620_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I234_MP5 (I1_p23_31 I1_c23_m XI1_I1620_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I234_MP4 (XI1_I1620_I234_p1 XI1_I1620_I234_An I1_p23_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I234_MP2 (VDD I1_I1620_pn31 XI1_I1620_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I234_MP3 (XI1_I1620_I234_p1 XI1_I1620_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I234_MP0 (VDD I1_I1620_pn31 XI1_I1620_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I226_MP1 (VDD I1_I1620_G22_0 XI1_I1620_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I226_MP5 (I1_p23_23 I1_I1620_G22_0 XI1_I1620_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I226_MP4 (XI1_I1620_I226_p1 XI1_I1620_I226_An I1_p23_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I226_MP2 (VDD I1_I1620_pn23 XI1_I1620_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I226_MP3 (XI1_I1620_I226_p1 XI1_I1620_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I226_MP0 (VDD I1_I1620_pn23 XI1_I1620_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I54_MP1 (VDD I1_b23_22 XI1_I1620_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I54_MP5 (I1_I1620_pn22 I1_b23_22 XI1_I1620_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I54_MP4 (XI1_I1620_I54_p1 XI1_I1620_I54_An I1_I1620_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I54_MP2 (VDD I1_p22_21 XI1_I1620_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I54_MP3 (XI1_I1620_I54_p1 XI1_I1620_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I54_MP0 (VDD I1_p22_21 XI1_I1620_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I225_MP1 (VDD I1_I1620_G21_0 XI1_I1620_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I225_MP5 (I1_p23_22 I1_I1620_G21_0 XI1_I1620_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I225_MP4 (XI1_I1620_I225_p1 XI1_I1620_I225_An I1_p23_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I225_MP2 (VDD I1_I1620_pn22 XI1_I1620_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I225_MP3 (XI1_I1620_I225_p1 XI1_I1620_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I225_MP0 (VDD I1_I1620_pn22 XI1_I1620_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2094_MP1 (VDD I1_nqkn6 XI1_I2094_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2094_MP5 (DIVQ_6 I1_nqkn6 XI1_I2094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2094_MP4 (XI1_I2094_p1 XI1_I2094_An DIVQ_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2094_MP2 (VDD I1_qu6_b3_5 XI1_I2094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2094_MP3 (XI1_I2094_p1 XI1_I2094_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2094_MP0 (VDD I1_qu6_b3_5 XI1_I2094_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I230_MP1 (VDD I1_I1758_G26_0 XI1_I1758_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I230_MP5 (I1_p26_27 I1_I1758_G26_0 XI1_I1758_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I230_MP4 (XI1_I1758_I230_p1 XI1_I1758_I230_An I1_p26_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I230_MP2 (VDD I1_I1758_pn27 XI1_I1758_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I230_MP3 (XI1_I1758_I230_p1 XI1_I1758_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I230_MP0 (VDD I1_I1758_pn27 XI1_I1758_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I228_MP1 (VDD I1_I1758_G24_0 XI1_I1758_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I228_MP5 (I1_p26_25 I1_I1758_G24_0 XI1_I1758_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I228_MP4 (XI1_I1758_I228_p1 XI1_I1758_I228_An I1_p26_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I228_MP2 (VDD I1_I1758_pn25 XI1_I1758_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I228_MP3 (XI1_I1758_I228_p1 XI1_I1758_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I228_MP0 (VDD I1_I1758_pn25 XI1_I1758_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I226_MP1 (VDD I1_I1758_G22_0 XI1_I1758_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I226_MP5 (I1_p26_23 I1_I1758_G22_0 XI1_I1758_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I226_MP4 (XI1_I1758_I226_p1 XI1_I1758_I226_An I1_p26_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I226_MP2 (VDD I1_I1758_pn23 XI1_I1758_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I226_MP3 (XI1_I1758_I226_p1 XI1_I1758_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I226_MP0 (VDD I1_I1758_pn23 XI1_I1758_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I224_MP1 (VDD I1_I1758_G20_0 XI1_I1758_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I224_MP5 (I1_p26_21 I1_I1758_G20_0 XI1_I1758_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I224_MP4 (XI1_I1758_I224_p1 XI1_I1758_I224_An I1_p26_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I224_MP2 (VDD I1_I1758_pn21 XI1_I1758_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I224_MP3 (XI1_I1758_I224_p1 XI1_I1758_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I224_MP0 (VDD I1_I1758_pn21 XI1_I1758_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I222_MP1 (VDD I1_I1758_G18_0 XI1_I1758_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I222_MP5 (I1_p26_19 I1_I1758_G18_0 XI1_I1758_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I222_MP4 (XI1_I1758_I222_p1 XI1_I1758_I222_An I1_p26_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I222_MP2 (VDD I1_I1758_pn19 XI1_I1758_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I222_MP3 (XI1_I1758_I222_p1 XI1_I1758_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I222_MP0 (VDD I1_I1758_pn19 XI1_I1758_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I33_MP1 (VDD I1_b26_1 XI1_I1758_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I33_MP5 (I1_I1758_pn1 I1_b26_1 XI1_I1758_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I33_MP4 (XI1_I1758_I33_p1 XI1_I1758_I33_An I1_I1758_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I33_MP2 (VDD I1_p25_0 XI1_I1758_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I33_MP3 (XI1_I1758_I33_p1 XI1_I1758_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I33_MP0 (VDD I1_p25_0 XI1_I1758_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I34_MP1 (VDD I1_b26_2 XI1_I1758_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I34_MP5 (I1_I1758_pn2 I1_b26_2 XI1_I1758_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I34_MP4 (XI1_I1758_I34_p1 XI1_I1758_I34_An I1_I1758_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I34_MP2 (VDD I1_p25_1 XI1_I1758_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I34_MP3 (XI1_I1758_I34_p1 XI1_I1758_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I34_MP0 (VDD I1_p25_1 XI1_I1758_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I62_MP1 (VDD I1_b24_30 XI1_I1666_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I62_MP5 (I1_I1666_pn30 I1_b24_30 XI1_I1666_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I62_MP4 (XI1_I1666_I62_p1 XI1_I1666_I62_An I1_I1666_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I62_MP2 (VDD I1_p23_29 XI1_I1666_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I62_MP3 (XI1_I1666_I62_p1 XI1_I1666_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I62_MP0 (VDD I1_p23_29 XI1_I1666_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I58_MP1 (VDD I1_b24_26 XI1_I1666_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I58_MP5 (I1_I1666_pn26 I1_b24_26 XI1_I1666_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I58_MP4 (XI1_I1666_I58_p1 XI1_I1666_I58_An I1_I1666_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I58_MP2 (VDD I1_p23_25 XI1_I1666_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I58_MP3 (XI1_I1666_I58_p1 XI1_I1666_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I58_MP0 (VDD I1_p23_25 XI1_I1666_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I57_MP1 (VDD I1_b24_25 XI1_I1666_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I57_MP5 (I1_I1666_pn25 I1_b24_25 XI1_I1666_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I57_MP4 (XI1_I1666_I57_p1 XI1_I1666_I57_An I1_I1666_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I57_MP2 (VDD I1_p23_24 XI1_I1666_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I57_MP3 (XI1_I1666_I57_p1 XI1_I1666_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I57_MP0 (VDD I1_p23_24 XI1_I1666_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I63_MP1 (VDD I1_b23_31 XI1_I1620_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I63_MP5 (I1_I1620_pn31 I1_b23_31 XI1_I1620_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I63_MP4 (XI1_I1620_I63_p1 XI1_I1620_I63_An I1_I1620_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I63_MP2 (VDD I1_p22_30 XI1_I1620_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I63_MP3 (XI1_I1620_I63_p1 XI1_I1620_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I63_MP0 (VDD I1_p22_30 XI1_I1620_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I55_MP1 (VDD I1_b23_23 XI1_I1620_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I55_MP5 (I1_I1620_pn23 I1_b23_23 XI1_I1620_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I55_MP4 (XI1_I1620_I55_p1 XI1_I1620_I55_An I1_I1620_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I55_MP2 (VDD I1_p22_22 XI1_I1620_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I55_MP3 (XI1_I1620_I55_p1 XI1_I1620_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I55_MP0 (VDD I1_p22_22 XI1_I1620_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I232_MP1 (VDD I1_I1620_G28_0 XI1_I1620_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I232_MP5 (I1_p23_29 I1_I1620_G28_0 XI1_I1620_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I232_MP4 (XI1_I1620_I232_p1 XI1_I1620_I232_An I1_p23_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I232_MP2 (VDD I1_I1620_pn29 XI1_I1620_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I232_MP3 (XI1_I1620_I232_p1 XI1_I1620_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I232_MP0 (VDD I1_I1620_pn29 XI1_I1620_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I228_MP1 (VDD I1_I1620_G24_0 XI1_I1620_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I228_MP5 (I1_p23_25 I1_I1620_G24_0 XI1_I1620_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I228_MP4 (XI1_I1620_I228_p1 XI1_I1620_I228_An I1_p23_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I228_MP2 (VDD I1_I1620_pn25 XI1_I1620_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I228_MP3 (XI1_I1620_I228_p1 XI1_I1620_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I228_MP0 (VDD I1_I1620_pn25 XI1_I1620_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I227_MP1 (VDD I1_I1620_G23_0 XI1_I1620_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I227_MP5 (I1_p23_24 I1_I1620_G23_0 XI1_I1620_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I227_MP4 (XI1_I1620_I227_p1 XI1_I1620_I227_An I1_p23_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I227_MP2 (VDD I1_I1620_pn24 XI1_I1620_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I227_MP3 (XI1_I1620_I227_p1 XI1_I1620_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I227_MP0 (VDD I1_I1620_pn24 XI1_I1620_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I49_MP1 (VDD I1_nakn5 XI1_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I49_MP5 (I1_aa5 I1_nakn5 XI1_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I49_MP4 (XI1_I49_p1 XI1_I49_An I1_aa5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I49_MP2 (VDD A_5 XI1_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I49_MP3 (XI1_I49_p1 XI1_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I49_MP0 (VDD A_5 XI1_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I50_MP1 (VDD I1_b27_18 XI1_I1804_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I50_MP5 (I1_I1804_pn18 I1_b27_18 XI1_I1804_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I50_MP4 (XI1_I1804_I50_p1 XI1_I1804_I50_An I1_I1804_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I50_MP2 (VDD I1_p26_17 XI1_I1804_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I50_MP3 (XI1_I1804_I50_p1 XI1_I1804_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I50_MP0 (VDD I1_p26_17 XI1_I1804_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I220_MP1 (VDD I1_I1758_G16_0 XI1_I1758_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I220_MP5 (I1_p26_17 I1_I1758_G16_0 XI1_I1758_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I220_MP4 (XI1_I1758_I220_p1 XI1_I1758_I220_An I1_p26_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I220_MP2 (VDD I1_I1758_pn17 XI1_I1758_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I220_MP3 (XI1_I1758_I220_p1 XI1_I1758_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I220_MP0 (VDD I1_I1758_pn17 XI1_I1758_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I47_MP1 (VDD I1_b27_15 XI1_I1804_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I47_MP5 (I1_I1804_pn15 I1_b27_15 XI1_I1804_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I47_MP4 (XI1_I1804_I47_p1 XI1_I1804_I47_An I1_I1804_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I47_MP2 (VDD I1_p26_14 XI1_I1804_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I47_MP3 (XI1_I1804_I47_p1 XI1_I1804_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I47_MP0 (VDD I1_p26_14 XI1_I1804_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I45_MP1 (VDD I1_b27_13 XI1_I1804_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I45_MP5 (I1_I1804_pn13 I1_b27_13 XI1_I1804_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I45_MP4 (XI1_I1804_I45_p1 XI1_I1804_I45_An I1_I1804_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I45_MP2 (VDD I1_p26_12 XI1_I1804_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I45_MP3 (XI1_I1804_I45_p1 XI1_I1804_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I45_MP0 (VDD I1_p26_12 XI1_I1804_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I40_MP1 (VDD I1_b27_8 XI1_I1804_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I40_MP5 (I1_I1804_pn8 I1_b27_8 XI1_I1804_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I40_MP4 (XI1_I1804_I40_p1 XI1_I1804_I40_An I1_I1804_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I40_MP2 (VDD I1_p26_7 XI1_I1804_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I40_MP3 (XI1_I1804_I40_p1 XI1_I1804_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I40_MP0 (VDD I1_p26_7 XI1_I1804_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I208_MP1 (VDD I1_I1758_G4_0 XI1_I1758_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I208_MP5 (I1_p26_5 I1_I1758_G4_0 XI1_I1758_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I208_MP4 (XI1_I1758_I208_p1 XI1_I1758_I208_An I1_p26_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I208_MP2 (VDD I1_I1758_pn5 XI1_I1758_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I208_MP3 (XI1_I1758_I208_p1 XI1_I1758_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I208_MP0 (VDD I1_I1758_pn5 XI1_I1758_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I205_MP1 (VDD I1_I1758_G1_0 XI1_I1758_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I205_MP5 (I1_p26_2 I1_I1758_G1_0 XI1_I1758_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I205_MP4 (XI1_I1758_I205_p1 XI1_I1758_I205_An I1_p26_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I205_MP2 (VDD I1_I1758_pn2 XI1_I1758_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I205_MP3 (XI1_I1758_I205_p1 XI1_I1758_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I205_MP0 (VDD I1_I1758_pn2 XI1_I1758_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I204_MP1 (VDD I1_I1758_G0_0 XI1_I1758_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I204_MP5 (I1_p26_1 I1_I1758_G0_0 XI1_I1758_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I204_MP4 (XI1_I1758_I204_p1 XI1_I1758_I204_An I1_p26_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I204_MP2 (VDD I1_I1758_pn1 XI1_I1758_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I204_MP3 (XI1_I1758_I204_p1 XI1_I1758_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I204_MP0 (VDD I1_I1758_pn1 XI1_I1758_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I203_MP1 (VDD I1_qu6_b3_5 XI1_I1758_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I203_MP5 (I1_p26_0 I1_qu6_b3_5 XI1_I1758_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I203_MP4 (XI1_I1758_I203_p1 XI1_I1758_I203_An I1_p26_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I203_MP2 (VDD I1_I1758_pn0 XI1_I1758_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I203_MP3 (XI1_I1758_I203_p1 XI1_I1758_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I203_MP0 (VDD I1_I1758_pn0 XI1_I1758_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I63_MP1 (VDD I1_b24_31 XI1_I1666_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I63_MP5 (I1_I1666_pn31 I1_b24_31 XI1_I1666_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I63_MP4 (XI1_I1666_I63_p1 XI1_I1666_I63_An I1_I1666_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I63_MP2 (VDD I1_p23_30 XI1_I1666_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I63_MP3 (XI1_I1666_I63_p1 XI1_I1666_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I63_MP0 (VDD I1_p23_30 XI1_I1666_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I57_MP1 (VDD I1_b23_25 XI1_I1620_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I57_MP5 (I1_I1620_pn25 I1_b23_25 XI1_I1620_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I57_MP4 (XI1_I1620_I57_p1 XI1_I1620_I57_An I1_I1620_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I57_MP2 (VDD I1_p22_24 XI1_I1620_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I57_MP3 (XI1_I1620_I57_p1 XI1_I1620_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I57_MP0 (VDD I1_p22_24 XI1_I1620_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I233_MP1 (VDD I1_I1620_G29_0 XI1_I1620_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I233_MP5 (I1_p23_30 I1_I1620_G29_0 XI1_I1620_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I233_MP4 (XI1_I1620_I233_p1 XI1_I1620_I233_An I1_p23_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I233_MP2 (VDD I1_I1620_pn30 XI1_I1620_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I233_MP3 (XI1_I1620_I233_p1 XI1_I1620_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I233_MP0 (VDD I1_I1620_pn30 XI1_I1620_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I56_MP1 (VDD I1_b23_24 XI1_I1620_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I56_MP5 (I1_I1620_pn24 I1_b23_24 XI1_I1620_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I56_MP4 (XI1_I1620_I56_p1 XI1_I1620_I56_An I1_I1620_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I56_MP2 (VDD I1_p22_23 XI1_I1620_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I56_MP3 (XI1_I1620_I56_p1 XI1_I1620_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I56_MP0 (VDD I1_p22_23 XI1_I1620_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I64_MP1 (VDD I0_B_1_b3_5 XI0_I1660_I64_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I64_MP5 (I0_I1660_pn0 I0_B_1_b3_5 XI0_I1660_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I64_MP4 (XI0_I1660_I64_p1 XI0_I1660_I64_An I0_I1660_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I64_MP2 (VDD I0_pp0_0 XI0_I1660_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I64_MP3 (XI0_I1660_I64_p1 XI0_I1660_I64_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I64_MP0 (VDD I0_pp0_0 XI0_I1660_I64_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I62_MP1 (VDD I1_b27_30 XI1_I1804_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I62_MP5 (I1_I1804_pn30 I1_b27_30 XI1_I1804_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I62_MP4 (XI1_I1804_I62_p1 XI1_I1804_I62_An I1_I1804_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I62_MP2 (VDD I1_p26_29 XI1_I1804_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I62_MP3 (XI1_I1804_I62_p1 XI1_I1804_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I62_MP0 (VDD I1_p26_29 XI1_I1804_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I58_MP1 (VDD I1_b27_26 XI1_I1804_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I58_MP5 (I1_I1804_pn26 I1_b27_26 XI1_I1804_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I58_MP4 (XI1_I1804_I58_p1 XI1_I1804_I58_An I1_I1804_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I58_MP2 (VDD I1_p26_25 XI1_I1804_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I58_MP3 (XI1_I1804_I58_p1 XI1_I1804_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I58_MP0 (VDD I1_p26_25 XI1_I1804_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I56_MP1 (VDD I1_b27_24 XI1_I1804_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I56_MP5 (I1_I1804_pn24 I1_b27_24 XI1_I1804_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I56_MP4 (XI1_I1804_I56_p1 XI1_I1804_I56_An I1_I1804_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I56_MP2 (VDD I1_p26_23 XI1_I1804_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I56_MP3 (XI1_I1804_I56_p1 XI1_I1804_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I56_MP0 (VDD I1_p26_23 XI1_I1804_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I55_MP1 (VDD I1_b27_23 XI1_I1804_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I55_MP5 (I1_I1804_pn23 I1_b27_23 XI1_I1804_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I55_MP4 (XI1_I1804_I55_p1 XI1_I1804_I55_An I1_I1804_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I55_MP2 (VDD I1_p26_22 XI1_I1804_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I55_MP3 (XI1_I1804_I55_p1 XI1_I1804_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I55_MP0 (VDD I1_p26_22 XI1_I1804_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I53_MP1 (VDD I1_b27_21 XI1_I1804_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I53_MP5 (I1_I1804_pn21 I1_b27_21 XI1_I1804_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I53_MP4 (XI1_I1804_I53_p1 XI1_I1804_I53_An I1_I1804_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I53_MP2 (VDD I1_p26_20 XI1_I1804_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I53_MP3 (XI1_I1804_I53_p1 XI1_I1804_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I53_MP0 (VDD I1_p26_20 XI1_I1804_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I51_MP1 (VDD I1_b27_19 XI1_I1804_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I51_MP5 (I1_I1804_pn19 I1_b27_19 XI1_I1804_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I51_MP4 (XI1_I1804_I51_p1 XI1_I1804_I51_An I1_I1804_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I51_MP2 (VDD I1_p26_18 XI1_I1804_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I51_MP3 (XI1_I1804_I51_p1 XI1_I1804_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I51_MP0 (VDD I1_p26_18 XI1_I1804_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I49_MP1 (VDD I1_b27_17 XI1_I1804_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I49_MP5 (I1_I1804_pn17 I1_b27_17 XI1_I1804_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I49_MP4 (XI1_I1804_I49_p1 XI1_I1804_I49_An I1_I1804_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I49_MP2 (VDD I1_p26_16 XI1_I1804_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I49_MP3 (XI1_I1804_I49_p1 XI1_I1804_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I49_MP0 (VDD I1_p26_16 XI1_I1804_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I48_MP1 (VDD I1_b27_16 XI1_I1804_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I48_MP5 (I1_I1804_pn16 I1_b27_16 XI1_I1804_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I48_MP4 (XI1_I1804_I48_p1 XI1_I1804_I48_An I1_I1804_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I48_MP2 (VDD I1_p26_15 XI1_I1804_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I48_MP3 (XI1_I1804_I48_p1 XI1_I1804_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I48_MP0 (VDD I1_p26_15 XI1_I1804_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I46_MP1 (VDD I1_b27_14 XI1_I1804_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I46_MP5 (I1_I1804_pn14 I1_b27_14 XI1_I1804_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I46_MP4 (XI1_I1804_I46_p1 XI1_I1804_I46_An I1_I1804_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I46_MP2 (VDD I1_p26_13 XI1_I1804_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I46_MP3 (XI1_I1804_I46_p1 XI1_I1804_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I46_MP0 (VDD I1_p26_13 XI1_I1804_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I44_MP1 (VDD I1_b27_12 XI1_I1804_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I44_MP5 (I1_I1804_pn12 I1_b27_12 XI1_I1804_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I44_MP4 (XI1_I1804_I44_p1 XI1_I1804_I44_An I1_I1804_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I44_MP2 (VDD I1_p26_11 XI1_I1804_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I44_MP3 (XI1_I1804_I44_p1 XI1_I1804_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I44_MP0 (VDD I1_p26_11 XI1_I1804_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I43_MP1 (VDD I1_b27_11 XI1_I1804_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I43_MP5 (I1_I1804_pn11 I1_b27_11 XI1_I1804_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I43_MP4 (XI1_I1804_I43_p1 XI1_I1804_I43_An I1_I1804_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I43_MP2 (VDD I1_p26_10 XI1_I1804_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I43_MP3 (XI1_I1804_I43_p1 XI1_I1804_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I43_MP0 (VDD I1_p26_10 XI1_I1804_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I42_MP1 (VDD I1_b27_10 XI1_I1804_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I42_MP5 (I1_I1804_pn10 I1_b27_10 XI1_I1804_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I42_MP4 (XI1_I1804_I42_p1 XI1_I1804_I42_An I1_I1804_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I42_MP2 (VDD I1_p26_9 XI1_I1804_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I42_MP3 (XI1_I1804_I42_p1 XI1_I1804_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I42_MP0 (VDD I1_p26_9 XI1_I1804_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I41_MP1 (VDD I1_b27_9 XI1_I1804_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I41_MP5 (I1_I1804_pn9 I1_b27_9 XI1_I1804_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I41_MP4 (XI1_I1804_I41_p1 XI1_I1804_I41_An I1_I1804_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I41_MP2 (VDD I1_p26_8 XI1_I1804_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I41_MP3 (XI1_I1804_I41_p1 XI1_I1804_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I41_MP0 (VDD I1_p26_8 XI1_I1804_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I38_MP1 (VDD I1_b27_6 XI1_I1804_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I38_MP5 (I1_I1804_pn6 I1_b27_6 XI1_I1804_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I38_MP4 (XI1_I1804_I38_p1 XI1_I1804_I38_An I1_I1804_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I38_MP2 (VDD I1_p26_5 XI1_I1804_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I38_MP3 (XI1_I1804_I38_p1 XI1_I1804_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I38_MP0 (VDD I1_p26_5 XI1_I1804_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I36_MP1 (VDD I1_b27_4 XI1_I1804_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I36_MP5 (I1_I1804_pn4 I1_b27_4 XI1_I1804_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I36_MP4 (XI1_I1804_I36_p1 XI1_I1804_I36_An I1_I1804_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I36_MP2 (VDD I1_p26_3 XI1_I1804_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I36_MP3 (XI1_I1804_I36_p1 XI1_I1804_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I36_MP0 (VDD I1_p26_3 XI1_I1804_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I32_MP1 (VDD I1_b26_0 XI1_I1758_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1758_I32_MP5 (I1_I1758_pn0 I1_b26_0 XI1_I1758_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1758_I32_MP4 (XI1_I1758_I32_p1 XI1_I1758_I32_An I1_I1758_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I32_MP2 (VDD I1_aa5 XI1_I1758_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1758_I32_MP3 (XI1_I1758_I32_p1 XI1_I1758_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I32_MP0 (VDD I1_aa5 XI1_I1758_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I60_MP1 (VDD I1_b24_28 XI1_I1666_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I60_MP5 (I1_I1666_pn28 I1_b24_28 XI1_I1666_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I60_MP4 (XI1_I1666_I60_p1 XI1_I1666_I60_An I1_I1666_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I60_MP2 (VDD I1_p23_27 XI1_I1666_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I60_MP3 (XI1_I1666_I60_p1 XI1_I1666_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I60_MP0 (VDD I1_p23_27 XI1_I1666_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I59_MP1 (VDD I1_b24_27 XI1_I1666_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I59_MP5 (I1_I1666_pn27 I1_b24_27 XI1_I1666_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I59_MP4 (XI1_I1666_I59_p1 XI1_I1666_I59_An I1_I1666_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I59_MP2 (VDD I1_p23_26 XI1_I1666_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I59_MP3 (XI1_I1666_I59_p1 XI1_I1666_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I59_MP0 (VDD I1_p23_26 XI1_I1666_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I61_MP1 (VDD I1_b23_29 XI1_I1620_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I61_MP5 (I1_I1620_pn29 I1_b23_29 XI1_I1620_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I61_MP4 (XI1_I1620_I61_p1 XI1_I1620_I61_An I1_I1620_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I61_MP2 (VDD I1_p22_28 XI1_I1620_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I61_MP3 (XI1_I1620_I61_p1 XI1_I1620_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I61_MP0 (VDD I1_p22_28 XI1_I1620_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I62_MP1 (VDD I1_b23_30 XI1_I1620_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I62_MP5 (I1_I1620_pn30 I1_b23_30 XI1_I1620_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I62_MP4 (XI1_I1620_I62_p1 XI1_I1620_I62_An I1_I1620_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I62_MP2 (VDD I1_p22_29 XI1_I1620_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I62_MP3 (XI1_I1620_I62_p1 XI1_I1620_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I62_MP0 (VDD I1_p22_29 XI1_I1620_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I58_MP1 (VDD I1_b23_26 XI1_I1620_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I58_MP5 (I1_I1620_pn26 I1_b23_26 XI1_I1620_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I58_MP4 (XI1_I1620_I58_p1 XI1_I1620_I58_An I1_I1620_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I58_MP2 (VDD I1_p22_25 XI1_I1620_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I58_MP3 (XI1_I1620_I58_p1 XI1_I1620_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I58_MP0 (VDD I1_p22_25 XI1_I1620_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I230_MP1 (VDD I1_I1620_G26_0 XI1_I1620_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I230_MP5 (I1_p23_27 I1_I1620_G26_0 XI1_I1620_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I230_MP4 (XI1_I1620_I230_p1 XI1_I1620_I230_An I1_p23_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I230_MP2 (VDD I1_I1620_pn27 XI1_I1620_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I230_MP3 (XI1_I1620_I230_p1 XI1_I1620_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I230_MP0 (VDD I1_I1620_pn27 XI1_I1620_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I229_MP1 (VDD I1_I1620_G25_0 XI1_I1620_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I229_MP5 (I1_p23_26 I1_I1620_G25_0 XI1_I1620_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I229_MP4 (XI1_I1620_I229_p1 XI1_I1620_I229_An I1_p23_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I229_MP2 (VDD I1_I1620_pn26 XI1_I1620_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I229_MP3 (XI1_I1620_I229_p1 XI1_I1620_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I229_MP0 (VDD I1_I1620_pn26 XI1_I1620_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I46_MP1 (VDD I1_nakn4 XI1_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I46_MP5 (I1_aa4 I1_nakn4 XI1_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I46_MP4 (XI1_I46_p1 XI1_I46_An I1_aa4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I46_MP2 (VDD A_4 XI1_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I46_MP3 (XI1_I46_p1 XI1_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I46_MP0 (VDD A_4 XI1_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2091_MP1 (VDD I1_nqkn5 XI1_I2091_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2091_MP5 (DIVQ_5 I1_nqkn5 XI1_I2091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2091_MP4 (XI1_I2091_p1 XI1_I2091_An DIVQ_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2091_MP2 (VDD I1_qu5_b3_5 XI1_I2091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2091_MP3 (XI1_I2091_p1 XI1_I2091_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2091_MP0 (VDD I1_qu5_b3_5 XI1_I2091_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I63_MP1 (VDD I1_b27_31 XI1_I1804_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I63_MP5 (I1_I1804_pn31 I1_b27_31 XI1_I1804_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I63_MP4 (XI1_I1804_I63_p1 XI1_I1804_I63_An I1_I1804_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I63_MP2 (VDD I1_p26_30 XI1_I1804_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I63_MP3 (XI1_I1804_I63_p1 XI1_I1804_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I63_MP0 (VDD I1_p26_30 XI1_I1804_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I59_MP1 (VDD I1_b27_27 XI1_I1804_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I59_MP5 (I1_I1804_pn27 I1_b27_27 XI1_I1804_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I59_MP4 (XI1_I1804_I59_p1 XI1_I1804_I59_An I1_I1804_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I59_MP2 (VDD I1_p26_26 XI1_I1804_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I59_MP3 (XI1_I1804_I59_p1 XI1_I1804_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I59_MP0 (VDD I1_p26_26 XI1_I1804_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I57_MP1 (VDD I1_b27_25 XI1_I1804_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I57_MP5 (I1_I1804_pn25 I1_b27_25 XI1_I1804_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I57_MP4 (XI1_I1804_I57_p1 XI1_I1804_I57_An I1_I1804_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I57_MP2 (VDD I1_p26_24 XI1_I1804_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I57_MP3 (XI1_I1804_I57_p1 XI1_I1804_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I57_MP0 (VDD I1_p26_24 XI1_I1804_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I54_MP1 (VDD I1_b27_22 XI1_I1804_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I54_MP5 (I1_I1804_pn22 I1_b27_22 XI1_I1804_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I54_MP4 (XI1_I1804_I54_p1 XI1_I1804_I54_An I1_I1804_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I54_MP2 (VDD I1_p26_21 XI1_I1804_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I54_MP3 (XI1_I1804_I54_p1 XI1_I1804_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I54_MP0 (VDD I1_p26_21 XI1_I1804_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I52_MP1 (VDD I1_b27_20 XI1_I1804_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I52_MP5 (I1_I1804_pn20 I1_b27_20 XI1_I1804_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I52_MP4 (XI1_I1804_I52_p1 XI1_I1804_I52_An I1_I1804_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I52_MP2 (VDD I1_p26_19 XI1_I1804_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I52_MP3 (XI1_I1804_I52_p1 XI1_I1804_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I52_MP0 (VDD I1_p26_19 XI1_I1804_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I39_MP1 (VDD I1_b27_7 XI1_I1804_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I39_MP5 (I1_I1804_pn7 I1_b27_7 XI1_I1804_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I39_MP4 (XI1_I1804_I39_p1 XI1_I1804_I39_An I1_I1804_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I39_MP2 (VDD I1_p26_6 XI1_I1804_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I39_MP3 (XI1_I1804_I39_p1 XI1_I1804_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I39_MP0 (VDD I1_p26_6 XI1_I1804_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I37_MP1 (VDD I1_b27_5 XI1_I1804_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I37_MP5 (I1_I1804_pn5 I1_b27_5 XI1_I1804_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I37_MP4 (XI1_I1804_I37_p1 XI1_I1804_I37_An I1_I1804_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I37_MP2 (VDD I1_p26_4 XI1_I1804_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I37_MP3 (XI1_I1804_I37_p1 XI1_I1804_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I37_MP0 (VDD I1_p26_4 XI1_I1804_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I35_MP1 (VDD I1_b27_3 XI1_I1804_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I35_MP5 (I1_I1804_pn3 I1_b27_3 XI1_I1804_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I35_MP4 (XI1_I1804_I35_p1 XI1_I1804_I35_An I1_I1804_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I35_MP2 (VDD I1_p26_2 XI1_I1804_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I35_MP3 (XI1_I1804_I35_p1 XI1_I1804_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I35_MP0 (VDD I1_p26_2 XI1_I1804_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I34_MP1 (VDD I1_b27_2 XI1_I1804_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I34_MP5 (I1_I1804_pn2 I1_b27_2 XI1_I1804_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I34_MP4 (XI1_I1804_I34_p1 XI1_I1804_I34_An I1_I1804_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I34_MP2 (VDD I1_p26_1 XI1_I1804_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I34_MP3 (XI1_I1804_I34_p1 XI1_I1804_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I34_MP0 (VDD I1_p26_1 XI1_I1804_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I32_MP1 (VDD I1_b27_0 XI1_I1804_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I32_MP5 (I1_I1804_pn0 I1_b27_0 XI1_I1804_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I32_MP4 (XI1_I1804_I32_p1 XI1_I1804_I32_An I1_I1804_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I32_MP2 (VDD I1_aa4 XI1_I1804_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I32_MP3 (XI1_I1804_I32_p1 XI1_I1804_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I32_MP0 (VDD I1_aa4 XI1_I1804_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I203_MP1 (VDD I1_qu5_b3_5 XI1_I1804_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I203_MP5 (I1_p27_0 I1_qu5_b3_5 XI1_I1804_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I203_MP4 (XI1_I1804_I203_p1 XI1_I1804_I203_An I1_p27_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I203_MP2 (VDD I1_I1804_pn0 XI1_I1804_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I203_MP3 (XI1_I1804_I203_p1 XI1_I1804_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I203_MP0 (VDD I1_I1804_pn0 XI1_I1804_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I61_MP1 (VDD I1_b24_29 XI1_I1666_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1666_I61_MP5 (I1_I1666_pn29 I1_b24_29 XI1_I1666_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I61_MP4 (XI1_I1666_I61_p1 XI1_I1666_I61_An I1_I1666_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I61_MP2 (VDD I1_p23_28 XI1_I1666_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1666_I61_MP3 (XI1_I1666_I61_p1 XI1_I1666_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I61_MP0 (VDD I1_p23_28 XI1_I1666_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I32_MP1 (VDD I1_b28_0 XI1_I1850_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I32_MP5 (I1_I1850_pn0 I1_b28_0 XI1_I1850_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I32_MP4 (XI1_I1850_I32_p1 XI1_I1850_I32_An I1_I1850_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I32_MP2 (VDD I1_aa3 XI1_I1850_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I32_MP3 (XI1_I1850_I32_p1 XI1_I1850_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I32_MP0 (VDD I1_aa3 XI1_I1850_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I60_MP1 (VDD I1_b23_28 XI1_I1620_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I60_MP5 (I1_I1620_pn28 I1_b23_28 XI1_I1620_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I60_MP4 (XI1_I1620_I60_p1 XI1_I1620_I60_An I1_I1620_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I60_MP2 (VDD I1_p22_27 XI1_I1620_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I60_MP3 (XI1_I1620_I60_p1 XI1_I1620_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I60_MP0 (VDD I1_p22_27 XI1_I1620_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I231_MP1 (VDD I1_I1620_G27_0 XI1_I1620_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I231_MP5 (I1_p23_28 I1_I1620_G27_0 XI1_I1620_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I231_MP4 (XI1_I1620_I231_p1 XI1_I1620_I231_An I1_p23_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I231_MP2 (VDD I1_I1620_pn28 XI1_I1620_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I231_MP3 (XI1_I1620_I231_p1 XI1_I1620_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I231_MP0 (VDD I1_I1620_pn28 XI1_I1620_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I59_MP1 (VDD I1_b23_27 XI1_I1620_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1620_I59_MP5 (I1_I1620_pn27 I1_b23_27 XI1_I1620_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1620_I59_MP4 (XI1_I1620_I59_p1 XI1_I1620_I59_An I1_I1620_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I59_MP2 (VDD I1_p22_26 XI1_I1620_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1620_I59_MP3 (XI1_I1620_I59_p1 XI1_I1620_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I59_MP0 (VDD I1_p22_26 XI1_I1620_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I32_MP1 (VDD I1_b29_0 XI1_I1896_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I32_MP5 (I1_I1896_pn0 I1_b29_0 XI1_I1896_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I32_MP4 (XI1_I1896_I32_p1 XI1_I1896_I32_An I1_I1896_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I32_MP2 (VDD I1_aa2 XI1_I1896_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I32_MP3 (XI1_I1896_I32_p1 XI1_I1896_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I32_MP0 (VDD I1_aa2 XI1_I1896_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I40_MP1 (VDD I1_nakn2 XI1_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I40_MP5 (I1_aa2 I1_nakn2 XI1_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I40_MP4 (XI1_I40_p1 XI1_I40_An I1_aa2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I40_MP2 (VDD A_2 XI1_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I40_MP3 (XI1_I40_p1 XI1_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I40_MP0 (VDD A_2 XI1_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I32_MP1 (VDD I1_b30_0 XI1_I1942_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I32_MP5 (I1_I1942_pn0 I1_b30_0 XI1_I1942_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I32_MP4 (XI1_I1942_I32_p1 XI1_I1942_I32_An I1_I1942_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I32_MP2 (VDD I1_aa1 XI1_I1942_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I32_MP3 (XI1_I1942_I32_p1 XI1_I1942_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I32_MP0 (VDD I1_aa1 XI1_I1942_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I43_MP1 (VDD I1_nakn3 XI1_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I43_MP5 (I1_aa3 I1_nakn3 XI1_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I43_MP4 (XI1_I43_p1 XI1_I43_An I1_aa3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I43_MP2 (VDD A_3 XI1_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I43_MP3 (XI1_I43_p1 XI1_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I43_MP0 (VDD A_3 XI1_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I37_MP1 (VDD I1_nakn1 XI1_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I37_MP5 (I1_aa1 I1_nakn1 XI1_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I37_MP4 (XI1_I37_p1 XI1_I37_An I1_aa1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I37_MP2 (VDD A_1 XI1_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I37_MP3 (XI1_I37_p1 XI1_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I37_MP0 (VDD A_1 XI1_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2082_MP1 (VDD I1_nqkn2 XI1_I2082_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2082_MP5 (DIVQ_2 I1_nqkn2 XI1_I2082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2082_MP4 (XI1_I2082_p1 XI1_I2082_An DIVQ_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2082_MP2 (VDD I1_qu2_b3_5 XI1_I2082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2082_MP3 (XI1_I2082_p1 XI1_I2082_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2082_MP0 (VDD I1_qu2_b3_5 XI1_I2082_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I467_MP1 (VDD VSS XI0_I1660_I467_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I467_MP5 (MULP_0 VSS XI0_I1660_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I467_MP4 (XI0_I1660_I467_p1 XI0_I1660_I467_An MULP_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I467_MP2 (VDD I0_I1660_pn0 XI0_I1660_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I467_MP3 (XI0_I1660_I467_p1 XI0_I1660_I467_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I467_MP0 (VDD I0_I1660_pn0 XI0_I1660_I467_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I72_MP1 (VDD I0_ha252_0 XI0_I1660_I72_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I72_MP5 (I0_I1660_pn8 I0_ha252_0 XI0_I1660_I72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I72_MP4 (XI0_I1660_I72_p1 XI0_I1660_I72_An I0_I1660_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I72_MP2 (VDD I0_ha251_1 XI0_I1660_I72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I72_MP3 (XI0_I1660_I72_p1 XI0_I1660_I72_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I72_MP0 (VDD I0_ha251_1 XI0_I1660_I72_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I73_MP1 (VDD I0_ha253_0 XI0_I1660_I73_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I73_MP5 (I0_I1660_pn9 I0_ha253_0 XI0_I1660_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I73_MP4 (XI0_I1660_I73_p1 XI0_I1660_I73_An I0_I1660_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I73_MP2 (VDD I0_ha252_1 XI0_I1660_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I73_MP3 (XI0_I1660_I73_p1 XI0_I1660_I73_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I73_MP0 (VDD I0_ha252_1 XI0_I1660_I73_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I75_MP1 (VDD I0_ha255_0 XI0_I1660_I75_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I75_MP5 (I0_I1660_pn11 I0_ha255_0 XI0_I1660_I75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I75_MP4 (XI0_I1660_I75_p1 XI0_I1660_I75_An I0_I1660_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I75_MP2 (VDD I0_ha254_1 XI0_I1660_I75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I75_MP3 (XI0_I1660_I75_p1 XI0_I1660_I75_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I75_MP0 (VDD I0_ha254_1 XI0_I1660_I75_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I78_MP1 (VDD I0_ha258_0 XI0_I1660_I78_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I78_MP5 (I0_I1660_pn14 I0_ha258_0 XI0_I1660_I78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I78_MP4 (XI0_I1660_I78_p1 XI0_I1660_I78_An I0_I1660_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I78_MP2 (VDD I0_ha257_1 XI0_I1660_I78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I78_MP3 (XI0_I1660_I78_p1 XI0_I1660_I78_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I78_MP0 (VDD I0_ha257_1 XI0_I1660_I78_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I60_MP1 (VDD I1_b27_28 XI1_I1804_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I60_MP5 (I1_I1804_pn28 I1_b27_28 XI1_I1804_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I60_MP4 (XI1_I1804_I60_p1 XI1_I1804_I60_An I1_I1804_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I60_MP2 (VDD I1_p26_27 XI1_I1804_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I60_MP3 (XI1_I1804_I60_p1 XI1_I1804_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I60_MP0 (VDD I1_p26_27 XI1_I1804_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I33_MP1 (VDD I1_b27_1 XI1_I1804_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I33_MP5 (I1_I1804_pn1 I1_b27_1 XI1_I1804_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I33_MP4 (XI1_I1804_I33_p1 XI1_I1804_I33_An I1_I1804_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I33_MP2 (VDD I1_p26_0 XI1_I1804_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I33_MP3 (XI1_I1804_I33_p1 XI1_I1804_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I33_MP0 (VDD I1_p26_0 XI1_I1804_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I204_MP1 (VDD I1_I1804_G0_0 XI1_I1804_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I204_MP5 (I1_p27_1 I1_I1804_G0_0 XI1_I1804_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I204_MP4 (XI1_I1804_I204_p1 XI1_I1804_I204_An I1_p27_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I204_MP2 (VDD I1_I1804_pn1 XI1_I1804_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I204_MP3 (XI1_I1804_I204_p1 XI1_I1804_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I204_MP0 (VDD I1_I1804_pn1 XI1_I1804_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I33_MP1 (VDD I1_b28_1 XI1_I1850_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I33_MP5 (I1_I1850_pn1 I1_b28_1 XI1_I1850_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I33_MP4 (XI1_I1850_I33_p1 XI1_I1850_I33_An I1_I1850_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I33_MP2 (VDD I1_p27_0 XI1_I1850_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I33_MP3 (XI1_I1850_I33_p1 XI1_I1850_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I33_MP0 (VDD I1_p27_0 XI1_I1850_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I203_MP1 (VDD I1_qu4_b3_5 XI1_I1850_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I203_MP5 (I1_p28_0 I1_qu4_b3_5 XI1_I1850_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I203_MP4 (XI1_I1850_I203_p1 XI1_I1850_I203_An I1_p28_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I203_MP2 (VDD I1_I1850_pn0 XI1_I1850_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I203_MP3 (XI1_I1850_I203_p1 XI1_I1850_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I203_MP0 (VDD I1_I1850_pn0 XI1_I1850_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I33_MP1 (VDD I1_b29_1 XI1_I1896_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I33_MP5 (I1_I1896_pn1 I1_b29_1 XI1_I1896_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I33_MP4 (XI1_I1896_I33_p1 XI1_I1896_I33_An I1_I1896_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I33_MP2 (VDD I1_p28_0 XI1_I1896_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I33_MP3 (XI1_I1896_I33_p1 XI1_I1896_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I33_MP0 (VDD I1_p28_0 XI1_I1896_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I204_MP1 (VDD I1_I1896_G0_0 XI1_I1896_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I204_MP5 (I1_p29_1 I1_I1896_G0_0 XI1_I1896_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I204_MP4 (XI1_I1896_I204_p1 XI1_I1896_I204_An I1_p29_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I204_MP2 (VDD I1_I1896_pn1 XI1_I1896_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I204_MP3 (XI1_I1896_I204_p1 XI1_I1896_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I204_MP0 (VDD I1_I1896_pn1 XI1_I1896_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I35_MP1 (VDD I1_b30_3 XI1_I1942_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I35_MP5 (I1_I1942_pn3 I1_b30_3 XI1_I1942_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I35_MP4 (XI1_I1942_I35_p1 XI1_I1942_I35_An I1_I1942_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I35_MP2 (VDD I1_p29_2 XI1_I1942_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I35_MP3 (XI1_I1942_I35_p1 XI1_I1942_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I35_MP0 (VDD I1_p29_2 XI1_I1942_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I34_MP1 (VDD I1_b30_2 XI1_I1942_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I34_MP5 (I1_I1942_pn2 I1_b30_2 XI1_I1942_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I34_MP4 (XI1_I1942_I34_p1 XI1_I1942_I34_An I1_I1942_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I34_MP2 (VDD I1_p29_1 XI1_I1942_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I34_MP3 (XI1_I1942_I34_p1 XI1_I1942_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I34_MP0 (VDD I1_p29_1 XI1_I1942_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I33_MP1 (VDD I1_b30_1 XI1_I1942_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I33_MP5 (I1_I1942_pn1 I1_b30_1 XI1_I1942_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I33_MP4 (XI1_I1942_I33_p1 XI1_I1942_I33_An I1_I1942_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I33_MP2 (VDD I1_p29_0 XI1_I1942_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I33_MP3 (XI1_I1942_I33_p1 XI1_I1942_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I33_MP0 (VDD I1_p29_0 XI1_I1942_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I203_MP1 (VDD I1_qu3_b3_5 XI1_I1896_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I203_MP5 (I1_p29_0 I1_qu3_b3_5 XI1_I1896_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I203_MP4 (XI1_I1896_I203_p1 XI1_I1896_I203_An I1_p29_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I203_MP2 (VDD I1_I1896_pn0 XI1_I1896_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I203_MP3 (XI1_I1896_I203_p1 XI1_I1896_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I203_MP0 (VDD I1_I1896_pn0 XI1_I1896_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I203_MP1 (VDD I1_qu2_b3_5 XI1_I1942_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I203_MP5 (I1_p30_0 I1_qu2_b3_5 XI1_I1942_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I203_MP4 (XI1_I1942_I203_p1 XI1_I1942_I203_An I1_p30_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I203_MP2 (VDD I1_I1942_pn0 XI1_I1942_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I203_MP3 (XI1_I1942_I203_p1 XI1_I1942_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I203_MP0 (VDD I1_I1942_pn0 XI1_I1942_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2088_MP1 (VDD I1_nqkn4 XI1_I2088_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2088_MP5 (DIVQ_4 I1_nqkn4 XI1_I2088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2088_MP4 (XI1_I2088_p1 XI1_I2088_An DIVQ_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2088_MP2 (VDD I1_qu4_b3_5 XI1_I2088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2088_MP3 (XI1_I2088_p1 XI1_I2088_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2088_MP0 (VDD I1_qu4_b3_5 XI1_I2088_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2085_MP1 (VDD I1_nqkn3 XI1_I2085_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2085_MP5 (DIVQ_3 I1_nqkn3 XI1_I2085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2085_MP4 (XI1_I2085_p1 XI1_I2085_An DIVQ_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2085_MP2 (VDD I1_qu3_b3_5 XI1_I2085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2085_MP3 (XI1_I2085_p1 XI1_I2085_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2085_MP0 (VDD I1_qu3_b3_5 XI1_I2085_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2079_MP1 (VDD I1_nqkn1 XI1_I2079_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2079_MP5 (DIVQ_1 I1_nqkn1 XI1_I2079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2079_MP4 (XI1_I2079_p1 XI1_I2079_An DIVQ_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2079_MP2 (VDD I1_qu1_b3_5 XI1_I2079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2079_MP3 (XI1_I2079_p1 XI1_I2079_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2079_MP0 (VDD I1_qu1_b3_5 XI1_I2079_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I70_MP1 (VDD I0_ha250_0 XI0_I1660_I70_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I70_MP5 (I0_I1660_pn6 I0_ha250_0 XI0_I1660_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I70_MP4 (XI0_I1660_I70_p1 XI0_I1660_I70_An I0_I1660_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I70_MP2 (VDD I0_fa249_1 XI0_I1660_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I70_MP3 (XI0_I1660_I70_p1 XI0_I1660_I70_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I70_MP0 (VDD I0_fa249_1 XI0_I1660_I70_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I71_MP1 (VDD I0_ha251_0 XI0_I1660_I71_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I71_MP5 (I0_I1660_pn7 I0_ha251_0 XI0_I1660_I71_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I71_MP4 (XI0_I1660_I71_p1 XI0_I1660_I71_An I0_I1660_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I71_MP2 (VDD I0_ha250_1 XI0_I1660_I71_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I71_MP3 (XI0_I1660_I71_p1 XI0_I1660_I71_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I71_MP0 (VDD I0_ha250_1 XI0_I1660_I71_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I475_MP1 (VDD I0_I1660_G7_0 XI0_I1660_I475_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I475_MP5 (MULP_8 I0_I1660_G7_0 XI0_I1660_I475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I475_MP4 (XI0_I1660_I475_p1 XI0_I1660_I475_An MULP_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I475_MP2 (VDD I0_I1660_pn8 XI0_I1660_I475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I475_MP3 (XI0_I1660_I475_p1 XI0_I1660_I475_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I475_MP0 (VDD I0_I1660_pn8 XI0_I1660_I475_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I74_MP1 (VDD I0_ha254_0 XI0_I1660_I74_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I74_MP5 (I0_I1660_pn10 I0_ha254_0 XI0_I1660_I74_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I74_MP4 (XI0_I1660_I74_p1 XI0_I1660_I74_An I0_I1660_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I74_MP2 (VDD I0_ha253_1 XI0_I1660_I74_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I74_MP3 (XI0_I1660_I74_p1 XI0_I1660_I74_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I74_MP0 (VDD I0_ha253_1 XI0_I1660_I74_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I76_MP1 (VDD I0_ha256_0 XI0_I1660_I76_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I76_MP5 (I0_I1660_pn12 I0_ha256_0 XI0_I1660_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I76_MP4 (XI0_I1660_I76_p1 XI0_I1660_I76_An I0_I1660_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I76_MP2 (VDD I0_ha255_1 XI0_I1660_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I76_MP3 (XI0_I1660_I76_p1 XI0_I1660_I76_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I76_MP0 (VDD I0_ha255_1 XI0_I1660_I76_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I77_MP1 (VDD I0_ha257_0 XI0_I1660_I77_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I77_MP5 (I0_I1660_pn13 I0_ha257_0 XI0_I1660_I77_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I77_MP4 (XI0_I1660_I77_p1 XI0_I1660_I77_An I0_I1660_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I77_MP2 (VDD I0_ha256_1 XI0_I1660_I77_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I77_MP3 (XI0_I1660_I77_p1 XI0_I1660_I77_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I77_MP0 (VDD I0_ha256_1 XI0_I1660_I77_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I79_MP1 (VDD I0_ha259_0 XI0_I1660_I79_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I79_MP5 (I0_I1660_pn15 I0_ha259_0 XI0_I1660_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I79_MP4 (XI0_I1660_I79_p1 XI0_I1660_I79_An I0_I1660_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I79_MP2 (VDD I0_ha258_1 XI0_I1660_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I79_MP3 (XI0_I1660_I79_p1 XI0_I1660_I79_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I79_MP0 (VDD I0_ha258_1 XI0_I1660_I79_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I80_MP1 (VDD I0_ha260_0 XI0_I1660_I80_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I80_MP5 (I0_I1660_pn16 I0_ha260_0 XI0_I1660_I80_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I80_MP4 (XI0_I1660_I80_p1 XI0_I1660_I80_An I0_I1660_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I80_MP2 (VDD I0_ha259_1 XI0_I1660_I80_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I80_MP3 (XI0_I1660_I80_p1 XI0_I1660_I80_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I80_MP0 (VDD I0_ha259_1 XI0_I1660_I80_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I82_MP1 (VDD I0_ha262_0 XI0_I1660_I82_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I82_MP5 (I0_I1660_pn18 I0_ha262_0 XI0_I1660_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I82_MP4 (XI0_I1660_I82_p1 XI0_I1660_I82_An I0_I1660_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I82_MP2 (VDD I0_ha261_1 XI0_I1660_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I82_MP3 (XI0_I1660_I82_p1 XI0_I1660_I82_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I82_MP0 (VDD I0_ha261_1 XI0_I1660_I82_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I83_MP1 (VDD I0_ha263_0 XI0_I1660_I83_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I83_MP5 (I0_I1660_pn19 I0_ha263_0 XI0_I1660_I83_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I83_MP4 (XI0_I1660_I83_p1 XI0_I1660_I83_An I0_I1660_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I83_MP2 (VDD I0_ha262_1 XI0_I1660_I83_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I83_MP3 (XI0_I1660_I83_p1 XI0_I1660_I83_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I83_MP0 (VDD I0_ha262_1 XI0_I1660_I83_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I84_MP1 (VDD I0_ha264_0 XI0_I1660_I84_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I84_MP5 (I0_I1660_pn20 I0_ha264_0 XI0_I1660_I84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I84_MP4 (XI0_I1660_I84_p1 XI0_I1660_I84_An I0_I1660_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I84_MP2 (VDD I0_ha263_1 XI0_I1660_I84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I84_MP3 (XI0_I1660_I84_p1 XI0_I1660_I84_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I84_MP0 (VDD I0_ha263_1 XI0_I1660_I84_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I87_MP1 (VDD I0_ha267_0 XI0_I1660_I87_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I87_MP5 (I0_I1660_pn23 I0_ha267_0 XI0_I1660_I87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I87_MP4 (XI0_I1660_I87_p1 XI0_I1660_I87_An I0_I1660_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I87_MP2 (VDD I0_ha266_1 XI0_I1660_I87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I87_MP3 (XI0_I1660_I87_p1 XI0_I1660_I87_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I87_MP0 (VDD I0_ha266_1 XI0_I1660_I87_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I88_MP1 (VDD I0_ha268_0 XI0_I1660_I88_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I88_MP5 (I0_I1660_pn24 I0_ha268_0 XI0_I1660_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I88_MP4 (XI0_I1660_I88_p1 XI0_I1660_I88_An I0_I1660_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I88_MP2 (VDD I0_ha267_1 XI0_I1660_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I88_MP3 (XI0_I1660_I88_p1 XI0_I1660_I88_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I88_MP0 (VDD I0_ha267_1 XI0_I1660_I88_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I89_MP1 (VDD I0_ha269_0 XI0_I1660_I89_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I89_MP5 (I0_I1660_pn25 I0_ha269_0 XI0_I1660_I89_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I89_MP4 (XI0_I1660_I89_p1 XI0_I1660_I89_An I0_I1660_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I89_MP2 (VDD I0_ha268_1 XI0_I1660_I89_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I89_MP3 (XI0_I1660_I89_p1 XI0_I1660_I89_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I89_MP0 (VDD I0_ha268_1 XI0_I1660_I89_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I61_MP1 (VDD I1_b27_29 XI1_I1804_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I61_MP5 (I1_I1804_pn29 I1_b27_29 XI1_I1804_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I61_MP4 (XI1_I1804_I61_p1 XI1_I1804_I61_An I1_I1804_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I61_MP2 (VDD I1_p26_28 XI1_I1804_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I61_MP3 (XI1_I1804_I61_p1 XI1_I1804_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I61_MP0 (VDD I1_p26_28 XI1_I1804_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I205_MP1 (VDD I1_I1804_G1_0 XI1_I1804_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I205_MP5 (I1_p27_2 I1_I1804_G1_0 XI1_I1804_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I205_MP4 (XI1_I1804_I205_p1 XI1_I1804_I205_An I1_p27_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I205_MP2 (VDD I1_I1804_pn2 XI1_I1804_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I205_MP3 (XI1_I1804_I205_p1 XI1_I1804_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I205_MP0 (VDD I1_I1804_pn2 XI1_I1804_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I35_MP1 (VDD I1_b28_3 XI1_I1850_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I35_MP5 (I1_I1850_pn3 I1_b28_3 XI1_I1850_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I35_MP4 (XI1_I1850_I35_p1 XI1_I1850_I35_An I1_I1850_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I35_MP2 (VDD I1_p27_2 XI1_I1850_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I35_MP3 (XI1_I1850_I35_p1 XI1_I1850_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I35_MP0 (VDD I1_p27_2 XI1_I1850_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I34_MP1 (VDD I1_b28_2 XI1_I1850_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I34_MP5 (I1_I1850_pn2 I1_b28_2 XI1_I1850_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I34_MP4 (XI1_I1850_I34_p1 XI1_I1850_I34_An I1_I1850_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I34_MP2 (VDD I1_p27_1 XI1_I1850_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I34_MP3 (XI1_I1850_I34_p1 XI1_I1850_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I34_MP0 (VDD I1_p27_1 XI1_I1850_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I204_MP1 (VDD I1_I1850_G0_0 XI1_I1850_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I204_MP5 (I1_p28_1 I1_I1850_G0_0 XI1_I1850_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I204_MP4 (XI1_I1850_I204_p1 XI1_I1850_I204_An I1_p28_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I204_MP2 (VDD I1_I1850_pn1 XI1_I1850_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I204_MP3 (XI1_I1850_I204_p1 XI1_I1850_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I204_MP0 (VDD I1_I1850_pn1 XI1_I1850_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I35_MP1 (VDD I1_b29_3 XI1_I1896_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I35_MP5 (I1_I1896_pn3 I1_b29_3 XI1_I1896_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I35_MP4 (XI1_I1896_I35_p1 XI1_I1896_I35_An I1_I1896_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I35_MP2 (VDD I1_p28_2 XI1_I1896_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I35_MP3 (XI1_I1896_I35_p1 XI1_I1896_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I35_MP0 (VDD I1_p28_2 XI1_I1896_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I34_MP1 (VDD I1_b29_2 XI1_I1896_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I34_MP5 (I1_I1896_pn2 I1_b29_2 XI1_I1896_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I34_MP4 (XI1_I1896_I34_p1 XI1_I1896_I34_An I1_I1896_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I34_MP2 (VDD I1_p28_1 XI1_I1896_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I34_MP3 (XI1_I1896_I34_p1 XI1_I1896_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I34_MP0 (VDD I1_p28_1 XI1_I1896_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I205_MP1 (VDD I1_I1896_G1_0 XI1_I1896_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I205_MP5 (I1_p29_2 I1_I1896_G1_0 XI1_I1896_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I205_MP4 (XI1_I1896_I205_p1 XI1_I1896_I205_An I1_p29_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I205_MP2 (VDD I1_I1896_pn2 XI1_I1896_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I205_MP3 (XI1_I1896_I205_p1 XI1_I1896_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I205_MP0 (VDD I1_I1896_pn2 XI1_I1896_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I37_MP1 (VDD I1_b30_5 XI1_I1942_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I37_MP5 (I1_I1942_pn5 I1_b30_5 XI1_I1942_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I37_MP4 (XI1_I1942_I37_p1 XI1_I1942_I37_An I1_I1942_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I37_MP2 (VDD I1_p29_4 XI1_I1942_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I37_MP3 (XI1_I1942_I37_p1 XI1_I1942_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I37_MP0 (VDD I1_p29_4 XI1_I1942_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I36_MP1 (VDD I1_b30_4 XI1_I1942_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I36_MP5 (I1_I1942_pn4 I1_b30_4 XI1_I1942_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I36_MP4 (XI1_I1942_I36_p1 XI1_I1942_I36_An I1_I1942_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I36_MP2 (VDD I1_p29_3 XI1_I1942_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I36_MP3 (XI1_I1942_I36_p1 XI1_I1942_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I36_MP0 (VDD I1_p29_3 XI1_I1942_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I205_MP1 (VDD I1_I1942_G1_0 XI1_I1942_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I205_MP5 (I1_p30_2 I1_I1942_G1_0 XI1_I1942_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I205_MP4 (XI1_I1942_I205_p1 XI1_I1942_I205_An I1_p30_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I205_MP2 (VDD I1_I1942_pn2 XI1_I1942_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I205_MP3 (XI1_I1942_I205_p1 XI1_I1942_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I205_MP0 (VDD I1_I1942_pn2 XI1_I1942_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I204_MP1 (VDD I1_I1942_G0_0 XI1_I1942_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I204_MP5 (I1_p30_1 I1_I1942_G0_0 XI1_I1942_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I204_MP4 (XI1_I1942_I204_p1 XI1_I1942_I204_An I1_p30_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I204_MP2 (VDD I1_I1942_pn1 XI1_I1942_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I204_MP3 (XI1_I1942_I204_p1 XI1_I1942_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I204_MP0 (VDD I1_I1942_pn1 XI1_I1942_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I37_MP1 (VDD I1_b31_5 XI1_I1988_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I37_MP5 (I1_I1988_pn5 I1_b31_5 XI1_I1988_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I37_MP4 (XI1_I1988_I37_p1 XI1_I1988_I37_An I1_I1988_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I37_MP2 (VDD I1_p30_4 XI1_I1988_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I37_MP3 (XI1_I1988_I37_p1 XI1_I1988_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I37_MP0 (VDD I1_p30_4 XI1_I1988_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I36_MP1 (VDD I1_b31_4 XI1_I1988_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I36_MP5 (I1_I1988_pn4 I1_b31_4 XI1_I1988_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I36_MP4 (XI1_I1988_I36_p1 XI1_I1988_I36_An I1_I1988_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I36_MP2 (VDD I1_p30_3 XI1_I1988_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I36_MP3 (XI1_I1988_I36_p1 XI1_I1988_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I36_MP0 (VDD I1_p30_3 XI1_I1988_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I35_MP1 (VDD I1_b31_3 XI1_I1988_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I35_MP5 (I1_I1988_pn3 I1_b31_3 XI1_I1988_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I35_MP4 (XI1_I1988_I35_p1 XI1_I1988_I35_An I1_I1988_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I35_MP2 (VDD I1_p30_2 XI1_I1988_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I35_MP3 (XI1_I1988_I35_p1 XI1_I1988_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I35_MP0 (VDD I1_p30_2 XI1_I1988_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I34_MP1 (VDD I1_b31_2 XI1_I1988_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I34_MP5 (I1_I1988_pn2 I1_b31_2 XI1_I1988_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I34_MP4 (XI1_I1988_I34_p1 XI1_I1988_I34_An I1_I1988_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I34_MP2 (VDD I1_p30_1 XI1_I1988_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I34_MP3 (XI1_I1988_I34_p1 XI1_I1988_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I34_MP0 (VDD I1_p30_1 XI1_I1988_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I33_MP1 (VDD I1_b31_1 XI1_I1988_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I33_MP5 (I1_I1988_pn1 I1_b31_1 XI1_I1988_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I33_MP4 (XI1_I1988_I33_p1 XI1_I1988_I33_An I1_I1988_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I33_MP2 (VDD I1_p30_0 XI1_I1988_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I33_MP3 (XI1_I1988_I33_p1 XI1_I1988_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I33_MP0 (VDD I1_p30_0 XI1_I1988_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I205_MP1 (VDD I1_I1988_G1_0 XI1_I1988_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I205_MP5 (I1_p31_2 I1_I1988_G1_0 XI1_I1988_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I205_MP4 (XI1_I1988_I205_p1 XI1_I1988_I205_An I1_p31_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I205_MP2 (VDD I1_I1988_pn2 XI1_I1988_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I205_MP3 (XI1_I1988_I205_p1 XI1_I1988_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I205_MP0 (VDD I1_I1988_pn2 XI1_I1988_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I32_MP1 (VDD I1_b31_0 XI1_I1988_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I32_MP5 (I1_I1988_pn0 I1_b31_0 XI1_I1988_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I32_MP4 (XI1_I1988_I32_p1 XI1_I1988_I32_An I1_I1988_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I32_MP2 (VDD A_0 XI1_I1988_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I32_MP3 (XI1_I1988_I32_p1 XI1_I1988_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I32_MP0 (VDD A_0 XI1_I1988_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I203_MP1 (VDD I1_qu1_b3_5 XI1_I1988_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I203_MP5 (I1_p31_0 I1_qu1_b3_5 XI1_I1988_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I203_MP4 (XI1_I1988_I203_p1 XI1_I1988_I203_An I1_p31_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I203_MP2 (VDD I1_I1988_pn0 XI1_I1988_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I203_MP3 (XI1_I1988_I203_p1 XI1_I1988_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I203_MP0 (VDD I1_I1988_pn0 XI1_I1988_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I32_MP1 (VDD I1_dm0 XI1_I2066_I32_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I32_MP5 (I1_I2066_pn0 I1_dm0 XI1_I2066_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I32_MP4 (XI1_I2066_I32_p1 XI1_I2066_I32_An I1_I2066_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I32_MP2 (VDD I1_p31_0 XI1_I2066_I32_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I32_MP3 (XI1_I2066_I32_p1 XI1_I2066_I32_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I32_MP0 (VDD I1_p31_0 XI1_I2066_I32_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I468_MP1 (VDD I0_I1660_G0_0 XI0_I1660_I468_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I468_MP5 (MULP_1 I0_I1660_G0_0 XI0_I1660_I468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I468_MP4 (XI0_I1660_I468_p1 XI0_I1660_I468_An MULP_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I468_MP2 (VDD I0_I1660_pn1 XI0_I1660_I468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I468_MP3 (XI0_I1660_I468_p1 XI0_I1660_I468_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I468_MP0 (VDD I0_I1660_pn1 XI0_I1660_I468_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I65_MP1 (VDD VSS XI0_I1660_I65_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I65_MP5 (I0_I1660_pn1 VSS XI0_I1660_I65_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I65_MP4 (XI0_I1660_I65_p1 XI0_I1660_I65_An I0_I1660_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I65_MP2 (VDD I0_pp0_1 XI0_I1660_I65_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I65_MP3 (XI0_I1660_I65_p1 XI0_I1660_I65_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I65_MP0 (VDD I0_pp0_1 XI0_I1660_I65_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I68_MP1 (VDD VSS XI0_I1660_I68_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I68_MP5 (I0_I1660_pn4 VSS XI0_I1660_I68_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I68_MP4 (XI0_I1660_I68_p1 XI0_I1660_I68_An I0_I1660_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I68_MP2 (VDD I0_fa209_0 XI0_I1660_I68_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I68_MP3 (XI0_I1660_I68_p1 XI0_I1660_I68_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I68_MP0 (VDD I0_fa209_0 XI0_I1660_I68_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I69_MP1 (VDD VSS XI0_I1660_I69_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I69_MP5 (I0_I1660_pn5 VSS XI0_I1660_I69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I69_MP4 (XI0_I1660_I69_p1 XI0_I1660_I69_An I0_I1660_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I69_MP2 (VDD I0_fa249_0 XI0_I1660_I69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I69_MP3 (XI0_I1660_I69_p1 XI0_I1660_I69_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I69_MP0 (VDD I0_fa249_0 XI0_I1660_I69_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I473_MP1 (VDD I0_I1660_G5_0 XI0_I1660_I473_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I473_MP5 (MULP_6 I0_I1660_G5_0 XI0_I1660_I473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I473_MP4 (XI0_I1660_I473_p1 XI0_I1660_I473_An MULP_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I473_MP2 (VDD I0_I1660_pn6 XI0_I1660_I473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I473_MP3 (XI0_I1660_I473_p1 XI0_I1660_I473_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I473_MP0 (VDD I0_I1660_pn6 XI0_I1660_I473_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I474_MP1 (VDD I0_I1660_G6_0 XI0_I1660_I474_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I474_MP5 (MULP_7 I0_I1660_G6_0 XI0_I1660_I474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I474_MP4 (XI0_I1660_I474_p1 XI0_I1660_I474_An MULP_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I474_MP2 (VDD I0_I1660_pn7 XI0_I1660_I474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I474_MP3 (XI0_I1660_I474_p1 XI0_I1660_I474_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I474_MP0 (VDD I0_I1660_pn7 XI0_I1660_I474_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I484_MP1 (VDD I0_I1660_G16_0 XI0_I1660_I484_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I484_MP5 (MULP_17 I0_I1660_G16_0 XI0_I1660_I484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I484_MP4 (XI0_I1660_I484_p1 XI0_I1660_I484_An MULP_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I484_MP2 (VDD I0_I1660_pn17 XI0_I1660_I484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I484_MP3 (XI0_I1660_I484_p1 XI0_I1660_I484_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I484_MP0 (VDD I0_I1660_pn17 XI0_I1660_I484_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I486_MP1 (VDD I0_I1660_G18_0 XI0_I1660_I486_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I486_MP5 (MULP_19 I0_I1660_G18_0 XI0_I1660_I486_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I486_MP4 (XI0_I1660_I486_p1 XI0_I1660_I486_An MULP_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I486_MP2 (VDD I0_I1660_pn19 XI0_I1660_I486_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I486_MP3 (XI0_I1660_I486_p1 XI0_I1660_I486_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I486_MP0 (VDD I0_I1660_pn19 XI0_I1660_I486_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I81_MP1 (VDD I0_ha261_0 XI0_I1660_I81_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I81_MP5 (I0_I1660_pn17 I0_ha261_0 XI0_I1660_I81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I81_MP4 (XI0_I1660_I81_p1 XI0_I1660_I81_An I0_I1660_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I81_MP2 (VDD I0_ha260_1 XI0_I1660_I81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I81_MP3 (XI0_I1660_I81_p1 XI0_I1660_I81_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I81_MP0 (VDD I0_ha260_1 XI0_I1660_I81_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I487_MP1 (VDD I0_I1660_G19_0 XI0_I1660_I487_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I487_MP5 (MULP_20 I0_I1660_G19_0 XI0_I1660_I487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I487_MP4 (XI0_I1660_I487_p1 XI0_I1660_I487_An MULP_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I487_MP2 (VDD I0_I1660_pn20 XI0_I1660_I487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I487_MP3 (XI0_I1660_I487_p1 XI0_I1660_I487_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I487_MP0 (VDD I0_I1660_pn20 XI0_I1660_I487_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I490_MP1 (VDD I0_I1660_G22_0 XI0_I1660_I490_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I490_MP5 (MULP_23 I0_I1660_G22_0 XI0_I1660_I490_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I490_MP4 (XI0_I1660_I490_p1 XI0_I1660_I490_An MULP_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I490_MP2 (VDD I0_I1660_pn23 XI0_I1660_I490_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I490_MP3 (XI0_I1660_I490_p1 XI0_I1660_I490_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I490_MP0 (VDD I0_I1660_pn23 XI0_I1660_I490_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I85_MP1 (VDD I0_ha265_0 XI0_I1660_I85_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I85_MP5 (I0_I1660_pn21 I0_ha265_0 XI0_I1660_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I85_MP4 (XI0_I1660_I85_p1 XI0_I1660_I85_An I0_I1660_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I85_MP2 (VDD I0_ha264_1 XI0_I1660_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I85_MP3 (XI0_I1660_I85_p1 XI0_I1660_I85_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I85_MP0 (VDD I0_ha264_1 XI0_I1660_I85_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I86_MP1 (VDD I0_ha266_0 XI0_I1660_I86_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I86_MP5 (I0_I1660_pn22 I0_ha266_0 XI0_I1660_I86_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I86_MP4 (XI0_I1660_I86_p1 XI0_I1660_I86_An I0_I1660_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I86_MP2 (VDD I0_ha265_1 XI0_I1660_I86_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I86_MP3 (XI0_I1660_I86_p1 XI0_I1660_I86_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I86_MP0 (VDD I0_ha265_1 XI0_I1660_I86_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I491_MP1 (VDD I0_I1660_G23_0 XI0_I1660_I491_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I491_MP5 (MULP_24 I0_I1660_G23_0 XI0_I1660_I491_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I491_MP4 (XI0_I1660_I491_p1 XI0_I1660_I491_An MULP_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I491_MP2 (VDD I0_I1660_pn24 XI0_I1660_I491_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I491_MP3 (XI0_I1660_I491_p1 XI0_I1660_I491_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I491_MP0 (VDD I0_I1660_pn24 XI0_I1660_I491_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I90_MP1 (VDD I0_ha270_0 XI0_I1660_I90_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I90_MP5 (I0_I1660_pn26 I0_ha270_0 XI0_I1660_I90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I90_MP4 (XI0_I1660_I90_p1 XI0_I1660_I90_An I0_I1660_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I90_MP2 (VDD I0_ha269_1 XI0_I1660_I90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I90_MP3 (XI0_I1660_I90_p1 XI0_I1660_I90_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I90_MP0 (VDD I0_ha269_1 XI0_I1660_I90_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I91_MP1 (VDD I0_ha271_0 XI0_I1660_I91_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I91_MP5 (I0_I1660_pn27 I0_ha271_0 XI0_I1660_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I91_MP4 (XI0_I1660_I91_p1 XI0_I1660_I91_An I0_I1660_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I91_MP2 (VDD I0_ha270_1 XI0_I1660_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I91_MP3 (XI0_I1660_I91_p1 XI0_I1660_I91_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I91_MP0 (VDD I0_ha270_1 XI0_I1660_I91_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I232_MP1 (VDD I1_I1804_G28_0 XI1_I1804_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I232_MP5 (I1_p27_29 I1_I1804_G28_0 XI1_I1804_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I232_MP4 (XI1_I1804_I232_p1 XI1_I1804_I232_An I1_p27_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I232_MP2 (VDD I1_I1804_pn29 XI1_I1804_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I232_MP3 (XI1_I1804_I232_p1 XI1_I1804_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I232_MP0 (VDD I1_I1804_pn29 XI1_I1804_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I220_MP1 (VDD I1_I1804_G16_0 XI1_I1804_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I220_MP5 (I1_p27_17 I1_I1804_G16_0 XI1_I1804_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I220_MP4 (XI1_I1804_I220_p1 XI1_I1804_I220_An I1_p27_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I220_MP2 (VDD I1_I1804_pn17 XI1_I1804_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I220_MP3 (XI1_I1804_I220_p1 XI1_I1804_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I220_MP0 (VDD I1_I1804_pn17 XI1_I1804_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I210_MP1 (VDD I1_I1804_G6_0 XI1_I1804_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I210_MP5 (I1_p27_7 I1_I1804_G6_0 XI1_I1804_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I210_MP4 (XI1_I1804_I210_p1 XI1_I1804_I210_An I1_p27_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I210_MP2 (VDD I1_I1804_pn7 XI1_I1804_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I210_MP3 (XI1_I1804_I210_p1 XI1_I1804_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I210_MP0 (VDD I1_I1804_pn7 XI1_I1804_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I208_MP1 (VDD I1_I1804_G4_0 XI1_I1804_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I208_MP5 (I1_p27_5 I1_I1804_G4_0 XI1_I1804_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I208_MP4 (XI1_I1804_I208_p1 XI1_I1804_I208_An I1_p27_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I208_MP2 (VDD I1_I1804_pn5 XI1_I1804_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I208_MP3 (XI1_I1804_I208_p1 XI1_I1804_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I208_MP0 (VDD I1_I1804_pn5 XI1_I1804_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I36_MP1 (VDD I1_b28_4 XI1_I1850_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I36_MP5 (I1_I1850_pn4 I1_b28_4 XI1_I1850_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I36_MP4 (XI1_I1850_I36_p1 XI1_I1850_I36_An I1_I1850_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I36_MP2 (VDD I1_p27_3 XI1_I1850_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I36_MP3 (XI1_I1850_I36_p1 XI1_I1850_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I36_MP0 (VDD I1_p27_3 XI1_I1850_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I205_MP1 (VDD I1_I1850_G1_0 XI1_I1850_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I205_MP5 (I1_p28_2 I1_I1850_G1_0 XI1_I1850_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I205_MP4 (XI1_I1850_I205_p1 XI1_I1850_I205_An I1_p28_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I205_MP2 (VDD I1_I1850_pn2 XI1_I1850_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I205_MP3 (XI1_I1850_I205_p1 XI1_I1850_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I205_MP0 (VDD I1_I1850_pn2 XI1_I1850_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I36_MP1 (VDD I1_b29_4 XI1_I1896_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I36_MP5 (I1_I1896_pn4 I1_b29_4 XI1_I1896_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I36_MP4 (XI1_I1896_I36_p1 XI1_I1896_I36_An I1_I1896_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I36_MP2 (VDD I1_p28_3 XI1_I1896_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I36_MP3 (XI1_I1896_I36_p1 XI1_I1896_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I36_MP0 (VDD I1_p28_3 XI1_I1896_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I38_MP1 (VDD I1_b30_6 XI1_I1942_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I38_MP5 (I1_I1942_pn6 I1_b30_6 XI1_I1942_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I38_MP4 (XI1_I1942_I38_p1 XI1_I1942_I38_An I1_I1942_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I38_MP2 (VDD I1_p29_5 XI1_I1942_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I38_MP3 (XI1_I1942_I38_p1 XI1_I1942_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I38_MP0 (VDD I1_p29_5 XI1_I1942_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I208_MP1 (VDD I1_I1942_G4_0 XI1_I1942_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I208_MP5 (I1_p30_5 I1_I1942_G4_0 XI1_I1942_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I208_MP4 (XI1_I1942_I208_p1 XI1_I1942_I208_An I1_p30_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I208_MP2 (VDD I1_I1942_pn5 XI1_I1942_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I208_MP3 (XI1_I1942_I208_p1 XI1_I1942_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I208_MP0 (VDD I1_I1942_pn5 XI1_I1942_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I39_MP1 (VDD I1_b31_7 XI1_I1988_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I39_MP5 (I1_I1988_pn7 I1_b31_7 XI1_I1988_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I39_MP4 (XI1_I1988_I39_p1 XI1_I1988_I39_An I1_I1988_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I39_MP2 (VDD I1_p30_6 XI1_I1988_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I39_MP3 (XI1_I1988_I39_p1 XI1_I1988_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I39_MP0 (VDD I1_p30_6 XI1_I1988_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I38_MP1 (VDD I1_b31_6 XI1_I1988_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I38_MP5 (I1_I1988_pn6 I1_b31_6 XI1_I1988_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I38_MP4 (XI1_I1988_I38_p1 XI1_I1988_I38_An I1_I1988_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I38_MP2 (VDD I1_p30_5 XI1_I1988_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I38_MP3 (XI1_I1988_I38_p1 XI1_I1988_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I38_MP0 (VDD I1_p30_5 XI1_I1988_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I204_MP1 (VDD I1_I1988_G0_0 XI1_I1988_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I204_MP5 (I1_p31_1 I1_I1988_G0_0 XI1_I1988_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I204_MP4 (XI1_I1988_I204_p1 XI1_I1988_I204_An I1_p31_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I204_MP2 (VDD I1_I1988_pn1 XI1_I1988_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I204_MP3 (XI1_I1988_I204_p1 XI1_I1988_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I204_MP0 (VDD I1_I1988_pn1 XI1_I1988_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I34_MP1 (VDD I1_dm2 XI1_I2066_I34_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I34_MP5 (I1_I2066_pn2 I1_dm2 XI1_I2066_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I34_MP4 (XI1_I2066_I34_p1 XI1_I2066_I34_An I1_I2066_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I34_MP2 (VDD I1_p31_2 XI1_I2066_I34_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I34_MP3 (XI1_I2066_I34_p1 XI1_I2066_I34_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I34_MP0 (VDD I1_p31_2 XI1_I2066_I34_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I36_MP1 (VDD I1_dm4 XI1_I2066_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I36_MP5 (I1_I2066_pn4 I1_dm4 XI1_I2066_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I36_MP4 (XI1_I2066_I36_p1 XI1_I2066_I36_An I1_I2066_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I36_MP2 (VDD I1_p31_4 XI1_I2066_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I36_MP3 (XI1_I2066_I36_p1 XI1_I2066_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I36_MP0 (VDD I1_p31_4 XI1_I2066_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I35_MP1 (VDD I1_dm3 XI1_I2066_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I35_MP5 (I1_I2066_pn3 I1_dm3 XI1_I2066_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I35_MP4 (XI1_I2066_I35_p1 XI1_I2066_I35_An I1_I2066_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I35_MP2 (VDD I1_p31_3 XI1_I2066_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I35_MP3 (XI1_I2066_I35_p1 XI1_I2066_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I35_MP0 (VDD I1_p31_3 XI1_I2066_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I33_MP1 (VDD I1_dm1 XI1_I2066_I33_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I33_MP5 (I1_I2066_pn1 I1_dm1 XI1_I2066_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I33_MP4 (XI1_I2066_I33_p1 XI1_I2066_I33_An I1_I2066_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I33_MP2 (VDD I1_p31_1 XI1_I2066_I33_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I33_MP3 (XI1_I2066_I33_p1 XI1_I2066_I33_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I33_MP0 (VDD I1_p31_1 XI1_I2066_I33_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I66_MP1 (VDD VSS XI0_I1660_I66_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I66_MP5 (I0_I1660_pn2 VSS XI0_I1660_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I66_MP4 (XI0_I1660_I66_p1 XI0_I1660_I66_An I0_I1660_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I66_MP2 (VDD I0_fa1_0 XI0_I1660_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I66_MP3 (XI0_I1660_I66_p1 XI0_I1660_I66_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I66_MP0 (VDD I0_fa1_0 XI0_I1660_I66_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I485_MP1 (VDD I0_I1660_G17_0 XI0_I1660_I485_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I485_MP5 (MULP_18 I0_I1660_G17_0 XI0_I1660_I485_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I485_MP4 (XI0_I1660_I485_p1 XI0_I1660_I485_An MULP_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I485_MP2 (VDD I0_I1660_pn18 XI0_I1660_I485_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I485_MP3 (XI0_I1660_I485_p1 XI0_I1660_I485_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I485_MP0 (VDD I0_I1660_pn18 XI0_I1660_I485_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I488_MP1 (VDD I0_I1660_G20_0 XI0_I1660_I488_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I488_MP5 (MULP_21 I0_I1660_G20_0 XI0_I1660_I488_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I488_MP4 (XI0_I1660_I488_p1 XI0_I1660_I488_An MULP_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I488_MP2 (VDD I0_I1660_pn21 XI0_I1660_I488_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I488_MP3 (XI0_I1660_I488_p1 XI0_I1660_I488_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I488_MP0 (VDD I0_I1660_pn21 XI0_I1660_I488_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I489_MP1 (VDD I0_I1660_G21_0 XI0_I1660_I489_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I489_MP5 (MULP_22 I0_I1660_G21_0 XI0_I1660_I489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I489_MP4 (XI0_I1660_I489_p1 XI0_I1660_I489_An MULP_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I489_MP2 (VDD I0_I1660_pn22 XI0_I1660_I489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I489_MP3 (XI0_I1660_I489_p1 XI0_I1660_I489_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I489_MP0 (VDD I0_I1660_pn22 XI0_I1660_I489_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I492_MP1 (VDD I0_I1660_G24_0 XI0_I1660_I492_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I492_MP5 (MULP_25 I0_I1660_G24_0 XI0_I1660_I492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I492_MP4 (XI0_I1660_I492_p1 XI0_I1660_I492_An MULP_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I492_MP2 (VDD I0_I1660_pn25 XI0_I1660_I492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I492_MP3 (XI0_I1660_I492_p1 XI0_I1660_I492_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I492_MP0 (VDD I0_I1660_pn25 XI0_I1660_I492_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I493_MP1 (VDD I0_I1660_G25_0 XI0_I1660_I493_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I493_MP5 (MULP_26 I0_I1660_G25_0 XI0_I1660_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I493_MP4 (XI0_I1660_I493_p1 XI0_I1660_I493_An MULP_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I493_MP2 (VDD I0_I1660_pn26 XI0_I1660_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I493_MP3 (XI0_I1660_I493_p1 XI0_I1660_I493_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I493_MP0 (VDD I0_I1660_pn26 XI0_I1660_I493_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I494_MP1 (VDD I0_I1660_G26_0 XI0_I1660_I494_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I494_MP5 (MULP_27 I0_I1660_G26_0 XI0_I1660_I494_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I494_MP4 (XI0_I1660_I494_p1 XI0_I1660_I494_An MULP_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I494_MP2 (VDD I0_I1660_pn27 XI0_I1660_I494_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I494_MP3 (XI0_I1660_I494_p1 XI0_I1660_I494_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I494_MP0 (VDD I0_I1660_pn27 XI0_I1660_I494_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I496_MP1 (VDD I0_I1660_G28_0 XI0_I1660_I496_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I496_MP5 (MULP_29 I0_I1660_G28_0 XI0_I1660_I496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I496_MP4 (XI0_I1660_I496_p1 XI0_I1660_I496_An MULP_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I496_MP2 (VDD I0_I1660_pn29 XI0_I1660_I496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I496_MP3 (XI0_I1660_I496_p1 XI0_I1660_I496_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I496_MP0 (VDD I0_I1660_pn29 XI0_I1660_I496_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I495_MP1 (VDD I0_I1660_G27_0 XI0_I1660_I495_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I495_MP5 (MULP_28 I0_I1660_G27_0 XI0_I1660_I495_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I495_MP4 (XI0_I1660_I495_p1 XI0_I1660_I495_An MULP_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I495_MP2 (VDD I0_I1660_pn28 XI0_I1660_I495_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I495_MP3 (XI0_I1660_I495_p1 XI0_I1660_I495_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I495_MP0 (VDD I0_I1660_pn28 XI0_I1660_I495_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I92_MP1 (VDD I0_ha272_0 XI0_I1660_I92_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I92_MP5 (I0_I1660_pn28 I0_ha272_0 XI0_I1660_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I92_MP4 (XI0_I1660_I92_p1 XI0_I1660_I92_An I0_I1660_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I92_MP2 (VDD I0_ha271_1 XI0_I1660_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I92_MP3 (XI0_I1660_I92_p1 XI0_I1660_I92_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I92_MP0 (VDD I0_ha271_1 XI0_I1660_I92_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I93_MP1 (VDD I0_ha273_0 XI0_I1660_I93_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I93_MP5 (I0_I1660_pn29 I0_ha273_0 XI0_I1660_I93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I93_MP4 (XI0_I1660_I93_p1 XI0_I1660_I93_An I0_I1660_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I93_MP2 (VDD I0_ha272_1 XI0_I1660_I93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I93_MP3 (XI0_I1660_I93_p1 XI0_I1660_I93_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I93_MP0 (VDD I0_ha272_1 XI0_I1660_I93_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I234_MP1 (VDD I1_c27_m XI1_I1804_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I234_MP5 (I1_p27_31 I1_c27_m XI1_I1804_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I234_MP4 (XI1_I1804_I234_p1 XI1_I1804_I234_An I1_p27_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I234_MP2 (VDD I1_I1804_pn31 XI1_I1804_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I234_MP3 (XI1_I1804_I234_p1 XI1_I1804_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I234_MP0 (VDD I1_I1804_pn31 XI1_I1804_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I230_MP1 (VDD I1_I1804_G26_0 XI1_I1804_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I230_MP5 (I1_p27_27 I1_I1804_G26_0 XI1_I1804_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I230_MP4 (XI1_I1804_I230_p1 XI1_I1804_I230_An I1_p27_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I230_MP2 (VDD I1_I1804_pn27 XI1_I1804_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I230_MP3 (XI1_I1804_I230_p1 XI1_I1804_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I230_MP0 (VDD I1_I1804_pn27 XI1_I1804_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I226_MP1 (VDD I1_I1804_G22_0 XI1_I1804_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I226_MP5 (I1_p27_23 I1_I1804_G22_0 XI1_I1804_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I226_MP4 (XI1_I1804_I226_p1 XI1_I1804_I226_An I1_p27_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I226_MP2 (VDD I1_I1804_pn23 XI1_I1804_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I226_MP3 (XI1_I1804_I226_p1 XI1_I1804_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I226_MP0 (VDD I1_I1804_pn23 XI1_I1804_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I224_MP1 (VDD I1_I1804_G20_0 XI1_I1804_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I224_MP5 (I1_p27_21 I1_I1804_G20_0 XI1_I1804_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I224_MP4 (XI1_I1804_I224_p1 XI1_I1804_I224_An I1_p27_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I224_MP2 (VDD I1_I1804_pn21 XI1_I1804_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I224_MP3 (XI1_I1804_I224_p1 XI1_I1804_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I224_MP0 (VDD I1_I1804_pn21 XI1_I1804_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I222_MP1 (VDD I1_I1804_G18_0 XI1_I1804_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I222_MP5 (I1_p27_19 I1_I1804_G18_0 XI1_I1804_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I222_MP4 (XI1_I1804_I222_p1 XI1_I1804_I222_An I1_p27_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I222_MP2 (VDD I1_I1804_pn19 XI1_I1804_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I222_MP3 (XI1_I1804_I222_p1 XI1_I1804_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I222_MP0 (VDD I1_I1804_pn19 XI1_I1804_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I228_MP1 (VDD I1_I1804_G24_0 XI1_I1804_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I228_MP5 (I1_p27_25 I1_I1804_G24_0 XI1_I1804_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I228_MP4 (XI1_I1804_I228_p1 XI1_I1804_I228_An I1_p27_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I228_MP2 (VDD I1_I1804_pn25 XI1_I1804_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I228_MP3 (XI1_I1804_I228_p1 XI1_I1804_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I228_MP0 (VDD I1_I1804_pn25 XI1_I1804_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I209_MP1 (VDD I1_I1804_G5_0 XI1_I1804_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I209_MP5 (I1_p27_6 I1_I1804_G5_0 XI1_I1804_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I209_MP4 (XI1_I1804_I209_p1 XI1_I1804_I209_An I1_p27_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I209_MP2 (VDD I1_I1804_pn6 XI1_I1804_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I209_MP3 (XI1_I1804_I209_p1 XI1_I1804_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I209_MP0 (VDD I1_I1804_pn6 XI1_I1804_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I37_MP1 (VDD I1_b28_5 XI1_I1850_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I37_MP5 (I1_I1850_pn5 I1_b28_5 XI1_I1850_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I37_MP4 (XI1_I1850_I37_p1 XI1_I1850_I37_An I1_I1850_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I37_MP2 (VDD I1_p27_4 XI1_I1850_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I37_MP3 (XI1_I1850_I37_p1 XI1_I1850_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I37_MP0 (VDD I1_p27_4 XI1_I1850_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I38_MP1 (VDD I1_b29_6 XI1_I1896_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I38_MP5 (I1_I1896_pn6 I1_b29_6 XI1_I1896_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I38_MP4 (XI1_I1896_I38_p1 XI1_I1896_I38_An I1_I1896_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I38_MP2 (VDD I1_p28_5 XI1_I1896_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I38_MP3 (XI1_I1896_I38_p1 XI1_I1896_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I38_MP0 (VDD I1_p28_5 XI1_I1896_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I37_MP1 (VDD I1_b29_5 XI1_I1896_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I37_MP5 (I1_I1896_pn5 I1_b29_5 XI1_I1896_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I37_MP4 (XI1_I1896_I37_p1 XI1_I1896_I37_An I1_I1896_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I37_MP2 (VDD I1_p28_4 XI1_I1896_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I37_MP3 (XI1_I1896_I37_p1 XI1_I1896_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I37_MP0 (VDD I1_p28_4 XI1_I1896_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I208_MP1 (VDD I1_I1896_G4_0 XI1_I1896_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I208_MP5 (I1_p29_5 I1_I1896_G4_0 XI1_I1896_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I208_MP4 (XI1_I1896_I208_p1 XI1_I1896_I208_An I1_p29_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I208_MP2 (VDD I1_I1896_pn5 XI1_I1896_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I208_MP3 (XI1_I1896_I208_p1 XI1_I1896_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I208_MP0 (VDD I1_I1896_pn5 XI1_I1896_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I39_MP1 (VDD I1_b30_7 XI1_I1942_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I39_MP5 (I1_I1942_pn7 I1_b30_7 XI1_I1942_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I39_MP4 (XI1_I1942_I39_p1 XI1_I1942_I39_An I1_I1942_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I39_MP2 (VDD I1_p29_6 XI1_I1942_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I39_MP3 (XI1_I1942_I39_p1 XI1_I1942_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I39_MP0 (VDD I1_p29_6 XI1_I1942_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I209_MP1 (VDD I1_I1942_G5_0 XI1_I1942_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I209_MP5 (I1_p30_6 I1_I1942_G5_0 XI1_I1942_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I209_MP4 (XI1_I1942_I209_p1 XI1_I1942_I209_An I1_p30_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I209_MP2 (VDD I1_I1942_pn6 XI1_I1942_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I209_MP3 (XI1_I1942_I209_p1 XI1_I1942_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I209_MP0 (VDD I1_I1942_pn6 XI1_I1942_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I40_MP1 (VDD I1_b31_8 XI1_I1988_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I40_MP5 (I1_I1988_pn8 I1_b31_8 XI1_I1988_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I40_MP4 (XI1_I1988_I40_p1 XI1_I1988_I40_An I1_I1988_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I40_MP2 (VDD I1_p30_7 XI1_I1988_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I40_MP3 (XI1_I1988_I40_p1 XI1_I1988_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I40_MP0 (VDD I1_p30_7 XI1_I1988_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I209_MP1 (VDD I1_I1988_G5_0 XI1_I1988_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I209_MP5 (I1_p31_6 I1_I1988_G5_0 XI1_I1988_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I209_MP4 (XI1_I1988_I209_p1 XI1_I1988_I209_An I1_p31_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I209_MP2 (VDD I1_I1988_pn6 XI1_I1988_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I209_MP3 (XI1_I1988_I209_p1 XI1_I1988_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I209_MP0 (VDD I1_I1988_pn6 XI1_I1988_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I208_MP1 (VDD I1_I1988_G4_0 XI1_I1988_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I208_MP5 (I1_p31_5 I1_I1988_G4_0 XI1_I1988_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I208_MP4 (XI1_I1988_I208_p1 XI1_I1988_I208_An I1_p31_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I208_MP2 (VDD I1_I1988_pn5 XI1_I1988_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I208_MP3 (XI1_I1988_I208_p1 XI1_I1988_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I208_MP0 (VDD I1_I1988_pn5 XI1_I1988_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I38_MP1 (VDD I1_dm6 XI1_I2066_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I38_MP5 (I1_I2066_pn6 I1_dm6 XI1_I2066_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I38_MP4 (XI1_I2066_I38_p1 XI1_I2066_I38_An I1_I2066_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I38_MP2 (VDD I1_p31_6 XI1_I2066_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I38_MP3 (XI1_I2066_I38_p1 XI1_I2066_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I38_MP0 (VDD I1_p31_6 XI1_I2066_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I37_MP1 (VDD I1_dm5 XI1_I2066_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I37_MP5 (I1_I2066_pn5 I1_dm5 XI1_I2066_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I37_MP4 (XI1_I2066_I37_p1 XI1_I2066_I37_An I1_I2066_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I37_MP2 (VDD I1_p31_5 XI1_I2066_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I37_MP3 (XI1_I2066_I37_p1 XI1_I2066_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I37_MP0 (VDD I1_p31_5 XI1_I2066_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I67_MP1 (VDD VSS XI0_I1660_I67_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I67_MP5 (I0_I1660_pn3 VSS XI0_I1660_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I67_MP4 (XI0_I1660_I67_p1 XI0_I1660_I67_An I0_I1660_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I67_MP2 (VDD I0_fa137_0 XI0_I1660_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I67_MP3 (XI0_I1660_I67_p1 XI0_I1660_I67_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I67_MP0 (VDD I0_fa137_0 XI0_I1660_I67_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I203_MP1 (VDD VSS XI1_I2066_I203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I203_MP5 (DIVR_0 VSS XI1_I2066_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I203_MP4 (XI1_I2066_I203_p1 XI1_I2066_I203_An DIVR_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I203_MP2 (VDD I1_I2066_pn0 XI1_I2066_I203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I203_MP3 (XI1_I2066_I203_p1 XI1_I2066_I203_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I203_MP0 (VDD I1_I2066_pn0 XI1_I2066_I203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I469_MP1 (VDD I0_I1660_G1_0 XI0_I1660_I469_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I469_MP5 (MULP_2 I0_I1660_G1_0 XI0_I1660_I469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I469_MP4 (XI0_I1660_I469_p1 XI0_I1660_I469_An MULP_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I469_MP2 (VDD I0_I1660_pn2 XI0_I1660_I469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I469_MP3 (XI0_I1660_I469_p1 XI0_I1660_I469_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I469_MP0 (VDD I0_I1660_pn2 XI0_I1660_I469_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I472_MP1 (VDD I0_I1660_G4_0 XI0_I1660_I472_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I472_MP5 (MULP_5 I0_I1660_G4_0 XI0_I1660_I472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I472_MP4 (XI0_I1660_I472_p1 XI0_I1660_I472_An MULP_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I472_MP2 (VDD I0_I1660_pn5 XI0_I1660_I472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I472_MP3 (XI0_I1660_I472_p1 XI0_I1660_I472_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I472_MP0 (VDD I0_I1660_pn5 XI0_I1660_I472_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I94_MP1 (VDD I0_ha274_0 XI0_I1660_I94_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I94_MP5 (I0_I1660_pn30 I0_ha274_0 XI0_I1660_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I94_MP4 (XI0_I1660_I94_p1 XI0_I1660_I94_An I0_I1660_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I94_MP2 (VDD I0_ha273_1 XI0_I1660_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I94_MP3 (XI0_I1660_I94_p1 XI0_I1660_I94_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I94_MP0 (VDD I0_ha273_1 XI0_I1660_I94_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I39_MP1 (VDD I1_b28_7 XI1_I1850_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I39_MP5 (I1_I1850_pn7 I1_b28_7 XI1_I1850_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I39_MP4 (XI1_I1850_I39_p1 XI1_I1850_I39_An I1_I1850_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I39_MP2 (VDD I1_p27_6 XI1_I1850_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I39_MP3 (XI1_I1850_I39_p1 XI1_I1850_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I39_MP0 (VDD I1_p27_6 XI1_I1850_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I208_MP1 (VDD I1_I1850_G4_0 XI1_I1850_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I208_MP5 (I1_p28_5 I1_I1850_G4_0 XI1_I1850_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I208_MP4 (XI1_I1850_I208_p1 XI1_I1850_I208_An I1_p28_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I208_MP2 (VDD I1_I1850_pn5 XI1_I1850_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I208_MP3 (XI1_I1850_I208_p1 XI1_I1850_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I208_MP0 (VDD I1_I1850_pn5 XI1_I1850_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I39_MP1 (VDD I1_b29_7 XI1_I1896_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I39_MP5 (I1_I1896_pn7 I1_b29_7 XI1_I1896_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I39_MP4 (XI1_I1896_I39_p1 XI1_I1896_I39_An I1_I1896_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I39_MP2 (VDD I1_p28_6 XI1_I1896_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I39_MP3 (XI1_I1896_I39_p1 XI1_I1896_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I39_MP0 (VDD I1_p28_6 XI1_I1896_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I209_MP1 (VDD I1_I1896_G5_0 XI1_I1896_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I209_MP5 (I1_p29_6 I1_I1896_G5_0 XI1_I1896_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I209_MP4 (XI1_I1896_I209_p1 XI1_I1896_I209_An I1_p29_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I209_MP2 (VDD I1_I1896_pn6 XI1_I1896_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I209_MP3 (XI1_I1896_I209_p1 XI1_I1896_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I209_MP0 (VDD I1_I1896_pn6 XI1_I1896_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I210_MP1 (VDD I1_I1896_G6_0 XI1_I1896_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I210_MP5 (I1_p29_7 I1_I1896_G6_0 XI1_I1896_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I210_MP4 (XI1_I1896_I210_p1 XI1_I1896_I210_An I1_p29_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I210_MP2 (VDD I1_I1896_pn7 XI1_I1896_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I210_MP3 (XI1_I1896_I210_p1 XI1_I1896_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I210_MP0 (VDD I1_I1896_pn7 XI1_I1896_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I40_MP1 (VDD I1_b30_8 XI1_I1942_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I40_MP5 (I1_I1942_pn8 I1_b30_8 XI1_I1942_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I40_MP4 (XI1_I1942_I40_p1 XI1_I1942_I40_An I1_I1942_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I40_MP2 (VDD I1_p29_7 XI1_I1942_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I40_MP3 (XI1_I1942_I40_p1 XI1_I1942_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I40_MP0 (VDD I1_p29_7 XI1_I1942_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I41_MP1 (VDD I1_b30_9 XI1_I1942_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I41_MP5 (I1_I1942_pn9 I1_b30_9 XI1_I1942_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I41_MP4 (XI1_I1942_I41_p1 XI1_I1942_I41_An I1_I1942_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I41_MP2 (VDD I1_p29_8 XI1_I1942_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I41_MP3 (XI1_I1942_I41_p1 XI1_I1942_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I41_MP0 (VDD I1_p29_8 XI1_I1942_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I211_MP1 (VDD I1_I1942_G7_0 XI1_I1942_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I211_MP5 (I1_p30_8 I1_I1942_G7_0 XI1_I1942_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I211_MP4 (XI1_I1942_I211_p1 XI1_I1942_I211_An I1_p30_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I211_MP2 (VDD I1_I1942_pn8 XI1_I1942_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I211_MP3 (XI1_I1942_I211_p1 XI1_I1942_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I211_MP0 (VDD I1_I1942_pn8 XI1_I1942_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I210_MP1 (VDD I1_I1942_G6_0 XI1_I1942_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I210_MP5 (I1_p30_7 I1_I1942_G6_0 XI1_I1942_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I210_MP4 (XI1_I1942_I210_p1 XI1_I1942_I210_An I1_p30_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I210_MP2 (VDD I1_I1942_pn7 XI1_I1942_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I210_MP3 (XI1_I1942_I210_p1 XI1_I1942_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I210_MP0 (VDD I1_I1942_pn7 XI1_I1942_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I41_MP1 (VDD I1_b31_9 XI1_I1988_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I41_MP5 (I1_I1988_pn9 I1_b31_9 XI1_I1988_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I41_MP4 (XI1_I1988_I41_p1 XI1_I1988_I41_An I1_I1988_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I41_MP2 (VDD I1_p30_8 XI1_I1988_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I41_MP3 (XI1_I1988_I41_p1 XI1_I1988_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I41_MP0 (VDD I1_p30_8 XI1_I1988_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I211_MP1 (VDD I1_I1988_G7_0 XI1_I1988_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
