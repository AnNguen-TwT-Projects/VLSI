    I_MXI1_I746_I107_XG_MN1 (VSS I1_I746_G9_8 XI1_I746_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I109_XG_MN2 (I1_I746_G13_10n I1_I746_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I109_XG_MN0 (XI1_I746_I109_XG_n1 I1_I746_P13_12 I1_I746_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I109_XG_MN1 (VSS I1_I746_G11_10 XI1_I746_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I111_XG_MN2 (I1_I746_G15_12n I1_I746_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I111_XG_MN0 (XI1_I746_I111_XG_n1 I1_I746_P15_14 I1_I746_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I111_XG_MN1 (VSS I1_I746_G13_12 XI1_I746_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I113_XG_MN2 (I1_I746_G17_14n I1_I746_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I113_XG_MN0 (XI1_I746_I113_XG_n1 I1_I746_P17_16 I1_I746_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I113_XG_MN1 (VSS I1_I746_G15_14 XI1_I746_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I166_XG_MN2 (I1_I746_G15_0n I1_I746_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I166_XG_MN0 (XI1_I746_I166_XG_n1 I1_I746_P15_8 I1_I746_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I166_XG_MN1 (VSS I1_I746_G7_0 XI1_I746_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I174_XG_MN2 (I1_I746_G23_8n I1_I746_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I174_XG_MN0 (XI1_I746_I174_XG_n1 I1_I746_P23_16 I1_I746_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I174_XG_MN1 (VSS I1_I746_G15_8 XI1_I746_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I167_XG_MN2 (I1_I1344_G16_1n I1_I1344_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I167_XG_MN0 (XI1_I1344_I167_XG_n1 I1_I1344_P16_9 I1_I1344_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I167_XG_MN1 (VSS I1_I1344_G8_1 XI1_I1344_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I157_XG_MN2 (I1_I1344_G8_0n I1_I1344_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I157_XG_MN0 (XI1_I1344_I157_XG_n1 I1_I1344_P8_1 I1_I1344_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I157_XG_MN1 (VSS I1_I1344_G0_0 XI1_I1344_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I104_XG_MN2 (I1_I1344_G8_5n I1_I1344_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I104_XG_MN0 (XI1_I1344_I104_XG_n1 I1_I1344_P8_7 I1_I1344_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I104_XG_MN1 (VSS I1_I1344_G6_5 XI1_I1344_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I101_XG_MN2 (I1_I1344_G5_2n I1_I1344_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I101_XG_MN0 (XI1_I1344_I101_XG_n1 I1_I1344_P5_4 I1_I1344_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I101_XG_MN1 (VSS I1_I1344_G3_2 XI1_I1344_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I103_XG_MN2 (I1_I1298_G7_4n I1_I1298_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I103_XG_MN0 (XI1_I1298_I103_XG_n1 I1_I1298_P7_6 I1_I1298_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I103_XG_MN1 (VSS I1_I1298_G5_4 XI1_I1298_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I157_XG_MN2 (I1_I1252_G8_0n I1_I1252_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I157_XG_MN0 (XI1_I1252_I157_XG_n1 I1_I1252_P8_1 I1_I1252_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I157_XG_MN1 (VSS I1_I1252_G0_0 XI1_I1252_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I106_XG_MN2 (I1_I1252_G10_7n I1_I1252_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I106_XG_MN0 (XI1_I1252_I106_XG_n1 I1_I1252_P10_9 I1_I1252_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I106_XG_MN1 (VSS I1_I1252_G8_7 XI1_I1252_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I105_XG_MN2 (I1_I1252_G9_6n I1_I1252_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I105_XG_MN0 (XI1_I1252_I105_XG_n1 I1_I1252_P9_8 I1_I1252_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I105_XG_MN1 (VSS I1_I1252_G7_6 XI1_I1252_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I105_XG_MN2 (I1_I1206_G9_6n I1_I1206_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I105_XG_MN0 (XI1_I1206_I105_XG_n1 I1_I1206_P9_8 I1_I1206_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I105_XG_MN1 (VSS I1_I1206_G7_6 XI1_I1206_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I103_XG_MN2 (I1_I1206_G7_4n I1_I1206_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I103_XG_MN0 (XI1_I1206_I103_XG_n1 I1_I1206_P7_6 I1_I1206_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I103_XG_MN1 (VSS I1_I1206_G5_4 XI1_I1206_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I106_XG_MN2 (I1_I1206_G10_7n I1_I1206_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I106_XG_MN0 (XI1_I1206_I106_XG_n1 I1_I1206_P10_9 I1_I1206_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I106_XG_MN1 (VSS I1_I1206_G8_7 XI1_I1206_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I104_XG_MN2 (I1_I1206_G8_5n I1_I1206_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I104_XG_MN0 (XI1_I1206_I104_XG_n1 I1_I1206_P8_7 I1_I1206_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I104_XG_MN1 (VSS I1_I1206_G6_5 XI1_I1206_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I182_XG_MN2 (I1_I884_G31_16n I1_I884_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I182_XG_MN0 (XI1_I884_I182_XG_n1 I1_I884_P31_24 I1_I884_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I182_XG_MN1 (VSS I1_I884_G23_16 XI1_I884_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I180_XG_MN2 (I1_I884_G29_14n I1_I884_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I180_XG_MN0 (XI1_I884_I180_XG_n1 I1_I884_P29_22 I1_I884_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I180_XG_MN1 (VSS I1_I884_G21_14 XI1_I884_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I174_XG_MN2 (I1_I884_G23_8n I1_I884_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I174_XG_MN0 (XI1_I884_I174_XG_n1 I1_I884_P23_16 I1_I884_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I174_XG_MN1 (VSS I1_I884_G15_8 XI1_I884_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I166_XG_MN2 (I1_I884_G15_0n I1_I884_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I166_XG_MN0 (XI1_I884_I166_XG_n1 I1_I884_P15_8 I1_I884_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I166_XG_MN1 (VSS I1_I884_G7_0 XI1_I884_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I176_XG_MN2 (I1_I884_G25_10n I1_I884_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I176_XG_MN0 (XI1_I884_I176_XG_n1 I1_I884_P25_18 I1_I884_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I176_XG_MN1 (VSS I1_I884_G17_10 XI1_I884_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I172_XG_MN2 (I1_I884_G21_6n I1_I884_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I172_XG_MN0 (XI1_I884_I172_XG_n1 I1_I884_P21_14 I1_I884_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I172_XG_MN1 (VSS I1_I884_G13_6 XI1_I884_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I170_XG_MN2 (I1_I884_G19_4n I1_I884_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I170_XG_MN0 (XI1_I884_I170_XG_n1 I1_I884_P19_12 I1_I884_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I170_XG_MN1 (VSS I1_I884_G11_4 XI1_I884_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I162_XG_MN2 (I1_I884_G11_0n I1_I884_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I162_XG_MN0 (XI1_I884_I162_XG_n1 I1_I884_P11_4 I1_I884_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I162_XG_MN1 (VSS I1_I884_G3_0np XI1_I884_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I164_XG_MN2 (I1_I884_G13_0n I1_I884_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I164_XG_MN0 (XI1_I884_I164_XG_n1 I1_I884_P13_6 I1_I884_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I164_XG_MN1 (VSS I1_I884_G5_0 XI1_I884_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I107_XG_MN2 (I1_I884_G11_8n I1_I884_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I107_XG_MN0 (XI1_I884_I107_XG_n1 I1_I884_P11_10 I1_I884_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I107_XG_MN1 (VSS I1_I884_G9_8 XI1_I884_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I105_XG_MN2 (I1_I884_G9_6n I1_I884_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I105_XG_MN0 (XI1_I884_I105_XG_n1 I1_I884_P9_8 I1_I884_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I105_XG_MN1 (VSS I1_I884_G7_6 XI1_I884_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I99_XG_MN2 (I1_I746_G3_0n I1_I746_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I99_XG_MN0 (XI1_I746_I99_XG_n1 I1_I746_P3_2 I1_I746_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I99_XG_MN1 (VSS I1_I746_G1_0 XI1_I746_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I157_XG_MN2 (I1_I1298_G8_0n I1_I1298_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I157_XG_MN0 (XI1_I1298_I157_XG_n1 I1_I1298_P8_1 I1_I1298_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I157_XG_MN1 (VSS I1_I1298_G0_0 XI1_I1298_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I102_XG_MN2 (I1_I1298_G6_3n I1_I1298_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I102_XG_MN0 (XI1_I1298_I102_XG_n1 I1_I1298_P6_5 I1_I1298_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I102_XG_MN1 (VSS I1_I1298_G4_3 XI1_I1298_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I104_XG_MN2 (I1_I1298_G8_5n I1_I1298_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I104_XG_MN0 (XI1_I1298_I104_XG_n1 I1_I1298_P8_7 I1_I1298_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I104_XG_MN1 (VSS I1_I1298_G6_5 XI1_I1298_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I104_XG_MN2 (I1_I1252_G8_5n I1_I1252_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I104_XG_MN0 (XI1_I1252_I104_XG_n1 I1_I1252_P8_7 I1_I1252_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I104_XG_MN1 (VSS I1_I1252_G6_5 XI1_I1252_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I103_XG_MN2 (I1_I1252_G7_4n I1_I1252_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I103_XG_MN0 (XI1_I1252_I103_XG_n1 I1_I1252_P7_6 I1_I1252_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I103_XG_MN1 (VSS I1_I1252_G5_4 XI1_I1252_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I101_XG_MN2 (I1_I1206_G5_2n I1_I1206_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I101_XG_MN0 (XI1_I1206_I101_XG_n1 I1_I1206_P5_4 I1_I1206_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I101_XG_MN1 (VSS I1_I1206_G3_2 XI1_I1206_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I99_XG_MN2 (I1_I1206_G3_0n I1_I1206_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I99_XG_MN0 (XI1_I1206_I99_XG_n1 I1_I1206_P3_2 I1_I1206_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I99_XG_MN1 (VSS I1_I1206_G1_0 XI1_I1206_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I102_XG_MN2 (I1_I1206_G6_3n I1_I1206_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I102_XG_MN0 (XI1_I1206_I102_XG_n1 I1_I1206_P6_5 I1_I1206_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I102_XG_MN1 (VSS I1_I1206_G4_3 XI1_I1206_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I157_XG_MN2 (I1_I1206_G8_0n I1_I1206_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I157_XG_MN0 (XI1_I1206_I157_XG_n1 I1_I1206_P8_1 I1_I1206_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I157_XG_MN1 (VSS I1_I1206_G0_0 XI1_I1206_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I126_XG_MN2 (I1_I884_G30_27n I1_I884_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I126_XG_MN0 (XI1_I884_I126_XG_n1 I1_I884_P30_29 I1_I884_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I126_XG_MN1 (VSS I1_I884_G28_27 XI1_I884_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I124_XG_MN2 (I1_I884_G28_25n I1_I884_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I124_XG_MN0 (XI1_I884_I124_XG_n1 I1_I884_P28_27 I1_I884_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I124_XG_MN1 (VSS I1_I884_G26_25 XI1_I884_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I122_XG_MN2 (I1_I884_G26_23n I1_I884_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I122_XG_MN0 (XI1_I884_I122_XG_n1 I1_I884_P26_25 I1_I884_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I122_XG_MN1 (VSS I1_I884_G24_23 XI1_I884_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I116_XG_MN2 (I1_I884_G20_17n I1_I884_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I116_XG_MN0 (XI1_I884_I116_XG_n1 I1_I884_P20_19 I1_I884_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I116_XG_MN1 (VSS I1_I884_G18_17 XI1_I884_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I168_XG_MN2 (I1_I884_G17_2n I1_I884_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I168_XG_MN0 (XI1_I884_I168_XG_n1 I1_I884_P17_10 I1_I884_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I168_XG_MN1 (VSS I1_I884_G9_2 XI1_I884_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I158_XG_MN2 (I1_I884_G9_0n I1_I884_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I158_XG_MN0 (XI1_I884_I158_XG_n1 I1_I884_P9_2 I1_I884_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I158_XG_MN1 (VSS I1_I884_G1_0 XI1_I884_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I103_XG_MN2 (I1_I884_G7_4n I1_I884_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I103_XG_MN0 (XI1_I884_I103_XG_n1 I1_I884_P7_6 I1_I884_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I103_XG_MN1 (VSS I1_I884_G5_4 XI1_I884_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I166_XG_MN2 (I1_I700_G15_0n I1_I700_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I166_XG_MN0 (XI1_I700_I166_XG_n1 I1_I700_P15_8 I1_I700_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I166_XG_MN1 (VSS I1_I700_G7_0 XI1_I700_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I123_XG_MN2 (I1_I1390_G27_24n I1_I1390_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I123_XG_MN0 (XI1_I1390_I123_XG_n1 I1_I1390_P27_26 I1_I1390_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I123_XG_MN1 (VSS I1_I1390_G25_24 XI1_I1390_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I121_XG_MN2 (I1_I1390_G25_22n I1_I1390_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I121_XG_MN0 (XI1_I1390_I121_XG_n1 I1_I1390_P25_24 I1_I1390_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I121_XG_MN1 (VSS I1_I1390_G23_22 XI1_I1390_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I119_XG_MN2 (I1_I1390_G23_20n I1_I1390_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I119_XG_MN0 (XI1_I1390_I119_XG_n1 I1_I1390_P23_22 I1_I1390_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I119_XG_MN1 (VSS I1_I1390_G21_20 XI1_I1390_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I102_XG_MN2 (I1_I1344_G6_3n I1_I1344_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I102_XG_MN0 (XI1_I1344_I102_XG_n1 I1_I1344_P6_5 I1_I1344_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I102_XG_MN1 (VSS I1_I1344_G4_3 XI1_I1344_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I98_XG_MN2 (I1_I1252_G2_0n I1_I1252_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I98_XG_MN0 (XI1_I1252_I98_XG_n1 I1_I1252_P2_1 I1_I1252_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I98_XG_MN1 (VSS I1_I1252_G0_0 XI1_I1252_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I100_XG_MN2 (I1_I1252_G4_1n I1_I1252_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I100_XG_MN0 (XI1_I1252_I100_XG_n1 I1_I1252_P4_3 I1_I1252_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I100_XG_MN1 (VSS I1_I1252_G2_1 XI1_I1252_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I102_XG_MN2 (I1_I1252_G6_3n I1_I1252_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I102_XG_MN0 (XI1_I1252_I102_XG_n1 I1_I1252_P6_5 I1_I1252_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I102_XG_MN1 (VSS I1_I1252_G4_3 XI1_I1252_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I99_XG_MN2 (I1_I1252_G3_0n I1_I1252_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I99_XG_MN0 (XI1_I1252_I99_XG_n1 I1_I1252_P3_2 I1_I1252_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I99_XG_MN1 (VSS I1_I1252_G1_0 XI1_I1252_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I101_XG_MN2 (I1_I1252_G5_2n I1_I1252_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I101_XG_MN0 (XI1_I1252_I101_XG_n1 I1_I1252_P5_4 I1_I1252_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I101_XG_MN1 (VSS I1_I1252_G3_2 XI1_I1252_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I178_XG_MN2 (I1_I1160_G27_12n I1_I1160_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I178_XG_MN0 (XI1_I1160_I178_XG_n1 I1_I1160_P27_20 I1_I1160_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I178_XG_MN1 (VSS I1_I1160_G19_12 XI1_I1160_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I170_XG_MN2 (I1_I1160_G19_4n I1_I1160_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I170_XG_MN0 (XI1_I1160_I170_XG_n1 I1_I1160_P19_12 I1_I1160_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I170_XG_MN1 (VSS I1_I1160_G11_4 XI1_I1160_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I162_XG_MN2 (I1_I1160_G11_0n I1_I1160_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I162_XG_MN0 (XI1_I1160_I162_XG_n1 I1_I1160_P11_4 I1_I1160_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I162_XG_MN1 (VSS I1_I1160_G3_0np XI1_I1160_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I98_XG_MN2 (I1_I1206_G2_0n I1_I1206_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I98_XG_MN0 (XI1_I1206_I98_XG_n1 I1_I1206_P2_1 I1_I1206_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I98_XG_MN1 (VSS I1_I1206_G0_0 XI1_I1206_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I100_XG_MN2 (I1_I1206_G4_1n I1_I1206_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I100_XG_MN0 (XI1_I1206_I100_XG_n1 I1_I1206_P4_3 I1_I1206_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I100_XG_MN1 (VSS I1_I1206_G2_1 XI1_I1206_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I181_XG_MN2 (I1_I884_G30_15n I1_I884_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I181_XG_MN0 (XI1_I884_I181_XG_n1 I1_I884_P30_23 I1_I884_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I181_XG_MN1 (VSS I1_I884_G22_15 XI1_I884_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I177_XG_MN2 (I1_I884_G26_11n I1_I884_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I177_XG_MN0 (XI1_I884_I177_XG_n1 I1_I884_P26_19 I1_I884_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I177_XG_MN1 (VSS I1_I884_G18_11 XI1_I884_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I173_XG_MN2 (I1_I884_G22_7n I1_I884_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I173_XG_MN0 (XI1_I884_I173_XG_n1 I1_I884_P22_15 I1_I884_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I173_XG_MN1 (VSS I1_I884_G14_7 XI1_I884_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I165_XG_MN2 (I1_I884_G14_0n I1_I884_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I165_XG_MN0 (XI1_I884_I165_XG_n1 I1_I884_P14_7 I1_I884_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I165_XG_MN1 (VSS I1_I884_G6_0 XI1_I884_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I175_XG_MN2 (I1_I884_G24_9n I1_I884_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I175_XG_MN0 (XI1_I884_I175_XG_n1 I1_I884_P24_17 I1_I884_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I175_XG_MN1 (VSS I1_I884_G16_9 XI1_I884_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I114_XG_MN2 (I1_I884_G18_15n I1_I884_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I114_XG_MN0 (XI1_I884_I114_XG_n1 I1_I884_P18_17 I1_I884_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I114_XG_MN1 (VSS I1_I884_G16_15 XI1_I884_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I112_XG_MN2 (I1_I884_G16_13n I1_I884_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I112_XG_MN0 (XI1_I884_I112_XG_n1 I1_I884_P16_15 I1_I884_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I112_XG_MN1 (VSS I1_I884_G14_13 XI1_I884_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I110_XG_MN2 (I1_I884_G14_11n I1_I884_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I110_XG_MN0 (XI1_I884_I110_XG_n1 I1_I884_P14_13 I1_I884_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I110_XG_MN1 (VSS I1_I884_G12_11 XI1_I884_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I108_XG_MN2 (I1_I884_G12_9n I1_I884_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I108_XG_MN0 (XI1_I884_I108_XG_n1 I1_I884_P12_11 I1_I884_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I108_XG_MN1 (VSS I1_I884_G10_9 XI1_I884_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I106_XG_MN2 (I1_I884_G10_7n I1_I884_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I106_XG_MN0 (XI1_I884_I106_XG_n1 I1_I884_P10_9 I1_I884_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I106_XG_MN1 (VSS I1_I884_G8_7 XI1_I884_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I104_XG_MN2 (I1_I884_G8_5n I1_I884_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I104_XG_MN0 (XI1_I884_I104_XG_n1 I1_I884_P8_7 I1_I884_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I104_XG_MN1 (VSS I1_I884_G6_5 XI1_I884_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I102_XG_MN2 (I1_I884_G6_3n I1_I884_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I102_XG_MN0 (XI1_I884_I102_XG_n1 I1_I884_P6_5 I1_I884_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I102_XG_MN1 (VSS I1_I884_G4_3 XI1_I884_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I101_XG_MN2 (I1_I884_G5_2n I1_I884_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I101_XG_MN0 (XI1_I884_I101_XG_n1 I1_I884_P5_4 I1_I884_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I101_XG_MN1 (VSS I1_I884_G3_2 XI1_I884_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I99_XG_MN2 (I1_I884_G3_0n I1_I884_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I99_XG_MN0 (XI1_I884_I99_XG_n1 I1_I884_P3_2 I1_I884_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I99_XG_MN1 (VSS I1_I884_G1_0 XI1_I884_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I162_XG_MN2 (I1_I700_G11_0n I1_I700_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I162_XG_MN0 (XI1_I700_I162_XG_n1 I1_I700_P11_4 I1_I700_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I162_XG_MN1 (VSS I1_I700_G3_0np XI1_I700_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I164_XG_MN2 (I1_I700_G13_0n I1_I700_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I164_XG_MN0 (XI1_I700_I164_XG_n1 I1_I700_P13_6 I1_I700_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I164_XG_MN1 (VSS I1_I700_G5_0 XI1_I700_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I170_XG_MN2 (I1_I700_G19_4n I1_I700_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I170_XG_MN0 (XI1_I700_I170_XG_n1 I1_I700_P19_12 I1_I700_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I170_XG_MN1 (VSS I1_I700_G11_4 XI1_I700_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I172_XG_MN2 (I1_I700_G21_6n I1_I700_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I172_XG_MN0 (XI1_I700_I172_XG_n1 I1_I700_P21_14 I1_I700_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I172_XG_MN1 (VSS I1_I700_G13_6 XI1_I700_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I178_XG_MN2 (I1_I700_G27_12n I1_I700_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I178_XG_MN0 (XI1_I700_I178_XG_n1 I1_I700_P27_20 I1_I700_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I178_XG_MN1 (VSS I1_I700_G19_12 XI1_I700_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I174_XG_MN2 (I1_I700_G23_8n I1_I700_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I174_XG_MN0 (XI1_I700_I174_XG_n1 I1_I700_P23_16 I1_I700_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I174_XG_MN1 (VSS I1_I700_G15_8 XI1_I700_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I182_XG_MN2 (I1_I700_G31_16n I1_I700_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I182_XG_MN0 (XI1_I700_I182_XG_n1 I1_I700_P31_24 I1_I700_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I182_XG_MN1 (VSS I1_I700_G23_16 XI1_I700_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I127_XG_MN2 (I1_I1390_G31_28n I1_I1390_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I127_XG_MN0 (XI1_I1390_I127_XG_n1 I1_I1390_P31_30 I1_I1390_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I127_XG_MN1 (VSS I1_I1390_G29_28 XI1_I1390_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I125_XG_MN2 (I1_I1390_G29_26n I1_I1390_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I125_XG_MN0 (XI1_I1390_I125_XG_n1 I1_I1390_P29_28 I1_I1390_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I125_XG_MN1 (VSS I1_I1390_G27_26 XI1_I1390_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I117_XG_MN2 (I1_I1390_G21_18n I1_I1390_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I117_XG_MN0 (XI1_I1390_I117_XG_n1 I1_I1390_P21_20 I1_I1390_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I117_XG_MN1 (VSS I1_I1390_G19_18 XI1_I1390_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I115_XG_MN2 (I1_I1390_G19_16n I1_I1390_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I115_XG_MN0 (XI1_I1390_I115_XG_n1 I1_I1390_P19_18 I1_I1390_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I115_XG_MN1 (VSS I1_I1390_G17_16 XI1_I1390_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I113_XG_MN2 (I1_I1390_G17_14n I1_I1390_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I113_XG_MN0 (XI1_I1390_I113_XG_n1 I1_I1390_P17_16 I1_I1390_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I113_XG_MN1 (VSS I1_I1390_G15_14 XI1_I1390_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I99_XG_MN2 (I1_I1344_G3_0n I1_I1344_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I99_XG_MN0 (XI1_I1344_I99_XG_n1 I1_I1344_P3_2 I1_I1344_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I99_XG_MN1 (VSS I1_I1344_G1_0 XI1_I1344_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I100_XG_MN2 (I1_I1344_G4_1n I1_I1344_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I100_XG_MN0 (XI1_I1344_I100_XG_n1 I1_I1344_P4_3 I1_I1344_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I100_XG_MN1 (VSS I1_I1344_G2_1 XI1_I1344_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I98_XG_MN2 (I1_I1298_G2_0n I1_I1298_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I98_XG_MN0 (XI1_I1298_I98_XG_n1 I1_I1298_P2_1 I1_I1298_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I98_XG_MN1 (VSS I1_I1298_G0_0 XI1_I1298_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I100_XG_MN2 (I1_I1298_G4_1n I1_I1298_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I100_XG_MN0 (XI1_I1298_I100_XG_n1 I1_I1298_P4_3 I1_I1298_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I100_XG_MN1 (VSS I1_I1298_G2_1 XI1_I1298_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I174_XG_MN2 (I1_I1160_G23_8n I1_I1160_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I174_XG_MN0 (XI1_I1160_I174_XG_n1 I1_I1160_P23_16 I1_I1160_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I174_XG_MN1 (VSS I1_I1160_G15_8 XI1_I1160_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I166_XG_MN2 (I1_I1160_G15_0n I1_I1160_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I166_XG_MN0 (XI1_I1160_I166_XG_n1 I1_I1160_P15_8 I1_I1160_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I166_XG_MN1 (VSS I1_I1160_G7_0 XI1_I1160_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I179_XG_MN2 (I1_I884_G28_13n I1_I884_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I179_XG_MN0 (XI1_I884_I179_XG_n1 I1_I884_P28_21 I1_I884_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I179_XG_MN1 (VSS I1_I884_G20_13 XI1_I884_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I171_XG_MN2 (I1_I884_G20_5n I1_I884_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I171_XG_MN0 (XI1_I884_I171_XG_n1 I1_I884_P20_13 I1_I884_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I171_XG_MN1 (VSS I1_I884_G12_5 XI1_I884_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I163_XG_MN2 (I1_I884_G12_0n I1_I884_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I163_XG_MN0 (XI1_I884_I163_XG_n1 I1_I884_P12_5 I1_I884_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I163_XG_MN1 (VSS I1_I884_G4_0 XI1_I884_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I169_XG_MN2 (I1_I884_G18_3n I1_I884_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I169_XG_MN0 (XI1_I884_I169_XG_n1 I1_I884_P18_11 I1_I884_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I169_XG_MN1 (VSS I1_I884_G10_3 XI1_I884_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I160_XG_MN2 (I1_I884_G10_0n I1_I884_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I160_XG_MN0 (XI1_I884_I160_XG_n1 I1_I884_P10_3 I1_I884_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I160_XG_MN1 (VSS I1_I884_G2_0np XI1_I884_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I167_XG_MN2 (I1_I884_G16_1n I1_I884_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I167_XG_MN0 (XI1_I884_I167_XG_n1 I1_I884_P16_9 I1_I884_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I167_XG_MN1 (VSS I1_I884_G8_1 XI1_I884_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I157_XG_MN2 (I1_I884_G8_0n I1_I884_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I157_XG_MN0 (XI1_I884_I157_XG_n1 I1_I884_P8_1 I1_I884_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I157_XG_MN1 (VSS I1_I884_G0_0 XI1_I884_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I100_XG_MN2 (I1_I884_G4_1n I1_I884_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I100_XG_MN0 (XI1_I884_I100_XG_n1 I1_I884_P4_3 I1_I884_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I100_XG_MN1 (VSS I1_I884_G2_1 XI1_I884_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I158_XG_MN2 (I1_I700_G9_0n I1_I700_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I158_XG_MN0 (XI1_I700_I158_XG_n1 I1_I700_P9_2 I1_I700_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I158_XG_MN1 (VSS I1_I700_G1_0 XI1_I700_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I107_XG_MN2 (I1_I700_G11_8n I1_I700_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I107_XG_MN0 (XI1_I700_I107_XG_n1 I1_I700_P11_10 I1_I700_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I107_XG_MN1 (VSS I1_I700_G9_8 XI1_I700_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I109_XG_MN2 (I1_I700_G13_10n I1_I700_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I109_XG_MN0 (XI1_I700_I109_XG_n1 I1_I700_P13_12 I1_I700_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I109_XG_MN1 (VSS I1_I700_G11_10 XI1_I700_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I168_XG_MN2 (I1_I700_G17_2n I1_I700_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I168_XG_MN0 (XI1_I700_I168_XG_n1 I1_I700_P17_10 I1_I700_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I168_XG_MN1 (VSS I1_I700_G9_2 XI1_I700_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I111_XG_MN2 (I1_I700_G15_12n I1_I700_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I111_XG_MN0 (XI1_I700_I111_XG_n1 I1_I700_P15_14 I1_I700_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I111_XG_MN1 (VSS I1_I700_G13_12 XI1_I700_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I113_XG_MN2 (I1_I700_G17_14n I1_I700_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I113_XG_MN0 (XI1_I700_I113_XG_n1 I1_I700_P17_16 I1_I700_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I113_XG_MN1 (VSS I1_I700_G15_14 XI1_I700_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I115_XG_MN2 (I1_I700_G19_16n I1_I700_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I115_XG_MN0 (XI1_I700_I115_XG_n1 I1_I700_P19_18 I1_I700_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I115_XG_MN1 (VSS I1_I700_G17_16 XI1_I700_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I176_XG_MN2 (I1_I700_G25_10n I1_I700_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I176_XG_MN0 (XI1_I700_I176_XG_n1 I1_I700_P25_18 I1_I700_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I176_XG_MN1 (VSS I1_I700_G17_10 XI1_I700_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I180_XG_MN2 (I1_I700_G29_14n I1_I700_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I180_XG_MN0 (XI1_I700_I180_XG_n1 I1_I700_P29_22 I1_I700_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I180_XG_MN1 (VSS I1_I700_G21_14 XI1_I700_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I125_XG_MN2 (I1_I700_G29_26n I1_I700_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I125_XG_MN0 (XI1_I700_I125_XG_n1 I1_I700_P29_28 I1_I700_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I125_XG_MN1 (VSS I1_I700_G27_26 XI1_I700_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I127_XG_MN2 (I1_I700_G31_28n I1_I700_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I127_XG_MN0 (XI1_I700_I127_XG_n1 I1_I700_P31_30 I1_I700_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I127_XG_MN1 (VSS I1_I700_G29_28 XI1_I700_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I182_XG_MN2 (I1_I1390_G31_16n I1_I1390_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I182_XG_MN0 (XI1_I1390_I182_XG_n1 I1_I1390_P31_24 I1_I1390_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I182_XG_MN1 (VSS I1_I1390_G23_16 XI1_I1390_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I180_XG_MN2 (I1_I1390_G29_14n I1_I1390_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I180_XG_MN0 (XI1_I1390_I180_XG_n1 I1_I1390_P29_22 I1_I1390_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I180_XG_MN1 (VSS I1_I1390_G21_14 XI1_I1390_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I174_XG_MN2 (I1_I1390_G23_8n I1_I1390_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I174_XG_MN0 (XI1_I1390_I174_XG_n1 I1_I1390_P23_16 I1_I1390_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I174_XG_MN1 (VSS I1_I1390_G15_8 XI1_I1390_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I178_XG_MN2 (I1_I1390_G27_12n I1_I1390_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I178_XG_MN0 (XI1_I1390_I178_XG_n1 I1_I1390_P27_20 I1_I1390_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I178_XG_MN1 (VSS I1_I1390_G19_12 XI1_I1390_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I111_XG_MN2 (I1_I1390_G15_12n I1_I1390_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I111_XG_MN0 (XI1_I1390_I111_XG_n1 I1_I1390_P15_14 I1_I1390_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I111_XG_MN1 (VSS I1_I1390_G13_12 XI1_I1390_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I109_XG_MN2 (I1_I1390_G13_10n I1_I1390_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I109_XG_MN0 (XI1_I1390_I109_XG_n1 I1_I1390_P13_12 I1_I1390_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I109_XG_MN1 (VSS I1_I1390_G11_10 XI1_I1390_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I98_XG_MN2 (I1_I1344_G2_0n I1_I1344_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I98_XG_MN0 (XI1_I1344_I98_XG_n1 I1_I1344_P2_1 I1_I1344_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I98_XG_MN1 (VSS I1_I1344_G0_0 XI1_I1344_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I182_XG_MN2 (I1_I1160_G31_16n I1_I1160_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I182_XG_MN0 (XI1_I1160_I182_XG_n1 I1_I1160_P31_24 I1_I1160_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I182_XG_MN1 (VSS I1_I1160_G23_16 XI1_I1160_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I180_XG_MN2 (I1_I1160_G29_14n I1_I1160_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I180_XG_MN0 (XI1_I1160_I180_XG_n1 I1_I1160_P29_22 I1_I1160_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I180_XG_MN1 (VSS I1_I1160_G21_14 XI1_I1160_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I172_XG_MN2 (I1_I1160_G21_6n I1_I1160_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I172_XG_MN0 (XI1_I1160_I172_XG_n1 I1_I1160_P21_14 I1_I1160_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I172_XG_MN1 (VSS I1_I1160_G13_6 XI1_I1160_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I164_XG_MN2 (I1_I1160_G13_0n I1_I1160_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I164_XG_MN0 (XI1_I1160_I164_XG_n1 I1_I1160_P13_6 I1_I1160_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I164_XG_MN1 (VSS I1_I1160_G5_0 XI1_I1160_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I176_XG_MN2 (I1_I1160_G25_10n I1_I1160_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I176_XG_MN0 (XI1_I1160_I176_XG_n1 I1_I1160_P25_18 I1_I1160_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I176_XG_MN1 (VSS I1_I1160_G17_10 XI1_I1160_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I168_XG_MN2 (I1_I1160_G17_2n I1_I1160_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I168_XG_MN0 (XI1_I1160_I168_XG_n1 I1_I1160_P17_10 I1_I1160_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I168_XG_MN1 (VSS I1_I1160_G9_2 XI1_I1160_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I158_XG_MN2 (I1_I1160_G9_0n I1_I1160_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I158_XG_MN0 (XI1_I1160_I158_XG_n1 I1_I1160_P9_2 I1_I1160_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I158_XG_MN1 (VSS I1_I1160_G1_0 XI1_I1160_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I98_XG_MN2 (I1_I884_G2_0n I1_I884_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I98_XG_MN0 (XI1_I884_I98_XG_n1 I1_I884_P2_1 I1_I884_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I98_XG_MN1 (VSS I1_I884_G0_0 XI1_I884_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I99_XG_MN2 (I1_I700_G3_0n I1_I700_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I99_XG_MN0 (XI1_I700_I99_XG_n1 I1_I700_P3_2 I1_I700_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I99_XG_MN1 (VSS I1_I700_G1_0 XI1_I700_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I101_XG_MN2 (I1_I700_G5_2n I1_I700_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I101_XG_MN0 (XI1_I700_I101_XG_n1 I1_I700_P5_4 I1_I700_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I101_XG_MN1 (VSS I1_I700_G3_2 XI1_I700_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I103_XG_MN2 (I1_I700_G7_4n I1_I700_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I103_XG_MN0 (XI1_I700_I103_XG_n1 I1_I700_P7_6 I1_I700_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I103_XG_MN1 (VSS I1_I700_G5_4 XI1_I700_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I105_XG_MN2 (I1_I700_G9_6n I1_I700_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I105_XG_MN0 (XI1_I700_I105_XG_n1 I1_I700_P9_8 I1_I700_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I105_XG_MN1 (VSS I1_I700_G7_6 XI1_I700_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I117_XG_MN2 (I1_I700_G21_18n I1_I700_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I117_XG_MN0 (XI1_I700_I117_XG_n1 I1_I700_P21_20 I1_I700_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I117_XG_MN1 (VSS I1_I700_G19_18 XI1_I700_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I119_XG_MN2 (I1_I700_G23_20n I1_I700_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I119_XG_MN0 (XI1_I700_I119_XG_n1 I1_I700_P23_22 I1_I700_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I119_XG_MN1 (VSS I1_I700_G21_20 XI1_I700_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I121_XG_MN2 (I1_I700_G25_22n I1_I700_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I121_XG_MN0 (XI1_I700_I121_XG_n1 I1_I700_P25_24 I1_I700_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I121_XG_MN1 (VSS I1_I700_G23_22 XI1_I700_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I123_XG_MN2 (I1_I700_G27_24n I1_I700_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I123_XG_MN0 (XI1_I700_I123_XG_n1 I1_I700_P27_26 I1_I700_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I123_XG_MN1 (VSS I1_I700_G25_24 XI1_I700_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I126_XG_MN2 (I1_I1390_G30_27n I1_I1390_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I126_XG_MN0 (XI1_I1390_I126_XG_n1 I1_I1390_P30_29 I1_I1390_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I126_XG_MN1 (VSS I1_I1390_G28_27 XI1_I1390_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I124_XG_MN2 (I1_I1390_G28_25n I1_I1390_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I124_XG_MN0 (XI1_I1390_I124_XG_n1 I1_I1390_P28_27 I1_I1390_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I124_XG_MN1 (VSS I1_I1390_G26_25 XI1_I1390_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I166_XG_MN2 (I1_I1390_G15_0n I1_I1390_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I166_XG_MN0 (XI1_I1390_I166_XG_n1 I1_I1390_P15_8 I1_I1390_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I166_XG_MN1 (VSS I1_I1390_G7_0 XI1_I1390_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I170_XG_MN2 (I1_I1390_G19_4n I1_I1390_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I170_XG_MN0 (XI1_I1390_I170_XG_n1 I1_I1390_P19_12 I1_I1390_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I170_XG_MN1 (VSS I1_I1390_G11_4 XI1_I1390_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I164_XG_MN2 (I1_I1390_G13_0n I1_I1390_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I164_XG_MN0 (XI1_I1390_I164_XG_n1 I1_I1390_P13_6 I1_I1390_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I164_XG_MN1 (VSS I1_I1390_G5_0 XI1_I1390_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I162_XG_MN2 (I1_I1390_G11_0n I1_I1390_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I162_XG_MN0 (XI1_I1390_I162_XG_n1 I1_I1390_P11_4 I1_I1390_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I162_XG_MN1 (VSS I1_I1390_G3_0np XI1_I1390_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I107_XG_MN2 (I1_I1390_G11_8n I1_I1390_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I107_XG_MN0 (XI1_I1390_I107_XG_n1 I1_I1390_P11_10 I1_I1390_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I107_XG_MN1 (VSS I1_I1390_G9_8 XI1_I1390_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I105_XG_MN2 (I1_I1390_G9_6n I1_I1390_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I105_XG_MN0 (XI1_I1390_I105_XG_n1 I1_I1390_P9_8 I1_I1390_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I105_XG_MN1 (VSS I1_I1390_G7_6 XI1_I1390_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I127_XG_MN2 (I1_I1160_G31_28n I1_I1160_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I127_XG_MN0 (XI1_I1160_I127_XG_n1 I1_I1160_P31_30 I1_I1160_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I127_XG_MN1 (VSS I1_I1160_G29_28 XI1_I1160_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I125_XG_MN2 (I1_I1160_G29_26n I1_I1160_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I125_XG_MN0 (XI1_I1160_I125_XG_n1 I1_I1160_P29_28 I1_I1160_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I125_XG_MN1 (VSS I1_I1160_G27_26 XI1_I1160_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I123_XG_MN2 (I1_I1160_G27_24n I1_I1160_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I123_XG_MN0 (XI1_I1160_I123_XG_n1 I1_I1160_P27_26 I1_I1160_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I123_XG_MN1 (VSS I1_I1160_G25_24 XI1_I1160_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I117_XG_MN2 (I1_I1160_G21_18n I1_I1160_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I117_XG_MN0 (XI1_I1160_I117_XG_n1 I1_I1160_P21_20 I1_I1160_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I117_XG_MN1 (VSS I1_I1160_G19_18 XI1_I1160_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I115_XG_MN2 (I1_I1160_G19_16n I1_I1160_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I115_XG_MN0 (XI1_I1160_I115_XG_n1 I1_I1160_P19_18 I1_I1160_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I115_XG_MN1 (VSS I1_I1160_G17_16 XI1_I1160_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I113_XG_MN2 (I1_I1160_G17_14n I1_I1160_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I113_XG_MN0 (XI1_I1160_I113_XG_n1 I1_I1160_P17_16 I1_I1160_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I113_XG_MN1 (VSS I1_I1160_G15_14 XI1_I1160_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I111_XG_MN2 (I1_I1160_G15_12n I1_I1160_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I111_XG_MN0 (XI1_I1160_I111_XG_n1 I1_I1160_P15_14 I1_I1160_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I111_XG_MN1 (VSS I1_I1160_G13_12 XI1_I1160_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I109_XG_MN2 (I1_I1160_G13_10n I1_I1160_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I109_XG_MN0 (XI1_I1160_I109_XG_n1 I1_I1160_P13_12 I1_I1160_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I109_XG_MN1 (VSS I1_I1160_G11_10 XI1_I1160_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I107_XG_MN2 (I1_I1160_G11_8n I1_I1160_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I107_XG_MN0 (XI1_I1160_I107_XG_n1 I1_I1160_P11_10 I1_I1160_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I107_XG_MN1 (VSS I1_I1160_G9_8 XI1_I1160_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I105_XG_MN2 (I1_I1160_G9_6n I1_I1160_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I105_XG_MN0 (XI1_I1160_I105_XG_n1 I1_I1160_P9_8 I1_I1160_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I105_XG_MN1 (VSS I1_I1160_G7_6 XI1_I1160_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I103_XG_MN2 (I1_I1160_G7_4n I1_I1160_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I103_XG_MN0 (XI1_I1160_I103_XG_n1 I1_I1160_P7_6 I1_I1160_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I103_XG_MN1 (VSS I1_I1160_G5_4 XI1_I1160_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I101_XG_MN2 (I1_I1160_G5_2n I1_I1160_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I101_XG_MN0 (XI1_I1160_I101_XG_n1 I1_I1160_P5_4 I1_I1160_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I101_XG_MN1 (VSS I1_I1160_G3_2 XI1_I1160_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I99_XG_MN2 (I1_I1160_G3_0n I1_I1160_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I99_XG_MN0 (XI1_I1160_I99_XG_n1 I1_I1160_P3_2 I1_I1160_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I99_XG_MN1 (VSS I1_I1160_G1_0 XI1_I1160_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I98_XG_MN2 (I1_I700_G2_0n I1_I700_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I98_XG_MN0 (XI1_I700_I98_XG_n1 I1_I700_P2_1 I1_I700_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I98_XG_MN1 (VSS I1_I700_G0_0 XI1_I700_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I100_XG_MN2 (I1_I700_G4_1n I1_I700_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I100_XG_MN0 (XI1_I700_I100_XG_n1 I1_I700_P4_3 I1_I700_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I100_XG_MN1 (VSS I1_I700_G2_1 XI1_I700_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I157_XG_MN2 (I1_I700_G8_0n I1_I700_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I157_XG_MN0 (XI1_I700_I157_XG_n1 I1_I700_P8_1 I1_I700_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I157_XG_MN1 (VSS I1_I700_G0_0 XI1_I700_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I160_XG_MN2 (I1_I700_G10_0n I1_I700_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I160_XG_MN0 (XI1_I700_I160_XG_n1 I1_I700_P10_3 I1_I700_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I160_XG_MN1 (VSS I1_I700_G2_0np XI1_I700_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I169_XG_MN2 (I1_I700_G18_3n I1_I700_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I169_XG_MN0 (XI1_I700_I169_XG_n1 I1_I700_P18_11 I1_I700_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I169_XG_MN1 (VSS I1_I700_G10_3 XI1_I700_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I163_XG_MN2 (I1_I700_G12_0n I1_I700_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I163_XG_MN0 (XI1_I700_I163_XG_n1 I1_I700_P12_5 I1_I700_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I163_XG_MN1 (VSS I1_I700_G4_0 XI1_I700_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I171_XG_MN2 (I1_I700_G20_5n I1_I700_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I171_XG_MN0 (XI1_I700_I171_XG_n1 I1_I700_P20_13 I1_I700_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I171_XG_MN1 (VSS I1_I700_G12_5 XI1_I700_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I165_XG_MN2 (I1_I700_G14_0n I1_I700_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I165_XG_MN0 (XI1_I700_I165_XG_n1 I1_I700_P14_7 I1_I700_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I165_XG_MN1 (VSS I1_I700_G6_0 XI1_I700_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I177_XG_MN2 (I1_I700_G26_11n I1_I700_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I177_XG_MN0 (XI1_I700_I177_XG_n1 I1_I700_P26_19 I1_I700_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I177_XG_MN1 (VSS I1_I700_G18_11 XI1_I700_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I173_XG_MN2 (I1_I700_G22_7n I1_I700_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I173_XG_MN0 (XI1_I700_I173_XG_n1 I1_I700_P22_15 I1_I700_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I173_XG_MN1 (VSS I1_I700_G14_7 XI1_I700_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I179_XG_MN2 (I1_I700_G28_13n I1_I700_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I179_XG_MN0 (XI1_I700_I179_XG_n1 I1_I700_P28_21 I1_I700_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I179_XG_MN1 (VSS I1_I700_G20_13 XI1_I700_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I181_XG_MN2 (I1_I700_G30_15n I1_I700_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I181_XG_MN0 (XI1_I700_I181_XG_n1 I1_I700_P30_23 I1_I700_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I181_XG_MN1 (VSS I1_I700_G22_15 XI1_I700_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I126_XG_MN2 (I1_I700_G30_27n I1_I700_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I126_XG_MN0 (XI1_I700_I126_XG_n1 I1_I700_P30_29 I1_I700_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I126_XG_MN1 (VSS I1_I700_G28_27 XI1_I700_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I122_XG_MN2 (I1_I1390_G26_23n I1_I1390_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I122_XG_MN0 (XI1_I1390_I122_XG_n1 I1_I1390_P26_25 I1_I1390_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I122_XG_MN1 (VSS I1_I1390_G24_23 XI1_I1390_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I120_XG_MN2 (I1_I1390_G24_21n I1_I1390_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I120_XG_MN0 (XI1_I1390_I120_XG_n1 I1_I1390_P24_23 I1_I1390_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I120_XG_MN1 (VSS I1_I1390_G22_21 XI1_I1390_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I118_XG_MN2 (I1_I1390_G22_19n I1_I1390_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I118_XG_MN0 (XI1_I1390_I118_XG_n1 I1_I1390_P22_21 I1_I1390_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I118_XG_MN1 (VSS I1_I1390_G20_19 XI1_I1390_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I116_XG_MN2 (I1_I1390_G20_17n I1_I1390_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I116_XG_MN0 (XI1_I1390_I116_XG_n1 I1_I1390_P20_19 I1_I1390_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I116_XG_MN1 (VSS I1_I1390_G18_17 XI1_I1390_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I112_XG_MN2 (I1_I1390_G16_13n I1_I1390_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I112_XG_MN0 (XI1_I1390_I112_XG_n1 I1_I1390_P16_15 I1_I1390_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I112_XG_MN1 (VSS I1_I1390_G14_13 XI1_I1390_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I168_XG_MN2 (I1_I1390_G17_2n I1_I1390_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I168_XG_MN0 (XI1_I1390_I168_XG_n1 I1_I1390_P17_10 I1_I1390_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I168_XG_MN1 (VSS I1_I1390_G9_2 XI1_I1390_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I158_XG_MN2 (I1_I1390_G9_0n I1_I1390_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I158_XG_MN0 (XI1_I1390_I158_XG_n1 I1_I1390_P9_2 I1_I1390_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I158_XG_MN1 (VSS I1_I1390_G1_0 XI1_I1390_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I103_XG_MN2 (I1_I1390_G7_4n I1_I1390_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I103_XG_MN0 (XI1_I1390_I103_XG_n1 I1_I1390_P7_6 I1_I1390_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I103_XG_MN1 (VSS I1_I1390_G5_4 XI1_I1390_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I126_XG_MN2 (I1_I1160_G30_27n I1_I1160_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I126_XG_MN0 (XI1_I1160_I126_XG_n1 I1_I1160_P30_29 I1_I1160_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I126_XG_MN1 (VSS I1_I1160_G28_27 XI1_I1160_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I181_XG_MN2 (I1_I1160_G30_15n I1_I1160_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I181_XG_MN0 (XI1_I1160_I181_XG_n1 I1_I1160_P30_23 I1_I1160_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I181_XG_MN1 (VSS I1_I1160_G22_15 XI1_I1160_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I163_XG_MN2 (I1_I1160_G12_0n I1_I1160_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I163_XG_MN0 (XI1_I1160_I163_XG_n1 I1_I1160_P12_5 I1_I1160_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I163_XG_MN1 (VSS I1_I1160_G4_0 XI1_I1160_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I157_XG_MN2 (I1_I1160_G8_0n I1_I1160_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I157_XG_MN0 (XI1_I1160_I157_XG_n1 I1_I1160_P8_1 I1_I1160_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I157_XG_MN1 (VSS I1_I1160_G0_0 XI1_I1160_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I125_XG_MN2 (I1_I930_G29_26n I1_I930_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I125_XG_MN0 (XI1_I930_I125_XG_n1 I1_I930_P29_28 I1_I930_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I125_XG_MN1 (VSS I1_I930_G27_26 XI1_I930_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I123_XG_MN2 (I1_I930_G27_24n I1_I930_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I123_XG_MN0 (XI1_I930_I123_XG_n1 I1_I930_P27_26 I1_I930_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I123_XG_MN1 (VSS I1_I930_G25_24 XI1_I930_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I121_XG_MN2 (I1_I930_G25_22n I1_I930_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I121_XG_MN0 (XI1_I930_I121_XG_n1 I1_I930_P25_24 I1_I930_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I121_XG_MN1 (VSS I1_I930_G23_22 XI1_I930_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I119_XG_MN2 (I1_I930_G23_20n I1_I930_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I119_XG_MN0 (XI1_I930_I119_XG_n1 I1_I930_P23_22 I1_I930_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I119_XG_MN1 (VSS I1_I930_G21_20 XI1_I930_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I117_XG_MN2 (I1_I930_G21_18n I1_I930_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I117_XG_MN0 (XI1_I930_I117_XG_n1 I1_I930_P21_20 I1_I930_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I117_XG_MN1 (VSS I1_I930_G19_18 XI1_I930_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I115_XG_MN2 (I1_I930_G19_16n I1_I930_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I115_XG_MN0 (XI1_I930_I115_XG_n1 I1_I930_P19_18 I1_I930_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I115_XG_MN1 (VSS I1_I930_G17_16 XI1_I930_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I113_XG_MN2 (I1_I930_G17_14n I1_I930_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I113_XG_MN0 (XI1_I930_I113_XG_n1 I1_I930_P17_16 I1_I930_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I113_XG_MN1 (VSS I1_I930_G15_14 XI1_I930_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I111_XG_MN2 (I1_I930_G15_12n I1_I930_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I111_XG_MN0 (XI1_I930_I111_XG_n1 I1_I930_P15_14 I1_I930_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I111_XG_MN1 (VSS I1_I930_G13_12 XI1_I930_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I109_XG_MN2 (I1_I930_G13_10n I1_I930_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I109_XG_MN0 (XI1_I930_I109_XG_n1 I1_I930_P13_12 I1_I930_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I109_XG_MN1 (VSS I1_I930_G11_10 XI1_I930_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I107_XG_MN2 (I1_I930_G11_8n I1_I930_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I107_XG_MN0 (XI1_I930_I107_XG_n1 I1_I930_P11_10 I1_I930_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I107_XG_MN1 (VSS I1_I930_G9_8 XI1_I930_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I102_XG_MN2 (I1_I700_G6_3n I1_I700_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I102_XG_MN0 (XI1_I700_I102_XG_n1 I1_I700_P6_5 I1_I700_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I102_XG_MN1 (VSS I1_I700_G4_3 XI1_I700_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I104_XG_MN2 (I1_I700_G8_5n I1_I700_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I104_XG_MN0 (XI1_I700_I104_XG_n1 I1_I700_P8_7 I1_I700_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I104_XG_MN1 (VSS I1_I700_G6_5 XI1_I700_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I167_XG_MN2 (I1_I700_G16_1n I1_I700_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I167_XG_MN0 (XI1_I700_I167_XG_n1 I1_I700_P16_9 I1_I700_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I167_XG_MN1 (VSS I1_I700_G8_1 XI1_I700_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I106_XG_MN2 (I1_I700_G10_7n I1_I700_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I106_XG_MN0 (XI1_I700_I106_XG_n1 I1_I700_P10_9 I1_I700_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I106_XG_MN1 (VSS I1_I700_G8_7 XI1_I700_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I108_XG_MN2 (I1_I700_G12_9n I1_I700_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I108_XG_MN0 (XI1_I700_I108_XG_n1 I1_I700_P12_11 I1_I700_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I108_XG_MN1 (VSS I1_I700_G10_9 XI1_I700_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I175_XG_MN2 (I1_I700_G24_9n I1_I700_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I175_XG_MN0 (XI1_I700_I175_XG_n1 I1_I700_P24_17 I1_I700_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I175_XG_MN1 (VSS I1_I700_G16_9 XI1_I700_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I112_XG_MN2 (I1_I700_G16_13n I1_I700_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I112_XG_MN0 (XI1_I700_I112_XG_n1 I1_I700_P16_15 I1_I700_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I112_XG_MN1 (VSS I1_I700_G14_13 XI1_I700_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I114_XG_MN2 (I1_I700_G18_15n I1_I700_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I114_XG_MN0 (XI1_I700_I114_XG_n1 I1_I700_P18_17 I1_I700_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I114_XG_MN1 (VSS I1_I700_G16_15 XI1_I700_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I116_XG_MN2 (I1_I700_G20_17n I1_I700_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I116_XG_MN0 (XI1_I700_I116_XG_n1 I1_I700_P20_19 I1_I700_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I116_XG_MN1 (VSS I1_I700_G18_17 XI1_I700_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I118_XG_MN2 (I1_I700_G22_19n I1_I700_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I118_XG_MN0 (XI1_I700_I118_XG_n1 I1_I700_P22_21 I1_I700_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I118_XG_MN1 (VSS I1_I700_G20_19 XI1_I700_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I120_XG_MN2 (I1_I700_G24_21n I1_I700_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I120_XG_MN0 (XI1_I700_I120_XG_n1 I1_I700_P24_23 I1_I700_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I120_XG_MN1 (VSS I1_I700_G22_21 XI1_I700_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I122_XG_MN2 (I1_I700_G26_23n I1_I700_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I122_XG_MN0 (XI1_I700_I122_XG_n1 I1_I700_P26_25 I1_I700_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I122_XG_MN1 (VSS I1_I700_G24_23 XI1_I700_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I124_XG_MN2 (I1_I700_G28_25n I1_I700_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I124_XG_MN0 (XI1_I700_I124_XG_n1 I1_I700_P28_27 I1_I700_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I124_XG_MN1 (VSS I1_I700_G26_25 XI1_I700_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I181_XG_MN2 (I1_I1390_G30_15n I1_I1390_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I181_XG_MN0 (XI1_I1390_I181_XG_n1 I1_I1390_P30_23 I1_I1390_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I181_XG_MN1 (VSS I1_I1390_G22_15 XI1_I1390_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I179_XG_MN2 (I1_I1390_G28_13n I1_I1390_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I179_XG_MN0 (XI1_I1390_I179_XG_n1 I1_I1390_P28_21 I1_I1390_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I179_XG_MN1 (VSS I1_I1390_G20_13 XI1_I1390_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I173_XG_MN2 (I1_I1390_G22_7n I1_I1390_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I173_XG_MN0 (XI1_I1390_I173_XG_n1 I1_I1390_P22_15 I1_I1390_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I173_XG_MN1 (VSS I1_I1390_G14_7 XI1_I1390_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I177_XG_MN2 (I1_I1390_G26_11n I1_I1390_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I177_XG_MN0 (XI1_I1390_I177_XG_n1 I1_I1390_P26_19 I1_I1390_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I177_XG_MN1 (VSS I1_I1390_G18_11 XI1_I1390_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I114_XG_MN2 (I1_I1390_G18_15n I1_I1390_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I114_XG_MN0 (XI1_I1390_I114_XG_n1 I1_I1390_P18_17 I1_I1390_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I114_XG_MN1 (VSS I1_I1390_G16_15 XI1_I1390_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I110_XG_MN2 (I1_I1390_G14_11n I1_I1390_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I110_XG_MN0 (XI1_I1390_I110_XG_n1 I1_I1390_P14_13 I1_I1390_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I110_XG_MN1 (VSS I1_I1390_G12_11 XI1_I1390_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I108_XG_MN2 (I1_I1390_G12_9n I1_I1390_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I108_XG_MN0 (XI1_I1390_I108_XG_n1 I1_I1390_P12_11 I1_I1390_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I108_XG_MN1 (VSS I1_I1390_G10_9 XI1_I1390_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I106_XG_MN2 (I1_I1390_G10_7n I1_I1390_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I106_XG_MN0 (XI1_I1390_I106_XG_n1 I1_I1390_P10_9 I1_I1390_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I106_XG_MN1 (VSS I1_I1390_G8_7 XI1_I1390_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I104_XG_MN2 (I1_I1390_G8_5n I1_I1390_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I104_XG_MN0 (XI1_I1390_I104_XG_n1 I1_I1390_P8_7 I1_I1390_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I104_XG_MN1 (VSS I1_I1390_G6_5 XI1_I1390_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I101_XG_MN2 (I1_I1390_G5_2n I1_I1390_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I101_XG_MN0 (XI1_I1390_I101_XG_n1 I1_I1390_P5_4 I1_I1390_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I101_XG_MN1 (VSS I1_I1390_G3_2 XI1_I1390_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I124_XG_MN2 (I1_I1160_G28_25n I1_I1160_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I124_XG_MN0 (XI1_I1160_I124_XG_n1 I1_I1160_P28_27 I1_I1160_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I124_XG_MN1 (VSS I1_I1160_G26_25 XI1_I1160_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I122_XG_MN2 (I1_I1160_G26_23n I1_I1160_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I122_XG_MN0 (XI1_I1160_I122_XG_n1 I1_I1160_P26_25 I1_I1160_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I122_XG_MN1 (VSS I1_I1160_G24_23 XI1_I1160_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I173_XG_MN2 (I1_I1160_G22_7n I1_I1160_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I173_XG_MN0 (XI1_I1160_I173_XG_n1 I1_I1160_P22_15 I1_I1160_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I173_XG_MN1 (VSS I1_I1160_G14_7 XI1_I1160_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I165_XG_MN2 (I1_I1160_G14_0n I1_I1160_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I165_XG_MN0 (XI1_I1160_I165_XG_n1 I1_I1160_P14_7 I1_I1160_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I165_XG_MN1 (VSS I1_I1160_G6_0 XI1_I1160_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I179_XG_MN2 (I1_I1160_G28_13n I1_I1160_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I179_XG_MN0 (XI1_I1160_I179_XG_n1 I1_I1160_P28_21 I1_I1160_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I179_XG_MN1 (VSS I1_I1160_G20_13 XI1_I1160_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I177_XG_MN2 (I1_I1160_G26_11n I1_I1160_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I177_XG_MN0 (XI1_I1160_I177_XG_n1 I1_I1160_P26_19 I1_I1160_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I177_XG_MN1 (VSS I1_I1160_G18_11 XI1_I1160_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I171_XG_MN2 (I1_I1160_G20_5n I1_I1160_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I171_XG_MN0 (XI1_I1160_I171_XG_n1 I1_I1160_P20_13 I1_I1160_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I171_XG_MN1 (VSS I1_I1160_G12_5 XI1_I1160_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I160_XG_MN2 (I1_I1160_G10_0n I1_I1160_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I160_XG_MN0 (XI1_I1160_I160_XG_n1 I1_I1160_P10_3 I1_I1160_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I160_XG_MN1 (VSS I1_I1160_G2_0np XI1_I1160_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I175_XG_MN2 (I1_I1160_G24_9n I1_I1160_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I175_XG_MN0 (XI1_I1160_I175_XG_n1 I1_I1160_P24_17 I1_I1160_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I175_XG_MN1 (VSS I1_I1160_G16_9 XI1_I1160_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I167_XG_MN2 (I1_I1160_G16_1n I1_I1160_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I167_XG_MN0 (XI1_I1160_I167_XG_n1 I1_I1160_P16_9 I1_I1160_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I167_XG_MN1 (VSS I1_I1160_G8_1 XI1_I1160_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I100_XG_MN2 (I1_I1160_G4_1n I1_I1160_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I100_XG_MN0 (XI1_I1160_I100_XG_n1 I1_I1160_P4_3 I1_I1160_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I100_XG_MN1 (VSS I1_I1160_G2_1 XI1_I1160_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I98_XG_MN2 (I1_I1160_G2_0n I1_I1160_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I98_XG_MN0 (XI1_I1160_I98_XG_n1 I1_I1160_P2_1 I1_I1160_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I98_XG_MN1 (VSS I1_I1160_G0_0 XI1_I1160_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I127_XG_MN2 (I1_I930_G31_28n I1_I930_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I127_XG_MN0 (XI1_I930_I127_XG_n1 I1_I930_P31_30 I1_I930_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I127_XG_MN1 (VSS I1_I930_G29_28 XI1_I930_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I182_XG_MN2 (I1_I930_G31_16n I1_I930_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I182_XG_MN0 (XI1_I930_I182_XG_n1 I1_I930_P31_24 I1_I930_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I182_XG_MN1 (VSS I1_I930_G23_16 XI1_I930_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I180_XG_MN2 (I1_I930_G29_14n I1_I930_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I180_XG_MN0 (XI1_I930_I180_XG_n1 I1_I930_P29_22 I1_I930_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I180_XG_MN1 (VSS I1_I930_G21_14 XI1_I930_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I178_XG_MN2 (I1_I930_G27_12n I1_I930_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I178_XG_MN0 (XI1_I930_I178_XG_n1 I1_I930_P27_20 I1_I930_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I178_XG_MN1 (VSS I1_I930_G19_12 XI1_I930_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I174_XG_MN2 (I1_I930_G23_8n I1_I930_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I174_XG_MN0 (XI1_I930_I174_XG_n1 I1_I930_P23_16 I1_I930_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I174_XG_MN1 (VSS I1_I930_G15_8 XI1_I930_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I166_XG_MN2 (I1_I930_G15_0n I1_I930_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I166_XG_MN0 (XI1_I930_I166_XG_n1 I1_I930_P15_8 I1_I930_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I166_XG_MN1 (VSS I1_I930_G7_0 XI1_I930_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I172_XG_MN2 (I1_I930_G21_6n I1_I930_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I172_XG_MN0 (XI1_I930_I172_XG_n1 I1_I930_P21_14 I1_I930_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I172_XG_MN1 (VSS I1_I930_G13_6 XI1_I930_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I176_XG_MN2 (I1_I930_G25_10n I1_I930_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I176_XG_MN0 (XI1_I930_I176_XG_n1 I1_I930_P25_18 I1_I930_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I176_XG_MN1 (VSS I1_I930_G17_10 XI1_I930_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I170_XG_MN2 (I1_I930_G19_4n I1_I930_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I170_XG_MN0 (XI1_I930_I170_XG_n1 I1_I930_P19_12 I1_I930_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I170_XG_MN1 (VSS I1_I930_G11_4 XI1_I930_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I168_XG_MN2 (I1_I930_G17_2n I1_I930_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I168_XG_MN0 (XI1_I930_I168_XG_n1 I1_I930_P17_10 I1_I930_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I168_XG_MN1 (VSS I1_I930_G9_2 XI1_I930_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I105_XG_MN2 (I1_I930_G9_6n I1_I930_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I105_XG_MN0 (XI1_I930_I105_XG_n1 I1_I930_P9_8 I1_I930_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I105_XG_MN1 (VSS I1_I930_G7_6 XI1_I930_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I103_XG_MN2 (I1_I930_G7_4n I1_I930_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I103_XG_MN0 (XI1_I930_I103_XG_n1 I1_I930_P7_6 I1_I930_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I103_XG_MN1 (VSS I1_I930_G5_4 XI1_I930_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I700_I110_XG_MN2 (I1_I700_G14_11n I1_I700_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I700_I110_XG_MN0 (XI1_I700_I110_XG_n1 I1_I700_P14_13 I1_I700_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I700_I110_XG_MN1 (VSS I1_I700_G12_11 XI1_I700_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I165_XG_MN2 (I1_I1390_G14_0n I1_I1390_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I165_XG_MN0 (XI1_I1390_I165_XG_n1 I1_I1390_P14_7 I1_I1390_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I165_XG_MN1 (VSS I1_I1390_G6_0 XI1_I1390_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I175_XG_MN2 (I1_I1390_G24_9n I1_I1390_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I175_XG_MN0 (XI1_I1390_I175_XG_n1 I1_I1390_P24_17 I1_I1390_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I175_XG_MN1 (VSS I1_I1390_G16_9 XI1_I1390_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I171_XG_MN2 (I1_I1390_G20_5n I1_I1390_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I171_XG_MN0 (XI1_I1390_I171_XG_n1 I1_I1390_P20_13 I1_I1390_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I171_XG_MN1 (VSS I1_I1390_G12_5 XI1_I1390_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I163_XG_MN2 (I1_I1390_G12_0n I1_I1390_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I163_XG_MN0 (XI1_I1390_I163_XG_n1 I1_I1390_P12_5 I1_I1390_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I163_XG_MN1 (VSS I1_I1390_G4_0 XI1_I1390_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I169_XG_MN2 (I1_I1390_G18_3n I1_I1390_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I169_XG_MN0 (XI1_I1390_I169_XG_n1 I1_I1390_P18_11 I1_I1390_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I169_XG_MN1 (VSS I1_I1390_G10_3 XI1_I1390_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I160_XG_MN2 (I1_I1390_G10_0n I1_I1390_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I160_XG_MN0 (XI1_I1390_I160_XG_n1 I1_I1390_P10_3 I1_I1390_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I160_XG_MN1 (VSS I1_I1390_G2_0np XI1_I1390_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I167_XG_MN2 (I1_I1390_G16_1n I1_I1390_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I167_XG_MN0 (XI1_I1390_I167_XG_n1 I1_I1390_P16_9 I1_I1390_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I167_XG_MN1 (VSS I1_I1390_G8_1 XI1_I1390_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I102_XG_MN2 (I1_I1390_G6_3n I1_I1390_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I102_XG_MN0 (XI1_I1390_I102_XG_n1 I1_I1390_P6_5 I1_I1390_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I102_XG_MN1 (VSS I1_I1390_G4_3 XI1_I1390_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I99_XG_MN2 (I1_I1390_G3_0n I1_I1390_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I99_XG_MN0 (XI1_I1390_I99_XG_n1 I1_I1390_P3_2 I1_I1390_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I99_XG_MN1 (VSS I1_I1390_G1_0 XI1_I1390_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I120_XG_MN2 (I1_I1160_G24_21n I1_I1160_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I120_XG_MN0 (XI1_I1160_I120_XG_n1 I1_I1160_P24_23 I1_I1160_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I120_XG_MN1 (VSS I1_I1160_G22_21 XI1_I1160_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I118_XG_MN2 (I1_I1160_G22_19n I1_I1160_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I118_XG_MN0 (XI1_I1160_I118_XG_n1 I1_I1160_P22_21 I1_I1160_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I118_XG_MN1 (VSS I1_I1160_G20_19 XI1_I1160_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I116_XG_MN2 (I1_I1160_G20_17n I1_I1160_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I116_XG_MN0 (XI1_I1160_I116_XG_n1 I1_I1160_P20_19 I1_I1160_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I116_XG_MN1 (VSS I1_I1160_G18_17 XI1_I1160_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I169_XG_MN2 (I1_I1160_G18_3n I1_I1160_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I169_XG_MN0 (XI1_I1160_I169_XG_n1 I1_I1160_P18_11 I1_I1160_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I169_XG_MN1 (VSS I1_I1160_G10_3 XI1_I1160_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I106_XG_MN2 (I1_I1160_G10_7n I1_I1160_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I106_XG_MN0 (XI1_I1160_I106_XG_n1 I1_I1160_P10_9 I1_I1160_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I106_XG_MN1 (VSS I1_I1160_G8_7 XI1_I1160_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I104_XG_MN2 (I1_I1160_G8_5n I1_I1160_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I104_XG_MN0 (XI1_I1160_I104_XG_n1 I1_I1160_P8_7 I1_I1160_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I104_XG_MN1 (VSS I1_I1160_G6_5 XI1_I1160_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I102_XG_MN2 (I1_I1160_G6_3n I1_I1160_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1160_I102_XG_MN0 (XI1_I1160_I102_XG_n1 I1_I1160_P6_5 I1_I1160_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1160_I102_XG_MN1 (VSS I1_I1160_G4_3 XI1_I1160_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I126_XG_MN2 (I1_I930_G30_27n I1_I930_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I126_XG_MN0 (XI1_I930_I126_XG_n1 I1_I930_P30_29 I1_I930_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I126_XG_MN1 (VSS I1_I930_G28_27 XI1_I930_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I124_XG_MN2 (I1_I930_G28_25n I1_I930_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I124_XG_MN0 (XI1_I930_I124_XG_n1 I1_I930_P28_27 I1_I930_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I124_XG_MN1 (VSS I1_I930_G26_25 XI1_I930_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I122_XG_MN2 (I1_I930_G26_23n I1_I930_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I122_XG_MN0 (XI1_I930_I122_XG_n1 I1_I930_P26_25 I1_I930_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I122_XG_MN1 (VSS I1_I930_G24_23 XI1_I930_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I120_XG_MN2 (I1_I930_G24_21n I1_I930_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I120_XG_MN0 (XI1_I930_I120_XG_n1 I1_I930_P24_23 I1_I930_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I120_XG_MN1 (VSS I1_I930_G22_21 XI1_I930_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I118_XG_MN2 (I1_I930_G22_19n I1_I930_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I118_XG_MN0 (XI1_I930_I118_XG_n1 I1_I930_P22_21 I1_I930_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I118_XG_MN1 (VSS I1_I930_G20_19 XI1_I930_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I114_XG_MN2 (I1_I930_G18_15n I1_I930_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I114_XG_MN0 (XI1_I930_I114_XG_n1 I1_I930_P18_17 I1_I930_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I114_XG_MN1 (VSS I1_I930_G16_15 XI1_I930_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I112_XG_MN2 (I1_I930_G16_13n I1_I930_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I112_XG_MN0 (XI1_I930_I112_XG_n1 I1_I930_P16_15 I1_I930_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I112_XG_MN1 (VSS I1_I930_G14_13 XI1_I930_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I164_XG_MN2 (I1_I930_G13_0n I1_I930_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I164_XG_MN0 (XI1_I930_I164_XG_n1 I1_I930_P13_6 I1_I930_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I164_XG_MN1 (VSS I1_I930_G5_0 XI1_I930_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I110_XG_MN2 (I1_I930_G14_11n I1_I930_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I110_XG_MN0 (XI1_I930_I110_XG_n1 I1_I930_P14_13 I1_I930_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I110_XG_MN1 (VSS I1_I930_G12_11 XI1_I930_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I162_XG_MN2 (I1_I930_G11_0n I1_I930_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I162_XG_MN0 (XI1_I930_I162_XG_n1 I1_I930_P11_4 I1_I930_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I162_XG_MN1 (VSS I1_I930_G3_0np XI1_I930_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I158_XG_MN2 (I1_I930_G9_0n I1_I930_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I158_XG_MN0 (XI1_I930_I158_XG_n1 I1_I930_P9_2 I1_I930_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I158_XG_MN1 (VSS I1_I930_G1_0 XI1_I930_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I930_I101_XG_MN2 (I1_I930_G5_2n I1_I930_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I930_I101_XG_MN0 (XI1_I930_I101_XG_n1 I1_I930_P5_4 I1_I930_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I930_I101_XG_MN1 (VSS I1_I930_G3_2 XI1_I930_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I157_XG_MN2 (I1_I1390_G8_0n I1_I1390_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I157_XG_MN0 (XI1_I1390_I157_XG_n1 I1_I1390_P8_1 I1_I1390_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1390_I157_XG_MN1 (VSS I1_I1390_G0_0 XI1_I1390_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1390_I100_XG_MN2 (I1_I1390_G4_1n I1_I1390_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1390_I100_XG_MN0 (XI1_I1390_I100_XG_n1 I1_I1390_P4_3 I1_I1390_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1390_I100_XG_MN1 (VSS I1_I1390_G2_1 XI1_I1390_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1390_I98_XG_MN2 (I1_I1390_G2_0n I1_I1390_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1390_I98_XG_MN0 (XI1_I1390_I98_XG_n1 I1_I1390_P2_1 I1_I1390_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1390_I98_XG_MN1 (VSS I1_I1390_G0_0 XI1_I1390_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1160_I114_XG_MN2 (I1_I1160_G18_15n I1_I1160_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1160_I114_XG_MN0 (XI1_I1160_I114_XG_n1 I1_I1160_P18_17 I1_I1160_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1160_I114_XG_MN1 (VSS I1_I1160_G16_15 XI1_I1160_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1160_I112_XG_MN2 (I1_I1160_G16_13n I1_I1160_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1160_I112_XG_MN0 (XI1_I1160_I112_XG_n1 I1_I1160_P16_15 I1_I1160_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1160_I112_XG_MN1 (VSS I1_I1160_G14_13 XI1_I1160_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1160_I110_XG_MN2 (I1_I1160_G14_11n I1_I1160_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1160_I110_XG_MN0 (XI1_I1160_I110_XG_n1 I1_I1160_P14_13 I1_I1160_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1160_I110_XG_MN1 (VSS I1_I1160_G12_11 XI1_I1160_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1160_I108_XG_MN2 (I1_I1160_G12_9n I1_I1160_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1160_I108_XG_MN0 (XI1_I1160_I108_XG_n1 I1_I1160_P12_11 I1_I1160_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1160_I108_XG_MN1 (VSS I1_I1160_G10_9 XI1_I1160_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I181_XG_MN2 (I1_I930_G30_15n I1_I930_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I181_XG_MN0 (XI1_I930_I181_XG_n1 I1_I930_P30_23 I1_I930_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I181_XG_MN1 (VSS I1_I930_G22_15 XI1_I930_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I179_XG_MN2 (I1_I930_G28_13n I1_I930_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I179_XG_MN0 (XI1_I930_I179_XG_n1 I1_I930_P28_21 I1_I930_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I179_XG_MN1 (VSS I1_I930_G20_13 XI1_I930_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I177_XG_MN2 (I1_I930_G26_11n I1_I930_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I177_XG_MN0 (XI1_I930_I177_XG_n1 I1_I930_P26_19 I1_I930_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I177_XG_MN1 (VSS I1_I930_G18_11 XI1_I930_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I116_XG_MN2 (I1_I930_G20_17n I1_I930_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I116_XG_MN0 (XI1_I930_I116_XG_n1 I1_I930_P20_19 I1_I930_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I116_XG_MN1 (VSS I1_I930_G18_17 XI1_I930_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I175_XG_MN2 (I1_I930_G24_9n I1_I930_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I175_XG_MN0 (XI1_I930_I175_XG_n1 I1_I930_P24_17 I1_I930_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I175_XG_MN1 (VSS I1_I930_G16_9 XI1_I930_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I108_XG_MN2 (I1_I930_G12_9n I1_I930_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I108_XG_MN0 (XI1_I930_I108_XG_n1 I1_I930_P12_11 I1_I930_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I108_XG_MN1 (VSS I1_I930_G10_9 XI1_I930_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I169_XG_MN2 (I1_I930_G18_3n I1_I930_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I169_XG_MN0 (XI1_I930_I169_XG_n1 I1_I930_P18_11 I1_I930_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I169_XG_MN1 (VSS I1_I930_G10_3 XI1_I930_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I106_XG_MN2 (I1_I930_G10_7n I1_I930_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I106_XG_MN0 (XI1_I930_I106_XG_n1 I1_I930_P10_9 I1_I930_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I106_XG_MN1 (VSS I1_I930_G8_7 XI1_I930_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I104_XG_MN2 (I1_I930_G8_5n I1_I930_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I104_XG_MN0 (XI1_I930_I104_XG_n1 I1_I930_P8_7 I1_I930_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I104_XG_MN1 (VSS I1_I930_G6_5 XI1_I930_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I102_XG_MN2 (I1_I930_G6_3n I1_I930_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I102_XG_MN0 (XI1_I930_I102_XG_n1 I1_I930_P6_5 I1_I930_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I102_XG_MN1 (VSS I1_I930_G4_3 XI1_I930_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I99_XG_MN2 (I1_I930_G3_0n I1_I930_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I99_XG_MN0 (XI1_I930_I99_XG_n1 I1_I930_P3_2 I1_I930_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I99_XG_MN1 (VSS I1_I930_G1_0 XI1_I930_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I162_XG_MN2 (I1_I654_G11_0n I1_I654_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I162_XG_MN0 (XI1_I654_I162_XG_n1 I1_I654_P11_4 I1_I654_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I162_XG_MN1 (VSS I1_I654_G3_0np XI1_I654_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I170_XG_MN2 (I1_I654_G19_4n I1_I654_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I170_XG_MN0 (XI1_I654_I170_XG_n1 I1_I654_P19_12 I1_I654_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I170_XG_MN1 (VSS I1_I654_G11_4 XI1_I654_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I164_XG_MN2 (I1_I654_G13_0n I1_I654_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I164_XG_MN0 (XI1_I654_I164_XG_n1 I1_I654_P13_6 I1_I654_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I164_XG_MN1 (VSS I1_I654_G5_0 XI1_I654_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I166_XG_MN2 (I1_I654_G15_0n I1_I654_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I166_XG_MN0 (XI1_I654_I166_XG_n1 I1_I654_P15_8 I1_I654_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I166_XG_MN1 (VSS I1_I654_G7_0 XI1_I654_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I173_XG_MN2 (I1_I930_G22_7n I1_I930_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I173_XG_MN0 (XI1_I930_I173_XG_n1 I1_I930_P22_15 I1_I930_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I173_XG_MN1 (VSS I1_I930_G14_7 XI1_I930_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I165_XG_MN2 (I1_I930_G14_0n I1_I930_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I165_XG_MN0 (XI1_I930_I165_XG_n1 I1_I930_P14_7 I1_I930_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I165_XG_MN1 (VSS I1_I930_G6_0 XI1_I930_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I171_XG_MN2 (I1_I930_G20_5n I1_I930_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I171_XG_MN0 (XI1_I930_I171_XG_n1 I1_I930_P20_13 I1_I930_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I171_XG_MN1 (VSS I1_I930_G12_5 XI1_I930_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I163_XG_MN2 (I1_I930_G12_0n I1_I930_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I163_XG_MN0 (XI1_I930_I163_XG_n1 I1_I930_P12_5 I1_I930_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I163_XG_MN1 (VSS I1_I930_G4_0 XI1_I930_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I167_XG_MN2 (I1_I930_G16_1n I1_I930_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I167_XG_MN0 (XI1_I930_I167_XG_n1 I1_I930_P16_9 I1_I930_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I167_XG_MN1 (VSS I1_I930_G8_1 XI1_I930_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I160_XG_MN2 (I1_I930_G10_0n I1_I930_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I160_XG_MN0 (XI1_I930_I160_XG_n1 I1_I930_P10_3 I1_I930_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I160_XG_MN1 (VSS I1_I930_G2_0np XI1_I930_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I100_XG_MN2 (I1_I930_G4_1n I1_I930_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I100_XG_MN0 (XI1_I930_I100_XG_n1 I1_I930_P4_3 I1_I930_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I100_XG_MN1 (VSS I1_I930_G2_1 XI1_I930_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I99_XG_MN2 (I1_I654_G3_0n I1_I654_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I99_XG_MN0 (XI1_I654_I99_XG_n1 I1_I654_P3_2 I1_I654_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I99_XG_MN1 (VSS I1_I654_G1_0 XI1_I654_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I101_XG_MN2 (I1_I654_G5_2n I1_I654_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I101_XG_MN0 (XI1_I654_I101_XG_n1 I1_I654_P5_4 I1_I654_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I101_XG_MN1 (VSS I1_I654_G3_2 XI1_I654_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I158_XG_MN2 (I1_I654_G9_0n I1_I654_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I158_XG_MN0 (XI1_I654_I158_XG_n1 I1_I654_P9_2 I1_I654_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I158_XG_MN1 (VSS I1_I654_G1_0 XI1_I654_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I168_XG_MN2 (I1_I654_G17_2n I1_I654_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I168_XG_MN0 (XI1_I654_I168_XG_n1 I1_I654_P17_10 I1_I654_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I168_XG_MN1 (VSS I1_I654_G9_2 XI1_I654_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I176_XG_MN2 (I1_I654_G25_10n I1_I654_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I176_XG_MN0 (XI1_I654_I176_XG_n1 I1_I654_P25_18 I1_I654_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I176_XG_MN1 (VSS I1_I654_G17_10 XI1_I654_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I172_XG_MN2 (I1_I654_G21_6n I1_I654_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I172_XG_MN0 (XI1_I654_I172_XG_n1 I1_I654_P21_14 I1_I654_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I172_XG_MN1 (VSS I1_I654_G13_6 XI1_I654_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I178_XG_MN2 (I1_I654_G27_12n I1_I654_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I178_XG_MN0 (XI1_I654_I178_XG_n1 I1_I654_P27_20 I1_I654_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I178_XG_MN1 (VSS I1_I654_G19_12 XI1_I654_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I174_XG_MN2 (I1_I654_G23_8n I1_I654_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I174_XG_MN0 (XI1_I654_I174_XG_n1 I1_I654_P23_16 I1_I654_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I174_XG_MN1 (VSS I1_I654_G15_8 XI1_I654_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I180_XG_MN2 (I1_I654_G29_14n I1_I654_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I180_XG_MN0 (XI1_I654_I180_XG_n1 I1_I654_P29_22 I1_I654_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I180_XG_MN1 (VSS I1_I654_G21_14 XI1_I654_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I182_XG_MN2 (I1_I654_G31_16n I1_I654_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I182_XG_MN0 (XI1_I654_I182_XG_n1 I1_I654_P31_24 I1_I654_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I182_XG_MN1 (VSS I1_I654_G23_16 XI1_I654_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I114_XG_MN2 (I1_I1436_G18_15n I1_I1436_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I114_XG_MN0 (XI1_I1436_I114_XG_n1 I1_I1436_P18_17 I1_I1436_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I114_XG_MN1 (VSS I1_I1436_G16_15 XI1_I1436_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I110_XG_MN2 (I1_I1436_G14_11n I1_I1436_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I110_XG_MN0 (XI1_I1436_I110_XG_n1 I1_I1436_P14_13 I1_I1436_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I110_XG_MN1 (VSS I1_I1436_G12_11 XI1_I1436_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I127_XG_MN2 (I1_I1114_G31_28n I1_I1114_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I127_XG_MN0 (XI1_I1114_I127_XG_n1 I1_I1114_P31_30 I1_I1114_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I127_XG_MN1 (VSS I1_I1114_G29_28 XI1_I1114_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I125_XG_MN2 (I1_I1114_G29_26n I1_I1114_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I125_XG_MN0 (XI1_I1114_I125_XG_n1 I1_I1114_P29_28 I1_I1114_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I125_XG_MN1 (VSS I1_I1114_G27_26 XI1_I1114_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I126_XG_MN2 (I1_I1114_G30_27n I1_I1114_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I126_XG_MN0 (XI1_I1114_I126_XG_n1 I1_I1114_P30_29 I1_I1114_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I126_XG_MN1 (VSS I1_I1114_G28_27 XI1_I1114_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I181_XG_MN2 (I1_I1114_G30_15n I1_I1114_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I181_XG_MN0 (XI1_I1114_I181_XG_n1 I1_I1114_P30_23 I1_I1114_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I181_XG_MN1 (VSS I1_I1114_G22_15 XI1_I1114_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I157_XG_MN2 (I1_I930_G8_0n I1_I930_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I157_XG_MN0 (XI1_I930_I157_XG_n1 I1_I930_P8_1 I1_I930_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I157_XG_MN1 (VSS I1_I930_G0_0 XI1_I930_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I930_I98_XG_MN2 (I1_I930_G2_0n I1_I930_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I930_I98_XG_MN0 (XI1_I930_I98_XG_n1 I1_I930_P2_1 I1_I930_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I930_I98_XG_MN1 (VSS I1_I930_G0_0 XI1_I930_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I98_XG_MN2 (I1_I654_G2_0n I1_I654_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I98_XG_MN0 (XI1_I654_I98_XG_n1 I1_I654_P2_1 I1_I654_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I98_XG_MN1 (VSS I1_I654_G0_0 XI1_I654_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I103_XG_MN2 (I1_I654_G7_4n I1_I654_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I103_XG_MN0 (XI1_I654_I103_XG_n1 I1_I654_P7_6 I1_I654_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I103_XG_MN1 (VSS I1_I654_G5_4 XI1_I654_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I105_XG_MN2 (I1_I654_G9_6n I1_I654_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I105_XG_MN0 (XI1_I654_I105_XG_n1 I1_I654_P9_8 I1_I654_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I105_XG_MN1 (VSS I1_I654_G7_6 XI1_I654_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I107_XG_MN2 (I1_I654_G11_8n I1_I654_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I107_XG_MN0 (XI1_I654_I107_XG_n1 I1_I654_P11_10 I1_I654_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I107_XG_MN1 (VSS I1_I654_G9_8 XI1_I654_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I109_XG_MN2 (I1_I654_G13_10n I1_I654_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I109_XG_MN0 (XI1_I654_I109_XG_n1 I1_I654_P13_12 I1_I654_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I109_XG_MN1 (VSS I1_I654_G11_10 XI1_I654_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I111_XG_MN2 (I1_I654_G15_12n I1_I654_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I111_XG_MN0 (XI1_I654_I111_XG_n1 I1_I654_P15_14 I1_I654_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I111_XG_MN1 (VSS I1_I654_G13_12 XI1_I654_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I113_XG_MN2 (I1_I654_G17_14n I1_I654_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I113_XG_MN0 (XI1_I654_I113_XG_n1 I1_I654_P17_16 I1_I654_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I113_XG_MN1 (VSS I1_I654_G15_14 XI1_I654_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I115_XG_MN2 (I1_I654_G19_16n I1_I654_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I115_XG_MN0 (XI1_I654_I115_XG_n1 I1_I654_P19_18 I1_I654_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I115_XG_MN1 (VSS I1_I654_G17_16 XI1_I654_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I117_XG_MN2 (I1_I654_G21_18n I1_I654_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I117_XG_MN0 (XI1_I654_I117_XG_n1 I1_I654_P21_20 I1_I654_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I117_XG_MN1 (VSS I1_I654_G19_18 XI1_I654_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I119_XG_MN2 (I1_I654_G23_20n I1_I654_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I119_XG_MN0 (XI1_I654_I119_XG_n1 I1_I654_P23_22 I1_I654_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I119_XG_MN1 (VSS I1_I654_G21_20 XI1_I654_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I121_XG_MN2 (I1_I654_G25_22n I1_I654_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I121_XG_MN0 (XI1_I654_I121_XG_n1 I1_I654_P25_24 I1_I654_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I121_XG_MN1 (VSS I1_I654_G23_22 XI1_I654_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I123_XG_MN2 (I1_I654_G27_24n I1_I654_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I123_XG_MN0 (XI1_I654_I123_XG_n1 I1_I654_P27_26 I1_I654_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I123_XG_MN1 (VSS I1_I654_G25_24 XI1_I654_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I125_XG_MN2 (I1_I654_G29_26n I1_I654_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I125_XG_MN0 (XI1_I654_I125_XG_n1 I1_I654_P29_28 I1_I654_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I125_XG_MN1 (VSS I1_I654_G27_26 XI1_I654_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I124_XG_MN2 (I1_I1436_G28_25n I1_I1436_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I124_XG_MN0 (XI1_I1436_I124_XG_n1 I1_I1436_P28_27 I1_I1436_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I124_XG_MN1 (VSS I1_I1436_G26_25 XI1_I1436_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I122_XG_MN2 (I1_I1436_G26_23n I1_I1436_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I122_XG_MN0 (XI1_I1436_I122_XG_n1 I1_I1436_P26_25 I1_I1436_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I122_XG_MN1 (VSS I1_I1436_G24_23 XI1_I1436_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I120_XG_MN2 (I1_I1436_G24_21n I1_I1436_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I120_XG_MN0 (XI1_I1436_I120_XG_n1 I1_I1436_P24_23 I1_I1436_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I120_XG_MN1 (VSS I1_I1436_G22_21 XI1_I1436_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I118_XG_MN2 (I1_I1436_G22_19n I1_I1436_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I118_XG_MN0 (XI1_I1436_I118_XG_n1 I1_I1436_P22_21 I1_I1436_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I118_XG_MN1 (VSS I1_I1436_G20_19 XI1_I1436_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I116_XG_MN2 (I1_I1436_G20_17n I1_I1436_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I116_XG_MN0 (XI1_I1436_I116_XG_n1 I1_I1436_P20_19 I1_I1436_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I116_XG_MN1 (VSS I1_I1436_G18_17 XI1_I1436_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I112_XG_MN2 (I1_I1436_G16_13n I1_I1436_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I112_XG_MN0 (XI1_I1436_I112_XG_n1 I1_I1436_P16_15 I1_I1436_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I112_XG_MN1 (VSS I1_I1436_G14_13 XI1_I1436_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I108_XG_MN2 (I1_I1436_G12_9n I1_I1436_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I108_XG_MN0 (XI1_I1436_I108_XG_n1 I1_I1436_P12_11 I1_I1436_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I108_XG_MN1 (VSS I1_I1436_G10_9 XI1_I1436_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I106_XG_MN2 (I1_I1436_G10_7n I1_I1436_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I106_XG_MN0 (XI1_I1436_I106_XG_n1 I1_I1436_P10_9 I1_I1436_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I106_XG_MN1 (VSS I1_I1436_G8_7 XI1_I1436_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I104_XG_MN2 (I1_I1436_G8_5n I1_I1436_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I104_XG_MN0 (XI1_I1436_I104_XG_n1 I1_I1436_P8_7 I1_I1436_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I104_XG_MN1 (VSS I1_I1436_G6_5 XI1_I1436_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I102_XG_MN2 (I1_I1436_G6_3n I1_I1436_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I102_XG_MN0 (XI1_I1436_I102_XG_n1 I1_I1436_P6_5 I1_I1436_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I102_XG_MN1 (VSS I1_I1436_G4_3 XI1_I1436_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I123_XG_MN2 (I1_I1114_G27_24n I1_I1114_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I123_XG_MN0 (XI1_I1114_I123_XG_n1 I1_I1114_P27_26 I1_I1114_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I123_XG_MN1 (VSS I1_I1114_G25_24 XI1_I1114_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I124_XG_MN2 (I1_I1114_G28_25n I1_I1114_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I124_XG_MN0 (XI1_I1114_I124_XG_n1 I1_I1114_P28_27 I1_I1114_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I124_XG_MN1 (VSS I1_I1114_G26_25 XI1_I1114_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I122_XG_MN2 (I1_I1114_G26_23n I1_I1114_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I122_XG_MN0 (XI1_I1114_I122_XG_n1 I1_I1114_P26_25 I1_I1114_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I122_XG_MN1 (VSS I1_I1114_G24_23 XI1_I1114_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I173_XG_MN2 (I1_I1114_G22_7n I1_I1114_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I173_XG_MN0 (XI1_I1114_I173_XG_n1 I1_I1114_P22_15 I1_I1114_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I173_XG_MN1 (VSS I1_I1114_G14_7 XI1_I1114_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I126_XG_MN2 (I1_I1068_G30_27n I1_I1068_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I126_XG_MN0 (XI1_I1068_I126_XG_n1 I1_I1068_P30_29 I1_I1068_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I126_XG_MN1 (VSS I1_I1068_G28_27 XI1_I1068_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I127_XG_MN2 (I1_I1068_G31_28n I1_I1068_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I127_XG_MN0 (XI1_I1068_I127_XG_n1 I1_I1068_P31_30 I1_I1068_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I127_XG_MN1 (VSS I1_I1068_G29_28 XI1_I1068_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I100_XG_MN2 (I1_I654_G4_1n I1_I654_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I100_XG_MN0 (XI1_I654_I100_XG_n1 I1_I654_P4_3 I1_I654_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I100_XG_MN1 (VSS I1_I654_G2_1 XI1_I654_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I157_XG_MN2 (I1_I654_G8_0n I1_I654_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I157_XG_MN0 (XI1_I654_I157_XG_n1 I1_I654_P8_1 I1_I654_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I157_XG_MN1 (VSS I1_I654_G0_0 XI1_I654_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I167_XG_MN2 (I1_I654_G16_1n I1_I654_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I167_XG_MN0 (XI1_I654_I167_XG_n1 I1_I654_P16_9 I1_I654_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I167_XG_MN1 (VSS I1_I654_G8_1 XI1_I654_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I160_XG_MN2 (I1_I654_G10_0n I1_I654_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I160_XG_MN0 (XI1_I654_I160_XG_n1 I1_I654_P10_3 I1_I654_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I160_XG_MN1 (VSS I1_I654_G2_0np XI1_I654_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I169_XG_MN2 (I1_I654_G18_3n I1_I654_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I169_XG_MN0 (XI1_I654_I169_XG_n1 I1_I654_P18_11 I1_I654_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I169_XG_MN1 (VSS I1_I654_G10_3 XI1_I654_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I163_XG_MN2 (I1_I654_G12_0n I1_I654_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I163_XG_MN0 (XI1_I654_I163_XG_n1 I1_I654_P12_5 I1_I654_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I163_XG_MN1 (VSS I1_I654_G4_0 XI1_I654_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I171_XG_MN2 (I1_I654_G20_5n I1_I654_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I171_XG_MN0 (XI1_I654_I171_XG_n1 I1_I654_P20_13 I1_I654_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I171_XG_MN1 (VSS I1_I654_G12_5 XI1_I654_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I165_XG_MN2 (I1_I654_G14_0n I1_I654_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I165_XG_MN0 (XI1_I654_I165_XG_n1 I1_I654_P14_7 I1_I654_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I165_XG_MN1 (VSS I1_I654_G6_0 XI1_I654_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I173_XG_MN2 (I1_I654_G22_7n I1_I654_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I173_XG_MN0 (XI1_I654_I173_XG_n1 I1_I654_P22_15 I1_I654_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I173_XG_MN1 (VSS I1_I654_G14_7 XI1_I654_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I181_XG_MN2 (I1_I654_G30_15n I1_I654_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I181_XG_MN0 (XI1_I654_I181_XG_n1 I1_I654_P30_23 I1_I654_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I181_XG_MN1 (VSS I1_I654_G22_15 XI1_I654_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I126_XG_MN2 (I1_I654_G30_27n I1_I654_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I126_XG_MN0 (XI1_I654_I126_XG_n1 I1_I654_P30_29 I1_I654_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I126_XG_MN1 (VSS I1_I654_G28_27 XI1_I654_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I127_XG_MN2 (I1_I654_G31_28n I1_I654_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I127_XG_MN0 (XI1_I654_I127_XG_n1 I1_I654_P31_30 I1_I654_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I127_XG_MN1 (VSS I1_I654_G29_28 XI1_I654_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I126_XG_MN2 (I1_I1436_G30_27n I1_I1436_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I126_XG_MN0 (XI1_I1436_I126_XG_n1 I1_I1436_P30_29 I1_I1436_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I126_XG_MN1 (VSS I1_I1436_G28_27 XI1_I1436_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I181_XG_MN2 (I1_I1436_G30_15n I1_I1436_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I181_XG_MN0 (XI1_I1436_I181_XG_n1 I1_I1436_P30_23 I1_I1436_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I181_XG_MN1 (VSS I1_I1436_G22_15 XI1_I1436_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I179_XG_MN2 (I1_I1436_G28_13n I1_I1436_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I179_XG_MN0 (XI1_I1436_I179_XG_n1 I1_I1436_P28_21 I1_I1436_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I179_XG_MN1 (VSS I1_I1436_G20_13 XI1_I1436_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I173_XG_MN2 (I1_I1436_G22_7n I1_I1436_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I173_XG_MN0 (XI1_I1436_I173_XG_n1 I1_I1436_P22_15 I1_I1436_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I173_XG_MN1 (VSS I1_I1436_G14_7 XI1_I1436_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I177_XG_MN2 (I1_I1436_G26_11n I1_I1436_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I177_XG_MN0 (XI1_I1436_I177_XG_n1 I1_I1436_P26_19 I1_I1436_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I177_XG_MN1 (VSS I1_I1436_G18_11 XI1_I1436_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I165_XG_MN2 (I1_I1436_G14_0n I1_I1436_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I165_XG_MN0 (XI1_I1436_I165_XG_n1 I1_I1436_P14_7 I1_I1436_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I165_XG_MN1 (VSS I1_I1436_G6_0 XI1_I1436_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I171_XG_MN2 (I1_I1436_G20_5n I1_I1436_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I171_XG_MN0 (XI1_I1436_I171_XG_n1 I1_I1436_P20_13 I1_I1436_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I171_XG_MN1 (VSS I1_I1436_G12_5 XI1_I1436_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I163_XG_MN2 (I1_I1436_G12_0n I1_I1436_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I163_XG_MN0 (XI1_I1436_I163_XG_n1 I1_I1436_P12_5 I1_I1436_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I163_XG_MN1 (VSS I1_I1436_G4_0 XI1_I1436_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I175_XG_MN2 (I1_I1436_G24_9n I1_I1436_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I175_XG_MN0 (XI1_I1436_I175_XG_n1 I1_I1436_P24_17 I1_I1436_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I175_XG_MN1 (VSS I1_I1436_G16_9 XI1_I1436_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I169_XG_MN2 (I1_I1436_G18_3n I1_I1436_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I169_XG_MN0 (XI1_I1436_I169_XG_n1 I1_I1436_P18_11 I1_I1436_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I169_XG_MN1 (VSS I1_I1436_G10_3 XI1_I1436_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I160_XG_MN2 (I1_I1436_G10_0n I1_I1436_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I160_XG_MN0 (XI1_I1436_I160_XG_n1 I1_I1436_P10_3 I1_I1436_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I160_XG_MN1 (VSS I1_I1436_G2_0np XI1_I1436_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I167_XG_MN2 (I1_I1436_G16_1n I1_I1436_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I167_XG_MN0 (XI1_I1436_I167_XG_n1 I1_I1436_P16_9 I1_I1436_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I167_XG_MN1 (VSS I1_I1436_G8_1 XI1_I1436_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I100_XG_MN2 (I1_I1436_G4_1n I1_I1436_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I100_XG_MN0 (XI1_I1436_I100_XG_n1 I1_I1436_P4_3 I1_I1436_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I100_XG_MN1 (VSS I1_I1436_G2_1 XI1_I1436_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I182_XG_MN2 (I1_I1114_G31_16n I1_I1114_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I182_XG_MN0 (XI1_I1114_I182_XG_n1 I1_I1114_P31_24 I1_I1114_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I182_XG_MN1 (VSS I1_I1114_G23_16 XI1_I1114_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I121_XG_MN2 (I1_I1114_G25_22n I1_I1114_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I121_XG_MN0 (XI1_I1114_I121_XG_n1 I1_I1114_P25_24 I1_I1114_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I121_XG_MN1 (VSS I1_I1114_G23_22 XI1_I1114_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I119_XG_MN2 (I1_I1114_G23_20n I1_I1114_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I119_XG_MN0 (XI1_I1114_I119_XG_n1 I1_I1114_P23_22 I1_I1114_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I119_XG_MN1 (VSS I1_I1114_G21_20 XI1_I1114_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I120_XG_MN2 (I1_I1114_G24_21n I1_I1114_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I120_XG_MN0 (XI1_I1114_I120_XG_n1 I1_I1114_P24_23 I1_I1114_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I120_XG_MN1 (VSS I1_I1114_G22_21 XI1_I1114_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I165_XG_MN2 (I1_I1114_G14_0n I1_I1114_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I165_XG_MN0 (XI1_I1114_I165_XG_n1 I1_I1114_P14_7 I1_I1114_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I165_XG_MN1 (VSS I1_I1114_G6_0 XI1_I1114_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I181_XG_MN2 (I1_I1068_G30_15n I1_I1068_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I181_XG_MN0 (XI1_I1068_I181_XG_n1 I1_I1068_P30_23 I1_I1068_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I181_XG_MN1 (VSS I1_I1068_G22_15 XI1_I1068_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I122_XG_MN2 (I1_I1068_G26_23n I1_I1068_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I122_XG_MN0 (XI1_I1068_I122_XG_n1 I1_I1068_P26_25 I1_I1068_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I122_XG_MN1 (VSS I1_I1068_G24_23 XI1_I1068_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I124_XG_MN2 (I1_I1068_G28_25n I1_I1068_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I124_XG_MN0 (XI1_I1068_I124_XG_n1 I1_I1068_P28_27 I1_I1068_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I124_XG_MN1 (VSS I1_I1068_G26_25 XI1_I1068_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I182_XG_MN2 (I1_I1068_G31_16n I1_I1068_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I182_XG_MN0 (XI1_I1068_I182_XG_n1 I1_I1068_P31_24 I1_I1068_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I182_XG_MN1 (VSS I1_I1068_G23_16 XI1_I1068_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I125_XG_MN2 (I1_I1068_G29_26n I1_I1068_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I125_XG_MN0 (XI1_I1068_I125_XG_n1 I1_I1068_P29_28 I1_I1068_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I125_XG_MN1 (VSS I1_I1068_G27_26 XI1_I1068_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I123_XG_MN2 (I1_I1068_G27_24n I1_I1068_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I123_XG_MN0 (XI1_I1068_I123_XG_n1 I1_I1068_P27_26 I1_I1068_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I123_XG_MN1 (VSS I1_I1068_G25_24 XI1_I1068_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I127_XG_MN2 (I1_I976_G31_28n I1_I976_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I127_XG_MN0 (XI1_I976_I127_XG_n1 I1_I976_P31_30 I1_I976_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I127_XG_MN1 (VSS I1_I976_G29_28 XI1_I976_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I125_XG_MN2 (I1_I976_G29_26n I1_I976_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I125_XG_MN0 (XI1_I976_I125_XG_n1 I1_I976_P29_28 I1_I976_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I125_XG_MN1 (VSS I1_I976_G27_26 XI1_I976_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I123_XG_MN2 (I1_I976_G27_24n I1_I976_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I123_XG_MN0 (XI1_I976_I123_XG_n1 I1_I976_P27_26 I1_I976_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I123_XG_MN1 (VSS I1_I976_G25_24 XI1_I976_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I121_XG_MN2 (I1_I976_G25_22n I1_I976_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I121_XG_MN0 (XI1_I976_I121_XG_n1 I1_I976_P25_24 I1_I976_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I121_XG_MN1 (VSS I1_I976_G23_22 XI1_I976_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I119_XG_MN2 (I1_I976_G23_20n I1_I976_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I119_XG_MN0 (XI1_I976_I119_XG_n1 I1_I976_P23_22 I1_I976_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I119_XG_MN1 (VSS I1_I976_G21_20 XI1_I976_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I180_XG_MN2 (I1_I976_G29_14n I1_I976_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I180_XG_MN0 (XI1_I976_I180_XG_n1 I1_I976_P29_22 I1_I976_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I180_XG_MN1 (VSS I1_I976_G21_14 XI1_I976_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I117_XG_MN2 (I1_I976_G21_18n I1_I976_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I117_XG_MN0 (XI1_I976_I117_XG_n1 I1_I976_P21_20 I1_I976_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I117_XG_MN1 (VSS I1_I976_G19_18 XI1_I976_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I115_XG_MN2 (I1_I976_G19_16n I1_I976_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I115_XG_MN0 (XI1_I976_I115_XG_n1 I1_I976_P19_18 I1_I976_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I115_XG_MN1 (VSS I1_I976_G17_16 XI1_I976_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I113_XG_MN2 (I1_I976_G17_14n I1_I976_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I113_XG_MN0 (XI1_I976_I113_XG_n1 I1_I976_P17_16 I1_I976_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I113_XG_MN1 (VSS I1_I976_G15_14 XI1_I976_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I176_XG_MN2 (I1_I976_G25_10n I1_I976_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I176_XG_MN0 (XI1_I976_I176_XG_n1 I1_I976_P25_18 I1_I976_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I176_XG_MN1 (VSS I1_I976_G17_10 XI1_I976_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I109_XG_MN2 (I1_I976_G13_10n I1_I976_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I109_XG_MN0 (XI1_I976_I109_XG_n1 I1_I976_P13_12 I1_I976_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I109_XG_MN1 (VSS I1_I976_G11_10 XI1_I976_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I102_XG_MN2 (I1_I654_G6_3n I1_I654_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I102_XG_MN0 (XI1_I654_I102_XG_n1 I1_I654_P6_5 I1_I654_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I102_XG_MN1 (VSS I1_I654_G4_3 XI1_I654_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I104_XG_MN2 (I1_I654_G8_5n I1_I654_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I104_XG_MN0 (XI1_I654_I104_XG_n1 I1_I654_P8_7 I1_I654_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I104_XG_MN1 (VSS I1_I654_G6_5 XI1_I654_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I106_XG_MN2 (I1_I654_G10_7n I1_I654_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I106_XG_MN0 (XI1_I654_I106_XG_n1 I1_I654_P10_9 I1_I654_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I106_XG_MN1 (VSS I1_I654_G8_7 XI1_I654_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I175_XG_MN2 (I1_I654_G24_9n I1_I654_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I175_XG_MN0 (XI1_I654_I175_XG_n1 I1_I654_P24_17 I1_I654_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I175_XG_MN1 (VSS I1_I654_G16_9 XI1_I654_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I110_XG_MN2 (I1_I654_G14_11n I1_I654_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I110_XG_MN0 (XI1_I654_I110_XG_n1 I1_I654_P14_13 I1_I654_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I110_XG_MN1 (VSS I1_I654_G12_11 XI1_I654_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I177_XG_MN2 (I1_I654_G26_11n I1_I654_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I177_XG_MN0 (XI1_I654_I177_XG_n1 I1_I654_P26_19 I1_I654_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I177_XG_MN1 (VSS I1_I654_G18_11 XI1_I654_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I179_XG_MN2 (I1_I654_G28_13n I1_I654_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I179_XG_MN0 (XI1_I654_I179_XG_n1 I1_I654_P28_21 I1_I654_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I179_XG_MN1 (VSS I1_I654_G20_13 XI1_I654_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I118_XG_MN2 (I1_I654_G22_19n I1_I654_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I118_XG_MN0 (XI1_I654_I118_XG_n1 I1_I654_P22_21 I1_I654_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I118_XG_MN1 (VSS I1_I654_G20_19 XI1_I654_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I120_XG_MN2 (I1_I654_G24_21n I1_I654_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I120_XG_MN0 (XI1_I654_I120_XG_n1 I1_I654_P24_23 I1_I654_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I120_XG_MN1 (VSS I1_I654_G22_21 XI1_I654_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I122_XG_MN2 (I1_I654_G26_23n I1_I654_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I122_XG_MN0 (XI1_I654_I122_XG_n1 I1_I654_P26_25 I1_I654_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I122_XG_MN1 (VSS I1_I654_G24_23 XI1_I654_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I124_XG_MN2 (I1_I654_G28_25n I1_I654_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I124_XG_MN0 (XI1_I654_I124_XG_n1 I1_I654_P28_27 I1_I654_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I124_XG_MN1 (VSS I1_I654_G26_25 XI1_I654_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I125_XG_MN2 (I1_I1436_G29_26n I1_I1436_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I125_XG_MN0 (XI1_I1436_I125_XG_n1 I1_I1436_P29_28 I1_I1436_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I125_XG_MN1 (VSS I1_I1436_G27_26 XI1_I1436_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I123_XG_MN2 (I1_I1436_G27_24n I1_I1436_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I123_XG_MN0 (XI1_I1436_I123_XG_n1 I1_I1436_P27_26 I1_I1436_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I123_XG_MN1 (VSS I1_I1436_G25_24 XI1_I1436_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I121_XG_MN2 (I1_I1436_G25_22n I1_I1436_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I121_XG_MN0 (XI1_I1436_I121_XG_n1 I1_I1436_P25_24 I1_I1436_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I121_XG_MN1 (VSS I1_I1436_G23_22 XI1_I1436_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I119_XG_MN2 (I1_I1436_G23_20n I1_I1436_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I119_XG_MN0 (XI1_I1436_I119_XG_n1 I1_I1436_P23_22 I1_I1436_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I119_XG_MN1 (VSS I1_I1436_G21_20 XI1_I1436_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I117_XG_MN2 (I1_I1436_G21_18n I1_I1436_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I117_XG_MN0 (XI1_I1436_I117_XG_n1 I1_I1436_P21_20 I1_I1436_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I117_XG_MN1 (VSS I1_I1436_G19_18 XI1_I1436_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I115_XG_MN2 (I1_I1436_G19_16n I1_I1436_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I115_XG_MN0 (XI1_I1436_I115_XG_n1 I1_I1436_P19_18 I1_I1436_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I115_XG_MN1 (VSS I1_I1436_G17_16 XI1_I1436_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I113_XG_MN2 (I1_I1436_G17_14n I1_I1436_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I113_XG_MN0 (XI1_I1436_I113_XG_n1 I1_I1436_P17_16 I1_I1436_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I113_XG_MN1 (VSS I1_I1436_G15_14 XI1_I1436_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I111_XG_MN2 (I1_I1436_G15_12n I1_I1436_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I111_XG_MN0 (XI1_I1436_I111_XG_n1 I1_I1436_P15_14 I1_I1436_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I111_XG_MN1 (VSS I1_I1436_G13_12 XI1_I1436_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I109_XG_MN2 (I1_I1436_G13_10n I1_I1436_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I109_XG_MN0 (XI1_I1436_I109_XG_n1 I1_I1436_P13_12 I1_I1436_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I109_XG_MN1 (VSS I1_I1436_G11_10 XI1_I1436_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I157_XG_MN2 (I1_I1436_G8_0n I1_I1436_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I157_XG_MN0 (XI1_I1436_I157_XG_n1 I1_I1436_P8_1 I1_I1436_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I157_XG_MN1 (VSS I1_I1436_G0_0 XI1_I1436_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I98_XG_MN2 (I1_I1436_G2_0n I1_I1436_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I98_XG_MN0 (XI1_I1436_I98_XG_n1 I1_I1436_P2_1 I1_I1436_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I98_XG_MN1 (VSS I1_I1436_G0_0 XI1_I1436_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I174_XG_MN2 (I1_I1114_G23_8n I1_I1114_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I174_XG_MN0 (XI1_I1114_I174_XG_n1 I1_I1114_P23_16 I1_I1114_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I174_XG_MN1 (VSS I1_I1114_G15_8 XI1_I1114_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I180_XG_MN2 (I1_I1114_G29_14n I1_I1114_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I180_XG_MN0 (XI1_I1114_I180_XG_n1 I1_I1114_P29_22 I1_I1114_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I180_XG_MN1 (VSS I1_I1114_G21_14 XI1_I1114_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I117_XG_MN2 (I1_I1114_G21_18n I1_I1114_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I117_XG_MN0 (XI1_I1114_I117_XG_n1 I1_I1114_P21_20 I1_I1114_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I117_XG_MN1 (VSS I1_I1114_G19_18 XI1_I1114_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I177_XG_MN2 (I1_I1114_G26_11n I1_I1114_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I177_XG_MN0 (XI1_I1114_I177_XG_n1 I1_I1114_P26_19 I1_I1114_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I177_XG_MN1 (VSS I1_I1114_G18_11 XI1_I1114_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I118_XG_MN2 (I1_I1114_G22_19n I1_I1114_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I118_XG_MN0 (XI1_I1114_I118_XG_n1 I1_I1114_P22_21 I1_I1114_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I118_XG_MN1 (VSS I1_I1114_G20_19 XI1_I1114_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I179_XG_MN2 (I1_I1068_G28_13n I1_I1068_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I179_XG_MN0 (XI1_I1068_I179_XG_n1 I1_I1068_P28_21 I1_I1068_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I179_XG_MN1 (VSS I1_I1068_G20_13 XI1_I1068_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I120_XG_MN2 (I1_I1068_G24_21n I1_I1068_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I120_XG_MN0 (XI1_I1068_I120_XG_n1 I1_I1068_P24_23 I1_I1068_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I120_XG_MN1 (VSS I1_I1068_G22_21 XI1_I1068_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I180_XG_MN2 (I1_I1068_G29_14n I1_I1068_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I180_XG_MN0 (XI1_I1068_I180_XG_n1 I1_I1068_P29_22 I1_I1068_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I180_XG_MN1 (VSS I1_I1068_G21_14 XI1_I1068_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I121_XG_MN2 (I1_I1068_G25_22n I1_I1068_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I121_XG_MN0 (XI1_I1068_I121_XG_n1 I1_I1068_P25_24 I1_I1068_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I121_XG_MN1 (VSS I1_I1068_G23_22 XI1_I1068_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I126_XG_MN2 (I1_I976_G30_27n I1_I976_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I126_XG_MN0 (XI1_I976_I126_XG_n1 I1_I976_P30_29 I1_I976_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I126_XG_MN1 (VSS I1_I976_G28_27 XI1_I976_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I124_XG_MN2 (I1_I976_G28_25n I1_I976_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I124_XG_MN0 (XI1_I976_I124_XG_n1 I1_I976_P28_27 I1_I976_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I124_XG_MN1 (VSS I1_I976_G26_25 XI1_I976_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I122_XG_MN2 (I1_I976_G26_23n I1_I976_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I122_XG_MN0 (XI1_I976_I122_XG_n1 I1_I976_P26_25 I1_I976_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I122_XG_MN1 (VSS I1_I976_G24_23 XI1_I976_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I182_XG_MN2 (I1_I976_G31_16n I1_I976_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I182_XG_MN0 (XI1_I976_I182_XG_n1 I1_I976_P31_24 I1_I976_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I182_XG_MN1 (VSS I1_I976_G23_16 XI1_I976_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I174_XG_MN2 (I1_I976_G23_8n I1_I976_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I174_XG_MN0 (XI1_I976_I174_XG_n1 I1_I976_P23_16 I1_I976_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I174_XG_MN1 (VSS I1_I976_G15_8 XI1_I976_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I166_XG_MN2 (I1_I976_G15_0n I1_I976_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I166_XG_MN0 (XI1_I976_I166_XG_n1 I1_I976_P15_8 I1_I976_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I166_XG_MN1 (VSS I1_I976_G7_0 XI1_I976_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I178_XG_MN2 (I1_I976_G27_12n I1_I976_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I178_XG_MN0 (XI1_I976_I178_XG_n1 I1_I976_P27_20 I1_I976_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I178_XG_MN1 (VSS I1_I976_G19_12 XI1_I976_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I111_XG_MN2 (I1_I976_G15_12n I1_I976_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I111_XG_MN0 (XI1_I976_I111_XG_n1 I1_I976_P15_14 I1_I976_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I111_XG_MN1 (VSS I1_I976_G13_12 XI1_I976_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I172_XG_MN2 (I1_I976_G21_6n I1_I976_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I172_XG_MN0 (XI1_I976_I172_XG_n1 I1_I976_P21_14 I1_I976_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I172_XG_MN1 (VSS I1_I976_G13_6 XI1_I976_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I164_XG_MN2 (I1_I976_G13_0n I1_I976_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I164_XG_MN0 (XI1_I976_I164_XG_n1 I1_I976_P13_6 I1_I976_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I164_XG_MN1 (VSS I1_I976_G5_0 XI1_I976_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I107_XG_MN2 (I1_I976_G11_8n I1_I976_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I107_XG_MN0 (XI1_I976_I107_XG_n1 I1_I976_P11_10 I1_I976_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I107_XG_MN1 (VSS I1_I976_G9_8 XI1_I976_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I108_XG_MN2 (I1_I654_G12_9n I1_I654_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I108_XG_MN0 (XI1_I654_I108_XG_n1 I1_I654_P12_11 I1_I654_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I108_XG_MN1 (VSS I1_I654_G10_9 XI1_I654_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I112_XG_MN2 (I1_I654_G16_13n I1_I654_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I112_XG_MN0 (XI1_I654_I112_XG_n1 I1_I654_P16_15 I1_I654_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I112_XG_MN1 (VSS I1_I654_G14_13 XI1_I654_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I114_XG_MN2 (I1_I654_G18_15n I1_I654_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I114_XG_MN0 (XI1_I654_I114_XG_n1 I1_I654_P18_17 I1_I654_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I114_XG_MN1 (VSS I1_I654_G16_15 XI1_I654_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I654_I116_XG_MN2 (I1_I654_G20_17n I1_I654_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I654_I116_XG_MN0 (XI1_I654_I116_XG_n1 I1_I654_P20_19 I1_I654_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I654_I116_XG_MN1 (VSS I1_I654_G18_17 XI1_I654_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I127_XG_MN2 (I1_I1436_G31_28n I1_I1436_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I127_XG_MN0 (XI1_I1436_I127_XG_n1 I1_I1436_P31_30 I1_I1436_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I127_XG_MN1 (VSS I1_I1436_G29_28 XI1_I1436_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I180_XG_MN2 (I1_I1436_G29_14n I1_I1436_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I180_XG_MN0 (XI1_I1436_I180_XG_n1 I1_I1436_P29_22 I1_I1436_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I180_XG_MN1 (VSS I1_I1436_G21_14 XI1_I1436_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I164_XG_MN2 (I1_I1436_G13_0n I1_I1436_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I164_XG_MN0 (XI1_I1436_I164_XG_n1 I1_I1436_P13_6 I1_I1436_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I164_XG_MN1 (VSS I1_I1436_G5_0 XI1_I1436_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I107_XG_MN2 (I1_I1436_G11_8n I1_I1436_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I107_XG_MN0 (XI1_I1436_I107_XG_n1 I1_I1436_P11_10 I1_I1436_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I107_XG_MN1 (VSS I1_I1436_G9_8 XI1_I1436_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I168_XG_MN2 (I1_I1436_G17_2n I1_I1436_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I168_XG_MN0 (XI1_I1436_I168_XG_n1 I1_I1436_P17_10 I1_I1436_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I168_XG_MN1 (VSS I1_I1436_G9_2 XI1_I1436_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I105_XG_MN2 (I1_I1436_G9_6n I1_I1436_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I105_XG_MN0 (XI1_I1436_I105_XG_n1 I1_I1436_P9_8 I1_I1436_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I105_XG_MN1 (VSS I1_I1436_G7_6 XI1_I1436_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I103_XG_MN2 (I1_I1436_G7_4n I1_I1436_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I103_XG_MN0 (XI1_I1436_I103_XG_n1 I1_I1436_P7_6 I1_I1436_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I103_XG_MN1 (VSS I1_I1436_G5_4 XI1_I1436_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I101_XG_MN2 (I1_I1436_G5_2n I1_I1436_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I101_XG_MN0 (XI1_I1436_I101_XG_n1 I1_I1436_P5_4 I1_I1436_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I101_XG_MN1 (VSS I1_I1436_G3_2 XI1_I1436_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I99_XG_MN2 (I1_I1436_G3_0n I1_I1436_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I99_XG_MN0 (XI1_I1436_I99_XG_n1 I1_I1436_P3_2 I1_I1436_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I99_XG_MN1 (VSS I1_I1436_G1_0 XI1_I1436_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I178_XG_MN2 (I1_I1114_G27_12n I1_I1114_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I178_XG_MN0 (XI1_I1114_I178_XG_n1 I1_I1114_P27_20 I1_I1114_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I178_XG_MN1 (VSS I1_I1114_G19_12 XI1_I1114_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I166_XG_MN2 (I1_I1114_G15_0n I1_I1114_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I166_XG_MN0 (XI1_I1114_I166_XG_n1 I1_I1114_P15_8 I1_I1114_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I166_XG_MN1 (VSS I1_I1114_G7_0 XI1_I1114_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I172_XG_MN2 (I1_I1114_G21_6n I1_I1114_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I172_XG_MN0 (XI1_I1114_I172_XG_n1 I1_I1114_P21_14 I1_I1114_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I172_XG_MN1 (VSS I1_I1114_G13_6 XI1_I1114_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I115_XG_MN2 (I1_I1114_G19_16n I1_I1114_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I115_XG_MN0 (XI1_I1114_I115_XG_n1 I1_I1114_P19_18 I1_I1114_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I115_XG_MN1 (VSS I1_I1114_G17_16 XI1_I1114_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I179_XG_MN2 (I1_I1114_G28_13n I1_I1114_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I179_XG_MN0 (XI1_I1114_I179_XG_n1 I1_I1114_P28_21 I1_I1114_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I179_XG_MN1 (VSS I1_I1114_G20_13 XI1_I1114_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I116_XG_MN2 (I1_I1114_G20_17n I1_I1114_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I116_XG_MN0 (XI1_I1114_I116_XG_n1 I1_I1114_P20_19 I1_I1114_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I116_XG_MN1 (VSS I1_I1114_G18_17 XI1_I1114_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I114_XG_MN2 (I1_I1114_G18_15n I1_I1114_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I114_XG_MN0 (XI1_I1114_I114_XG_n1 I1_I1114_P18_17 I1_I1114_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I114_XG_MN1 (VSS I1_I1114_G16_15 XI1_I1114_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I173_XG_MN2 (I1_I1068_G22_7n I1_I1068_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I173_XG_MN0 (XI1_I1068_I173_XG_n1 I1_I1068_P22_15 I1_I1068_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I173_XG_MN1 (VSS I1_I1068_G14_7 XI1_I1068_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I118_XG_MN2 (I1_I1068_G22_19n I1_I1068_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I118_XG_MN0 (XI1_I1068_I118_XG_n1 I1_I1068_P22_21 I1_I1068_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I118_XG_MN1 (VSS I1_I1068_G20_19 XI1_I1068_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I166_XG_MN2 (I1_I1068_G15_0n I1_I1068_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I166_XG_MN0 (XI1_I1068_I166_XG_n1 I1_I1068_P15_8 I1_I1068_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I166_XG_MN1 (VSS I1_I1068_G7_0 XI1_I1068_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I174_XG_MN2 (I1_I1068_G23_8n I1_I1068_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I174_XG_MN0 (XI1_I1068_I174_XG_n1 I1_I1068_P23_16 I1_I1068_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I174_XG_MN1 (VSS I1_I1068_G15_8 XI1_I1068_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I119_XG_MN2 (I1_I1068_G23_20n I1_I1068_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I119_XG_MN0 (XI1_I1068_I119_XG_n1 I1_I1068_P23_22 I1_I1068_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I119_XG_MN1 (VSS I1_I1068_G21_20 XI1_I1068_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I126_XG_MN2 (I1_I1022_G30_27n I1_I1022_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I126_XG_MN0 (XI1_I1022_I126_XG_n1 I1_I1022_P30_29 I1_I1022_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I126_XG_MN1 (VSS I1_I1022_G28_27 XI1_I1022_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I127_XG_MN2 (I1_I1022_G31_28n I1_I1022_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I127_XG_MN0 (XI1_I1022_I127_XG_n1 I1_I1022_P31_30 I1_I1022_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I127_XG_MN1 (VSS I1_I1022_G29_28 XI1_I1022_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I120_XG_MN2 (I1_I976_G24_21n I1_I976_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I120_XG_MN0 (XI1_I976_I120_XG_n1 I1_I976_P24_23 I1_I976_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I120_XG_MN1 (VSS I1_I976_G22_21 XI1_I976_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I118_XG_MN2 (I1_I976_G22_19n I1_I976_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I118_XG_MN0 (XI1_I976_I118_XG_n1 I1_I976_P22_21 I1_I976_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I118_XG_MN1 (VSS I1_I976_G20_19 XI1_I976_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I170_XG_MN2 (I1_I976_G19_4n I1_I976_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I170_XG_MN0 (XI1_I976_I170_XG_n1 I1_I976_P19_12 I1_I976_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I170_XG_MN1 (VSS I1_I976_G11_4 XI1_I976_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I168_XG_MN2 (I1_I976_G17_2n I1_I976_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I168_XG_MN0 (XI1_I976_I168_XG_n1 I1_I976_P17_10 I1_I976_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I168_XG_MN1 (VSS I1_I976_G9_2 XI1_I976_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I105_XG_MN2 (I1_I976_G9_6n I1_I976_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I105_XG_MN0 (XI1_I976_I105_XG_n1 I1_I976_P9_8 I1_I976_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I105_XG_MN1 (VSS I1_I976_G7_6 XI1_I976_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I103_XG_MN2 (I1_I976_G7_4n I1_I976_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I103_XG_MN0 (XI1_I976_I103_XG_n1 I1_I976_P7_6 I1_I976_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I103_XG_MN1 (VSS I1_I976_G5_4 XI1_I976_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I182_XG_MN2 (I1_I1436_G31_16n I1_I1436_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I182_XG_MN0 (XI1_I1436_I182_XG_n1 I1_I1436_P31_24 I1_I1436_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I182_XG_MN1 (VSS I1_I1436_G23_16 XI1_I1436_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I178_XG_MN2 (I1_I1436_G27_12n I1_I1436_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I178_XG_MN0 (XI1_I1436_I178_XG_n1 I1_I1436_P27_20 I1_I1436_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I178_XG_MN1 (VSS I1_I1436_G19_12 XI1_I1436_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I174_XG_MN2 (I1_I1436_G23_8n I1_I1436_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I174_XG_MN0 (XI1_I1436_I174_XG_n1 I1_I1436_P23_16 I1_I1436_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I174_XG_MN1 (VSS I1_I1436_G15_8 XI1_I1436_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I166_XG_MN2 (I1_I1436_G15_0n I1_I1436_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I166_XG_MN0 (XI1_I1436_I166_XG_n1 I1_I1436_P15_8 I1_I1436_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I166_XG_MN1 (VSS I1_I1436_G7_0 XI1_I1436_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I170_XG_MN2 (I1_I1436_G19_4n I1_I1436_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I170_XG_MN0 (XI1_I1436_I170_XG_n1 I1_I1436_P19_12 I1_I1436_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I170_XG_MN1 (VSS I1_I1436_G11_4 XI1_I1436_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I162_XG_MN2 (I1_I1436_G11_0n I1_I1436_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I162_XG_MN0 (XI1_I1436_I162_XG_n1 I1_I1436_P11_4 I1_I1436_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I162_XG_MN1 (VSS I1_I1436_G3_0np XI1_I1436_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1436_I158_XG_MN2 (I1_I1436_G9_0n I1_I1436_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1436_I158_XG_MN0 (XI1_I1436_I158_XG_n1 I1_I1436_P9_2 I1_I1436_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1436_I158_XG_MN1 (VSS I1_I1436_G1_0 XI1_I1436_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I176_XG_MN2 (I1_I1114_G25_10n I1_I1114_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I176_XG_MN0 (XI1_I1114_I176_XG_n1 I1_I1114_P25_18 I1_I1114_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I176_XG_MN1 (VSS I1_I1114_G17_10 XI1_I1114_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I164_XG_MN2 (I1_I1114_G13_0n I1_I1114_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I164_XG_MN0 (XI1_I1114_I164_XG_n1 I1_I1114_P13_6 I1_I1114_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I164_XG_MN1 (VSS I1_I1114_G5_0 XI1_I1114_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I113_XG_MN2 (I1_I1114_G17_14n I1_I1114_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I113_XG_MN0 (XI1_I1114_I113_XG_n1 I1_I1114_P17_16 I1_I1114_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I113_XG_MN1 (VSS I1_I1114_G15_14 XI1_I1114_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I175_XG_MN2 (I1_I1114_G24_9n I1_I1114_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I175_XG_MN0 (XI1_I1114_I175_XG_n1 I1_I1114_P24_17 I1_I1114_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I175_XG_MN1 (VSS I1_I1114_G16_9 XI1_I1114_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I171_XG_MN2 (I1_I1114_G20_5n I1_I1114_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I171_XG_MN0 (XI1_I1114_I171_XG_n1 I1_I1114_P20_13 I1_I1114_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I171_XG_MN1 (VSS I1_I1114_G12_5 XI1_I1114_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I169_XG_MN2 (I1_I1114_G18_3n I1_I1114_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I169_XG_MN0 (XI1_I1114_I169_XG_n1 I1_I1114_P18_11 I1_I1114_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I169_XG_MN1 (VSS I1_I1114_G10_3 XI1_I1114_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I160_XG_MN2 (I1_I1114_G10_0n I1_I1114_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I160_XG_MN0 (XI1_I1114_I160_XG_n1 I1_I1114_P10_3 I1_I1114_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I160_XG_MN1 (VSS I1_I1114_G2_0np XI1_I1114_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I112_XG_MN2 (I1_I1114_G16_13n I1_I1114_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I112_XG_MN0 (XI1_I1114_I112_XG_n1 I1_I1114_P16_15 I1_I1114_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I112_XG_MN1 (VSS I1_I1114_G14_13 XI1_I1114_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I165_XG_MN2 (I1_I1068_G14_0n I1_I1068_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I165_XG_MN0 (XI1_I1068_I165_XG_n1 I1_I1068_P14_7 I1_I1068_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I165_XG_MN1 (VSS I1_I1068_G6_0 XI1_I1068_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I177_XG_MN2 (I1_I1068_G26_11n I1_I1068_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I177_XG_MN0 (XI1_I1068_I177_XG_n1 I1_I1068_P26_19 I1_I1068_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I177_XG_MN1 (VSS I1_I1068_G18_11 XI1_I1068_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I116_XG_MN2 (I1_I1068_G20_17n I1_I1068_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I116_XG_MN0 (XI1_I1068_I116_XG_n1 I1_I1068_P20_19 I1_I1068_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I116_XG_MN1 (VSS I1_I1068_G18_17 XI1_I1068_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I172_XG_MN2 (I1_I1068_G21_6n I1_I1068_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I172_XG_MN0 (XI1_I1068_I172_XG_n1 I1_I1068_P21_14 I1_I1068_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I172_XG_MN1 (VSS I1_I1068_G13_6 XI1_I1068_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I178_XG_MN2 (I1_I1068_G27_12n I1_I1068_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I178_XG_MN0 (XI1_I1068_I178_XG_n1 I1_I1068_P27_20 I1_I1068_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I178_XG_MN1 (VSS I1_I1068_G19_12 XI1_I1068_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I117_XG_MN2 (I1_I1068_G21_18n I1_I1068_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I117_XG_MN0 (XI1_I1068_I117_XG_n1 I1_I1068_P21_20 I1_I1068_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I117_XG_MN1 (VSS I1_I1068_G19_18 XI1_I1068_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I124_XG_MN2 (I1_I1022_G28_25n I1_I1022_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I124_XG_MN0 (XI1_I1022_I124_XG_n1 I1_I1022_P28_27 I1_I1022_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I124_XG_MN1 (VSS I1_I1022_G26_25 XI1_I1022_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I122_XG_MN2 (I1_I1022_G26_23n I1_I1022_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I122_XG_MN0 (XI1_I1022_I122_XG_n1 I1_I1022_P26_25 I1_I1022_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I122_XG_MN1 (VSS I1_I1022_G24_23 XI1_I1022_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I125_XG_MN2 (I1_I1022_G29_26n I1_I1022_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I125_XG_MN0 (XI1_I1022_I125_XG_n1 I1_I1022_P29_28 I1_I1022_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I125_XG_MN1 (VSS I1_I1022_G27_26 XI1_I1022_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I181_XG_MN2 (I1_I976_G30_15n I1_I976_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I181_XG_MN0 (XI1_I976_I181_XG_n1 I1_I976_P30_23 I1_I976_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I181_XG_MN1 (VSS I1_I976_G22_15 XI1_I976_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I116_XG_MN2 (I1_I976_G20_17n I1_I976_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I116_XG_MN0 (XI1_I976_I116_XG_n1 I1_I976_P20_19 I1_I976_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I116_XG_MN1 (VSS I1_I976_G18_17 XI1_I976_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I114_XG_MN2 (I1_I976_G18_15n I1_I976_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I114_XG_MN0 (XI1_I976_I114_XG_n1 I1_I976_P18_17 I1_I976_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I114_XG_MN1 (VSS I1_I976_G16_15 XI1_I976_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I112_XG_MN2 (I1_I976_G16_13n I1_I976_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I112_XG_MN0 (XI1_I976_I112_XG_n1 I1_I976_P16_15 I1_I976_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I112_XG_MN1 (VSS I1_I976_G14_13 XI1_I976_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I110_XG_MN2 (I1_I976_G14_11n I1_I976_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I110_XG_MN0 (XI1_I976_I110_XG_n1 I1_I976_P14_13 I1_I976_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I110_XG_MN1 (VSS I1_I976_G12_11 XI1_I976_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I162_XG_MN2 (I1_I976_G11_0n I1_I976_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I162_XG_MN0 (XI1_I976_I162_XG_n1 I1_I976_P11_4 I1_I976_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I162_XG_MN1 (VSS I1_I976_G3_0np XI1_I976_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I158_XG_MN2 (I1_I976_G9_0n I1_I976_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I158_XG_MN0 (XI1_I976_I158_XG_n1 I1_I976_P9_2 I1_I976_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I158_XG_MN1 (VSS I1_I976_G1_0 XI1_I976_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I157_XG_MN2 (I1_I608_G8_0n I1_I608_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I157_XG_MN0 (XI1_I608_I157_XG_n1 I1_I608_P8_1 I1_I608_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I157_XG_MN1 (VSS I1_I608_G0_0 XI1_I608_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I170_XG_MN2 (I1_I1114_G19_4n I1_I1114_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I170_XG_MN0 (XI1_I1114_I170_XG_n1 I1_I1114_P19_12 I1_I1114_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I170_XG_MN1 (VSS I1_I1114_G11_4 XI1_I1114_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I168_XG_MN2 (I1_I1114_G17_2n I1_I1114_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I168_XG_MN0 (XI1_I1114_I168_XG_n1 I1_I1114_P17_10 I1_I1114_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I168_XG_MN1 (VSS I1_I1114_G9_2 XI1_I1114_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I111_XG_MN2 (I1_I1114_G15_12n I1_I1114_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I111_XG_MN0 (XI1_I1114_I111_XG_n1 I1_I1114_P15_14 I1_I1114_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I111_XG_MN1 (VSS I1_I1114_G13_12 XI1_I1114_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I109_XG_MN2 (I1_I1114_G13_10n I1_I1114_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I109_XG_MN0 (XI1_I1114_I109_XG_n1 I1_I1114_P13_12 I1_I1114_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I109_XG_MN1 (VSS I1_I1114_G11_10 XI1_I1114_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I163_XG_MN2 (I1_I1114_G12_0n I1_I1114_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I163_XG_MN0 (XI1_I1114_I163_XG_n1 I1_I1114_P12_5 I1_I1114_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I163_XG_MN1 (VSS I1_I1114_G4_0 XI1_I1114_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I110_XG_MN2 (I1_I1114_G14_11n I1_I1114_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I110_XG_MN0 (XI1_I1114_I110_XG_n1 I1_I1114_P14_13 I1_I1114_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I110_XG_MN1 (VSS I1_I1114_G12_11 XI1_I1114_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I171_XG_MN2 (I1_I1068_G20_5n I1_I1068_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I171_XG_MN0 (XI1_I1068_I171_XG_n1 I1_I1068_P20_13 I1_I1068_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I171_XG_MN1 (VSS I1_I1068_G12_5 XI1_I1068_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I164_XG_MN2 (I1_I1068_G13_0n I1_I1068_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I164_XG_MN0 (XI1_I1068_I164_XG_n1 I1_I1068_P13_6 I1_I1068_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I164_XG_MN1 (VSS I1_I1068_G5_0 XI1_I1068_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I170_XG_MN2 (I1_I1068_G19_4n I1_I1068_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I170_XG_MN0 (XI1_I1068_I170_XG_n1 I1_I1068_P19_12 I1_I1068_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I170_XG_MN1 (VSS I1_I1068_G11_4 XI1_I1068_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I115_XG_MN2 (I1_I1068_G19_16n I1_I1068_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I115_XG_MN0 (XI1_I1068_I115_XG_n1 I1_I1068_P19_18 I1_I1068_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I115_XG_MN1 (VSS I1_I1068_G17_16 XI1_I1068_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I120_XG_MN2 (I1_I1022_G24_21n I1_I1022_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I120_XG_MN0 (XI1_I1022_I120_XG_n1 I1_I1022_P24_23 I1_I1022_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I120_XG_MN1 (VSS I1_I1022_G22_21 XI1_I1022_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I123_XG_MN2 (I1_I1022_G27_24n I1_I1022_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I123_XG_MN0 (XI1_I1022_I123_XG_n1 I1_I1022_P27_26 I1_I1022_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I123_XG_MN1 (VSS I1_I1022_G25_24 XI1_I1022_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I121_XG_MN2 (I1_I1022_G25_22n I1_I1022_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I121_XG_MN0 (XI1_I1022_I121_XG_n1 I1_I1022_P25_24 I1_I1022_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I121_XG_MN1 (VSS I1_I1022_G23_22 XI1_I1022_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I179_XG_MN2 (I1_I976_G28_13n I1_I976_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I179_XG_MN0 (XI1_I976_I179_XG_n1 I1_I976_P28_21 I1_I976_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I179_XG_MN1 (VSS I1_I976_G20_13 XI1_I976_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I173_XG_MN2 (I1_I976_G22_7n I1_I976_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I173_XG_MN0 (XI1_I976_I173_XG_n1 I1_I976_P22_15 I1_I976_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I173_XG_MN1 (VSS I1_I976_G14_7 XI1_I976_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I177_XG_MN2 (I1_I976_G26_11n I1_I976_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I177_XG_MN0 (XI1_I976_I177_XG_n1 I1_I976_P26_19 I1_I976_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I177_XG_MN1 (VSS I1_I976_G18_11 XI1_I976_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I175_XG_MN2 (I1_I976_G24_9n I1_I976_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I175_XG_MN0 (XI1_I976_I175_XG_n1 I1_I976_P24_17 I1_I976_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I175_XG_MN1 (VSS I1_I976_G16_9 XI1_I976_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I108_XG_MN2 (I1_I976_G12_9n I1_I976_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I108_XG_MN0 (XI1_I976_I108_XG_n1 I1_I976_P12_11 I1_I976_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I108_XG_MN1 (VSS I1_I976_G10_9 XI1_I976_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I106_XG_MN2 (I1_I976_G10_7n I1_I976_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I106_XG_MN0 (XI1_I976_I106_XG_n1 I1_I976_P10_9 I1_I976_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I106_XG_MN1 (VSS I1_I976_G8_7 XI1_I976_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I101_XG_MN2 (I1_I976_G5_2n I1_I976_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I101_XG_MN0 (XI1_I976_I101_XG_n1 I1_I976_P5_4 I1_I976_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I101_XG_MN1 (VSS I1_I976_G3_2 XI1_I976_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I98_XG_MN2 (I1_I608_G2_0n I1_I608_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I98_XG_MN0 (XI1_I608_I98_XG_n1 I1_I608_P2_1 I1_I608_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I98_XG_MN1 (VSS I1_I608_G0_0 XI1_I608_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I100_XG_MN2 (I1_I608_G4_1n I1_I608_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I100_XG_MN0 (XI1_I608_I100_XG_n1 I1_I608_P4_3 I1_I608_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I100_XG_MN1 (VSS I1_I608_G2_1 XI1_I608_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I167_XG_MN2 (I1_I608_G16_1n I1_I608_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I167_XG_MN0 (XI1_I608_I167_XG_n1 I1_I608_P16_9 I1_I608_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I167_XG_MN1 (VSS I1_I608_G8_1 XI1_I608_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I160_XG_MN2 (I1_I608_G10_0n I1_I608_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I160_XG_MN0 (XI1_I608_I160_XG_n1 I1_I608_P10_3 I1_I608_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I160_XG_MN1 (VSS I1_I608_G2_0np XI1_I608_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I169_XG_MN2 (I1_I608_G18_3n I1_I608_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I169_XG_MN0 (XI1_I608_I169_XG_n1 I1_I608_P18_11 I1_I608_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I169_XG_MN1 (VSS I1_I608_G10_3 XI1_I608_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I175_XG_MN2 (I1_I608_G24_9n I1_I608_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I175_XG_MN0 (XI1_I608_I175_XG_n1 I1_I608_P24_17 I1_I608_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I175_XG_MN1 (VSS I1_I608_G16_9 XI1_I608_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I163_XG_MN2 (I1_I608_G12_0n I1_I608_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I163_XG_MN0 (XI1_I608_I163_XG_n1 I1_I608_P12_5 I1_I608_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I163_XG_MN1 (VSS I1_I608_G4_0 XI1_I608_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I171_XG_MN2 (I1_I608_G20_5n I1_I608_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I171_XG_MN0 (XI1_I608_I171_XG_n1 I1_I608_P20_13 I1_I608_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I171_XG_MN1 (VSS I1_I608_G12_5 XI1_I608_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I165_XG_MN2 (I1_I608_G14_0n I1_I608_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I165_XG_MN0 (XI1_I608_I165_XG_n1 I1_I608_P14_7 I1_I608_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I165_XG_MN1 (VSS I1_I608_G6_0 XI1_I608_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I177_XG_MN2 (I1_I608_G26_11n I1_I608_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I177_XG_MN0 (XI1_I608_I177_XG_n1 I1_I608_P26_19 I1_I608_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I177_XG_MN1 (VSS I1_I608_G18_11 XI1_I608_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I173_XG_MN2 (I1_I608_G22_7n I1_I608_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I173_XG_MN0 (XI1_I608_I173_XG_n1 I1_I608_P22_15 I1_I608_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I173_XG_MN1 (VSS I1_I608_G14_7 XI1_I608_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I179_XG_MN2 (I1_I608_G28_13n I1_I608_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I179_XG_MN0 (XI1_I608_I179_XG_n1 I1_I608_P28_21 I1_I608_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I179_XG_MN1 (VSS I1_I608_G20_13 XI1_I608_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I181_XG_MN2 (I1_I608_G30_15n I1_I608_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I181_XG_MN0 (XI1_I608_I181_XG_n1 I1_I608_P30_23 I1_I608_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I181_XG_MN1 (VSS I1_I608_G22_15 XI1_I608_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I126_XG_MN2 (I1_I608_G30_27n I1_I608_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I126_XG_MN0 (XI1_I608_I126_XG_n1 I1_I608_P30_29 I1_I608_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I126_XG_MN1 (VSS I1_I608_G28_27 XI1_I608_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I162_XG_MN2 (I1_I1114_G11_0n I1_I1114_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I162_XG_MN0 (XI1_I1114_I162_XG_n1 I1_I1114_P11_4 I1_I1114_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I162_XG_MN1 (VSS I1_I1114_G3_0np XI1_I1114_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I158_XG_MN2 (I1_I1114_G9_0n I1_I1114_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I158_XG_MN0 (XI1_I1114_I158_XG_n1 I1_I1114_P9_2 I1_I1114_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I158_XG_MN1 (VSS I1_I1114_G1_0 XI1_I1114_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I163_XG_MN2 (I1_I1068_G12_0n I1_I1068_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I163_XG_MN0 (XI1_I1068_I163_XG_n1 I1_I1068_P12_5 I1_I1068_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I163_XG_MN1 (VSS I1_I1068_G4_0 XI1_I1068_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I169_XG_MN2 (I1_I1068_G18_3n I1_I1068_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I169_XG_MN0 (XI1_I1068_I169_XG_n1 I1_I1068_P18_11 I1_I1068_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I169_XG_MN1 (VSS I1_I1068_G10_3 XI1_I1068_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I114_XG_MN2 (I1_I1068_G18_15n I1_I1068_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I114_XG_MN0 (XI1_I1068_I114_XG_n1 I1_I1068_P18_17 I1_I1068_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I114_XG_MN1 (VSS I1_I1068_G16_15 XI1_I1068_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I162_XG_MN2 (I1_I1068_G11_0n I1_I1068_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I162_XG_MN0 (XI1_I1068_I162_XG_n1 I1_I1068_P11_4 I1_I1068_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I162_XG_MN1 (VSS I1_I1068_G3_0np XI1_I1068_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I176_XG_MN2 (I1_I1068_G25_10n I1_I1068_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I176_XG_MN0 (XI1_I1068_I176_XG_n1 I1_I1068_P25_18 I1_I1068_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I176_XG_MN1 (VSS I1_I1068_G17_10 XI1_I1068_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I113_XG_MN2 (I1_I1068_G17_14n I1_I1068_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I113_XG_MN0 (XI1_I1068_I113_XG_n1 I1_I1068_P17_16 I1_I1068_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I113_XG_MN1 (VSS I1_I1068_G15_14 XI1_I1068_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I181_XG_MN2 (I1_I1022_G30_15n I1_I1022_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I181_XG_MN0 (XI1_I1022_I181_XG_n1 I1_I1022_P30_23 I1_I1022_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I181_XG_MN1 (VSS I1_I1022_G22_15 XI1_I1022_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I118_XG_MN2 (I1_I1022_G22_19n I1_I1022_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I118_XG_MN0 (XI1_I1022_I118_XG_n1 I1_I1022_P22_21 I1_I1022_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I118_XG_MN1 (VSS I1_I1022_G20_19 XI1_I1022_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I182_XG_MN2 (I1_I1022_G31_16n I1_I1022_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I182_XG_MN0 (XI1_I1022_I182_XG_n1 I1_I1022_P31_24 I1_I1022_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I182_XG_MN1 (VSS I1_I1022_G23_16 XI1_I1022_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I119_XG_MN2 (I1_I1022_G23_20n I1_I1022_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I119_XG_MN0 (XI1_I1022_I119_XG_n1 I1_I1022_P23_22 I1_I1022_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I119_XG_MN1 (VSS I1_I1022_G21_20 XI1_I1022_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I165_XG_MN2 (I1_I976_G14_0n I1_I976_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I165_XG_MN0 (XI1_I976_I165_XG_n1 I1_I976_P14_7 I1_I976_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I165_XG_MN1 (VSS I1_I976_G6_0 XI1_I976_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I171_XG_MN2 (I1_I976_G20_5n I1_I976_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I171_XG_MN0 (XI1_I976_I171_XG_n1 I1_I976_P20_13 I1_I976_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I171_XG_MN1 (VSS I1_I976_G12_5 XI1_I976_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I163_XG_MN2 (I1_I976_G12_0n I1_I976_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I163_XG_MN0 (XI1_I976_I163_XG_n1 I1_I976_P12_5 I1_I976_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I163_XG_MN1 (VSS I1_I976_G4_0 XI1_I976_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I169_XG_MN2 (I1_I976_G18_3n I1_I976_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I169_XG_MN0 (XI1_I976_I169_XG_n1 I1_I976_P18_11 I1_I976_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I169_XG_MN1 (VSS I1_I976_G10_3 XI1_I976_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I160_XG_MN2 (I1_I976_G10_0n I1_I976_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I160_XG_MN0 (XI1_I976_I160_XG_n1 I1_I976_P10_3 I1_I976_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I160_XG_MN1 (VSS I1_I976_G2_0np XI1_I976_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I104_XG_MN2 (I1_I976_G8_5n I1_I976_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I104_XG_MN0 (XI1_I976_I104_XG_n1 I1_I976_P8_7 I1_I976_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I104_XG_MN1 (VSS I1_I976_G6_5 XI1_I976_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I102_XG_MN2 (I1_I976_G6_3n I1_I976_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I102_XG_MN0 (XI1_I976_I102_XG_n1 I1_I976_P6_5 I1_I976_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I102_XG_MN1 (VSS I1_I976_G4_3 XI1_I976_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I99_XG_MN2 (I1_I976_G3_0n I1_I976_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I99_XG_MN0 (XI1_I976_I99_XG_n1 I1_I976_P3_2 I1_I976_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I99_XG_MN1 (VSS I1_I976_G1_0 XI1_I976_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I102_XG_MN2 (I1_I608_G6_3n I1_I608_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I102_XG_MN0 (XI1_I608_I102_XG_n1 I1_I608_P6_5 I1_I608_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I102_XG_MN1 (VSS I1_I608_G4_3 XI1_I608_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I104_XG_MN2 (I1_I608_G8_5n I1_I608_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I104_XG_MN0 (XI1_I608_I104_XG_n1 I1_I608_P8_7 I1_I608_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I104_XG_MN1 (VSS I1_I608_G6_5 XI1_I608_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I106_XG_MN2 (I1_I608_G10_7n I1_I608_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I106_XG_MN0 (XI1_I608_I106_XG_n1 I1_I608_P10_9 I1_I608_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I106_XG_MN1 (VSS I1_I608_G8_7 XI1_I608_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I108_XG_MN2 (I1_I608_G12_9n I1_I608_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I108_XG_MN0 (XI1_I608_I108_XG_n1 I1_I608_P12_11 I1_I608_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I108_XG_MN1 (VSS I1_I608_G10_9 XI1_I608_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I110_XG_MN2 (I1_I608_G14_11n I1_I608_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I110_XG_MN0 (XI1_I608_I110_XG_n1 I1_I608_P14_13 I1_I608_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I110_XG_MN1 (VSS I1_I608_G12_11 XI1_I608_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I112_XG_MN2 (I1_I608_G16_13n I1_I608_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I112_XG_MN0 (XI1_I608_I112_XG_n1 I1_I608_P16_15 I1_I608_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I112_XG_MN1 (VSS I1_I608_G14_13 XI1_I608_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I114_XG_MN2 (I1_I608_G18_15n I1_I608_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I114_XG_MN0 (XI1_I608_I114_XG_n1 I1_I608_P18_17 I1_I608_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I114_XG_MN1 (VSS I1_I608_G16_15 XI1_I608_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I116_XG_MN2 (I1_I608_G20_17n I1_I608_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I116_XG_MN0 (XI1_I608_I116_XG_n1 I1_I608_P20_19 I1_I608_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I116_XG_MN1 (VSS I1_I608_G18_17 XI1_I608_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I118_XG_MN2 (I1_I608_G22_19n I1_I608_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I118_XG_MN0 (XI1_I608_I118_XG_n1 I1_I608_P22_21 I1_I608_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I118_XG_MN1 (VSS I1_I608_G20_19 XI1_I608_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I120_XG_MN2 (I1_I608_G24_21n I1_I608_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I120_XG_MN0 (XI1_I608_I120_XG_n1 I1_I608_P24_23 I1_I608_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I120_XG_MN1 (VSS I1_I608_G22_21 XI1_I608_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I122_XG_MN2 (I1_I608_G26_23n I1_I608_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I122_XG_MN0 (XI1_I608_I122_XG_n1 I1_I608_P26_25 I1_I608_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I122_XG_MN1 (VSS I1_I608_G24_23 XI1_I608_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I124_XG_MN2 (I1_I608_G28_25n I1_I608_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I124_XG_MN0 (XI1_I608_I124_XG_n1 I1_I608_P28_27 I1_I608_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I124_XG_MN1 (VSS I1_I608_G26_25 XI1_I608_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I121_XG_MN2 (I1_I1482_G25_22n I1_I1482_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I121_XG_MN0 (XI1_I1482_I121_XG_n1 I1_I1482_P25_24 I1_I1482_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I121_XG_MN1 (VSS I1_I1482_G23_22 XI1_I1482_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I119_XG_MN2 (I1_I1482_G23_20n I1_I1482_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I119_XG_MN0 (XI1_I1482_I119_XG_n1 I1_I1482_P23_22 I1_I1482_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I119_XG_MN1 (VSS I1_I1482_G21_20 XI1_I1482_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I117_XG_MN2 (I1_I1482_G21_18n I1_I1482_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I117_XG_MN0 (XI1_I1482_I117_XG_n1 I1_I1482_P21_20 I1_I1482_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I117_XG_MN1 (VSS I1_I1482_G19_18 XI1_I1482_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I115_XG_MN2 (I1_I1482_G19_16n I1_I1482_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I115_XG_MN0 (XI1_I1482_I115_XG_n1 I1_I1482_P19_18 I1_I1482_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I115_XG_MN1 (VSS I1_I1482_G17_16 XI1_I1482_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I113_XG_MN2 (I1_I1482_G17_14n I1_I1482_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I113_XG_MN0 (XI1_I1482_I113_XG_n1 I1_I1482_P17_16 I1_I1482_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I113_XG_MN1 (VSS I1_I1482_G15_14 XI1_I1482_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I111_XG_MN2 (I1_I1482_G15_12n I1_I1482_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I111_XG_MN0 (XI1_I1482_I111_XG_n1 I1_I1482_P15_14 I1_I1482_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I111_XG_MN1 (VSS I1_I1482_G13_12 XI1_I1482_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I109_XG_MN2 (I1_I1482_G13_10n I1_I1482_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I109_XG_MN0 (XI1_I1482_I109_XG_n1 I1_I1482_P13_12 I1_I1482_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I109_XG_MN1 (VSS I1_I1482_G11_10 XI1_I1482_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I107_XG_MN2 (I1_I1482_G11_8n I1_I1482_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I107_XG_MN0 (XI1_I1482_I107_XG_n1 I1_I1482_P11_10 I1_I1482_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I107_XG_MN1 (VSS I1_I1482_G9_8 XI1_I1482_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I105_XG_MN2 (I1_I1482_G9_6n I1_I1482_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I105_XG_MN0 (XI1_I1482_I105_XG_n1 I1_I1482_P9_8 I1_I1482_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I105_XG_MN1 (VSS I1_I1482_G7_6 XI1_I1482_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I103_XG_MN2 (I1_I1482_G7_4n I1_I1482_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I103_XG_MN0 (XI1_I1482_I103_XG_n1 I1_I1482_P7_6 I1_I1482_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I103_XG_MN1 (VSS I1_I1482_G5_4 XI1_I1482_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I101_XG_MN2 (I1_I1482_G5_2n I1_I1482_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I101_XG_MN0 (XI1_I1482_I101_XG_n1 I1_I1482_P5_4 I1_I1482_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I101_XG_MN1 (VSS I1_I1482_G3_2 XI1_I1482_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I99_XG_MN2 (I1_I1482_G3_0n I1_I1482_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I99_XG_MN0 (XI1_I1482_I99_XG_n1 I1_I1482_P3_2 I1_I1482_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I99_XG_MN1 (VSS I1_I1482_G1_0 XI1_I1482_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I105_XG_MN2 (I1_I1114_G9_6n I1_I1114_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I105_XG_MN0 (XI1_I1114_I105_XG_n1 I1_I1114_P9_8 I1_I1114_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I105_XG_MN1 (VSS I1_I1114_G7_6 XI1_I1114_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I107_XG_MN2 (I1_I1114_G11_8n I1_I1114_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I107_XG_MN0 (XI1_I1114_I107_XG_n1 I1_I1114_P11_10 I1_I1114_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I107_XG_MN1 (VSS I1_I1114_G9_8 XI1_I1114_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I108_XG_MN2 (I1_I1114_G12_9n I1_I1114_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I108_XG_MN0 (XI1_I1114_I108_XG_n1 I1_I1114_P12_11 I1_I1114_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I108_XG_MN1 (VSS I1_I1114_G10_9 XI1_I1114_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I167_XG_MN2 (I1_I1114_G16_1n I1_I1114_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I167_XG_MN0 (XI1_I1114_I167_XG_n1 I1_I1114_P16_9 I1_I1114_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I167_XG_MN1 (VSS I1_I1114_G8_1 XI1_I1114_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I160_XG_MN2 (I1_I1068_G10_0n I1_I1068_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I160_XG_MN0 (XI1_I1068_I160_XG_n1 I1_I1068_P10_3 I1_I1068_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I160_XG_MN1 (VSS I1_I1068_G2_0np XI1_I1068_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I112_XG_MN2 (I1_I1068_G16_13n I1_I1068_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I112_XG_MN0 (XI1_I1068_I112_XG_n1 I1_I1068_P16_15 I1_I1068_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I112_XG_MN1 (VSS I1_I1068_G14_13 XI1_I1068_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I110_XG_MN2 (I1_I1068_G14_11n I1_I1068_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I110_XG_MN0 (XI1_I1068_I110_XG_n1 I1_I1068_P14_13 I1_I1068_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I110_XG_MN1 (VSS I1_I1068_G12_11 XI1_I1068_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I111_XG_MN2 (I1_I1068_G15_12n I1_I1068_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I111_XG_MN0 (XI1_I1068_I111_XG_n1 I1_I1068_P15_14 I1_I1068_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I111_XG_MN1 (VSS I1_I1068_G13_12 XI1_I1068_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I173_XG_MN2 (I1_I1022_G22_7n I1_I1022_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I173_XG_MN0 (XI1_I1022_I173_XG_n1 I1_I1022_P22_15 I1_I1022_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I173_XG_MN1 (VSS I1_I1022_G14_7 XI1_I1022_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I174_XG_MN2 (I1_I1022_G23_8n I1_I1022_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I174_XG_MN0 (XI1_I1022_I174_XG_n1 I1_I1022_P23_16 I1_I1022_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I174_XG_MN1 (VSS I1_I1022_G15_8 XI1_I1022_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I117_XG_MN2 (I1_I1022_G21_18n I1_I1022_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I117_XG_MN0 (XI1_I1022_I117_XG_n1 I1_I1022_P21_20 I1_I1022_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I117_XG_MN1 (VSS I1_I1022_G19_18 XI1_I1022_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I115_XG_MN2 (I1_I1022_G19_16n I1_I1022_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I115_XG_MN0 (XI1_I1022_I115_XG_n1 I1_I1022_P19_18 I1_I1022_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I115_XG_MN1 (VSS I1_I1022_G17_16 XI1_I1022_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I167_XG_MN2 (I1_I976_G16_1n I1_I976_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I167_XG_MN0 (XI1_I976_I167_XG_n1 I1_I976_P16_9 I1_I976_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I167_XG_MN1 (VSS I1_I976_G8_1 XI1_I976_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I100_XG_MN2 (I1_I976_G4_1n I1_I976_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I100_XG_MN0 (XI1_I976_I100_XG_n1 I1_I976_P4_3 I1_I976_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I100_XG_MN1 (VSS I1_I976_G2_1 XI1_I976_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I99_XG_MN2 (I1_I608_G3_0n I1_I608_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I99_XG_MN0 (XI1_I608_I99_XG_n1 I1_I608_P3_2 I1_I608_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I99_XG_MN1 (VSS I1_I608_G1_0 XI1_I608_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I101_XG_MN2 (I1_I608_G5_2n I1_I608_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I101_XG_MN0 (XI1_I608_I101_XG_n1 I1_I608_P5_4 I1_I608_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I101_XG_MN1 (VSS I1_I608_G3_2 XI1_I608_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I158_XG_MN2 (I1_I608_G9_0n I1_I608_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I158_XG_MN0 (XI1_I608_I158_XG_n1 I1_I608_P9_2 I1_I608_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I158_XG_MN1 (VSS I1_I608_G1_0 XI1_I608_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I168_XG_MN2 (I1_I608_G17_2n I1_I608_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I168_XG_MN0 (XI1_I608_I168_XG_n1 I1_I608_P17_10 I1_I608_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I168_XG_MN1 (VSS I1_I608_G9_2 XI1_I608_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I162_XG_MN2 (I1_I608_G11_0n I1_I608_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I162_XG_MN0 (XI1_I608_I162_XG_n1 I1_I608_P11_4 I1_I608_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I162_XG_MN1 (VSS I1_I608_G3_0np XI1_I608_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I170_XG_MN2 (I1_I608_G19_4n I1_I608_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I170_XG_MN0 (XI1_I608_I170_XG_n1 I1_I608_P19_12 I1_I608_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I170_XG_MN1 (VSS I1_I608_G11_4 XI1_I608_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I164_XG_MN2 (I1_I608_G13_0n I1_I608_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I164_XG_MN0 (XI1_I608_I164_XG_n1 I1_I608_P13_6 I1_I608_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I164_XG_MN1 (VSS I1_I608_G5_0 XI1_I608_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I172_XG_MN2 (I1_I608_G21_6n I1_I608_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I172_XG_MN0 (XI1_I608_I172_XG_n1 I1_I608_P21_14 I1_I608_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I172_XG_MN1 (VSS I1_I608_G13_6 XI1_I608_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I166_XG_MN2 (I1_I608_G15_0n I1_I608_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I166_XG_MN0 (XI1_I608_I166_XG_n1 I1_I608_P15_8 I1_I608_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I166_XG_MN1 (VSS I1_I608_G7_0 XI1_I608_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I174_XG_MN2 (I1_I608_G23_8n I1_I608_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I174_XG_MN0 (XI1_I608_I174_XG_n1 I1_I608_P23_16 I1_I608_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I174_XG_MN1 (VSS I1_I608_G15_8 XI1_I608_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I180_XG_MN2 (I1_I608_G29_14n I1_I608_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I180_XG_MN0 (XI1_I608_I180_XG_n1 I1_I608_P29_22 I1_I608_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I180_XG_MN1 (VSS I1_I608_G21_14 XI1_I608_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I182_XG_MN2 (I1_I608_G31_16n I1_I608_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I182_XG_MN0 (XI1_I608_I182_XG_n1 I1_I608_P31_24 I1_I608_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I182_XG_MN1 (VSS I1_I608_G23_16 XI1_I608_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I127_XG_MN2 (I1_I608_G31_28n I1_I608_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I127_XG_MN0 (XI1_I608_I127_XG_n1 I1_I608_P31_30 I1_I608_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I127_XG_MN1 (VSS I1_I608_G29_28 XI1_I608_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I182_XG_MN2 (I1_I1482_G31_16n I1_I1482_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I182_XG_MN0 (XI1_I1482_I182_XG_n1 I1_I1482_P31_24 I1_I1482_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I182_XG_MN1 (VSS I1_I1482_G23_16 XI1_I1482_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I174_XG_MN2 (I1_I1482_G23_8n I1_I1482_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I174_XG_MN0 (XI1_I1482_I174_XG_n1 I1_I1482_P23_16 I1_I1482_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I174_XG_MN1 (VSS I1_I1482_G15_8 XI1_I1482_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I166_XG_MN2 (I1_I1482_G15_0n I1_I1482_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I166_XG_MN0 (XI1_I1482_I166_XG_n1 I1_I1482_P15_8 I1_I1482_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I166_XG_MN1 (VSS I1_I1482_G7_0 XI1_I1482_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I176_XG_MN2 (I1_I1482_G25_10n I1_I1482_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I176_XG_MN0 (XI1_I1482_I176_XG_n1 I1_I1482_P25_18 I1_I1482_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I176_XG_MN1 (VSS I1_I1482_G17_10 XI1_I1482_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I172_XG_MN2 (I1_I1482_G21_6n I1_I1482_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I172_XG_MN0 (XI1_I1482_I172_XG_n1 I1_I1482_P21_14 I1_I1482_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I172_XG_MN1 (VSS I1_I1482_G13_6 XI1_I1482_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I164_XG_MN2 (I1_I1482_G13_0n I1_I1482_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I164_XG_MN0 (XI1_I1482_I164_XG_n1 I1_I1482_P13_6 I1_I1482_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I164_XG_MN1 (VSS I1_I1482_G5_0 XI1_I1482_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I170_XG_MN2 (I1_I1482_G19_4n I1_I1482_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I170_XG_MN0 (XI1_I1482_I170_XG_n1 I1_I1482_P19_12 I1_I1482_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I170_XG_MN1 (VSS I1_I1482_G11_4 XI1_I1482_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I162_XG_MN2 (I1_I1482_G11_0n I1_I1482_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I162_XG_MN0 (XI1_I1482_I162_XG_n1 I1_I1482_P11_4 I1_I1482_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I162_XG_MN1 (VSS I1_I1482_G3_0np XI1_I1482_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I168_XG_MN2 (I1_I1482_G17_2n I1_I1482_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I168_XG_MN0 (XI1_I1482_I168_XG_n1 I1_I1482_P17_10 I1_I1482_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I168_XG_MN1 (VSS I1_I1482_G9_2 XI1_I1482_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I158_XG_MN2 (I1_I1482_G9_0n I1_I1482_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I158_XG_MN0 (XI1_I1482_I158_XG_n1 I1_I1482_P9_2 I1_I1482_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I158_XG_MN1 (VSS I1_I1482_G1_0 XI1_I1482_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I102_XG_MN2 (I1_I1482_G6_3n I1_I1482_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I102_XG_MN0 (XI1_I1482_I102_XG_n1 I1_I1482_P6_5 I1_I1482_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I102_XG_MN1 (VSS I1_I1482_G4_3 XI1_I1482_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I98_XG_MN2 (I1_I1482_G2_0n I1_I1482_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I98_XG_MN0 (XI1_I1482_I98_XG_n1 I1_I1482_P2_1 I1_I1482_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I98_XG_MN1 (VSS I1_I1482_G0_0 XI1_I1482_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I103_XG_MN2 (I1_I1114_G7_4n I1_I1114_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I103_XG_MN0 (XI1_I1114_I103_XG_n1 I1_I1114_P7_6 I1_I1114_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I103_XG_MN1 (VSS I1_I1114_G5_4 XI1_I1114_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I99_XG_MN2 (I1_I1114_G3_0n I1_I1114_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I99_XG_MN0 (XI1_I1114_I99_XG_n1 I1_I1114_P3_2 I1_I1114_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I99_XG_MN1 (VSS I1_I1114_G1_0 XI1_I1114_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I106_XG_MN2 (I1_I1114_G10_7n I1_I1114_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I106_XG_MN0 (XI1_I1114_I106_XG_n1 I1_I1114_P10_9 I1_I1114_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I106_XG_MN1 (VSS I1_I1114_G8_7 XI1_I1114_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I157_XG_MN2 (I1_I1114_G8_0n I1_I1114_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I157_XG_MN0 (XI1_I1114_I157_XG_n1 I1_I1114_P8_1 I1_I1114_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I157_XG_MN1 (VSS I1_I1114_G0_0 XI1_I1114_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I175_XG_MN2 (I1_I1068_G24_9n I1_I1068_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I175_XG_MN0 (XI1_I1068_I175_XG_n1 I1_I1068_P24_17 I1_I1068_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I175_XG_MN1 (VSS I1_I1068_G16_9 XI1_I1068_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I108_XG_MN2 (I1_I1068_G12_9n I1_I1068_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I108_XG_MN0 (XI1_I1068_I108_XG_n1 I1_I1068_P12_11 I1_I1068_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I108_XG_MN1 (VSS I1_I1068_G10_9 XI1_I1068_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I168_XG_MN2 (I1_I1068_G17_2n I1_I1068_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I168_XG_MN0 (XI1_I1068_I168_XG_n1 I1_I1068_P17_10 I1_I1068_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I168_XG_MN1 (VSS I1_I1068_G9_2 XI1_I1068_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I107_XG_MN2 (I1_I1068_G11_8n I1_I1068_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I107_XG_MN0 (XI1_I1068_I107_XG_n1 I1_I1068_P11_10 I1_I1068_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I107_XG_MN1 (VSS I1_I1068_G9_8 XI1_I1068_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I109_XG_MN2 (I1_I1068_G13_10n I1_I1068_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I109_XG_MN0 (XI1_I1068_I109_XG_n1 I1_I1068_P13_12 I1_I1068_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I109_XG_MN1 (VSS I1_I1068_G11_10 XI1_I1068_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I165_XG_MN2 (I1_I1022_G14_0n I1_I1022_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I165_XG_MN0 (XI1_I1022_I165_XG_n1 I1_I1022_P14_7 I1_I1022_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I165_XG_MN1 (VSS I1_I1022_G6_0 XI1_I1022_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I114_XG_MN2 (I1_I1022_G18_15n I1_I1022_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I114_XG_MN0 (XI1_I1022_I114_XG_n1 I1_I1022_P18_17 I1_I1022_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I114_XG_MN1 (VSS I1_I1022_G16_15 XI1_I1022_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I180_XG_MN2 (I1_I1022_G29_14n I1_I1022_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I180_XG_MN0 (XI1_I1022_I180_XG_n1 I1_I1022_P29_22 I1_I1022_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I180_XG_MN1 (VSS I1_I1022_G21_14 XI1_I1022_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I166_XG_MN2 (I1_I1022_G15_0n I1_I1022_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I166_XG_MN0 (XI1_I1022_I166_XG_n1 I1_I1022_P15_8 I1_I1022_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I166_XG_MN1 (VSS I1_I1022_G7_0 XI1_I1022_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I178_XG_MN2 (I1_I1022_G27_12n I1_I1022_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I178_XG_MN0 (XI1_I1022_I178_XG_n1 I1_I1022_P27_20 I1_I1022_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I178_XG_MN1 (VSS I1_I1022_G19_12 XI1_I1022_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I170_XG_MN2 (I1_I1022_G19_4n I1_I1022_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I170_XG_MN0 (XI1_I1022_I170_XG_n1 I1_I1022_P19_12 I1_I1022_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I170_XG_MN1 (VSS I1_I1022_G11_4 XI1_I1022_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I113_XG_MN2 (I1_I1022_G17_14n I1_I1022_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I113_XG_MN0 (XI1_I1022_I113_XG_n1 I1_I1022_P17_16 I1_I1022_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I113_XG_MN1 (VSS I1_I1022_G15_14 XI1_I1022_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I157_XG_MN2 (I1_I976_G8_0n I1_I976_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I157_XG_MN0 (XI1_I976_I157_XG_n1 I1_I976_P8_1 I1_I976_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I157_XG_MN1 (VSS I1_I976_G0_0 XI1_I976_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I976_I98_XG_MN2 (I1_I976_G2_0n I1_I976_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I976_I98_XG_MN0 (XI1_I976_I98_XG_n1 I1_I976_P2_1 I1_I976_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I976_I98_XG_MN1 (VSS I1_I976_G0_0 XI1_I976_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I103_XG_MN2 (I1_I608_G7_4n I1_I608_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I103_XG_MN0 (XI1_I608_I103_XG_n1 I1_I608_P7_6 I1_I608_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I103_XG_MN1 (VSS I1_I608_G5_4 XI1_I608_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I105_XG_MN2 (I1_I608_G9_6n I1_I608_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I105_XG_MN0 (XI1_I608_I105_XG_n1 I1_I608_P9_8 I1_I608_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I105_XG_MN1 (VSS I1_I608_G7_6 XI1_I608_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I107_XG_MN2 (I1_I608_G11_8n I1_I608_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I107_XG_MN0 (XI1_I608_I107_XG_n1 I1_I608_P11_10 I1_I608_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I107_XG_MN1 (VSS I1_I608_G9_8 XI1_I608_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I109_XG_MN2 (I1_I608_G13_10n I1_I608_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I109_XG_MN0 (XI1_I608_I109_XG_n1 I1_I608_P13_12 I1_I608_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I109_XG_MN1 (VSS I1_I608_G11_10 XI1_I608_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I176_XG_MN2 (I1_I608_G25_10n I1_I608_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I176_XG_MN0 (XI1_I608_I176_XG_n1 I1_I608_P25_18 I1_I608_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I176_XG_MN1 (VSS I1_I608_G17_10 XI1_I608_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I178_XG_MN2 (I1_I608_G27_12n I1_I608_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I178_XG_MN0 (XI1_I608_I178_XG_n1 I1_I608_P27_20 I1_I608_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I178_XG_MN1 (VSS I1_I608_G19_12 XI1_I608_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I121_XG_MN2 (I1_I608_G25_22n I1_I608_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I121_XG_MN0 (XI1_I608_I121_XG_n1 I1_I608_P25_24 I1_I608_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I121_XG_MN1 (VSS I1_I608_G23_22 XI1_I608_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I123_XG_MN2 (I1_I608_G27_24n I1_I608_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I123_XG_MN0 (XI1_I608_I123_XG_n1 I1_I608_P27_26 I1_I608_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I123_XG_MN1 (VSS I1_I608_G25_24 XI1_I608_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I125_XG_MN2 (I1_I608_G29_26n I1_I608_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I125_XG_MN0 (XI1_I608_I125_XG_n1 I1_I608_P29_28 I1_I608_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I125_XG_MN1 (VSS I1_I608_G27_26 XI1_I608_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I123_XG_MN2 (I1_I1482_G27_24n I1_I1482_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I123_XG_MN0 (XI1_I1482_I123_XG_n1 I1_I1482_P27_26 I1_I1482_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I123_XG_MN1 (VSS I1_I1482_G25_24 XI1_I1482_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I180_XG_MN2 (I1_I1482_G29_14n I1_I1482_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I180_XG_MN0 (XI1_I1482_I180_XG_n1 I1_I1482_P29_22 I1_I1482_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I180_XG_MN1 (VSS I1_I1482_G21_14 XI1_I1482_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I178_XG_MN2 (I1_I1482_G27_12n I1_I1482_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I178_XG_MN0 (XI1_I1482_I178_XG_n1 I1_I1482_P27_20 I1_I1482_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I178_XG_MN1 (VSS I1_I1482_G19_12 XI1_I1482_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I112_XG_MN2 (I1_I1482_G16_13n I1_I1482_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I112_XG_MN0 (XI1_I1482_I112_XG_n1 I1_I1482_P16_15 I1_I1482_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I112_XG_MN1 (VSS I1_I1482_G14_13 XI1_I1482_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I110_XG_MN2 (I1_I1482_G14_11n I1_I1482_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I110_XG_MN0 (XI1_I1482_I110_XG_n1 I1_I1482_P14_13 I1_I1482_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I110_XG_MN1 (VSS I1_I1482_G12_11 XI1_I1482_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I108_XG_MN2 (I1_I1482_G12_9n I1_I1482_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I108_XG_MN0 (XI1_I1482_I108_XG_n1 I1_I1482_P12_11 I1_I1482_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I108_XG_MN1 (VSS I1_I1482_G10_9 XI1_I1482_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I106_XG_MN2 (I1_I1482_G10_7n I1_I1482_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I106_XG_MN0 (XI1_I1482_I106_XG_n1 I1_I1482_P10_9 I1_I1482_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I106_XG_MN1 (VSS I1_I1482_G8_7 XI1_I1482_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I104_XG_MN2 (I1_I1482_G8_5n I1_I1482_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I104_XG_MN0 (XI1_I1482_I104_XG_n1 I1_I1482_P8_7 I1_I1482_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I104_XG_MN1 (VSS I1_I1482_G6_5 XI1_I1482_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I100_XG_MN2 (I1_I1482_G4_1n I1_I1482_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I100_XG_MN0 (XI1_I1482_I100_XG_n1 I1_I1482_P4_3 I1_I1482_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I100_XG_MN1 (VSS I1_I1482_G2_1 XI1_I1482_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I101_XG_MN2 (I1_I1114_G5_2n I1_I1114_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I101_XG_MN0 (XI1_I1114_I101_XG_n1 I1_I1114_P5_4 I1_I1114_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I101_XG_MN1 (VSS I1_I1114_G3_2 XI1_I1114_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I104_XG_MN2 (I1_I1114_G8_5n I1_I1114_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I104_XG_MN0 (XI1_I1114_I104_XG_n1 I1_I1114_P8_7 I1_I1114_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I104_XG_MN1 (VSS I1_I1114_G6_5 XI1_I1114_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I102_XG_MN2 (I1_I1114_G6_3n I1_I1114_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I102_XG_MN0 (XI1_I1114_I102_XG_n1 I1_I1114_P6_5 I1_I1114_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I102_XG_MN1 (VSS I1_I1114_G4_3 XI1_I1114_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I100_XG_MN2 (I1_I1114_G4_1n I1_I1114_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I100_XG_MN0 (XI1_I1114_I100_XG_n1 I1_I1114_P4_3 I1_I1114_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I100_XG_MN1 (VSS I1_I1114_G2_1 XI1_I1114_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1114_I98_XG_MN2 (I1_I1114_G2_0n I1_I1114_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1114_I98_XG_MN0 (XI1_I1114_I98_XG_n1 I1_I1114_P2_1 I1_I1114_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1114_I98_XG_MN1 (VSS I1_I1114_G0_0 XI1_I1114_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I167_XG_MN2 (I1_I1068_G16_1n I1_I1068_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I167_XG_MN0 (XI1_I1068_I167_XG_n1 I1_I1068_P16_9 I1_I1068_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I167_XG_MN1 (VSS I1_I1068_G8_1 XI1_I1068_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I106_XG_MN2 (I1_I1068_G10_7n I1_I1068_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I106_XG_MN0 (XI1_I1068_I106_XG_n1 I1_I1068_P10_9 I1_I1068_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I106_XG_MN1 (VSS I1_I1068_G8_7 XI1_I1068_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I158_XG_MN2 (I1_I1068_G9_0n I1_I1068_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I158_XG_MN0 (XI1_I1068_I158_XG_n1 I1_I1068_P9_2 I1_I1068_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I158_XG_MN1 (VSS I1_I1068_G1_0 XI1_I1068_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I105_XG_MN2 (I1_I1068_G9_6n I1_I1068_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I105_XG_MN0 (XI1_I1068_I105_XG_n1 I1_I1068_P9_8 I1_I1068_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I105_XG_MN1 (VSS I1_I1068_G7_6 XI1_I1068_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I169_XG_MN2 (I1_I1022_G18_3n I1_I1022_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I169_XG_MN0 (XI1_I1022_I169_XG_n1 I1_I1022_P18_11 I1_I1022_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I169_XG_MN1 (VSS I1_I1022_G10_3 XI1_I1022_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I177_XG_MN2 (I1_I1022_G26_11n I1_I1022_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I177_XG_MN0 (XI1_I1022_I177_XG_n1 I1_I1022_P26_19 I1_I1022_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I177_XG_MN1 (VSS I1_I1022_G18_11 XI1_I1022_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I112_XG_MN2 (I1_I1022_G16_13n I1_I1022_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I112_XG_MN0 (XI1_I1022_I112_XG_n1 I1_I1022_P16_15 I1_I1022_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I112_XG_MN1 (VSS I1_I1022_G14_13 XI1_I1022_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I110_XG_MN2 (I1_I1022_G14_11n I1_I1022_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I110_XG_MN0 (XI1_I1022_I110_XG_n1 I1_I1022_P14_13 I1_I1022_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I110_XG_MN1 (VSS I1_I1022_G12_11 XI1_I1022_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I162_XG_MN2 (I1_I1022_G11_0n I1_I1022_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I162_XG_MN0 (XI1_I1022_I162_XG_n1 I1_I1022_P11_4 I1_I1022_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I162_XG_MN1 (VSS I1_I1022_G3_0np XI1_I1022_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I111_XG_MN2 (I1_I1022_G15_12n I1_I1022_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I111_XG_MN0 (XI1_I1022_I111_XG_n1 I1_I1022_P15_14 I1_I1022_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I111_XG_MN1 (VSS I1_I1022_G13_12 XI1_I1022_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I111_XG_MN2 (I1_I608_G15_12n I1_I608_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I111_XG_MN0 (XI1_I608_I111_XG_n1 I1_I608_P15_14 I1_I608_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I111_XG_MN1 (VSS I1_I608_G13_12 XI1_I608_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I113_XG_MN2 (I1_I608_G17_14n I1_I608_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I113_XG_MN0 (XI1_I608_I113_XG_n1 I1_I608_P17_16 I1_I608_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I113_XG_MN1 (VSS I1_I608_G15_14 XI1_I608_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I115_XG_MN2 (I1_I608_G19_16n I1_I608_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I115_XG_MN0 (XI1_I608_I115_XG_n1 I1_I608_P19_18 I1_I608_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I115_XG_MN1 (VSS I1_I608_G17_16 XI1_I608_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I117_XG_MN2 (I1_I608_G21_18n I1_I608_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I117_XG_MN0 (XI1_I608_I117_XG_n1 I1_I608_P21_20 I1_I608_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I117_XG_MN1 (VSS I1_I608_G19_18 XI1_I608_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I608_I119_XG_MN2 (I1_I608_G23_20n I1_I608_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I608_I119_XG_MN0 (XI1_I608_I119_XG_n1 I1_I608_P23_22 I1_I608_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I608_I119_XG_MN1 (VSS I1_I608_G21_20 XI1_I608_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I125_XG_MN2 (I1_I1482_G29_26n I1_I1482_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I125_XG_MN0 (XI1_I1482_I125_XG_n1 I1_I1482_P29_28 I1_I1482_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I125_XG_MN1 (VSS I1_I1482_G27_26 XI1_I1482_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I120_XG_MN2 (I1_I1482_G24_21n I1_I1482_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I120_XG_MN0 (XI1_I1482_I120_XG_n1 I1_I1482_P24_23 I1_I1482_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I120_XG_MN1 (VSS I1_I1482_G22_21 XI1_I1482_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I118_XG_MN2 (I1_I1482_G22_19n I1_I1482_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I118_XG_MN0 (XI1_I1482_I118_XG_n1 I1_I1482_P22_21 I1_I1482_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I118_XG_MN1 (VSS I1_I1482_G20_19 XI1_I1482_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I116_XG_MN2 (I1_I1482_G20_17n I1_I1482_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I116_XG_MN0 (XI1_I1482_I116_XG_n1 I1_I1482_P20_19 I1_I1482_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I116_XG_MN1 (VSS I1_I1482_G18_17 XI1_I1482_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I114_XG_MN2 (I1_I1482_G18_15n I1_I1482_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I114_XG_MN0 (XI1_I1482_I114_XG_n1 I1_I1482_P18_17 I1_I1482_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I114_XG_MN1 (VSS I1_I1482_G16_15 XI1_I1482_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I175_XG_MN2 (I1_I1482_G24_9n I1_I1482_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I175_XG_MN0 (XI1_I1482_I175_XG_n1 I1_I1482_P24_17 I1_I1482_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I175_XG_MN1 (VSS I1_I1482_G16_9 XI1_I1482_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I167_XG_MN2 (I1_I1482_G16_1n I1_I1482_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I167_XG_MN0 (XI1_I1482_I167_XG_n1 I1_I1482_P16_9 I1_I1482_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I167_XG_MN1 (VSS I1_I1482_G8_1 XI1_I1482_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I157_XG_MN2 (I1_I1482_G8_0n I1_I1482_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I157_XG_MN0 (XI1_I1482_I157_XG_n1 I1_I1482_P8_1 I1_I1482_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I157_XG_MN1 (VSS I1_I1482_G0_0 XI1_I1482_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I157_XG_MN2 (I1_I1068_G8_0n I1_I1068_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I157_XG_MN0 (XI1_I1068_I157_XG_n1 I1_I1068_P8_1 I1_I1068_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I157_XG_MN1 (VSS I1_I1068_G0_0 XI1_I1068_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I104_XG_MN2 (I1_I1068_G8_5n I1_I1068_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I104_XG_MN0 (XI1_I1068_I104_XG_n1 I1_I1068_P8_7 I1_I1068_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I104_XG_MN1 (VSS I1_I1068_G6_5 XI1_I1068_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I160_XG_MN2 (I1_I1022_G10_0n I1_I1022_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I160_XG_MN0 (XI1_I1022_I160_XG_n1 I1_I1022_P10_3 I1_I1022_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I160_XG_MN1 (VSS I1_I1022_G2_0np XI1_I1022_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I175_XG_MN2 (I1_I1022_G24_9n I1_I1022_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I175_XG_MN0 (XI1_I1022_I175_XG_n1 I1_I1022_P24_17 I1_I1022_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I175_XG_MN1 (VSS I1_I1022_G16_9 XI1_I1022_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I108_XG_MN2 (I1_I1022_G12_9n I1_I1022_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I108_XG_MN0 (XI1_I1022_I108_XG_n1 I1_I1022_P12_11 I1_I1022_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I108_XG_MN1 (VSS I1_I1022_G10_9 XI1_I1022_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I106_XG_MN2 (I1_I1022_G10_7n I1_I1022_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I106_XG_MN0 (XI1_I1022_I106_XG_n1 I1_I1022_P10_9 I1_I1022_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I106_XG_MN1 (VSS I1_I1022_G8_7 XI1_I1022_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I172_XG_MN2 (I1_I1022_G21_6n I1_I1022_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I172_XG_MN0 (XI1_I1022_I172_XG_n1 I1_I1022_P21_14 I1_I1022_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I172_XG_MN1 (VSS I1_I1022_G13_6 XI1_I1022_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I176_XG_MN2 (I1_I1022_G25_10n I1_I1022_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I176_XG_MN0 (XI1_I1022_I176_XG_n1 I1_I1022_P25_18 I1_I1022_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I176_XG_MN1 (VSS I1_I1022_G17_10 XI1_I1022_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I168_XG_MN2 (I1_I1022_G17_2n I1_I1022_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I168_XG_MN0 (XI1_I1022_I168_XG_n1 I1_I1022_P17_10 I1_I1022_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I168_XG_MN1 (VSS I1_I1022_G9_2 XI1_I1022_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I109_XG_MN2 (I1_I1022_G13_10n I1_I1022_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I109_XG_MN0 (XI1_I1022_I109_XG_n1 I1_I1022_P13_12 I1_I1022_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I109_XG_MN1 (VSS I1_I1022_G11_10 XI1_I1022_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I107_XG_MN2 (I1_I1022_G11_8n I1_I1022_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I107_XG_MN0 (XI1_I1022_I107_XG_n1 I1_I1022_P11_10 I1_I1022_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I107_XG_MN1 (VSS I1_I1022_G9_8 XI1_I1022_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I124_XG_MN2 (I1_I1482_G28_25n I1_I1482_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I124_XG_MN0 (XI1_I1482_I124_XG_n1 I1_I1482_P28_27 I1_I1482_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I124_XG_MN1 (VSS I1_I1482_G26_25 XI1_I1482_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I122_XG_MN2 (I1_I1482_G26_23n I1_I1482_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I122_XG_MN0 (XI1_I1482_I122_XG_n1 I1_I1482_P26_25 I1_I1482_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I122_XG_MN1 (VSS I1_I1482_G24_23 XI1_I1482_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I179_XG_MN2 (I1_I1482_G28_13n I1_I1482_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I179_XG_MN0 (XI1_I1482_I179_XG_n1 I1_I1482_P28_21 I1_I1482_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I179_XG_MN1 (VSS I1_I1482_G20_13 XI1_I1482_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I171_XG_MN2 (I1_I1482_G20_5n I1_I1482_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I171_XG_MN0 (XI1_I1482_I171_XG_n1 I1_I1482_P20_13 I1_I1482_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I171_XG_MN1 (VSS I1_I1482_G12_5 XI1_I1482_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I169_XG_MN2 (I1_I1482_G18_3n I1_I1482_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I169_XG_MN0 (XI1_I1482_I169_XG_n1 I1_I1482_P18_11 I1_I1482_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I169_XG_MN1 (VSS I1_I1482_G10_3 XI1_I1482_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I163_XG_MN2 (I1_I1482_G12_0n I1_I1482_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I163_XG_MN0 (XI1_I1482_I163_XG_n1 I1_I1482_P12_5 I1_I1482_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I163_XG_MN1 (VSS I1_I1482_G4_0 XI1_I1482_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I160_XG_MN2 (I1_I1482_G10_0n I1_I1482_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I160_XG_MN0 (XI1_I1482_I160_XG_n1 I1_I1482_P10_3 I1_I1482_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I160_XG_MN1 (VSS I1_I1482_G2_0np XI1_I1482_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I100_XG_MN2 (I1_I1068_G4_1n I1_I1068_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I100_XG_MN0 (XI1_I1068_I100_XG_n1 I1_I1068_P4_3 I1_I1068_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I100_XG_MN1 (VSS I1_I1068_G2_1 XI1_I1068_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I102_XG_MN2 (I1_I1068_G6_3n I1_I1068_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I102_XG_MN0 (XI1_I1068_I102_XG_n1 I1_I1068_P6_5 I1_I1068_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I102_XG_MN1 (VSS I1_I1068_G4_3 XI1_I1068_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I99_XG_MN2 (I1_I1068_G3_0n I1_I1068_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I99_XG_MN0 (XI1_I1068_I99_XG_n1 I1_I1068_P3_2 I1_I1068_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I99_XG_MN1 (VSS I1_I1068_G1_0 XI1_I1068_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I101_XG_MN2 (I1_I1068_G5_2n I1_I1068_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I101_XG_MN0 (XI1_I1068_I101_XG_n1 I1_I1068_P5_4 I1_I1068_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I101_XG_MN1 (VSS I1_I1068_G3_2 XI1_I1068_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I103_XG_MN2 (I1_I1068_G7_4n I1_I1068_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I103_XG_MN0 (XI1_I1068_I103_XG_n1 I1_I1068_P7_6 I1_I1068_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I103_XG_MN1 (VSS I1_I1068_G5_4 XI1_I1068_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I163_XG_MN2 (I1_I1022_G12_0n I1_I1022_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I163_XG_MN0 (XI1_I1022_I163_XG_n1 I1_I1022_P12_5 I1_I1022_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I163_XG_MN1 (VSS I1_I1022_G4_0 XI1_I1022_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I171_XG_MN2 (I1_I1022_G20_5n I1_I1022_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I171_XG_MN0 (XI1_I1022_I171_XG_n1 I1_I1022_P20_13 I1_I1022_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I171_XG_MN1 (VSS I1_I1022_G12_5 XI1_I1022_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I104_XG_MN2 (I1_I1022_G8_5n I1_I1022_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I104_XG_MN0 (XI1_I1022_I104_XG_n1 I1_I1022_P8_7 I1_I1022_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I104_XG_MN1 (VSS I1_I1022_G6_5 XI1_I1022_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I102_XG_MN2 (I1_I1022_G6_3n I1_I1022_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I102_XG_MN0 (XI1_I1022_I102_XG_n1 I1_I1022_P6_5 I1_I1022_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I102_XG_MN1 (VSS I1_I1022_G4_3 XI1_I1022_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I164_XG_MN2 (I1_I1022_G13_0n I1_I1022_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I164_XG_MN0 (XI1_I1022_I164_XG_n1 I1_I1022_P13_6 I1_I1022_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I164_XG_MN1 (VSS I1_I1022_G5_0 XI1_I1022_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I158_XG_MN2 (I1_I1022_G9_0n I1_I1022_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I158_XG_MN0 (XI1_I1022_I158_XG_n1 I1_I1022_P9_2 I1_I1022_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I158_XG_MN1 (VSS I1_I1022_G1_0 XI1_I1022_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I103_XG_MN2 (I1_I1022_G7_4n I1_I1022_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I103_XG_MN0 (XI1_I1022_I103_XG_n1 I1_I1022_P7_6 I1_I1022_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I103_XG_MN1 (VSS I1_I1022_G5_4 XI1_I1022_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I105_XG_MN2 (I1_I1022_G9_6n I1_I1022_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I105_XG_MN0 (XI1_I1022_I105_XG_n1 I1_I1022_P9_8 I1_I1022_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I105_XG_MN1 (VSS I1_I1022_G7_6 XI1_I1022_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I127_XG_MN2 (I1_I1482_G31_28n I1_I1482_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I127_XG_MN0 (XI1_I1482_I127_XG_n1 I1_I1482_P31_30 I1_I1482_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I127_XG_MN1 (VSS I1_I1482_G29_28 XI1_I1482_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I126_XG_MN2 (I1_I1482_G30_27n I1_I1482_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I126_XG_MN0 (XI1_I1482_I126_XG_n1 I1_I1482_P30_29 I1_I1482_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I126_XG_MN1 (VSS I1_I1482_G28_27 XI1_I1482_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I181_XG_MN2 (I1_I1482_G30_15n I1_I1482_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I181_XG_MN0 (XI1_I1482_I181_XG_n1 I1_I1482_P30_23 I1_I1482_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I181_XG_MN1 (VSS I1_I1482_G22_15 XI1_I1482_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I173_XG_MN2 (I1_I1482_G22_7n I1_I1482_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I173_XG_MN0 (XI1_I1482_I173_XG_n1 I1_I1482_P22_15 I1_I1482_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I173_XG_MN1 (VSS I1_I1482_G14_7 XI1_I1482_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I177_XG_MN2 (I1_I1482_G26_11n I1_I1482_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I177_XG_MN0 (XI1_I1482_I177_XG_n1 I1_I1482_P26_19 I1_I1482_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I177_XG_MN1 (VSS I1_I1482_G18_11 XI1_I1482_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1482_I165_XG_MN2 (I1_I1482_G14_0n I1_I1482_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1482_I165_XG_MN0 (XI1_I1482_I165_XG_n1 I1_I1482_P14_7 I1_I1482_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1482_I165_XG_MN1 (VSS I1_I1482_G6_0 XI1_I1482_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I114_XG_MN2 (I1_I1528_G18_15n I1_I1528_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I114_XG_MN0 (XI1_I1528_I114_XG_n1 I1_I1528_P18_17 I1_I1528_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I114_XG_MN1 (VSS I1_I1528_G16_15 XI1_I1528_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I112_XG_MN2 (I1_I1528_G16_13n I1_I1528_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I112_XG_MN0 (XI1_I1528_I112_XG_n1 I1_I1528_P16_15 I1_I1528_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I112_XG_MN1 (VSS I1_I1528_G14_13 XI1_I1528_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I110_XG_MN2 (I1_I1528_G14_11n I1_I1528_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I110_XG_MN0 (XI1_I1528_I110_XG_n1 I1_I1528_P14_13 I1_I1528_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I110_XG_MN1 (VSS I1_I1528_G12_11 XI1_I1528_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I108_XG_MN2 (I1_I1528_G12_9n I1_I1528_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I108_XG_MN0 (XI1_I1528_I108_XG_n1 I1_I1528_P12_11 I1_I1528_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I108_XG_MN1 (VSS I1_I1528_G10_9 XI1_I1528_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I106_XG_MN2 (I1_I1528_G10_7n I1_I1528_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I106_XG_MN0 (XI1_I1528_I106_XG_n1 I1_I1528_P10_9 I1_I1528_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I106_XG_MN1 (VSS I1_I1528_G8_7 XI1_I1528_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I104_XG_MN2 (I1_I1528_G8_5n I1_I1528_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I104_XG_MN0 (XI1_I1528_I104_XG_n1 I1_I1528_P8_7 I1_I1528_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I104_XG_MN1 (VSS I1_I1528_G6_5 XI1_I1528_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I102_XG_MN2 (I1_I1528_G6_3n I1_I1528_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I102_XG_MN0 (XI1_I1528_I102_XG_n1 I1_I1528_P6_5 I1_I1528_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I102_XG_MN1 (VSS I1_I1528_G4_3 XI1_I1528_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1068_I98_XG_MN2 (I1_I1068_G2_0n I1_I1068_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1068_I98_XG_MN0 (XI1_I1068_I98_XG_n1 I1_I1068_P2_1 I1_I1068_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1068_I98_XG_MN1 (VSS I1_I1068_G0_0 XI1_I1068_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I167_XG_MN2 (I1_I1022_G16_1n I1_I1022_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I167_XG_MN0 (XI1_I1022_I167_XG_n1 I1_I1022_P16_9 I1_I1022_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I167_XG_MN1 (VSS I1_I1022_G8_1 XI1_I1022_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I157_XG_MN2 (I1_I1022_G8_0n I1_I1022_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I157_XG_MN0 (XI1_I1022_I157_XG_n1 I1_I1022_P8_1 I1_I1022_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I157_XG_MN1 (VSS I1_I1022_G0_0 XI1_I1022_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I100_XG_MN2 (I1_I1022_G4_1n I1_I1022_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I100_XG_MN0 (XI1_I1022_I100_XG_n1 I1_I1022_P4_3 I1_I1022_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I100_XG_MN1 (VSS I1_I1022_G2_1 XI1_I1022_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I98_XG_MN2 (I1_I1022_G2_0n I1_I1022_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I98_XG_MN0 (XI1_I1022_I98_XG_n1 I1_I1022_P2_1 I1_I1022_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I98_XG_MN1 (VSS I1_I1022_G0_0 XI1_I1022_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I99_XG_MN2 (I1_I1022_G3_0n I1_I1022_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I99_XG_MN0 (XI1_I1022_I99_XG_n1 I1_I1022_P3_2 I1_I1022_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I99_XG_MN1 (VSS I1_I1022_G1_0 XI1_I1022_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1022_I101_XG_MN2 (I1_I1022_G5_2n I1_I1022_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1022_I101_XG_MN0 (XI1_I1022_I101_XG_n1 I1_I1022_P5_4 I1_I1022_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1022_I101_XG_MN1 (VSS I1_I1022_G3_2 XI1_I1022_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2159_MN2 (I1_nqkn28 I1_nqk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2159_MN0 (XI1_I2159_n1 I1_sq_b3_5 I1_nqkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2159_MN1 (VSS I1_qu27_b3_5 XI1_I2159_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2162_MN2 (I1_nqkn29 I1_nqk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2162_MN0 (XI1_I2162_n1 I1_sq_b3_5 I1_nqkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2162_MN1 (VSS I1_qu28_b3_5 XI1_I2162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2165_MN2 (I1_nqkn30 I1_nqk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2165_MN0 (XI1_I2165_n1 I1_sq_b3_5 I1_nqkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2165_MN1 (VSS I1_qu29_b3_5 XI1_I2165_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2168_MN2 (I1_nqkn31 I1_nqk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2168_MN0 (XI1_I2168_n1 I1_sq_b3_5 I1_nqkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2168_MN1 (VSS I1_qu30_b3_5 XI1_I2168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I98_XG_MN2 (I1_I562_G2_0n I1_I562_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I98_XG_MN0 (XI1_I562_I98_XG_n1 I1_I562_P2_1 I1_I562_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I98_XG_MN1 (VSS I1_I562_G0_0 XI1_I562_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I116_XG_MN2 (I1_I1528_G20_17n I1_I1528_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I116_XG_MN0 (XI1_I1528_I116_XG_n1 I1_I1528_P20_19 I1_I1528_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I116_XG_MN1 (VSS I1_I1528_G18_17 XI1_I1528_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I175_XG_MN2 (I1_I1528_G24_9n I1_I1528_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I175_XG_MN0 (XI1_I1528_I175_XG_n1 I1_I1528_P24_17 I1_I1528_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I175_XG_MN1 (VSS I1_I1528_G16_9 XI1_I1528_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I160_XG_MN2 (I1_I1528_G10_0n I1_I1528_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I160_XG_MN0 (XI1_I1528_I160_XG_n1 I1_I1528_P10_3 I1_I1528_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I160_XG_MN1 (VSS I1_I1528_G2_0np XI1_I1528_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I167_XG_MN2 (I1_I1528_G16_1n I1_I1528_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I167_XG_MN0 (XI1_I1528_I167_XG_n1 I1_I1528_P16_9 I1_I1528_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I167_XG_MN1 (VSS I1_I1528_G8_1 XI1_I1528_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I157_XG_MN2 (I1_I1528_G8_0n I1_I1528_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I157_XG_MN0 (XI1_I1528_I157_XG_n1 I1_I1528_P8_1 I1_I1528_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I157_XG_MN1 (VSS I1_I1528_G0_0 XI1_I1528_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I100_XG_MN2 (I1_I1528_G4_1n I1_I1528_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I100_XG_MN0 (XI1_I1528_I100_XG_n1 I1_I1528_P4_3 I1_I1528_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I100_XG_MN1 (VSS I1_I1528_G2_1 XI1_I1528_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I98_XG_MN2 (I1_I1528_G2_0n I1_I1528_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I98_XG_MN0 (XI1_I1528_I98_XG_n1 I1_I1528_P2_1 I1_I1528_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I98_XG_MN1 (VSS I1_I1528_G0_0 XI1_I1528_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2120_MN2 (I1_nqkn15 I1_nqk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2120_MN0 (XI1_I2120_n1 I1_sq_b3_2 I1_nqkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2120_MN1 (VSS I1_qu14_b3_5 XI1_I2120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2123_MN2 (I1_nqkn16 I1_nqk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2123_MN0 (XI1_I2123_n1 I1_sq_b3_2 I1_nqkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2123_MN1 (VSS I1_qu15_b3_5 XI1_I2123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2126_MN2 (I1_nqkn17 I1_nqk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2126_MN0 (XI1_I2126_n1 I1_sq_b3_3 I1_nqkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2126_MN1 (VSS I1_qu16_b3_5 XI1_I2126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2129_MN2 (I1_nqkn18 I1_nqk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2129_MN0 (XI1_I2129_n1 I1_sq_b3_3 I1_nqkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2129_MN1 (VSS I1_qu17_b3_5 XI1_I2129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2132_MN2 (I1_nqkn19 I1_nqk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2132_MN0 (XI1_I2132_n1 I1_sq_b3_3 I1_nqkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2132_MN1 (VSS I1_qu18_b3_5 XI1_I2132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2135_MN2 (I1_nqkn20 I1_nqk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2135_MN0 (XI1_I2135_n1 I1_sq_b3_3 I1_nqkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2135_MN1 (VSS I1_qu19_b3_5 XI1_I2135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2138_MN2 (I1_nqkn21 I1_nqk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2138_MN0 (XI1_I2138_n1 I1_sq_b3_3 I1_nqkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2138_MN1 (VSS I1_qu20_b3_5 XI1_I2138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2141_MN2 (I1_nqkn22 I1_nqk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2141_MN0 (XI1_I2141_n1 I1_sq_b3_3 I1_nqkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2141_MN1 (VSS I1_qu21_b3_5 XI1_I2141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2144_MN2 (I1_nqkn23 I1_nqk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2144_MN0 (XI1_I2144_n1 I1_sq_b3_4 I1_nqkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2144_MN1 (VSS I1_qu22_b3_5 XI1_I2144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2147_MN2 (I1_nqkn24 I1_nqk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2147_MN0 (XI1_I2147_n1 I1_sq_b3_4 I1_nqkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2147_MN1 (VSS I1_qu23_b3_5 XI1_I2147_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2150_MN2 (I1_nqkn25 I1_nqk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2150_MN0 (XI1_I2150_n1 I1_sq_b3_4 I1_nqkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2150_MN1 (VSS I1_qu24_b3_5 XI1_I2150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2153_MN2 (I1_nqkn26 I1_nqk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2153_MN0 (XI1_I2153_n1 I1_sq_b3_4 I1_nqkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2153_MN1 (VSS I1_qu25_b3_5 XI1_I2153_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2156_MN2 (I1_nqkn27 I1_nqk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2156_MN0 (XI1_I2156_n1 I1_sq_b3_4 I1_nqkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2156_MN1 (VSS I1_qu26_b3_5 XI1_I2156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I126_MN2 (I1_nakn31 I1_nak30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I126_MN0 (XI1_I126_n1 I1_A_31_b3_5 I1_nakn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I126_MN1 (VSS A_30 XI1_I126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I123_MN2 (I1_nakn30 I1_nak29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I123_MN0 (XI1_I123_n1 I1_A_31_b3_4 I1_nakn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I123_MN1 (VSS A_29 XI1_I123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I100_XG_MN2 (I1_I562_G4_1n I1_I562_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I100_XG_MN0 (XI1_I562_I100_XG_n1 I1_I562_P4_3 I1_I562_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I100_XG_MN1 (VSS I1_I562_G2_1 XI1_I562_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I102_XG_MN2 (I1_I562_G6_3n I1_I562_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I102_XG_MN0 (XI1_I562_I102_XG_n1 I1_I562_P6_5 I1_I562_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I102_XG_MN1 (VSS I1_I562_G4_3 XI1_I562_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I157_XG_MN2 (I1_I562_G8_0n I1_I562_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I157_XG_MN0 (XI1_I562_I157_XG_n1 I1_I562_P8_1 I1_I562_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I157_XG_MN1 (VSS I1_I562_G0_0 XI1_I562_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I167_XG_MN2 (I1_I562_G16_1n I1_I562_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I167_XG_MN0 (XI1_I562_I167_XG_n1 I1_I562_P16_9 I1_I562_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I167_XG_MN1 (VSS I1_I562_G8_1 XI1_I562_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I160_XG_MN2 (I1_I562_G10_0n I1_I562_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I160_XG_MN0 (XI1_I562_I160_XG_n1 I1_I562_P10_3 I1_I562_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I160_XG_MN1 (VSS I1_I562_G2_0np XI1_I562_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I169_XG_MN2 (I1_I562_G18_3n I1_I562_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I169_XG_MN0 (XI1_I562_I169_XG_n1 I1_I562_P18_11 I1_I562_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I169_XG_MN1 (VSS I1_I562_G10_3 XI1_I562_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I163_XG_MN2 (I1_I562_G12_0n I1_I562_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I163_XG_MN0 (XI1_I562_I163_XG_n1 I1_I562_P12_5 I1_I562_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I163_XG_MN1 (VSS I1_I562_G4_0 XI1_I562_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I171_XG_MN2 (I1_I562_G20_5n I1_I562_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I171_XG_MN0 (XI1_I562_I171_XG_n1 I1_I562_P20_13 I1_I562_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I171_XG_MN1 (VSS I1_I562_G12_5 XI1_I562_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I165_XG_MN2 (I1_I562_G14_0n I1_I562_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I165_XG_MN0 (XI1_I562_I165_XG_n1 I1_I562_P14_7 I1_I562_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I165_XG_MN1 (VSS I1_I562_G6_0 XI1_I562_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I173_XG_MN2 (I1_I562_G22_7n I1_I562_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I173_XG_MN0 (XI1_I562_I173_XG_n1 I1_I562_P22_15 I1_I562_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I173_XG_MN1 (VSS I1_I562_G14_7 XI1_I562_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I120_XG_MN2 (I1_I1528_G24_21n I1_I1528_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I120_XG_MN0 (XI1_I1528_I120_XG_n1 I1_I1528_P24_23 I1_I1528_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I120_XG_MN1 (VSS I1_I1528_G22_21 XI1_I1528_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I118_XG_MN2 (I1_I1528_G22_19n I1_I1528_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I118_XG_MN0 (XI1_I1528_I118_XG_n1 I1_I1528_P22_21 I1_I1528_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I118_XG_MN1 (VSS I1_I1528_G20_19 XI1_I1528_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I173_XG_MN2 (I1_I1528_G22_7n I1_I1528_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I173_XG_MN0 (XI1_I1528_I173_XG_n1 I1_I1528_P22_15 I1_I1528_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I173_XG_MN1 (VSS I1_I1528_G14_7 XI1_I1528_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I165_XG_MN2 (I1_I1528_G14_0n I1_I1528_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I165_XG_MN0 (XI1_I1528_I165_XG_n1 I1_I1528_P14_7 I1_I1528_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I165_XG_MN1 (VSS I1_I1528_G6_0 XI1_I1528_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I177_XG_MN2 (I1_I1528_G26_11n I1_I1528_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I177_XG_MN0 (XI1_I1528_I177_XG_n1 I1_I1528_P26_19 I1_I1528_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I177_XG_MN1 (VSS I1_I1528_G18_11 XI1_I1528_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I171_XG_MN2 (I1_I1528_G20_5n I1_I1528_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I171_XG_MN0 (XI1_I1528_I171_XG_n1 I1_I1528_P20_13 I1_I1528_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I171_XG_MN1 (VSS I1_I1528_G12_5 XI1_I1528_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I163_XG_MN2 (I1_I1528_G12_0n I1_I1528_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I163_XG_MN0 (XI1_I1528_I163_XG_n1 I1_I1528_P12_5 I1_I1528_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I163_XG_MN1 (VSS I1_I1528_G4_0 XI1_I1528_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I169_XG_MN2 (I1_I1528_G18_3n I1_I1528_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I169_XG_MN0 (XI1_I1528_I169_XG_n1 I1_I1528_P18_11 I1_I1528_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I169_XG_MN1 (VSS I1_I1528_G10_3 XI1_I1528_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I90_MN2 (I1_nakn19 I1_nak18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I90_MN0 (XI1_I90_n1 I1_A_31_b3_3 I1_nakn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I90_MN1 (VSS A_18 XI1_I90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I93_MN2 (I1_nakn20 I1_nak19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I93_MN0 (XI1_I93_n1 I1_A_31_b3_3 I1_nakn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I93_MN1 (VSS A_19 XI1_I93_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I96_MN2 (I1_nakn21 I1_nak20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I96_MN0 (XI1_I96_n1 I1_A_31_b3_3 I1_nakn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I96_MN1 (VSS A_20 XI1_I96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I505_MN2 (I1_nbkn30 I1_nbk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I505_MN0 (XI1_I505_n1 I1_B_31_b3_5 I1_nbkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I505_MN1 (VSS B_29 XI1_I505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I492_MN2 (I1_nbkn29 I1_nbk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I492_MN0 (XI1_I492_n1 I1_B_31_b3_4 I1_nbkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I492_MN1 (VSS B_28 XI1_I492_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I99_MN2 (I1_nakn22 I1_nak21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I99_MN0 (XI1_I99_n1 I1_A_31_b3_3 I1_nakn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I99_MN1 (VSS A_21 XI1_I99_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I102_MN2 (I1_nakn23 I1_nak22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I102_MN0 (XI1_I102_n1 I1_A_31_b3_3 I1_nakn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I102_MN1 (VSS A_22 XI1_I102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I105_MN2 (I1_nakn24 I1_nak23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I105_MN0 (XI1_I105_n1 I1_A_31_b3_3 I1_nakn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I105_MN1 (VSS A_23 XI1_I105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I108_MN2 (I1_nakn25 I1_nak24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I108_MN0 (XI1_I108_n1 I1_A_31_b3_4 I1_nakn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I108_MN1 (VSS A_24 XI1_I108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I111_MN2 (I1_nakn26 I1_nak25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I111_MN0 (XI1_I111_n1 I1_A_31_b3_4 I1_nakn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I111_MN1 (VSS A_25 XI1_I111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I120_MN2 (I1_nakn29 I1_nak28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I120_MN0 (XI1_I120_n1 I1_A_31_b3_4 I1_nakn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I120_MN1 (VSS A_28 XI1_I120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I104_XG_MN2 (I1_I562_G8_5n I1_I562_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I104_XG_MN0 (XI1_I562_I104_XG_n1 I1_I562_P8_7 I1_I562_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I104_XG_MN1 (VSS I1_I562_G6_5 XI1_I562_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I106_XG_MN2 (I1_I562_G10_7n I1_I562_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I106_XG_MN0 (XI1_I562_I106_XG_n1 I1_I562_P10_9 I1_I562_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I106_XG_MN1 (VSS I1_I562_G8_7 XI1_I562_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I108_XG_MN2 (I1_I562_G12_9n I1_I562_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I108_XG_MN0 (XI1_I562_I108_XG_n1 I1_I562_P12_11 I1_I562_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I108_XG_MN1 (VSS I1_I562_G10_9 XI1_I562_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I110_XG_MN2 (I1_I562_G14_11n I1_I562_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I110_XG_MN0 (XI1_I562_I110_XG_n1 I1_I562_P14_13 I1_I562_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I110_XG_MN1 (VSS I1_I562_G12_11 XI1_I562_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I175_XG_MN2 (I1_I562_G24_9n I1_I562_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I175_XG_MN0 (XI1_I562_I175_XG_n1 I1_I562_P24_17 I1_I562_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I175_XG_MN1 (VSS I1_I562_G16_9 XI1_I562_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I177_XG_MN2 (I1_I562_G26_11n I1_I562_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I177_XG_MN0 (XI1_I562_I177_XG_n1 I1_I562_P26_19 I1_I562_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I177_XG_MN1 (VSS I1_I562_G18_11 XI1_I562_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I179_XG_MN2 (I1_I562_G28_13n I1_I562_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I179_XG_MN0 (XI1_I562_I179_XG_n1 I1_I562_P28_21 I1_I562_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I179_XG_MN1 (VSS I1_I562_G20_13 XI1_I562_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I181_XG_MN2 (I1_I562_G30_15n I1_I562_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I181_XG_MN0 (XI1_I562_I181_XG_n1 I1_I562_P30_23 I1_I562_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I181_XG_MN1 (VSS I1_I562_G22_15 XI1_I562_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I126_XG_MN2 (I1_I562_G30_27n I1_I562_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I126_XG_MN0 (XI1_I562_I126_XG_n1 I1_I562_P30_29 I1_I562_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I126_XG_MN1 (VSS I1_I562_G28_27 XI1_I562_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I126_XG_MN2 (I1_I1528_G30_27n I1_I1528_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I126_XG_MN0 (XI1_I1528_I126_XG_n1 I1_I1528_P30_29 I1_I1528_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I126_XG_MN1 (VSS I1_I1528_G28_27 XI1_I1528_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I124_XG_MN2 (I1_I1528_G28_25n I1_I1528_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I124_XG_MN0 (XI1_I1528_I124_XG_n1 I1_I1528_P28_27 I1_I1528_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I124_XG_MN1 (VSS I1_I1528_G26_25 XI1_I1528_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I122_XG_MN2 (I1_I1528_G26_23n I1_I1528_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I122_XG_MN0 (XI1_I1528_I122_XG_n1 I1_I1528_P26_25 I1_I1528_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I122_XG_MN1 (VSS I1_I1528_G24_23 XI1_I1528_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I115_XG_MN2 (I1_I1528_G19_16n I1_I1528_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I115_XG_MN0 (XI1_I1528_I115_XG_n1 I1_I1528_P19_18 I1_I1528_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I115_XG_MN1 (VSS I1_I1528_G17_16 XI1_I1528_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I181_XG_MN2 (I1_I1528_G30_15n I1_I1528_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I181_XG_MN0 (XI1_I1528_I181_XG_n1 I1_I1528_P30_23 I1_I1528_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I181_XG_MN1 (VSS I1_I1528_G22_15 XI1_I1528_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I179_XG_MN2 (I1_I1528_G28_13n I1_I1528_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I179_XG_MN0 (XI1_I1528_I179_XG_n1 I1_I1528_P28_21 I1_I1528_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I179_XG_MN1 (VSS I1_I1528_G20_13 XI1_I1528_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I105_XG_MN2 (I1_I1528_G9_6n I1_I1528_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I105_XG_MN0 (XI1_I1528_I105_XG_n1 I1_I1528_P9_8 I1_I1528_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I105_XG_MN1 (VSS I1_I1528_G7_6 XI1_I1528_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I103_XG_MN2 (I1_I1528_G7_4n I1_I1528_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I103_XG_MN0 (XI1_I1528_I103_XG_n1 I1_I1528_P7_6 I1_I1528_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I103_XG_MN1 (VSS I1_I1528_G5_4 XI1_I1528_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I101_XG_MN2 (I1_I1528_G5_2n I1_I1528_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I101_XG_MN0 (XI1_I1528_I101_XG_n1 I1_I1528_P5_4 I1_I1528_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I101_XG_MN1 (VSS I1_I1528_G3_2 XI1_I1528_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I99_XG_MN2 (I1_I1528_G3_0n I1_I1528_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I99_XG_MN0 (XI1_I1528_I99_XG_n1 I1_I1528_P3_2 I1_I1528_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I99_XG_MN1 (VSS I1_I1528_G1_0 XI1_I1528_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I109_XG_MN2 (I1_I1574_G13_10n I1_I1574_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I109_XG_MN0 (XI1_I1574_I109_XG_n1 I1_I1574_P13_12 I1_I1574_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I109_XG_MN1 (VSS I1_I1574_G11_10 XI1_I1574_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I75_MN2 (I1_nakn14 I1_nak13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I75_MN0 (XI1_I75_n1 I1_A_31_b3_2 I1_nakn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I75_MN1 (VSS A_13 XI1_I75_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I78_MN2 (I1_nakn15 I1_nak14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I78_MN0 (XI1_I78_n1 I1_A_31_b3_2 I1_nakn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I78_MN1 (VSS A_14 XI1_I78_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2117_MN2 (I1_nqkn14 I1_nqk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2117_MN0 (XI1_I2117_n1 I1_sq_b3_2 I1_nqkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2117_MN1 (VSS I1_qu13_b3_5 XI1_I2117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I81_MN2 (I1_nakn16 I1_nak15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I81_MN0 (XI1_I81_n1 I1_A_31_b3_2 I1_nakn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I81_MN1 (VSS A_15 XI1_I81_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I84_MN2 (I1_nakn17 I1_nak16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I84_MN0 (XI1_I84_n1 I1_A_31_b3_2 I1_nakn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I84_MN1 (VSS A_16 XI1_I84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I310_MN2 (I1_nbkn15 I1_nbk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I310_MN0 (XI1_I310_n1 I1_B_31_b3_2 I1_nbkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I310_MN1 (VSS B_14 XI1_I310_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I87_MN2 (I1_nakn18 I1_nak17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I87_MN0 (XI1_I87_n1 I1_A_31_b3_2 I1_nakn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I87_MN1 (VSS A_17 XI1_I87_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I375_MN2 (I1_nbkn20 I1_nbk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I375_MN0 (XI1_I375_n1 I1_B_31_b3_3 I1_nbkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I375_MN1 (VSS B_19 XI1_I375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I388_MN2 (I1_nbkn21 I1_nbk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I388_MN0 (XI1_I388_n1 I1_B_31_b3_3 I1_nbkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I388_MN1 (VSS B_20 XI1_I388_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I401_MN2 (I1_nbkn22 I1_nbk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I401_MN0 (XI1_I401_n1 I1_B_31_b3_3 I1_nbkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I401_MN1 (VSS B_21 XI1_I401_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I414_MN2 (I1_nbkn23 I1_nbk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I414_MN0 (XI1_I414_n1 I1_B_31_b3_3 I1_nbkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I414_MN1 (VSS B_22 XI1_I414_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I427_MN2 (I1_nbkn24 I1_nbk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I427_MN0 (XI1_I427_n1 I1_B_31_b3_4 I1_nbkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I427_MN1 (VSS B_23 XI1_I427_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I518_MN2 (I1_nbkn31 I1_nbk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I518_MN0 (XI1_I518_n1 I1_B_31_b3_5 I1_nbkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I518_MN1 (VSS B_30 XI1_I518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I479_MN2 (I1_nbkn28 I1_nbk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I479_MN0 (XI1_I479_n1 I1_B_31_b3_4 I1_nbkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I479_MN1 (VSS B_27 XI1_I479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I114_MN2 (I1_nakn27 I1_nak26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I114_MN0 (XI1_I114_n1 I1_A_31_b3_4 I1_nakn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I114_MN1 (VSS A_26 XI1_I114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I117_MN2 (I1_nakn28 I1_nak27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I117_MN0 (XI1_I117_n1 I1_A_31_b3_4 I1_nakn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I117_MN1 (VSS A_27 XI1_I117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I112_XG_MN2 (I1_I562_G16_13n I1_I562_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I112_XG_MN0 (XI1_I562_I112_XG_n1 I1_I562_P16_15 I1_I562_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I112_XG_MN1 (VSS I1_I562_G14_13 XI1_I562_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I114_XG_MN2 (I1_I562_G18_15n I1_I562_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I114_XG_MN0 (XI1_I562_I114_XG_n1 I1_I562_P18_17 I1_I562_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I114_XG_MN1 (VSS I1_I562_G16_15 XI1_I562_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I116_XG_MN2 (I1_I562_G20_17n I1_I562_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I116_XG_MN0 (XI1_I562_I116_XG_n1 I1_I562_P20_19 I1_I562_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I116_XG_MN1 (VSS I1_I562_G18_17 XI1_I562_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I118_XG_MN2 (I1_I562_G22_19n I1_I562_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I118_XG_MN0 (XI1_I562_I118_XG_n1 I1_I562_P22_21 I1_I562_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I118_XG_MN1 (VSS I1_I562_G20_19 XI1_I562_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I120_XG_MN2 (I1_I562_G24_21n I1_I562_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I120_XG_MN0 (XI1_I562_I120_XG_n1 I1_I562_P24_23 I1_I562_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I120_XG_MN1 (VSS I1_I562_G22_21 XI1_I562_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I122_XG_MN2 (I1_I562_G26_23n I1_I562_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I122_XG_MN0 (XI1_I562_I122_XG_n1 I1_I562_P26_25 I1_I562_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I122_XG_MN1 (VSS I1_I562_G24_23 XI1_I562_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I124_XG_MN2 (I1_I562_G28_25n I1_I562_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I124_XG_MN0 (XI1_I562_I124_XG_n1 I1_I562_P28_27 I1_I562_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I124_XG_MN1 (VSS I1_I562_G26_25 XI1_I562_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I178_XG_MN2 (I1_I1712_G27_12n I1_I1712_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I178_XG_MN0 (XI1_I1712_I178_XG_n1 I1_I1712_P27_20 I1_I1712_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I178_XG_MN1 (VSS I1_I1712_G19_12 XI1_I1712_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I174_XG_MN2 (I1_I1712_G23_8n I1_I1712_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I174_XG_MN0 (XI1_I1712_I174_XG_n1 I1_I1712_P23_16 I1_I1712_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I174_XG_MN1 (VSS I1_I1712_G15_8 XI1_I1712_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I127_XG_MN2 (I1_I1528_G31_28n I1_I1528_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I127_XG_MN0 (XI1_I1528_I127_XG_n1 I1_I1528_P31_30 I1_I1528_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I127_XG_MN1 (VSS I1_I1528_G29_28 XI1_I1528_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I125_XG_MN2 (I1_I1528_G29_26n I1_I1528_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I125_XG_MN0 (XI1_I1528_I125_XG_n1 I1_I1528_P29_28 I1_I1528_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I125_XG_MN1 (VSS I1_I1528_G27_26 XI1_I1528_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I123_XG_MN2 (I1_I1528_G27_24n I1_I1528_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I123_XG_MN0 (XI1_I1528_I123_XG_n1 I1_I1528_P27_26 I1_I1528_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I123_XG_MN1 (VSS I1_I1528_G25_24 XI1_I1528_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I121_XG_MN2 (I1_I1528_G25_22n I1_I1528_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I121_XG_MN0 (XI1_I1528_I121_XG_n1 I1_I1528_P25_24 I1_I1528_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I121_XG_MN1 (VSS I1_I1528_G23_22 XI1_I1528_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I119_XG_MN2 (I1_I1528_G23_20n I1_I1528_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I119_XG_MN0 (XI1_I1528_I119_XG_n1 I1_I1528_P23_22 I1_I1528_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I119_XG_MN1 (VSS I1_I1528_G21_20 XI1_I1528_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I117_XG_MN2 (I1_I1528_G21_18n I1_I1528_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I117_XG_MN0 (XI1_I1528_I117_XG_n1 I1_I1528_P21_20 I1_I1528_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I117_XG_MN1 (VSS I1_I1528_G19_18 XI1_I1528_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I113_XG_MN2 (I1_I1528_G17_14n I1_I1528_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I113_XG_MN0 (XI1_I1528_I113_XG_n1 I1_I1528_P17_16 I1_I1528_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I113_XG_MN1 (VSS I1_I1528_G15_14 XI1_I1528_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I111_XG_MN2 (I1_I1528_G15_12n I1_I1528_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I111_XG_MN0 (XI1_I1528_I111_XG_n1 I1_I1528_P15_14 I1_I1528_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I111_XG_MN1 (VSS I1_I1528_G13_12 XI1_I1528_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I109_XG_MN2 (I1_I1528_G13_10n I1_I1528_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I109_XG_MN0 (XI1_I1528_I109_XG_n1 I1_I1528_P13_12 I1_I1528_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I109_XG_MN1 (VSS I1_I1528_G11_10 XI1_I1528_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I107_XG_MN2 (I1_I1528_G11_8n I1_I1528_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I107_XG_MN0 (XI1_I1528_I107_XG_n1 I1_I1528_P11_10 I1_I1528_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I107_XG_MN1 (VSS I1_I1528_G9_8 XI1_I1528_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I158_XG_MN2 (I1_I1528_G9_0n I1_I1528_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I158_XG_MN0 (XI1_I1528_I158_XG_n1 I1_I1528_P9_2 I1_I1528_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I158_XG_MN1 (VSS I1_I1528_G1_0 XI1_I1528_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I170_XG_MN2 (I1_I1574_G19_4n I1_I1574_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I170_XG_MN0 (XI1_I1574_I170_XG_n1 I1_I1574_P19_12 I1_I1574_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I170_XG_MN1 (VSS I1_I1574_G11_4 XI1_I1574_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I111_XG_MN2 (I1_I1574_G15_12n I1_I1574_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I111_XG_MN0 (XI1_I1574_I111_XG_n1 I1_I1574_P15_14 I1_I1574_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I111_XG_MN1 (VSS I1_I1574_G13_12 XI1_I1574_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I162_XG_MN2 (I1_I1574_G11_0n I1_I1574_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I162_XG_MN0 (XI1_I1574_I162_XG_n1 I1_I1574_P11_4 I1_I1574_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I162_XG_MN1 (VSS I1_I1574_G3_0np XI1_I1574_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I107_XG_MN2 (I1_I1574_G11_8n I1_I1574_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I107_XG_MN0 (XI1_I1574_I107_XG_n1 I1_I1574_P11_10 I1_I1574_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I107_XG_MN1 (VSS I1_I1574_G9_8 XI1_I1574_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I105_XG_MN2 (I1_I1574_G9_6n I1_I1574_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I105_XG_MN0 (XI1_I1574_I105_XG_n1 I1_I1574_P9_8 I1_I1574_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I105_XG_MN1 (VSS I1_I1574_G7_6 XI1_I1574_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I72_MN2 (I1_nakn13 I1_nak12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I72_MN0 (XI1_I72_n1 I1_A_31_b3_2 I1_nakn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I72_MN1 (VSS A_12 XI1_I72_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2114_MN2 (I1_nqkn13 I1_nqk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2114_MN0 (XI1_I2114_n1 I1_sq_b3_2 I1_nqkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2114_MN1 (VSS I1_qu12_b3_5 XI1_I2114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I2111_MN2 (I1_nqkn12 I1_nqk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I2111_MN0 (XI1_I2111_n1 I1_sq_b3_2 I1_nqkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I2111_MN1 (VSS I1_qu11_b3_5 XI1_I2111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I245_MN2 (I1_nbkn10 I1_nbk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I245_MN0 (XI1_I245_n1 I1_B_31_b3_1 I1_nbkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I245_MN1 (VSS B_9 XI1_I245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I258_MN2 (I1_nbkn11 I1_nbk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I258_MN0 (XI1_I258_n1 I1_B_31_b3_1 I1_nbkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I258_MN1 (VSS B_10 XI1_I258_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I271_MN2 (I1_nbkn12 I1_nbk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I271_MN0 (XI1_I271_n1 I1_B_31_b3_1 I1_nbkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I271_MN1 (VSS B_11 XI1_I271_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I180_MN2 (I1_nbkn5 I1_nbk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I180_MN0 (XI1_I180_n1 I1_B_31_b3_0 I1_nbkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I180_MN1 (VSS B_4 XI1_I180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I284_MN2 (I1_nbkn13 I1_nbk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I284_MN0 (XI1_I284_n1 I1_B_31_b3_2 I1_nbkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I284_MN1 (VSS B_12 XI1_I284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I297_MN2 (I1_nbkn14 I1_nbk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I297_MN0 (XI1_I297_n1 I1_B_31_b3_2 I1_nbkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I297_MN1 (VSS B_13 XI1_I297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I323_MN2 (I1_nbkn16 I1_nbk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I323_MN0 (XI1_I323_n1 I1_B_31_b3_2 I1_nbkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I323_MN1 (VSS B_15 XI1_I323_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I336_MN2 (I1_nbkn17 I1_nbk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I336_MN0 (XI1_I336_n1 I1_B_31_b3_2 I1_nbkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I336_MN1 (VSS B_16 XI1_I336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I349_MN2 (I1_nbkn18 I1_nbk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I349_MN0 (XI1_I349_n1 I1_B_31_b3_3 I1_nbkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I349_MN1 (VSS B_17 XI1_I349_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I362_MN2 (I1_nbkn19 I1_nbk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I362_MN0 (XI1_I362_n1 I1_B_31_b3_3 I1_nbkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I362_MN1 (VSS B_18 XI1_I362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I308_MN2 (I2_I3_q18_2 I2_I3_o18_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I308_MN0 (XI2_I3_I308_n1 I2_I3_SEL_AS_b3_3 I2_I3_q18_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I308_MN1 (VSS I2_S_18 XI2_I3_I308_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I320_MN2 (I2_I3_q19_2 I2_I3_o19_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I320_MN0 (XI2_I3_I320_n1 I2_I3_SEL_AS_b3_3 I2_I3_q19_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I320_MN1 (VSS I2_S_19 XI2_I3_I320_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I332_MN2 (I2_I3_q20_2 I2_I3_o20_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I332_MN0 (XI2_I3_I332_n1 I2_I3_SEL_AS_b3_3 I2_I3_q20_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I332_MN1 (VSS I2_S_20 XI2_I3_I332_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I344_MN2 (I2_I3_q21_2 I2_I3_o21_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I344_MN0 (XI2_I3_I344_n1 I2_I3_SEL_AS_b3_3 I2_I3_q21_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I344_MN1 (VSS I2_S_21 XI2_I3_I344_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I440_MN2 (I1_nbkn25 I1_nbk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I440_MN0 (XI1_I440_n1 I1_B_31_b3_4 I1_nbkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I440_MN1 (VSS B_24 XI1_I440_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I453_MN2 (I1_nbkn26 I1_nbk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I453_MN0 (XI1_I453_n1 I1_B_31_b3_4 I1_nbkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I453_MN1 (VSS B_25 XI1_I453_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I466_MN2 (I1_nbkn27 I1_nbk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I466_MN0 (XI1_I466_n1 I1_B_31_b3_4 I1_nbkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I466_MN1 (VSS B_26 XI1_I466_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I99_XG_MN2 (I1_I562_G3_0n I1_I562_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I99_XG_MN0 (XI1_I562_I99_XG_n1 I1_I562_P3_2 I1_I562_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I99_XG_MN1 (VSS I1_I562_G1_0 XI1_I562_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I101_XG_MN2 (I1_I562_G5_2n I1_I562_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I101_XG_MN0 (XI1_I562_I101_XG_n1 I1_I562_P5_4 I1_I562_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I101_XG_MN1 (VSS I1_I562_G3_2 XI1_I562_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I103_XG_MN2 (I1_I562_G7_4n I1_I562_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I103_XG_MN0 (XI1_I562_I103_XG_n1 I1_I562_P7_6 I1_I562_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I103_XG_MN1 (VSS I1_I562_G5_4 XI1_I562_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I105_XG_MN2 (I1_I562_G9_6n I1_I562_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I105_XG_MN0 (XI1_I562_I105_XG_n1 I1_I562_P9_8 I1_I562_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I105_XG_MN1 (VSS I1_I562_G7_6 XI1_I562_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I107_XG_MN2 (I1_I562_G11_8n I1_I562_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I107_XG_MN0 (XI1_I562_I107_XG_n1 I1_I562_P11_10 I1_I562_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I107_XG_MN1 (VSS I1_I562_G9_8 XI1_I562_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I182_XG_MN2 (I1_I1712_G31_16n I1_I1712_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I182_XG_MN0 (XI1_I1712_I182_XG_n1 I1_I1712_P31_24 I1_I1712_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I182_XG_MN1 (VSS I1_I1712_G23_16 XI1_I1712_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I166_XG_MN2 (I1_I1712_G15_0n I1_I1712_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I166_XG_MN0 (XI1_I1712_I166_XG_n1 I1_I1712_P15_8 I1_I1712_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I166_XG_MN1 (VSS I1_I1712_G7_0 XI1_I1712_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I170_XG_MN2 (I1_I1712_G19_4n I1_I1712_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I170_XG_MN0 (XI1_I1712_I170_XG_n1 I1_I1712_P19_12 I1_I1712_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I170_XG_MN1 (VSS I1_I1712_G11_4 XI1_I1712_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I162_XG_MN2 (I1_I1712_G11_0n I1_I1712_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I162_XG_MN0 (XI1_I1712_I162_XG_n1 I1_I1712_P11_4 I1_I1712_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I162_XG_MN1 (VSS I1_I1712_G3_0np XI1_I1712_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I182_XG_MN2 (I1_I1528_G31_16n I1_I1528_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I182_XG_MN0 (XI1_I1528_I182_XG_n1 I1_I1528_P31_24 I1_I1528_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I182_XG_MN1 (VSS I1_I1528_G23_16 XI1_I1528_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I166_XG_MN2 (I1_I1528_G15_0n I1_I1528_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I166_XG_MN0 (XI1_I1528_I166_XG_n1 I1_I1528_P15_8 I1_I1528_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I166_XG_MN1 (VSS I1_I1528_G7_0 XI1_I1528_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I178_XG_MN2 (I1_I1528_G27_12n I1_I1528_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I178_XG_MN0 (XI1_I1528_I178_XG_n1 I1_I1528_P27_20 I1_I1528_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I178_XG_MN1 (VSS I1_I1528_G19_12 XI1_I1528_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I180_XG_MN2 (I1_I1528_G29_14n I1_I1528_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I180_XG_MN0 (XI1_I1528_I180_XG_n1 I1_I1528_P29_22 I1_I1528_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I180_XG_MN1 (VSS I1_I1528_G21_14 XI1_I1528_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I176_XG_MN2 (I1_I1528_G25_10n I1_I1528_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I176_XG_MN0 (XI1_I1528_I176_XG_n1 I1_I1528_P25_18 I1_I1528_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I176_XG_MN1 (VSS I1_I1528_G17_10 XI1_I1528_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I164_XG_MN2 (I1_I1528_G13_0n I1_I1528_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I164_XG_MN0 (XI1_I1528_I164_XG_n1 I1_I1528_P13_6 I1_I1528_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I164_XG_MN1 (VSS I1_I1528_G5_0 XI1_I1528_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I170_XG_MN2 (I1_I1528_G19_4n I1_I1528_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I170_XG_MN0 (XI1_I1528_I170_XG_n1 I1_I1528_P19_12 I1_I1528_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I170_XG_MN1 (VSS I1_I1528_G11_4 XI1_I1528_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I162_XG_MN2 (I1_I1528_G11_0n I1_I1528_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I162_XG_MN0 (XI1_I1528_I162_XG_n1 I1_I1528_P11_4 I1_I1528_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I162_XG_MN1 (VSS I1_I1528_G3_0np XI1_I1528_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I168_XG_MN2 (I1_I1528_G17_2n I1_I1528_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I168_XG_MN0 (XI1_I1528_I168_XG_n1 I1_I1528_P17_10 I1_I1528_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I168_XG_MN1 (VSS I1_I1528_G9_2 XI1_I1528_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I178_XG_MN2 (I1_I1574_G27_12n I1_I1574_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I178_XG_MN0 (XI1_I1574_I178_XG_n1 I1_I1574_P27_20 I1_I1574_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I178_XG_MN1 (VSS I1_I1574_G19_12 XI1_I1574_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I174_XG_MN2 (I1_I1574_G23_8n I1_I1574_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I174_XG_MN0 (XI1_I1574_I174_XG_n1 I1_I1574_P23_16 I1_I1574_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I174_XG_MN1 (VSS I1_I1574_G15_8 XI1_I1574_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I166_XG_MN2 (I1_I1574_G15_0n I1_I1574_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I166_XG_MN0 (XI1_I1574_I166_XG_n1 I1_I1574_P15_8 I1_I1574_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I166_XG_MN1 (VSS I1_I1574_G7_0 XI1_I1574_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I103_XG_MN2 (I1_I1574_G7_4n I1_I1574_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I103_XG_MN0 (XI1_I1574_I103_XG_n1 I1_I1574_P7_6 I1_I1574_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I103_XG_MN1 (VSS I1_I1574_G5_4 XI1_I1574_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I232_MN2 (I1_nbkn9 I1_nbk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I232_MN0 (XI1_I232_n1 I1_B_31_b3_1 I1_nbkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I232_MN1 (VSS B_8 XI1_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I219_MN2 (I1_nbkn8 I1_nbk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I219_MN0 (XI1_I219_n1 I1_B_31_b3_1 I1_nbkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I219_MN1 (VSS B_7 XI1_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I206_MN2 (I1_nbkn7 I1_nbk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I206_MN0 (XI1_I206_n1 I1_B_31_b3_1 I1_nbkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I206_MN1 (VSS B_6 XI1_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I193_MN2 (I1_nbkn6 I1_nbk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I193_MN0 (XI1_I193_n1 I1_B_31_b3_0 I1_nbkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I193_MN1 (VSS B_5 XI1_I193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I167_MN2 (I1_nbkn4 I1_nbk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I167_MN0 (XI1_I167_n1 I1_B_31_b3_0 I1_nbkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I167_MN1 (VSS B_3 XI1_I167_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I154_MN2 (I1_nbkn3 I1_nbk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I154_MN0 (XI1_I154_n1 I1_B_31_b3_0 I1_nbkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I154_MN1 (VSS B_2 XI1_I154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I141_MN2 (I1_nbkn2 I1_nbk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I141_MN0 (XI1_I141_n1 I1_B_31_b3_0 I1_nbkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I141_MN1 (VSS B_1 XI1_I141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I296_MN2 (I2_I3_q17_2 I2_I3_o17_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I296_MN0 (XI2_I3_I296_n1 I2_I3_SEL_AS_b3_3 I2_I3_q17_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I296_MN1 (VSS I2_S_17 XI2_I3_I296_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I368_MN2 (I2_I3_q23_2 I2_I3_o23_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I368_MN0 (XI2_I3_I368_n1 I2_I3_SEL_AS_b3_4 I2_I3_q23_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I368_MN1 (VSS I2_S_23 XI2_I3_I368_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2_I3_I356_MN2 (I2_I3_q22_2 I2_I3_o22_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2_I3_I356_MN0 (XI2_I3_I356_n1 I2_I3_SEL_AS_b3_4 I2_I3_q22_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2_I3_I356_MN1 (VSS I2_S_22 XI2_I3_I356_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I158_XG_MN2 (I1_I562_G9_0n I1_I562_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I158_XG_MN0 (XI1_I562_I158_XG_n1 I1_I562_P9_2 I1_I562_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I158_XG_MN1 (VSS I1_I562_G1_0 XI1_I562_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I168_XG_MN2 (I1_I562_G17_2n I1_I562_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I168_XG_MN0 (XI1_I562_I168_XG_n1 I1_I562_P17_10 I1_I562_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I168_XG_MN1 (VSS I1_I562_G9_2 XI1_I562_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I109_XG_MN2 (I1_I562_G13_10n I1_I562_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I109_XG_MN0 (XI1_I562_I109_XG_n1 I1_I562_P13_12 I1_I562_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I109_XG_MN1 (VSS I1_I562_G11_10 XI1_I562_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I164_XG_MN2 (I1_I562_G13_0n I1_I562_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I164_XG_MN0 (XI1_I562_I164_XG_n1 I1_I562_P13_6 I1_I562_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I164_XG_MN1 (VSS I1_I562_G5_0 XI1_I562_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I111_XG_MN2 (I1_I562_G15_12n I1_I562_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I111_XG_MN0 (XI1_I562_I111_XG_n1 I1_I562_P15_14 I1_I562_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I111_XG_MN1 (VSS I1_I562_G13_12 XI1_I562_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I113_XG_MN2 (I1_I562_G17_14n I1_I562_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I113_XG_MN0 (XI1_I562_I113_XG_n1 I1_I562_P17_16 I1_I562_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I113_XG_MN1 (VSS I1_I562_G15_14 XI1_I562_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I115_XG_MN2 (I1_I562_G19_16n I1_I562_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I115_XG_MN0 (XI1_I562_I115_XG_n1 I1_I562_P19_18 I1_I562_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I115_XG_MN1 (VSS I1_I562_G17_16 XI1_I562_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I117_XG_MN2 (I1_I562_G21_18n I1_I562_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I117_XG_MN0 (XI1_I562_I117_XG_n1 I1_I562_P21_20 I1_I562_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I117_XG_MN1 (VSS I1_I562_G19_18 XI1_I562_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I119_XG_MN2 (I1_I562_G23_20n I1_I562_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I119_XG_MN0 (XI1_I562_I119_XG_n1 I1_I562_P23_22 I1_I562_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I119_XG_MN1 (VSS I1_I562_G21_20 XI1_I562_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I562_I121_XG_MN2 (I1_I562_G25_22n I1_I562_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I562_I121_XG_MN0 (XI1_I562_I121_XG_n1 I1_I562_P25_24 I1_I562_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I562_I121_XG_MN1 (VSS I1_I562_G23_22 XI1_I562_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I127_XG_MN2 (I1_I1712_G31_28n I1_I1712_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I127_XG_MN0 (XI1_I1712_I127_XG_n1 I1_I1712_P31_30 I1_I1712_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I127_XG_MN1 (VSS I1_I1712_G29_28 XI1_I1712_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1712_I176_XG_MN2 (I1_I1712_G25_10n I1_I1712_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1712_I176_XG_MN0 (XI1_I1712_I176_XG_n1 I1_I1712_P25_18 I1_I1712_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1712_I176_XG_MN1 (VSS I1_I1712_G17_10 XI1_I1712_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I174_XG_MN2 (I1_I1528_G23_8n I1_I1528_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I174_XG_MN0 (XI1_I1528_I174_XG_n1 I1_I1528_P23_16 I1_I1528_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I174_XG_MN1 (VSS I1_I1528_G15_8 XI1_I1528_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1528_I172_XG_MN2 (I1_I1528_G21_6n I1_I1528_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1528_I172_XG_MN0 (XI1_I1528_I172_XG_n1 I1_I1528_P21_14 I1_I1528_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1528_I172_XG_MN1 (VSS I1_I1528_G13_6 XI1_I1528_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I127_XG_MN2 (I1_I1574_G31_28n I1_I1574_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I127_XG_MN0 (XI1_I1574_I127_XG_n1 I1_I1574_P31_30 I1_I1574_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I127_XG_MN1 (VSS I1_I1574_G29_28 XI1_I1574_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I182_XG_MN2 (I1_I1574_G31_16n I1_I1574_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I182_XG_MN0 (XI1_I1574_I182_XG_n1 I1_I1574_P31_24 I1_I1574_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1_I1574_I182_XG_MN1 (VSS I1_I1574_G23_16 XI1_I1574_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1_I1574_I115_XG_MN2 (I1_I1574_G19_16n I1_I1574_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1_I1574_I115_XG_MN0 (XI1_I1574_I115_XG_n1 I1_I1574_P19_18 I1_I1574_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
