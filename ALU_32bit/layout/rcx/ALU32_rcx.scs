    I_MXI1_I1436_I182_XP_MN0 (I1_I1436_P31_16n I1_I1436_P31_24 XI1_I1436_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I178_XP_MN1 (XI1_I1436_I178_XP_n1 I1_I1436_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I178_XP_MN0 (I1_I1436_P27_12n I1_I1436_P27_20 XI1_I1436_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I174_XP_MN1 (XI1_I1436_I174_XP_n1 I1_I1436_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I174_XP_MN0 (I1_I1436_P23_8n I1_I1436_P23_16 XI1_I1436_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I176_XP_MN1 (XI1_I1436_I176_XP_n1 I1_I1436_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I176_XP_MN0 (I1_I1436_P25_10n I1_I1436_P25_18 XI1_I1436_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I170_XP_MN1 (XI1_I1436_I170_XP_n1 I1_I1436_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I170_XP_MN0 (I1_I1436_P19_4n I1_I1436_P19_12 XI1_I1436_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I8_MN1 (XI1_I1482_I8_n1 I1_b20_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I8_MN0 (I1_I1482_gn8 I1_p19_7 XI1_I1482_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I6_MN1 (XI1_I1482_I6_n1 I1_b20_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I6_MN0 (I1_I1482_gn6 I1_p19_5 XI1_I1482_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I0_MN1 (XI1_I1436_I0_n1 I1_b19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I0_MN0 (I1_I1436_gn0 I1_aa12 XI1_I1436_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I178_XP_MN1 (XI1_I1114_I178_XP_n1 I1_I1114_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I178_XP_MN0 (I1_I1114_P27_12n I1_I1114_P27_20 XI1_I1114_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I115_XP_MN1 (XI1_I1114_I115_XP_n1 I1_I1114_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I115_XP_MN0 (I1_I1114_P19_16n I1_I1114_P19_18 XI1_I1114_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I176_XP_MN1 (XI1_I1114_I176_XP_n1 I1_I1114_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I176_XP_MN0 (I1_I1114_P25_10n I1_I1114_P25_18 XI1_I1114_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I113_XP_MN1 (XI1_I1114_I113_XP_n1 I1_I1114_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I113_XP_MN0 (I1_I1114_P17_14n I1_I1114_P17_16 XI1_I1114_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I172_XP_MN1 (XI1_I1114_I172_XP_n1 I1_I1114_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I172_XP_MN0 (I1_I1114_P21_6n I1_I1114_P21_14 XI1_I1114_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I179_XP_MN1 (XI1_I1114_I179_XP_n1 I1_I1114_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I179_XP_MN0 (I1_I1114_P28_13n I1_I1114_P28_21 XI1_I1114_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I169_XP_MN1 (XI1_I1114_I169_XP_n1 I1_I1114_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I169_XP_MN0 (I1_I1114_P18_3n I1_I1114_P18_11 XI1_I1114_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I16_MN1 (XI1_I1114_I16_n1 I1_b12_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I16_MN0 (I1_I1114_gn16 I1_p11_15 XI1_I1114_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I177_XP_MN1 (XI1_I1068_I177_XP_n1 I1_I1068_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I177_XP_MN0 (I1_I1068_P26_11n I1_I1068_P26_19 XI1_I1068_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I172_XP_MN1 (XI1_I1068_I172_XP_n1 I1_I1068_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I172_XP_MN0 (I1_I1068_P21_6n I1_I1068_P21_14 XI1_I1068_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I178_XP_MN1 (XI1_I1068_I178_XP_n1 I1_I1068_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I178_XP_MN0 (I1_I1068_P27_12n I1_I1068_P27_20 XI1_I1068_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I20_MN1 (XI1_I1068_I20_n1 I1_b11_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I20_MN0 (I1_I1068_gn20 I1_p10_19 XI1_I1068_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I126_XP_MN1 (XI1_I1022_I126_XP_n1 I1_I1022_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I126_XP_MN0 (I1_I1022_P30_27n I1_I1022_P30_29 XI1_I1022_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I125_XP_MN1 (XI1_I1022_I125_XP_n1 I1_I1022_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I125_XP_MN0 (I1_I1022_P29_26n I1_I1022_P29_28 XI1_I1022_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I23_MN1 (XI1_I1022_I23_n1 I1_b10_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I23_MN0 (I1_I1022_gn23 I1_p9_22 XI1_I1022_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I22_MN1 (XI1_I1022_I22_n1 I1_b10_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I22_MN0 (I1_I1022_gn22 I1_p9_21 XI1_I1022_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I122_XP_MN1 (XI1_I976_I122_XP_n1 I1_I976_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I122_XP_MN0 (I1_I976_P26_23n I1_I976_P26_25 XI1_I976_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I120_XP_MN1 (XI1_I976_I120_XP_n1 I1_I976_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I120_XP_MN0 (I1_I976_P24_21n I1_I976_P24_23 XI1_I976_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I118_XP_MN1 (XI1_I976_I118_XP_n1 I1_I976_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I118_XP_MN0 (I1_I976_P22_19n I1_I976_P22_21 XI1_I976_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I116_XP_MN1 (XI1_I976_I116_XP_n1 I1_I976_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I116_XP_MN0 (I1_I976_P20_17n I1_I976_P20_19 XI1_I976_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I114_XP_MN1 (XI1_I976_I114_XP_n1 I1_I976_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I114_XP_MN0 (I1_I976_P18_15n I1_I976_P18_17 XI1_I976_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I112_XP_MN1 (XI1_I976_I112_XP_n1 I1_I976_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I112_XP_MN0 (I1_I976_P16_13n I1_I976_P16_15 XI1_I976_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I170_XP_MN1 (XI1_I976_I170_XP_n1 I1_I976_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I170_XP_MN0 (I1_I976_P19_4n I1_I976_P19_12 XI1_I976_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I168_XP_MN1 (XI1_I976_I168_XP_n1 I1_I976_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I168_XP_MN0 (I1_I976_P17_2n I1_I976_P17_10 XI1_I976_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I103_XP_MN1 (XI1_I976_I103_XP_n1 I1_I976_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I103_XP_MN0 (I1_I976_P7_4n I1_I976_P7_6 XI1_I976_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I5_MN1 (XI1_I976_I5_n1 I1_b9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I5_MN0 (I1_I976_gn5 I1_p8_4 XI1_I976_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I167_XP_MN1 (XI1_I608_I167_XP_n1 I1_I608_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I167_XP_MN0 (I1_I608_P16_1n I1_I608_P16_9 XI1_I608_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I175_XP_MN1 (XI1_I608_I175_XP_n1 I1_I608_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I175_XP_MN0 (I1_I608_P24_9n I1_I608_P24_17 XI1_I608_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I18_MN1 (XI1_I654_I18_n1 I1_b2_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I18_MN0 (I1_I654_gn18 I1_p1_17 XI1_I654_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I31_MN1 (XI1_I654_I31_n1 I1_b2_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I31_MN0 (I1_I654_gn31 I1_p1_30 XI1_I654_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I20_MN1 (XI1_I1482_I20_n1 I1_b20_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I20_MN0 (I1_I1482_gn20 I1_p19_19 XI1_I1482_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I18_MN1 (XI1_I1482_I18_n1 I1_b20_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I18_MN0 (I1_I1482_gn18 I1_p19_17 XI1_I1482_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I16_MN1 (XI1_I1482_I16_n1 I1_b20_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I16_MN0 (I1_I1482_gn16 I1_p19_15 XI1_I1482_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I15_MN1 (XI1_I1482_I15_n1 I1_b20_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I15_MN0 (I1_I1482_gn15 I1_p19_14 XI1_I1482_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I14_MN1 (XI1_I1482_I14_n1 I1_b20_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I14_MN0 (I1_I1482_gn14 I1_p19_13 XI1_I1482_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I13_MN1 (XI1_I1482_I13_n1 I1_b20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I13_MN0 (I1_I1482_gn13 I1_p19_12 XI1_I1482_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I12_MN1 (XI1_I1482_I12_n1 I1_b20_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I12_MN0 (I1_I1482_gn12 I1_p19_11 XI1_I1482_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I11_MN1 (XI1_I1482_I11_n1 I1_b20_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I11_MN0 (I1_I1482_gn11 I1_p19_10 XI1_I1482_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I10_MN1 (XI1_I1482_I10_n1 I1_b20_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I10_MN0 (I1_I1482_gn10 I1_p19_9 XI1_I1482_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I7_MN1 (XI1_I1482_I7_n1 I1_b20_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I7_MN0 (I1_I1482_gn7 I1_p19_6 XI1_I1482_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I5_MN1 (XI1_I1482_I5_n1 I1_b20_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I5_MN0 (I1_I1482_gn5 I1_p19_4 XI1_I1482_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I3_MN1 (XI1_I1482_I3_n1 I1_b20_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I3_MN0 (I1_I1482_gn3 I1_p19_2 XI1_I1482_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I4_MN1 (XI1_I1482_I4_n1 I1_b20_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I4_MN0 (I1_I1482_gn4 I1_p19_3 XI1_I1482_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I111_XP_MN1 (XI1_I1114_I111_XP_n1 I1_I1114_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I111_XP_MN0 (I1_I1114_P15_12n I1_I1114_P15_14 XI1_I1114_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I175_XP_MN1 (XI1_I1114_I175_XP_n1 I1_I1114_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I175_XP_MN0 (I1_I1114_P24_9n I1_I1114_P24_17 XI1_I1114_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I171_XP_MN1 (XI1_I1114_I171_XP_n1 I1_I1114_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I171_XP_MN0 (I1_I1114_P20_5n I1_I1114_P20_13 XI1_I1114_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I112_XP_MN1 (XI1_I1114_I112_XP_n1 I1_I1114_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I112_XP_MN0 (I1_I1114_P16_13n I1_I1114_P16_15 XI1_I1114_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I15_MN1 (XI1_I1114_I15_n1 I1_b12_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I15_MN0 (I1_I1114_gn15 I1_p11_14 XI1_I1114_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I14_MN1 (XI1_I1114_I14_n1 I1_b12_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I14_MN0 (I1_I1114_gn14 I1_p11_13 XI1_I1114_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I171_XP_MN1 (XI1_I1068_I171_XP_n1 I1_I1068_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I171_XP_MN0 (I1_I1068_P20_5n I1_I1068_P20_13 XI1_I1068_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I116_XP_MN1 (XI1_I1068_I116_XP_n1 I1_I1068_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I116_XP_MN0 (I1_I1068_P20_17n I1_I1068_P20_19 XI1_I1068_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I115_XP_MN1 (XI1_I1068_I115_XP_n1 I1_I1068_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I115_XP_MN0 (I1_I1068_P19_16n I1_I1068_P19_18 XI1_I1068_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I117_XP_MN1 (XI1_I1068_I117_XP_n1 I1_I1068_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I117_XP_MN0 (I1_I1068_P21_18n I1_I1068_P21_20 XI1_I1068_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I19_MN1 (XI1_I1068_I19_n1 I1_b11_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I19_MN0 (I1_I1068_gn19 I1_p10_18 XI1_I1068_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I17_MN1 (XI1_I1068_I17_n1 I1_b11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I17_MN0 (I1_I1068_gn17 I1_p10_16 XI1_I1068_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I18_MN1 (XI1_I1068_I18_n1 I1_b11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I18_MN0 (I1_I1068_gn18 I1_p10_17 XI1_I1068_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I124_XP_MN1 (XI1_I1022_I124_XP_n1 I1_I1022_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I124_XP_MN0 (I1_I1022_P28_25n I1_I1022_P28_27 XI1_I1022_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I122_XP_MN1 (XI1_I1022_I122_XP_n1 I1_I1022_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I122_XP_MN0 (I1_I1022_P26_23n I1_I1022_P26_25 XI1_I1022_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I123_XP_MN1 (XI1_I1022_I123_XP_n1 I1_I1022_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I123_XP_MN0 (I1_I1022_P27_24n I1_I1022_P27_26 XI1_I1022_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I21_MN1 (XI1_I1022_I21_n1 I1_b10_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I21_MN0 (I1_I1022_gn21 I1_p9_20 XI1_I1022_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I181_XP_MN1 (XI1_I976_I181_XP_n1 I1_I976_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I181_XP_MN0 (I1_I976_P30_15n I1_I976_P30_23 XI1_I976_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I173_XP_MN1 (XI1_I976_I173_XP_n1 I1_I976_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I173_XP_MN0 (I1_I976_P22_7n I1_I976_P22_15 XI1_I976_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I177_XP_MN1 (XI1_I976_I177_XP_n1 I1_I976_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I177_XP_MN0 (I1_I976_P26_11n I1_I976_P26_19 XI1_I976_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I110_XP_MN1 (XI1_I976_I110_XP_n1 I1_I976_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I110_XP_MN0 (I1_I976_P14_11n I1_I976_P14_13 XI1_I976_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I108_XP_MN1 (XI1_I976_I108_XP_n1 I1_I976_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I108_XP_MN0 (I1_I976_P12_9n I1_I976_P12_11 XI1_I976_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I101_XP_MN1 (XI1_I976_I101_XP_n1 I1_I976_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I101_XP_MN0 (I1_I976_P5_2n I1_I976_P5_4 XI1_I976_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I4_MN1 (XI1_I976_I4_n1 I1_b9_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I4_MN0 (I1_I976_gn4 I1_p8_3 XI1_I976_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I3_MN1 (XI1_I976_I3_n1 I1_b9_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I3_MN0 (I1_I976_gn3 I1_p8_2 XI1_I976_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I100_XP_MN1 (XI1_I608_I100_XP_n1 I1_I608_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I100_XP_MN0 (I1_I608_P4_1n I1_I608_P4_3 XI1_I608_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I102_XP_MN1 (XI1_I608_I102_XP_n1 I1_I608_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I102_XP_MN0 (I1_I608_P6_3n I1_I608_P6_5 XI1_I608_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I104_XP_MN1 (XI1_I608_I104_XP_n1 I1_I608_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I104_XP_MN0 (I1_I608_P8_5n I1_I608_P8_7 XI1_I608_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I169_XP_MN1 (XI1_I608_I169_XP_n1 I1_I608_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I169_XP_MN0 (I1_I608_P18_3n I1_I608_P18_11 XI1_I608_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I171_XP_MN1 (XI1_I608_I171_XP_n1 I1_I608_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I171_XP_MN0 (I1_I608_P20_5n I1_I608_P20_13 XI1_I608_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I177_XP_MN1 (XI1_I608_I177_XP_n1 I1_I608_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I177_XP_MN0 (I1_I608_P26_11n I1_I608_P26_19 XI1_I608_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I173_XP_MN1 (XI1_I608_I173_XP_n1 I1_I608_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I173_XP_MN0 (I1_I608_P22_7n I1_I608_P22_15 XI1_I608_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I179_XP_MN1 (XI1_I608_I179_XP_n1 I1_I608_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I179_XP_MN0 (I1_I608_P28_13n I1_I608_P28_21 XI1_I608_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I181_XP_MN1 (XI1_I608_I181_XP_n1 I1_I608_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I181_XP_MN0 (I1_I608_P30_15n I1_I608_P30_23 XI1_I608_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I124_XP_MN1 (XI1_I608_I124_XP_n1 I1_I608_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I124_XP_MN0 (I1_I608_P28_25n I1_I608_P28_27 XI1_I608_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I126_XP_MN1 (XI1_I608_I126_XP_n1 I1_I608_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I126_XP_MN0 (I1_I608_P30_27n I1_I608_P30_29 XI1_I608_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I23_MN1 (XI1_I1482_I23_n1 I1_b20_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I23_MN0 (I1_I1482_gn23 I1_p19_22 XI1_I1482_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I22_MN1 (XI1_I1482_I22_n1 I1_b20_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I22_MN0 (I1_I1482_gn22 I1_p19_21 XI1_I1482_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I21_MN1 (XI1_I1482_I21_n1 I1_b20_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I21_MN0 (I1_I1482_gn21 I1_p19_20 XI1_I1482_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I19_MN1 (XI1_I1482_I19_n1 I1_b20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I19_MN0 (I1_I1482_gn19 I1_p19_18 XI1_I1482_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I17_MN1 (XI1_I1482_I17_n1 I1_b20_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I17_MN0 (I1_I1482_gn17 I1_p19_16 XI1_I1482_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I9_MN1 (XI1_I1482_I9_n1 I1_b20_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I9_MN0 (I1_I1482_gn9 I1_p19_8 XI1_I1482_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I2_MN1 (XI1_I1482_I2_n1 I1_b20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I2_MN0 (I1_I1482_gn2 I1_p19_1 XI1_I1482_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I170_XP_MN1 (XI1_I1114_I170_XP_n1 I1_I1114_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I170_XP_MN0 (I1_I1114_P19_4n I1_I1114_P19_12 XI1_I1114_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I168_XP_MN1 (XI1_I1114_I168_XP_n1 I1_I1114_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I168_XP_MN0 (I1_I1114_P17_2n I1_I1114_P17_10 XI1_I1114_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I109_XP_MN1 (XI1_I1114_I109_XP_n1 I1_I1114_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I109_XP_MN0 (I1_I1114_P13_10n I1_I1114_P13_12 XI1_I1114_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I110_XP_MN1 (XI1_I1114_I110_XP_n1 I1_I1114_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I110_XP_MN0 (I1_I1114_P14_11n I1_I1114_P14_13 XI1_I1114_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I13_MN1 (XI1_I1114_I13_n1 I1_b12_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I13_MN0 (I1_I1114_gn13 I1_p11_12 XI1_I1114_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I114_XP_MN1 (XI1_I1068_I114_XP_n1 I1_I1068_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I114_XP_MN0 (I1_I1068_P18_15n I1_I1068_P18_17 XI1_I1068_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I170_XP_MN1 (XI1_I1068_I170_XP_n1 I1_I1068_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I170_XP_MN0 (I1_I1068_P19_4n I1_I1068_P19_12 XI1_I1068_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I111_XP_MN1 (XI1_I1068_I111_XP_n1 I1_I1068_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I111_XP_MN0 (I1_I1068_P15_12n I1_I1068_P15_14 XI1_I1068_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I113_XP_MN1 (XI1_I1068_I113_XP_n1 I1_I1068_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I113_XP_MN0 (I1_I1068_P17_14n I1_I1068_P17_16 XI1_I1068_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I16_MN1 (XI1_I1068_I16_n1 I1_b11_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I16_MN0 (I1_I1068_gn16 I1_p10_15 XI1_I1068_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I181_XP_MN1 (XI1_I1022_I181_XP_n1 I1_I1022_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I181_XP_MN0 (I1_I1022_P30_15n I1_I1022_P30_23 XI1_I1022_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I120_XP_MN1 (XI1_I1022_I120_XP_n1 I1_I1022_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I120_XP_MN0 (I1_I1022_P24_21n I1_I1022_P24_23 XI1_I1022_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I182_XP_MN1 (XI1_I1022_I182_XP_n1 I1_I1022_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I182_XP_MN0 (I1_I1022_P31_16n I1_I1022_P31_24 XI1_I1022_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I121_XP_MN1 (XI1_I1022_I121_XP_n1 I1_I1022_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I121_XP_MN0 (I1_I1022_P25_22n I1_I1022_P25_24 XI1_I1022_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I20_MN1 (XI1_I1022_I20_n1 I1_b10_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I20_MN0 (I1_I1022_gn20 I1_p9_19 XI1_I1022_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I19_MN1 (XI1_I1022_I19_n1 I1_b10_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I19_MN0 (I1_I1022_gn19 I1_p9_18 XI1_I1022_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I179_XP_MN1 (XI1_I976_I179_XP_n1 I1_I976_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I179_XP_MN0 (I1_I976_P28_13n I1_I976_P28_21 XI1_I976_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I171_XP_MN1 (XI1_I976_I171_XP_n1 I1_I976_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I171_XP_MN0 (I1_I976_P20_5n I1_I976_P20_13 XI1_I976_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I169_XP_MN1 (XI1_I976_I169_XP_n1 I1_I976_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I169_XP_MN0 (I1_I976_P18_3n I1_I976_P18_11 XI1_I976_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I175_XP_MN1 (XI1_I976_I175_XP_n1 I1_I976_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I175_XP_MN0 (I1_I976_P24_9n I1_I976_P24_17 XI1_I976_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I106_XP_MN1 (XI1_I976_I106_XP_n1 I1_I976_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I106_XP_MN0 (I1_I976_P10_7n I1_I976_P10_9 XI1_I976_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I104_XP_MN1 (XI1_I976_I104_XP_n1 I1_I976_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I104_XP_MN0 (I1_I976_P8_5n I1_I976_P8_7 XI1_I976_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I1_MN1 (XI1_I608_I1_n1 I1_b1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I1_MN0 (I1_I608_gn1 I1_p0_0 XI1_I608_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I106_XP_MN1 (XI1_I608_I106_XP_n1 I1_I608_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I106_XP_MN0 (I1_I608_P10_7n I1_I608_P10_9 XI1_I608_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I108_XP_MN1 (XI1_I608_I108_XP_n1 I1_I608_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I108_XP_MN0 (I1_I608_P12_9n I1_I608_P12_11 XI1_I608_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I110_XP_MN1 (XI1_I608_I110_XP_n1 I1_I608_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I110_XP_MN0 (I1_I608_P14_11n I1_I608_P14_13 XI1_I608_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I112_XP_MN1 (XI1_I608_I112_XP_n1 I1_I608_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I112_XP_MN0 (I1_I608_P16_13n I1_I608_P16_15 XI1_I608_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I114_XP_MN1 (XI1_I608_I114_XP_n1 I1_I608_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I114_XP_MN0 (I1_I608_P18_15n I1_I608_P18_17 XI1_I608_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I116_XP_MN1 (XI1_I608_I116_XP_n1 I1_I608_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I116_XP_MN0 (I1_I608_P20_17n I1_I608_P20_19 XI1_I608_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I118_XP_MN1 (XI1_I608_I118_XP_n1 I1_I608_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I118_XP_MN0 (I1_I608_P22_19n I1_I608_P22_21 XI1_I608_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I120_XP_MN1 (XI1_I608_I120_XP_n1 I1_I608_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I120_XP_MN0 (I1_I608_P24_21n I1_I608_P24_23 XI1_I608_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I122_XP_MN1 (XI1_I608_I122_XP_n1 I1_I608_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I122_XP_MN0 (I1_I608_P26_23n I1_I608_P26_25 XI1_I608_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I25_MN1 (XI1_I1482_I25_n1 I1_b20_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I25_MN0 (I1_I1482_gn25 I1_p19_24 XI1_I1482_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I24_MN1 (XI1_I1482_I24_n1 I1_b20_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I24_MN0 (I1_I1482_gn24 I1_p19_23 XI1_I1482_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I119_XP_MN1 (XI1_I1482_I119_XP_n1 I1_I1482_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I119_XP_MN0 (I1_I1482_P23_20n I1_I1482_P23_22 XI1_I1482_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I117_XP_MN1 (XI1_I1482_I117_XP_n1 I1_I1482_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I117_XP_MN0 (I1_I1482_P21_18n I1_I1482_P21_20 XI1_I1482_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I115_XP_MN1 (XI1_I1482_I115_XP_n1 I1_I1482_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I115_XP_MN0 (I1_I1482_P19_16n I1_I1482_P19_18 XI1_I1482_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I113_XP_MN1 (XI1_I1482_I113_XP_n1 I1_I1482_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I113_XP_MN0 (I1_I1482_P17_14n I1_I1482_P17_16 XI1_I1482_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I111_XP_MN1 (XI1_I1482_I111_XP_n1 I1_I1482_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I111_XP_MN0 (I1_I1482_P15_12n I1_I1482_P15_14 XI1_I1482_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I109_XP_MN1 (XI1_I1482_I109_XP_n1 I1_I1482_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I109_XP_MN0 (I1_I1482_P13_10n I1_I1482_P13_12 XI1_I1482_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I107_XP_MN1 (XI1_I1482_I107_XP_n1 I1_I1482_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I107_XP_MN0 (I1_I1482_P11_8n I1_I1482_P11_10 XI1_I1482_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I105_XP_MN1 (XI1_I1482_I105_XP_n1 I1_I1482_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I105_XP_MN0 (I1_I1482_P9_6n I1_I1482_P9_8 XI1_I1482_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I103_XP_MN1 (XI1_I1482_I103_XP_n1 I1_I1482_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I103_XP_MN0 (I1_I1482_P7_4n I1_I1482_P7_6 XI1_I1482_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I101_XP_MN1 (XI1_I1482_I101_XP_n1 I1_I1482_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I101_XP_MN0 (I1_I1482_P5_2n I1_I1482_P5_4 XI1_I1482_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I1_MN1 (XI1_I1482_I1_n1 I1_b20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I1_MN0 (I1_I1482_gn1 I1_p19_0 XI1_I1482_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I107_XP_MN1 (XI1_I1114_I107_XP_n1 I1_I1114_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I107_XP_MN0 (I1_I1114_P11_8n I1_I1114_P11_10 XI1_I1114_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I108_XP_MN1 (XI1_I1114_I108_XP_n1 I1_I1114_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I108_XP_MN0 (I1_I1114_P12_9n I1_I1114_P12_11 XI1_I1114_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I106_XP_MN1 (XI1_I1114_I106_XP_n1 I1_I1114_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I106_XP_MN0 (I1_I1114_P10_7n I1_I1114_P10_9 XI1_I1114_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I167_XP_MN1 (XI1_I1114_I167_XP_n1 I1_I1114_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I167_XP_MN0 (I1_I1114_P16_1n I1_I1114_P16_9 XI1_I1114_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I12_MN1 (XI1_I1114_I12_n1 I1_b12_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I12_MN0 (I1_I1114_gn12 I1_p11_11 XI1_I1114_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I169_XP_MN1 (XI1_I1068_I169_XP_n1 I1_I1068_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I169_XP_MN0 (I1_I1068_P18_3n I1_I1068_P18_11 XI1_I1068_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I112_XP_MN1 (XI1_I1068_I112_XP_n1 I1_I1068_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I112_XP_MN0 (I1_I1068_P16_13n I1_I1068_P16_15 XI1_I1068_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I110_XP_MN1 (XI1_I1068_I110_XP_n1 I1_I1068_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I110_XP_MN0 (I1_I1068_P14_11n I1_I1068_P14_13 XI1_I1068_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I176_XP_MN1 (XI1_I1068_I176_XP_n1 I1_I1068_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I176_XP_MN0 (I1_I1068_P25_10n I1_I1068_P25_18 XI1_I1068_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I109_XP_MN1 (XI1_I1068_I109_XP_n1 I1_I1068_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I109_XP_MN0 (I1_I1068_P13_10n I1_I1068_P13_12 XI1_I1068_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I14_MN1 (XI1_I1068_I14_n1 I1_b11_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I14_MN0 (I1_I1068_gn14 I1_p10_13 XI1_I1068_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I15_MN1 (XI1_I1068_I15_n1 I1_b11_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I15_MN0 (I1_I1068_gn15 I1_p10_14 XI1_I1068_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I118_XP_MN1 (XI1_I1022_I118_XP_n1 I1_I1022_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I118_XP_MN0 (I1_I1022_P22_19n I1_I1022_P22_21 XI1_I1022_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I174_XP_MN1 (XI1_I1022_I174_XP_n1 I1_I1022_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I174_XP_MN0 (I1_I1022_P23_8n I1_I1022_P23_16 XI1_I1022_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I119_XP_MN1 (XI1_I1022_I119_XP_n1 I1_I1022_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I119_XP_MN0 (I1_I1022_P23_20n I1_I1022_P23_22 XI1_I1022_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I18_MN1 (XI1_I1022_I18_n1 I1_b10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I18_MN0 (I1_I1022_gn18 I1_p9_17 XI1_I1022_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I16_MN1 (XI1_I1022_I16_n1 I1_b10_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I16_MN0 (I1_I1022_gn16 I1_p9_15 XI1_I1022_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I17_MN1 (XI1_I1022_I17_n1 I1_b10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I17_MN0 (I1_I1022_gn17 I1_p9_16 XI1_I1022_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I167_XP_MN1 (XI1_I976_I167_XP_n1 I1_I976_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I167_XP_MN0 (I1_I976_P16_1n I1_I976_P16_9 XI1_I976_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I102_XP_MN1 (XI1_I976_I102_XP_n1 I1_I976_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I102_XP_MN0 (I1_I976_P6_3n I1_I976_P6_5 XI1_I976_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I2_MN1 (XI1_I976_I2_n1 I1_b9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I2_MN0 (I1_I976_gn2 I1_p8_1 XI1_I976_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I2_MN1 (XI1_I608_I2_n1 I1_b1_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I2_MN0 (I1_I608_gn2 I1_p0_1 XI1_I608_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I101_XP_MN1 (XI1_I608_I101_XP_n1 I1_I608_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I101_XP_MN0 (I1_I608_P5_2n I1_I608_P5_4 XI1_I608_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I103_XP_MN1 (XI1_I608_I103_XP_n1 I1_I608_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I103_XP_MN0 (I1_I608_P7_4n I1_I608_P7_6 XI1_I608_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I168_XP_MN1 (XI1_I608_I168_XP_n1 I1_I608_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I168_XP_MN0 (I1_I608_P17_2n I1_I608_P17_10 XI1_I608_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I170_XP_MN1 (XI1_I608_I170_XP_n1 I1_I608_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I170_XP_MN0 (I1_I608_P19_4n I1_I608_P19_12 XI1_I608_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I176_XP_MN1 (XI1_I608_I176_XP_n1 I1_I608_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I176_XP_MN0 (I1_I608_P25_10n I1_I608_P25_18 XI1_I608_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I172_XP_MN1 (XI1_I608_I172_XP_n1 I1_I608_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I172_XP_MN0 (I1_I608_P21_6n I1_I608_P21_14 XI1_I608_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I178_XP_MN1 (XI1_I608_I178_XP_n1 I1_I608_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I178_XP_MN0 (I1_I608_P27_12n I1_I608_P27_20 XI1_I608_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I174_XP_MN1 (XI1_I608_I174_XP_n1 I1_I608_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I174_XP_MN0 (I1_I608_P23_8n I1_I608_P23_16 XI1_I608_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I180_XP_MN1 (XI1_I608_I180_XP_n1 I1_I608_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I180_XP_MN0 (I1_I608_P29_14n I1_I608_P29_22 XI1_I608_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I182_XP_MN1 (XI1_I608_I182_XP_n1 I1_I608_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I182_XP_MN0 (I1_I608_P31_16n I1_I608_P31_24 XI1_I608_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I127_XP_MN1 (XI1_I608_I127_XP_n1 I1_I608_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I127_XP_MN0 (I1_I608_P31_28n I1_I608_P31_30 XI1_I608_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I31_MN1 (XI1_I608_I31_n1 I1_b1_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I31_MN0 (I1_I608_gn31 I1_p0_30 XI1_I608_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I30_MN1 (XI1_I608_I30_n1 I1_b1_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I30_MN0 (I1_I608_gn30 I1_p0_29 XI1_I608_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I182_XP_MN1 (XI1_I1482_I182_XP_n1 I1_I1482_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I182_XP_MN0 (I1_I1482_P31_16n I1_I1482_P31_24 XI1_I1482_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I123_XP_MN1 (XI1_I1482_I123_XP_n1 I1_I1482_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I123_XP_MN0 (I1_I1482_P27_24n I1_I1482_P27_26 XI1_I1482_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I121_XP_MN1 (XI1_I1482_I121_XP_n1 I1_I1482_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I121_XP_MN0 (I1_I1482_P25_22n I1_I1482_P25_24 XI1_I1482_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I174_XP_MN1 (XI1_I1482_I174_XP_n1 I1_I1482_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I174_XP_MN0 (I1_I1482_P23_8n I1_I1482_P23_16 XI1_I1482_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I172_XP_MN1 (XI1_I1482_I172_XP_n1 I1_I1482_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I172_XP_MN0 (I1_I1482_P21_6n I1_I1482_P21_14 XI1_I1482_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I170_XP_MN1 (XI1_I1482_I170_XP_n1 I1_I1482_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I170_XP_MN0 (I1_I1482_P19_4n I1_I1482_P19_12 XI1_I1482_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I168_XP_MN1 (XI1_I1482_I168_XP_n1 I1_I1482_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I168_XP_MN0 (I1_I1482_P17_2n I1_I1482_P17_10 XI1_I1482_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I7_MN1 (XI1_I1528_I7_n1 I1_b21_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I7_MN0 (I1_I1528_gn7 I1_p20_6 XI1_I1528_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I103_XP_MN1 (XI1_I1114_I103_XP_n1 I1_I1114_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I103_XP_MN0 (I1_I1114_P7_4n I1_I1114_P7_6 XI1_I1114_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I105_XP_MN1 (XI1_I1114_I105_XP_n1 I1_I1114_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I105_XP_MN0 (I1_I1114_P9_6n I1_I1114_P9_8 XI1_I1114_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I101_XP_MN1 (XI1_I1114_I101_XP_n1 I1_I1114_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I101_XP_MN0 (I1_I1114_P5_2n I1_I1114_P5_4 XI1_I1114_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I104_XP_MN1 (XI1_I1114_I104_XP_n1 I1_I1114_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I104_XP_MN0 (I1_I1114_P8_5n I1_I1114_P8_7 XI1_I1114_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I11_MN1 (XI1_I1114_I11_n1 I1_b12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I11_MN0 (I1_I1114_gn11 I1_p11_10 XI1_I1114_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I175_XP_MN1 (XI1_I1068_I175_XP_n1 I1_I1068_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I175_XP_MN0 (I1_I1068_P24_9n I1_I1068_P24_17 XI1_I1068_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I108_XP_MN1 (XI1_I1068_I108_XP_n1 I1_I1068_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I108_XP_MN0 (I1_I1068_P12_9n I1_I1068_P12_11 XI1_I1068_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I168_XP_MN1 (XI1_I1068_I168_XP_n1 I1_I1068_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I168_XP_MN0 (I1_I1068_P17_2n I1_I1068_P17_10 XI1_I1068_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I107_XP_MN1 (XI1_I1068_I107_XP_n1 I1_I1068_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I107_XP_MN0 (I1_I1068_P11_8n I1_I1068_P11_10 XI1_I1068_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I173_XP_MN1 (XI1_I1022_I173_XP_n1 I1_I1022_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I173_XP_MN0 (I1_I1022_P22_7n I1_I1022_P22_15 XI1_I1022_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I179_XP_MN1 (XI1_I1022_I179_XP_n1 I1_I1022_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I179_XP_MN0 (I1_I1022_P28_13n I1_I1022_P28_21 XI1_I1022_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I116_XP_MN1 (XI1_I1022_I116_XP_n1 I1_I1022_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I116_XP_MN0 (I1_I1022_P20_17n I1_I1022_P20_19 XI1_I1022_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I114_XP_MN1 (XI1_I1022_I114_XP_n1 I1_I1022_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I114_XP_MN0 (I1_I1022_P18_15n I1_I1022_P18_17 XI1_I1022_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I178_XP_MN1 (XI1_I1022_I178_XP_n1 I1_I1022_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I178_XP_MN0 (I1_I1022_P27_12n I1_I1022_P27_20 XI1_I1022_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I117_XP_MN1 (XI1_I1022_I117_XP_n1 I1_I1022_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I117_XP_MN0 (I1_I1022_P21_18n I1_I1022_P21_20 XI1_I1022_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I115_XP_MN1 (XI1_I1022_I115_XP_n1 I1_I1022_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I115_XP_MN0 (I1_I1022_P19_16n I1_I1022_P19_18 XI1_I1022_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I14_MN1 (XI1_I1022_I14_n1 I1_b10_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I14_MN0 (I1_I1022_gn14 I1_p9_13 XI1_I1022_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I100_XP_MN1 (XI1_I976_I100_XP_n1 I1_I976_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I100_XP_MN0 (I1_I976_P4_1n I1_I976_P4_3 XI1_I976_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I0_MN1 (XI1_I930_I0_n1 I1_b8_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I0_MN0 (I1_I930_gn0 I1_aa23 XI1_I930_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I0_MN1 (XI1_I608_I0_n1 I1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I0_MN0 (I1_I608_gn0 I1_aa30 XI1_I608_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I3_MN1 (XI1_I608_I3_n1 I1_b1_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I3_MN0 (I1_I608_gn3 I1_p0_2 XI1_I608_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I4_MN1 (XI1_I608_I4_n1 I1_b1_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I4_MN0 (I1_I608_gn4 I1_p0_3 XI1_I608_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I5_MN1 (XI1_I608_I5_n1 I1_b1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I5_MN0 (I1_I608_gn5 I1_p0_4 XI1_I608_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I105_XP_MN1 (XI1_I608_I105_XP_n1 I1_I608_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I105_XP_MN0 (I1_I608_P9_6n I1_I608_P9_8 XI1_I608_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I107_XP_MN1 (XI1_I608_I107_XP_n1 I1_I608_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I107_XP_MN0 (I1_I608_P11_8n I1_I608_P11_10 XI1_I608_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I109_XP_MN1 (XI1_I608_I109_XP_n1 I1_I608_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I109_XP_MN0 (I1_I608_P13_10n I1_I608_P13_12 XI1_I608_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I111_XP_MN1 (XI1_I608_I111_XP_n1 I1_I608_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I111_XP_MN0 (I1_I608_P15_12n I1_I608_P15_14 XI1_I608_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I113_XP_MN1 (XI1_I608_I113_XP_n1 I1_I608_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I113_XP_MN0 (I1_I608_P17_14n I1_I608_P17_16 XI1_I608_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I115_XP_MN1 (XI1_I608_I115_XP_n1 I1_I608_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I115_XP_MN0 (I1_I608_P19_16n I1_I608_P19_18 XI1_I608_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I119_XP_MN1 (XI1_I608_I119_XP_n1 I1_I608_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I119_XP_MN0 (I1_I608_P23_20n I1_I608_P23_22 XI1_I608_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I121_XP_MN1 (XI1_I608_I121_XP_n1 I1_I608_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I121_XP_MN0 (I1_I608_P25_22n I1_I608_P25_24 XI1_I608_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I123_XP_MN1 (XI1_I608_I123_XP_n1 I1_I608_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I123_XP_MN0 (I1_I608_P27_24n I1_I608_P27_26 XI1_I608_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I125_XP_MN1 (XI1_I608_I125_XP_n1 I1_I608_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I125_XP_MN0 (I1_I608_P29_26n I1_I608_P29_28 XI1_I608_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I29_MN1 (XI1_I608_I29_n1 I1_b1_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I29_MN0 (I1_I608_gn29 I1_p0_28 XI1_I608_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I125_XP_MN1 (XI1_I1482_I125_XP_n1 I1_I1482_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I125_XP_MN0 (I1_I1482_P29_26n I1_I1482_P29_28 XI1_I1482_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I180_XP_MN1 (XI1_I1482_I180_XP_n1 I1_I1482_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I180_XP_MN0 (I1_I1482_P29_14n I1_I1482_P29_22 XI1_I1482_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I178_XP_MN1 (XI1_I1482_I178_XP_n1 I1_I1482_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I178_XP_MN0 (I1_I1482_P27_12n I1_I1482_P27_20 XI1_I1482_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I176_XP_MN1 (XI1_I1482_I176_XP_n1 I1_I1482_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I176_XP_MN0 (I1_I1482_P25_10n I1_I1482_P25_18 XI1_I1482_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I106_XP_MN1 (XI1_I1482_I106_XP_n1 I1_I1482_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I106_XP_MN0 (I1_I1482_P10_7n I1_I1482_P10_9 XI1_I1482_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I104_XP_MN1 (XI1_I1482_I104_XP_n1 I1_I1482_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I104_XP_MN0 (I1_I1482_P8_5n I1_I1482_P8_7 XI1_I1482_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I102_XP_MN1 (XI1_I1482_I102_XP_n1 I1_I1482_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I102_XP_MN0 (I1_I1482_P6_3n I1_I1482_P6_5 XI1_I1482_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I100_XP_MN1 (XI1_I1482_I100_XP_n1 I1_I1482_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I100_XP_MN0 (I1_I1482_P4_1n I1_I1482_P4_3 XI1_I1482_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I9_MN1 (XI1_I1528_I9_n1 I1_b21_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I9_MN0 (I1_I1528_gn9 I1_p20_8 XI1_I1528_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I6_MN1 (XI1_I1528_I6_n1 I1_b21_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I6_MN0 (I1_I1528_gn6 I1_p20_5 XI1_I1528_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I0_MN1 (XI1_I1482_I0_n1 I1_b20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I0_MN0 (I1_I1482_gn0 I1_aa11 XI1_I1482_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I10_MN1 (XI1_I1114_I10_n1 I1_b12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I10_MN0 (I1_I1114_gn10 I1_p11_9 XI1_I1114_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I102_XP_MN1 (XI1_I1114_I102_XP_n1 I1_I1114_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I102_XP_MN0 (I1_I1114_P6_3n I1_I1114_P6_5 XI1_I1114_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I100_XP_MN1 (XI1_I1114_I100_XP_n1 I1_I1114_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I100_XP_MN0 (I1_I1114_P4_1n I1_I1114_P4_3 XI1_I1114_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I167_XP_MN1 (XI1_I1068_I167_XP_n1 I1_I1068_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I167_XP_MN0 (I1_I1068_P16_1n I1_I1068_P16_9 XI1_I1068_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I106_XP_MN1 (XI1_I1068_I106_XP_n1 I1_I1068_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I106_XP_MN0 (I1_I1068_P10_7n I1_I1068_P10_9 XI1_I1068_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I105_XP_MN1 (XI1_I1068_I105_XP_n1 I1_I1068_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I105_XP_MN0 (I1_I1068_P9_6n I1_I1068_P9_8 XI1_I1068_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I9_MN1 (XI1_I1068_I9_n1 I1_b11_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I9_MN0 (I1_I1068_gn9 I1_p10_8 XI1_I1068_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I10_MN1 (XI1_I1068_I10_n1 I1_b11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I10_MN0 (I1_I1068_gn10 I1_p10_9 XI1_I1068_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I12_MN1 (XI1_I1068_I12_n1 I1_b11_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I12_MN0 (I1_I1068_gn12 I1_p10_11 XI1_I1068_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I11_MN1 (XI1_I1068_I11_n1 I1_b11_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I11_MN0 (I1_I1068_gn11 I1_p10_10 XI1_I1068_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I13_MN1 (XI1_I1068_I13_n1 I1_b11_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I13_MN0 (I1_I1068_gn13 I1_p10_12 XI1_I1068_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I177_XP_MN1 (XI1_I1022_I177_XP_n1 I1_I1022_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I177_XP_MN0 (I1_I1022_P26_11n I1_I1022_P26_19 XI1_I1022_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I112_XP_MN1 (XI1_I1022_I112_XP_n1 I1_I1022_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I112_XP_MN0 (I1_I1022_P16_13n I1_I1022_P16_15 XI1_I1022_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I180_XP_MN1 (XI1_I1022_I180_XP_n1 I1_I1022_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I180_XP_MN0 (I1_I1022_P29_14n I1_I1022_P29_22 XI1_I1022_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I170_XP_MN1 (XI1_I1022_I170_XP_n1 I1_I1022_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I170_XP_MN0 (I1_I1022_P19_4n I1_I1022_P19_12 XI1_I1022_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I113_XP_MN1 (XI1_I1022_I113_XP_n1 I1_I1022_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I113_XP_MN0 (I1_I1022_P17_14n I1_I1022_P17_16 XI1_I1022_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I111_XP_MN1 (XI1_I1022_I111_XP_n1 I1_I1022_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I111_XP_MN0 (I1_I1022_P15_12n I1_I1022_P15_14 XI1_I1022_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I15_MN1 (XI1_I1022_I15_n1 I1_b10_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I15_MN0 (I1_I1022_gn15 I1_p9_14 XI1_I1022_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I12_MN1 (XI1_I1022_I12_n1 I1_b10_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I12_MN0 (I1_I1022_gn12 I1_p9_11 XI1_I1022_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I13_MN1 (XI1_I1022_I13_n1 I1_b10_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I13_MN0 (I1_I1022_gn13 I1_p9_12 XI1_I1022_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I10_MN1 (XI1_I1022_I10_n1 I1_b10_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I10_MN0 (I1_I1022_gn10 I1_p9_9 XI1_I1022_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I11_MN1 (XI1_I1022_I11_n1 I1_b10_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I11_MN0 (I1_I1022_gn11 I1_p9_10 XI1_I1022_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I1_MN1 (XI1_I976_I1_n1 I1_b9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I1_MN0 (I1_I976_gn1 I1_p8_0 XI1_I976_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I6_MN1 (XI1_I608_I6_n1 I1_b1_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I6_MN0 (I1_I608_gn6 I1_p0_5 XI1_I608_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I7_MN1 (XI1_I608_I7_n1 I1_b1_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I7_MN0 (I1_I608_gn7 I1_p0_6 XI1_I608_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I9_MN1 (XI1_I608_I9_n1 I1_b1_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I9_MN0 (I1_I608_gn9 I1_p0_8 XI1_I608_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I10_MN1 (XI1_I608_I10_n1 I1_b1_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I10_MN0 (I1_I608_gn10 I1_p0_9 XI1_I608_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I117_XP_MN1 (XI1_I608_I117_XP_n1 I1_I608_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I117_XP_MN0 (I1_I608_P21_18n I1_I608_P21_20 XI1_I608_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I24_MN1 (XI1_I608_I24_n1 I1_b1_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I24_MN0 (I1_I608_gn24 I1_p0_23 XI1_I608_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I27_MN1 (XI1_I608_I27_n1 I1_b1_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I27_MN0 (I1_I608_gn27 I1_p0_26 XI1_I608_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I28_MN1 (XI1_I608_I28_n1 I1_b1_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I28_MN0 (I1_I608_gn28 I1_p0_27 XI1_I608_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I27_MN1 (XI1_I1482_I27_n1 I1_b20_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I27_MN0 (I1_I1482_gn27 I1_p19_26 XI1_I1482_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I26_MN1 (XI1_I1482_I26_n1 I1_b20_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I26_MN0 (I1_I1482_gn26 I1_p19_25 XI1_I1482_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I120_XP_MN1 (XI1_I1482_I120_XP_n1 I1_I1482_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I120_XP_MN0 (I1_I1482_P24_21n I1_I1482_P24_23 XI1_I1482_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I118_XP_MN1 (XI1_I1482_I118_XP_n1 I1_I1482_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I118_XP_MN0 (I1_I1482_P22_19n I1_I1482_P22_21 XI1_I1482_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I116_XP_MN1 (XI1_I1482_I116_XP_n1 I1_I1482_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I116_XP_MN0 (I1_I1482_P20_17n I1_I1482_P20_19 XI1_I1482_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I114_XP_MN1 (XI1_I1482_I114_XP_n1 I1_I1482_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I114_XP_MN0 (I1_I1482_P18_15n I1_I1482_P18_17 XI1_I1482_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I175_XP_MN1 (XI1_I1482_I175_XP_n1 I1_I1482_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I175_XP_MN0 (I1_I1482_P24_9n I1_I1482_P24_17 XI1_I1482_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I112_XP_MN1 (XI1_I1482_I112_XP_n1 I1_I1482_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I112_XP_MN0 (I1_I1482_P16_13n I1_I1482_P16_15 XI1_I1482_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I110_XP_MN1 (XI1_I1482_I110_XP_n1 I1_I1482_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I110_XP_MN0 (I1_I1482_P14_11n I1_I1482_P14_13 XI1_I1482_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I108_XP_MN1 (XI1_I1482_I108_XP_n1 I1_I1482_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I108_XP_MN0 (I1_I1482_P12_9n I1_I1482_P12_11 XI1_I1482_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I167_XP_MN1 (XI1_I1482_I167_XP_n1 I1_I1482_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I167_XP_MN0 (I1_I1482_P16_1n I1_I1482_P16_9 XI1_I1482_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I13_MN1 (XI1_I1528_I13_n1 I1_b21_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I13_MN0 (I1_I1528_gn13 I1_p20_12 XI1_I1528_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I10_MN1 (XI1_I1528_I10_n1 I1_b21_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I10_MN0 (I1_I1528_gn10 I1_p20_9 XI1_I1528_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I8_MN1 (XI1_I1528_I8_n1 I1_b21_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I8_MN0 (I1_I1528_gn8 I1_p20_7 XI1_I1528_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I5_MN1 (XI1_I1528_I5_n1 I1_b21_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I5_MN0 (I1_I1528_gn5 I1_p20_4 XI1_I1528_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I4_MN1 (XI1_I1528_I4_n1 I1_b21_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I4_MN0 (I1_I1528_gn4 I1_p20_3 XI1_I1528_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I9_MN1 (XI1_I1114_I9_n1 I1_b12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I9_MN0 (I1_I1114_gn9 I1_p11_8 XI1_I1114_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I8_MN1 (XI1_I1114_I8_n1 I1_b12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I8_MN0 (I1_I1114_gn8 I1_p11_7 XI1_I1114_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I7_MN1 (XI1_I1114_I7_n1 I1_b12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I7_MN0 (I1_I1114_gn7 I1_p11_6 XI1_I1114_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I2_MN1 (XI1_I1114_I2_n1 I1_b12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I2_MN0 (I1_I1114_gn2 I1_p11_1 XI1_I1114_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I1_MN1 (XI1_I1114_I1_n1 I1_b12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I1_MN0 (I1_I1114_gn1 I1_p11_0 XI1_I1114_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I104_XP_MN1 (XI1_I1068_I104_XP_n1 I1_I1068_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I104_XP_MN0 (I1_I1068_P8_5n I1_I1068_P8_7 XI1_I1068_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I101_XP_MN1 (XI1_I1068_I101_XP_n1 I1_I1068_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I101_XP_MN0 (I1_I1068_P5_2n I1_I1068_P5_4 XI1_I1068_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I103_XP_MN1 (XI1_I1068_I103_XP_n1 I1_I1068_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I103_XP_MN0 (I1_I1068_P7_4n I1_I1068_P7_6 XI1_I1068_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I0_MN1 (XI1_I1114_I0_n1 I1_b12_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I0_MN0 (I1_I1114_gn0 I1_aa19 XI1_I1114_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I169_XP_MN1 (XI1_I1022_I169_XP_n1 I1_I1022_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I169_XP_MN0 (I1_I1022_P18_3n I1_I1022_P18_11 XI1_I1022_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I175_XP_MN1 (XI1_I1022_I175_XP_n1 I1_I1022_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I175_XP_MN0 (I1_I1022_P24_9n I1_I1022_P24_17 XI1_I1022_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I110_XP_MN1 (XI1_I1022_I110_XP_n1 I1_I1022_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I110_XP_MN0 (I1_I1022_P14_11n I1_I1022_P14_13 XI1_I1022_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I108_XP_MN1 (XI1_I1022_I108_XP_n1 I1_I1022_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I108_XP_MN0 (I1_I1022_P12_9n I1_I1022_P12_11 XI1_I1022_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I172_XP_MN1 (XI1_I1022_I172_XP_n1 I1_I1022_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I172_XP_MN0 (I1_I1022_P21_6n I1_I1022_P21_14 XI1_I1022_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I176_XP_MN1 (XI1_I1022_I176_XP_n1 I1_I1022_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I176_XP_MN0 (I1_I1022_P25_10n I1_I1022_P25_18 XI1_I1022_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I109_XP_MN1 (XI1_I1022_I109_XP_n1 I1_I1022_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I109_XP_MN0 (I1_I1022_P13_10n I1_I1022_P13_12 XI1_I1022_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I107_XP_MN1 (XI1_I1022_I107_XP_n1 I1_I1022_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I107_XP_MN0 (I1_I1022_P11_8n I1_I1022_P11_10 XI1_I1022_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I8_MN1 (XI1_I1022_I8_n1 I1_b10_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I8_MN0 (I1_I1022_gn8 I1_p9_7 XI1_I1022_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I9_MN1 (XI1_I1022_I9_n1 I1_b10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I9_MN0 (I1_I1022_gn9 I1_p9_8 XI1_I1022_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I5_MN1 (XI1_I1022_I5_n1 I1_b10_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I5_MN0 (I1_I1022_gn5 I1_p9_4 XI1_I1022_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I1_MN1 (XI1_I562_I1_n1 I1_b0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I1_MN0 (I1_I562_gn1 VSS XI1_I562_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I8_MN1 (XI1_I608_I8_n1 I1_b1_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I8_MN0 (I1_I608_gn8 I1_p0_7 XI1_I608_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I11_MN1 (XI1_I608_I11_n1 I1_b1_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I11_MN0 (I1_I608_gn11 I1_p0_10 XI1_I608_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I12_MN1 (XI1_I608_I12_n1 I1_b1_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I12_MN0 (I1_I608_gn12 I1_p0_11 XI1_I608_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I13_MN1 (XI1_I608_I13_n1 I1_b1_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I13_MN0 (I1_I608_gn13 I1_p0_12 XI1_I608_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I14_MN1 (XI1_I608_I14_n1 I1_b1_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I14_MN0 (I1_I608_gn14 I1_p0_13 XI1_I608_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I15_MN1 (XI1_I608_I15_n1 I1_b1_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I15_MN0 (I1_I608_gn15 I1_p0_14 XI1_I608_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I16_MN1 (XI1_I608_I16_n1 I1_b1_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I16_MN0 (I1_I608_gn16 I1_p0_15 XI1_I608_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I19_MN1 (XI1_I608_I19_n1 I1_b1_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I19_MN0 (I1_I608_gn19 I1_p0_18 XI1_I608_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I20_MN1 (XI1_I608_I20_n1 I1_b1_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I20_MN0 (I1_I608_gn20 I1_p0_19 XI1_I608_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I21_MN1 (XI1_I608_I21_n1 I1_b1_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I21_MN0 (I1_I608_gn21 I1_p0_20 XI1_I608_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I22_MN1 (XI1_I608_I22_n1 I1_b1_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I22_MN0 (I1_I608_gn22 I1_p0_21 XI1_I608_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I23_MN1 (XI1_I608_I23_n1 I1_b1_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I23_MN0 (I1_I608_gn23 I1_p0_22 XI1_I608_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I25_MN1 (XI1_I608_I25_n1 I1_b1_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I25_MN0 (I1_I608_gn25 I1_p0_24 XI1_I608_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I26_MN1 (XI1_I608_I26_n1 I1_b1_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I26_MN0 (I1_I608_gn26 I1_p0_25 XI1_I608_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I28_MN1 (XI1_I1482_I28_n1 I1_b20_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I28_MN0 (I1_I1482_gn28 I1_p19_27 XI1_I1482_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I127_XP_MN1 (XI1_I1482_I127_XP_n1 I1_I1482_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I127_XP_MN0 (I1_I1482_P31_28n I1_I1482_P31_30 XI1_I1482_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I124_XP_MN1 (XI1_I1482_I124_XP_n1 I1_I1482_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I124_XP_MN0 (I1_I1482_P28_25n I1_I1482_P28_27 XI1_I1482_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I122_XP_MN1 (XI1_I1482_I122_XP_n1 I1_I1482_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I122_XP_MN0 (I1_I1482_P26_23n I1_I1482_P26_25 XI1_I1482_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I179_XP_MN1 (XI1_I1482_I179_XP_n1 I1_I1482_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I179_XP_MN0 (I1_I1482_P28_13n I1_I1482_P28_21 XI1_I1482_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I171_XP_MN1 (XI1_I1482_I171_XP_n1 I1_I1482_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I171_XP_MN0 (I1_I1482_P20_5n I1_I1482_P20_13 XI1_I1482_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I169_XP_MN1 (XI1_I1482_I169_XP_n1 I1_I1482_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I169_XP_MN0 (I1_I1482_P18_3n I1_I1482_P18_11 XI1_I1482_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I17_MN1 (XI1_I1528_I17_n1 I1_b21_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I17_MN0 (I1_I1528_gn17 I1_p20_16 XI1_I1528_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I15_MN1 (XI1_I1528_I15_n1 I1_b21_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I15_MN0 (I1_I1528_gn15 I1_p20_14 XI1_I1528_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I14_MN1 (XI1_I1528_I14_n1 I1_b21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I14_MN0 (I1_I1528_gn14 I1_p20_13 XI1_I1528_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I12_MN1 (XI1_I1528_I12_n1 I1_b21_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I12_MN0 (I1_I1528_gn12 I1_p20_11 XI1_I1528_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I11_MN1 (XI1_I1528_I11_n1 I1_b21_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I11_MN0 (I1_I1528_gn11 I1_p20_10 XI1_I1528_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I6_MN1 (XI1_I1114_I6_n1 I1_b12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I6_MN0 (I1_I1114_gn6 I1_p11_5 XI1_I1114_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I5_MN1 (XI1_I1114_I5_n1 I1_b12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I5_MN0 (I1_I1114_gn5 I1_p11_4 XI1_I1114_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I100_XP_MN1 (XI1_I1068_I100_XP_n1 I1_I1068_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I100_XP_MN0 (I1_I1068_P4_1n I1_I1068_P4_3 XI1_I1068_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I102_XP_MN1 (XI1_I1068_I102_XP_n1 I1_I1068_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I102_XP_MN0 (I1_I1068_P6_3n I1_I1068_P6_5 XI1_I1068_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I8_MN1 (XI1_I1068_I8_n1 I1_b11_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I8_MN0 (I1_I1068_gn8 I1_p10_7 XI1_I1068_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I6_MN1 (XI1_I1068_I6_n1 I1_b11_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I6_MN0 (I1_I1068_gn6 I1_p10_5 XI1_I1068_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I7_MN1 (XI1_I1068_I7_n1 I1_b11_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I7_MN0 (I1_I1068_gn7 I1_p10_6 XI1_I1068_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I171_XP_MN1 (XI1_I1022_I171_XP_n1 I1_I1022_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I171_XP_MN0 (I1_I1022_P20_5n I1_I1022_P20_13 XI1_I1022_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I104_XP_MN1 (XI1_I1022_I104_XP_n1 I1_I1022_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I104_XP_MN0 (I1_I1022_P8_5n I1_I1022_P8_7 XI1_I1022_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I106_XP_MN1 (XI1_I1022_I106_XP_n1 I1_I1022_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I106_XP_MN0 (I1_I1022_P10_7n I1_I1022_P10_9 XI1_I1022_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I168_XP_MN1 (XI1_I1022_I168_XP_n1 I1_I1022_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I168_XP_MN0 (I1_I1022_P17_2n I1_I1022_P17_10 XI1_I1022_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I105_XP_MN1 (XI1_I1022_I105_XP_n1 I1_I1022_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I105_XP_MN0 (I1_I1022_P9_6n I1_I1022_P9_8 XI1_I1022_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I103_XP_MN1 (XI1_I1022_I103_XP_n1 I1_I1022_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I103_XP_MN0 (I1_I1022_P7_4n I1_I1022_P7_6 XI1_I1022_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I6_MN1 (XI1_I1022_I6_n1 I1_b10_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I6_MN0 (I1_I1022_gn6 I1_p9_5 XI1_I1022_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I7_MN1 (XI1_I1022_I7_n1 I1_b10_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I7_MN0 (I1_I1022_gn7 I1_p9_6 XI1_I1022_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I4_MN1 (XI1_I1022_I4_n1 I1_b10_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I4_MN0 (I1_I1022_gn4 I1_p9_3 XI1_I1022_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I3_MN1 (XI1_I1022_I3_n1 I1_b10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I3_MN0 (I1_I1022_gn3 I1_p9_2 XI1_I1022_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I17_MN1 (XI1_I608_I17_n1 I1_b1_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I17_MN0 (I1_I608_gn17 I1_p0_16 XI1_I608_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I18_MN1 (XI1_I608_I18_n1 I1_b1_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I18_MN0 (I1_I608_gn18 I1_p0_17 XI1_I608_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I29_MN1 (XI1_I1482_I29_n1 I1_b20_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I29_MN0 (I1_I1482_gn29 I1_p19_28 XI1_I1482_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I126_XP_MN1 (XI1_I1482_I126_XP_n1 I1_I1482_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I126_XP_MN0 (I1_I1482_P30_27n I1_I1482_P30_29 XI1_I1482_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I181_XP_MN1 (XI1_I1482_I181_XP_n1 I1_I1482_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I181_XP_MN0 (I1_I1482_P30_15n I1_I1482_P30_23 XI1_I1482_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I173_XP_MN1 (XI1_I1482_I173_XP_n1 I1_I1482_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I173_XP_MN0 (I1_I1482_P22_7n I1_I1482_P22_15 XI1_I1482_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I177_XP_MN1 (XI1_I1482_I177_XP_n1 I1_I1482_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I177_XP_MN0 (I1_I1482_P26_11n I1_I1482_P26_19 XI1_I1482_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I20_MN1 (XI1_I1528_I20_n1 I1_b21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I20_MN0 (I1_I1528_gn20 I1_p20_19 XI1_I1528_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I18_MN1 (XI1_I1528_I18_n1 I1_b21_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I18_MN0 (I1_I1528_gn18 I1_p20_17 XI1_I1528_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I16_MN1 (XI1_I1528_I16_n1 I1_b21_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I16_MN0 (I1_I1528_gn16 I1_p20_15 XI1_I1528_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I112_XP_MN1 (XI1_I1528_I112_XP_n1 I1_I1528_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I112_XP_MN0 (I1_I1528_P16_13n I1_I1528_P16_15 XI1_I1528_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I110_XP_MN1 (XI1_I1528_I110_XP_n1 I1_I1528_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I110_XP_MN0 (I1_I1528_P14_11n I1_I1528_P14_13 XI1_I1528_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I108_XP_MN1 (XI1_I1528_I108_XP_n1 I1_I1528_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I108_XP_MN0 (I1_I1528_P12_9n I1_I1528_P12_11 XI1_I1528_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I106_XP_MN1 (XI1_I1528_I106_XP_n1 I1_I1528_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I106_XP_MN0 (I1_I1528_P10_7n I1_I1528_P10_9 XI1_I1528_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I104_XP_MN1 (XI1_I1528_I104_XP_n1 I1_I1528_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I104_XP_MN0 (I1_I1528_P8_5n I1_I1528_P8_7 XI1_I1528_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I102_XP_MN1 (XI1_I1528_I102_XP_n1 I1_I1528_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I102_XP_MN0 (I1_I1528_P6_3n I1_I1528_P6_5 XI1_I1528_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I3_MN1 (XI1_I1528_I3_n1 I1_b21_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I3_MN0 (I1_I1528_gn3 I1_p20_2 XI1_I1528_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I2_MN1 (XI1_I1528_I2_n1 I1_b21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I2_MN0 (I1_I1528_gn2 I1_p20_1 XI1_I1528_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I4_MN1 (XI1_I1114_I4_n1 I1_b12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I4_MN0 (I1_I1114_gn4 I1_p11_3 XI1_I1114_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I3_MN1 (XI1_I1114_I3_n1 I1_b12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I3_MN0 (I1_I1114_gn3 I1_p11_2 XI1_I1114_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I4_MN1 (XI1_I1068_I4_n1 I1_b11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I4_MN0 (I1_I1068_gn4 I1_p10_3 XI1_I1068_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I5_MN1 (XI1_I1068_I5_n1 I1_b11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I5_MN0 (I1_I1068_gn5 I1_p10_4 XI1_I1068_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I0_MN1 (XI1_I1068_I0_n1 I1_b11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I0_MN0 (I1_I1068_gn0 I1_aa20 XI1_I1068_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I100_XP_MN1 (XI1_I1022_I100_XP_n1 I1_I1022_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I100_XP_MN0 (I1_I1022_P4_1n I1_I1022_P4_3 XI1_I1022_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I102_XP_MN1 (XI1_I1022_I102_XP_n1 I1_I1022_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I102_XP_MN0 (I1_I1022_P6_3n I1_I1022_P6_5 XI1_I1022_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I101_XP_MN1 (XI1_I1022_I101_XP_n1 I1_I1022_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I101_XP_MN0 (I1_I1022_P5_2n I1_I1022_P5_4 XI1_I1022_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I1_MN1 (XI1_I1022_I1_n1 I1_b10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I1_MN0 (I1_I1022_gn1 I1_p9_0 XI1_I1022_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I2_MN1 (XI1_I1022_I2_n1 I1_b10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I2_MN0 (I1_I1022_gn2 I1_p9_1 XI1_I1022_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I0_MN1 (XI1_I976_I0_n1 I1_b9_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I0_MN0 (I1_I976_gn0 I1_aa22 XI1_I976_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I0_MN1 (XI1_I562_I0_n1 I1_b0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I0_MN0 (I1_I562_gn0 I1_aa31 XI1_I562_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I2_MN1 (XI1_I562_I2_n1 I1_b0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I2_MN0 (I1_I562_gn2 VSS XI1_I562_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I100_XP_MN1 (XI1_I562_I100_XP_n1 I1_I562_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I100_XP_MN0 (I1_I562_P4_1n I1_I562_P4_3 XI1_I562_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I9_MN1 (XI1_I562_I9_n1 I1_b0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I9_MN0 (I1_I562_gn9 VSS XI1_I562_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I11_MN1 (XI1_I562_I11_n1 I1_b0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I11_MN0 (I1_I562_gn11 VSS XI1_I562_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I13_MN1 (XI1_I562_I13_n1 I1_b0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I13_MN0 (I1_I562_gn13 VSS XI1_I562_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I29_MN1 (XI1_I562_I29_n1 I1_b0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I29_MN0 (I1_I562_gn29 VSS XI1_I562_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I30_MN1 (XI1_I1482_I30_n1 I1_b20_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I30_MN0 (I1_I1482_gn30 I1_p19_29 XI1_I1482_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I31_MN1 (XI1_I1482_I31_n1 I1_b20_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I31_MN0 (I1_I1482_gn31 I1_p19_30 XI1_I1482_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I25_MN1 (XI1_I1528_I25_n1 I1_b21_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I25_MN0 (I1_I1528_gn25 I1_p20_24 XI1_I1528_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I24_MN1 (XI1_I1528_I24_n1 I1_b21_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I24_MN0 (I1_I1528_gn24 I1_p20_23 XI1_I1528_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I23_MN1 (XI1_I1528_I23_n1 I1_b21_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I23_MN0 (I1_I1528_gn23 I1_p20_22 XI1_I1528_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I22_MN1 (XI1_I1528_I22_n1 I1_b21_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I22_MN0 (I1_I1528_gn22 I1_p20_21 XI1_I1528_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I21_MN1 (XI1_I1528_I21_n1 I1_b21_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I21_MN0 (I1_I1528_gn21 I1_p20_20 XI1_I1528_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I19_MN1 (XI1_I1528_I19_n1 I1_b21_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I19_MN0 (I1_I1528_gn19 I1_p20_18 XI1_I1528_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I116_XP_MN1 (XI1_I1528_I116_XP_n1 I1_I1528_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I116_XP_MN0 (I1_I1528_P20_17n I1_I1528_P20_19 XI1_I1528_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I114_XP_MN1 (XI1_I1528_I114_XP_n1 I1_I1528_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I114_XP_MN0 (I1_I1528_P18_15n I1_I1528_P18_17 XI1_I1528_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I175_XP_MN1 (XI1_I1528_I175_XP_n1 I1_I1528_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I175_XP_MN0 (I1_I1528_P24_9n I1_I1528_P24_17 XI1_I1528_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I169_XP_MN1 (XI1_I1528_I169_XP_n1 I1_I1528_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I169_XP_MN0 (I1_I1528_P18_3n I1_I1528_P18_11 XI1_I1528_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I167_XP_MN1 (XI1_I1528_I167_XP_n1 I1_I1528_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I167_XP_MN0 (I1_I1528_P16_1n I1_I1528_P16_9 XI1_I1528_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I100_XP_MN1 (XI1_I1528_I100_XP_n1 I1_I1528_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I100_XP_MN0 (I1_I1528_P4_1n I1_I1528_P4_3 XI1_I1528_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I1_MN1 (XI1_I1528_I1_n1 I1_b21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I1_MN0 (I1_I1528_gn1 I1_p20_0 XI1_I1528_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I1_MN1 (XI1_I1068_I1_n1 I1_b11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I1_MN0 (I1_I1068_gn1 I1_p10_0 XI1_I1068_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I2_MN1 (XI1_I1068_I2_n1 I1_b11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I2_MN0 (I1_I1068_gn2 I1_p10_1 XI1_I1068_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I3_MN1 (XI1_I1068_I3_n1 I1_b11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I3_MN0 (I1_I1068_gn3 I1_p10_2 XI1_I1068_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I167_XP_MN1 (XI1_I1022_I167_XP_n1 I1_I1022_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I167_XP_MN0 (I1_I1022_P16_1n I1_I1022_P16_9 XI1_I1022_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I0_MN1 (XI1_I1022_I0_n1 I1_b10_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I0_MN0 (I1_I1022_gn0 I1_aa21 XI1_I1022_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I3_MN1 (XI1_I562_I3_n1 I1_b0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I3_MN0 (I1_I562_gn3 VSS XI1_I562_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I102_XP_MN1 (XI1_I562_I102_XP_n1 I1_I562_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I102_XP_MN0 (I1_I562_P6_3n I1_I562_P6_5 XI1_I562_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I104_XP_MN1 (XI1_I562_I104_XP_n1 I1_I562_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I104_XP_MN0 (I1_I562_P8_5n I1_I562_P8_7 XI1_I562_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I167_XP_MN1 (XI1_I562_I167_XP_n1 I1_I562_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I167_XP_MN0 (I1_I562_P16_1n I1_I562_P16_9 XI1_I562_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I169_XP_MN1 (XI1_I562_I169_XP_n1 I1_I562_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I169_XP_MN0 (I1_I562_P18_3n I1_I562_P18_11 XI1_I562_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I175_XP_MN1 (XI1_I562_I175_XP_n1 I1_I562_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I175_XP_MN0 (I1_I562_P24_9n I1_I562_P24_17 XI1_I562_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I171_XP_MN1 (XI1_I562_I171_XP_n1 I1_I562_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I171_XP_MN0 (I1_I562_P20_5n I1_I562_P20_13 XI1_I562_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I17_MN1 (XI1_I562_I17_n1 I1_b0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I17_MN0 (I1_I562_gn17 VSS XI1_I562_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I177_XP_MN1 (XI1_I562_I177_XP_n1 I1_I562_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I177_XP_MN0 (I1_I562_P26_11n I1_I562_P26_19 XI1_I562_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I173_XP_MN1 (XI1_I562_I173_XP_n1 I1_I562_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I173_XP_MN0 (I1_I562_P22_7n I1_I562_P22_15 XI1_I562_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I19_MN1 (XI1_I562_I19_n1 I1_b0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I19_MN0 (I1_I562_gn19 VSS XI1_I562_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I21_MN1 (XI1_I562_I21_n1 I1_b0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I21_MN0 (I1_I562_gn21 VSS XI1_I562_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I31_MN1 (XI1_I562_I31_n1 I1_b0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I31_MN0 (I1_I562_gn31 VSS XI1_I562_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I30_MN1 (XI1_I1528_I30_n1 I1_b21_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I30_MN0 (I1_I1528_gn30 I1_p20_29 XI1_I1528_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I29_MN1 (XI1_I1528_I29_n1 I1_b21_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I29_MN0 (I1_I1528_gn29 I1_p20_28 XI1_I1528_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I120_XP_MN1 (XI1_I1528_I120_XP_n1 I1_I1528_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I120_XP_MN0 (I1_I1528_P24_21n I1_I1528_P24_23 XI1_I1528_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I118_XP_MN1 (XI1_I1528_I118_XP_n1 I1_I1528_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I118_XP_MN0 (I1_I1528_P22_19n I1_I1528_P22_21 XI1_I1528_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I173_XP_MN1 (XI1_I1528_I173_XP_n1 I1_I1528_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I173_XP_MN0 (I1_I1528_P22_7n I1_I1528_P22_15 XI1_I1528_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I179_XP_MN1 (XI1_I1528_I179_XP_n1 I1_I1528_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I179_XP_MN0 (I1_I1528_P28_13n I1_I1528_P28_21 XI1_I1528_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I177_XP_MN1 (XI1_I1528_I177_XP_n1 I1_I1528_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I177_XP_MN0 (I1_I1528_P26_11n I1_I1528_P26_19 XI1_I1528_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I171_XP_MN1 (XI1_I1528_I171_XP_n1 I1_I1528_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I171_XP_MN0 (I1_I1528_P20_5n I1_I1528_P20_13 XI1_I1528_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I11_MN1 (XI1_I1574_I11_n1 I1_b22_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I11_MN0 (I1_I1574_gn11 I1_p21_10 XI1_I1574_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I0_MN1 (XI1_I1528_I0_n1 I1_b21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I0_MN0 (I1_I1528_gn0 I1_aa10 XI1_I1528_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I114_MN1 (XI2_I2_I114_n1 B_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I114_MN0 (I2_I2_nand19 A_19 XI2_I2_I114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I317_MN1 (XI2_I3_I317_n1 I2_I3_n19_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I317_MN0 (I2_I3_o19_1 I2_I3_n19_2 XI2_I3_I317_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I313_MN1 (XI2_I3_I313_n1 I2_NOT_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I313_MN0 (I2_I3_n19_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I313_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I325_MN1 (XI2_I3_I325_n1 I2_NOT_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I325_MN0 (I2_I3_n20_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I325_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I329_MN1 (XI2_I3_I329_n1 I2_I3_n20_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I329_MN0 (I2_I3_o20_1 I2_I3_n20_2 XI2_I3_I329_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I4_MN1 (XI1_I562_I4_n1 I1_b0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I4_MN0 (I1_I562_gn4 VSS XI1_I562_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I5_MN1 (XI1_I562_I5_n1 I1_b0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I5_MN0 (I1_I562_gn5 VSS XI1_I562_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I6_MN1 (XI1_I562_I6_n1 I1_b0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I6_MN0 (I1_I562_gn6 VSS XI1_I562_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I7_MN1 (XI1_I562_I7_n1 I1_b0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I7_MN0 (I1_I562_gn7 VSS XI1_I562_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I106_XP_MN1 (XI1_I562_I106_XP_n1 I1_I562_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I106_XP_MN0 (I1_I562_P10_7n I1_I562_P10_9 XI1_I562_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I108_XP_MN1 (XI1_I562_I108_XP_n1 I1_I562_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I108_XP_MN0 (I1_I562_P12_9n I1_I562_P12_11 XI1_I562_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I110_XP_MN1 (XI1_I562_I110_XP_n1 I1_I562_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I110_XP_MN0 (I1_I562_P14_11n I1_I562_P14_13 XI1_I562_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I112_XP_MN1 (XI1_I562_I112_XP_n1 I1_I562_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I112_XP_MN0 (I1_I562_P16_13n I1_I562_P16_15 XI1_I562_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I179_XP_MN1 (XI1_I562_I179_XP_n1 I1_I562_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I179_XP_MN0 (I1_I562_P28_13n I1_I562_P28_21 XI1_I562_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I181_XP_MN1 (XI1_I562_I181_XP_n1 I1_I562_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I181_XP_MN0 (I1_I562_P30_15n I1_I562_P30_23 XI1_I562_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I124_XP_MN1 (XI1_I562_I124_XP_n1 I1_I562_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I124_XP_MN0 (I1_I562_P28_25n I1_I562_P28_27 XI1_I562_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I126_XP_MN1 (XI1_I562_I126_XP_n1 I1_I562_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I126_XP_MN0 (I1_I562_P30_27n I1_I562_P30_29 XI1_I562_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I30_MN1 (XI1_I562_I30_n1 I1_b0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I30_MN0 (I1_I562_gn30 VSS XI1_I562_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I31_MN1 (XI1_I1528_I31_n1 I1_b21_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I31_MN0 (I1_I1528_gn31 I1_p20_30 XI1_I1528_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I28_MN1 (XI1_I1528_I28_n1 I1_b21_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I28_MN0 (I1_I1528_gn28 I1_p20_27 XI1_I1528_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I27_MN1 (XI1_I1528_I27_n1 I1_b21_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I27_MN0 (I1_I1528_gn27 I1_p20_26 XI1_I1528_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I26_MN1 (XI1_I1528_I26_n1 I1_b21_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I26_MN0 (I1_I1528_gn26 I1_p20_25 XI1_I1528_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I126_XP_MN1 (XI1_I1528_I126_XP_n1 I1_I1528_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I126_XP_MN0 (I1_I1528_P30_27n I1_I1528_P30_29 XI1_I1528_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I124_XP_MN1 (XI1_I1528_I124_XP_n1 I1_I1528_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I124_XP_MN0 (I1_I1528_P28_25n I1_I1528_P28_27 XI1_I1528_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I122_XP_MN1 (XI1_I1528_I122_XP_n1 I1_I1528_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I122_XP_MN0 (I1_I1528_P26_23n I1_I1528_P26_25 XI1_I1528_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I181_XP_MN1 (XI1_I1528_I181_XP_n1 I1_I1528_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I181_XP_MN0 (I1_I1528_P30_15n I1_I1528_P30_23 XI1_I1528_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I105_XP_MN1 (XI1_I1528_I105_XP_n1 I1_I1528_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I105_XP_MN0 (I1_I1528_P9_6n I1_I1528_P9_8 XI1_I1528_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I103_XP_MN1 (XI1_I1528_I103_XP_n1 I1_I1528_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I103_XP_MN0 (I1_I1528_P7_4n I1_I1528_P7_6 XI1_I1528_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I101_XP_MN1 (XI1_I1528_I101_XP_n1 I1_I1528_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I101_XP_MN0 (I1_I1528_P5_2n I1_I1528_P5_4 XI1_I1528_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I12_MN1 (XI1_I1574_I12_n1 I1_b22_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I12_MN0 (I1_I1574_gn12 I1_p21_11 XI1_I1574_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I10_MN1 (XI1_I1574_I10_n1 I1_b22_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I10_MN0 (I1_I1574_gn10 I1_p21_9 XI1_I1574_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I9_MN1 (XI1_I1574_I9_n1 I1_b22_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I9_MN0 (I1_I1574_gn9 I1_p21_8 XI1_I1574_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I8_MN1 (XI1_I1574_I8_n1 I1_b22_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I8_MN0 (I1_I1574_gn8 I1_p21_7 XI1_I1574_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I7_MN1 (XI1_I1574_I7_n1 I1_b22_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I7_MN0 (I1_I1574_gn7 I1_p21_6 XI1_I1574_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I339_MN1 (XI2_I3_I339_n1 DIVQ_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I339_MN0 (I2_I3_n21_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I339_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I327_MN1 (XI2_I3_I327_n1 DIVQ_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I327_MN0 (I2_I3_n20_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I327_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I315_MN1 (XI2_I3_I315_n1 DIVQ_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I315_MN0 (I2_I3_n19_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I315_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I363_MN1 (XI2_I3_I363_n1 DIVQ_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I363_MN0 (I2_I3_n23_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I126_MN1 (XI2_I2_I126_n1 B_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I126_MN0 (I2_I2_nand21 A_21 XI2_I2_I126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I311_MN1 (XI2_I3_I311_n1 I2_OR_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I311_MN0 (I2_I3_n19_1 I2_I3_SEL_OR_b3_3 XI2_I3_I311_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I321_MN1 (XI2_I3_I321_n1 I2_I3_q19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I321_MN0 (Y_19 I2_I3_q19_1 XI2_I3_I321_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I312_MN1 (XI2_I3_I312_n1 I2_XOR_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I312_MN0 (I2_I3_n19_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I312_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I300_MN1 (XI2_I3_I300_n1 I2_XOR_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I300_MN0 (I2_I3_n18_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I300_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I305_MN1 (XI2_I3_I305_n1 I2_I3_n18_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I305_MN0 (I2_I3_o18_1 I2_I3_n18_2 XI2_I3_I305_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I298_MN1 (XI2_I3_I298_n1 I2_AND_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I298_MN0 (I2_I3_n18_0 I2_I3_SEL_AND_b3_3 XI2_I3_I298_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I333_MN1 (XI2_I3_I333_n1 I2_I3_q20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I333_MN0 (Y_20 I2_I3_q20_1 XI2_I3_I333_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I328_MN1 (XI2_I3_I328_n1 I2_I3_n20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I328_MN0 (I2_I3_o20_0 I2_I3_n20_0 XI2_I3_I328_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I322_MN1 (XI2_I3_I322_n1 I2_AND_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I322_MN0 (I2_I3_n20_0 I2_I3_SEL_AND_b3_3 XI2_I3_I322_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I324_MN1 (XI2_I3_I324_n1 I2_XOR_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I324_MN0 (I2_I3_n20_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I324_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I120_MN1 (XI2_I2_I120_n1 B_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I120_MN0 (I2_I2_nand20 A_20 XI2_I2_I120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I132_MN1 (XI2_I2_I132_n1 B_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I132_MN0 (I2_I2_nand22 A_22 XI2_I2_I132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I37_MN1 (XI2_I4_I37_n1 I2_I4_z0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I37_MN0 (I2_I4_z1_5 I2_I4_z0_10 XI2_I4_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I8_MN1 (XI1_I562_I8_n1 I1_b0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I8_MN0 (I1_I562_gn8 VSS XI1_I562_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I10_MN1 (XI1_I562_I10_n1 I1_b0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I10_MN0 (I1_I562_gn10 VSS XI1_I562_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I12_MN1 (XI1_I562_I12_n1 I1_b0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I12_MN0 (I1_I562_gn12 VSS XI1_I562_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I14_MN1 (XI1_I562_I14_n1 I1_b0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I14_MN0 (I1_I562_gn14 VSS XI1_I562_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I15_MN1 (XI1_I562_I15_n1 I1_b0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I15_MN0 (I1_I562_gn15 VSS XI1_I562_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I114_XP_MN1 (XI1_I562_I114_XP_n1 I1_I562_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I114_XP_MN0 (I1_I562_P18_15n I1_I562_P18_17 XI1_I562_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I116_XP_MN1 (XI1_I562_I116_XP_n1 I1_I562_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I116_XP_MN0 (I1_I562_P20_17n I1_I562_P20_19 XI1_I562_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I118_XP_MN1 (XI1_I562_I118_XP_n1 I1_I562_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I118_XP_MN0 (I1_I562_P22_19n I1_I562_P22_21 XI1_I562_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I20_MN1 (XI1_I562_I20_n1 I1_b0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I20_MN0 (I1_I562_gn20 VSS XI1_I562_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I120_XP_MN1 (XI1_I562_I120_XP_n1 I1_I562_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I120_XP_MN0 (I1_I562_P24_21n I1_I562_P24_23 XI1_I562_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I122_XP_MN1 (XI1_I562_I122_XP_n1 I1_I562_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I122_XP_MN0 (I1_I562_P26_23n I1_I562_P26_25 XI1_I562_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I27_MN1 (XI1_I562_I27_n1 I1_b0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I27_MN0 (I1_I562_gn27 VSS XI1_I562_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I28_MN1 (XI1_I562_I28_n1 I1_b0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I28_MN0 (I1_I562_gn28 VSS XI1_I562_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I174_XP_MN1 (XI1_I1712_I174_XP_n1 I1_I1712_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I174_XP_MN0 (I1_I1712_P23_8n I1_I1712_P23_16 XI1_I1712_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I127_XP_MN1 (XI1_I1528_I127_XP_n1 I1_I1528_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I127_XP_MN0 (I1_I1528_P31_28n I1_I1528_P31_30 XI1_I1528_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I125_XP_MN1 (XI1_I1528_I125_XP_n1 I1_I1528_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I125_XP_MN0 (I1_I1528_P29_26n I1_I1528_P29_28 XI1_I1528_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I123_XP_MN1 (XI1_I1528_I123_XP_n1 I1_I1528_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I123_XP_MN0 (I1_I1528_P27_24n I1_I1528_P27_26 XI1_I1528_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I121_XP_MN1 (XI1_I1528_I121_XP_n1 I1_I1528_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I121_XP_MN0 (I1_I1528_P25_22n I1_I1528_P25_24 XI1_I1528_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I119_XP_MN1 (XI1_I1528_I119_XP_n1 I1_I1528_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I119_XP_MN0 (I1_I1528_P23_20n I1_I1528_P23_22 XI1_I1528_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I117_XP_MN1 (XI1_I1528_I117_XP_n1 I1_I1528_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I117_XP_MN0 (I1_I1528_P21_18n I1_I1528_P21_20 XI1_I1528_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I115_XP_MN1 (XI1_I1528_I115_XP_n1 I1_I1528_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I115_XP_MN0 (I1_I1528_P19_16n I1_I1528_P19_18 XI1_I1528_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I113_XP_MN1 (XI1_I1528_I113_XP_n1 I1_I1528_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I113_XP_MN0 (I1_I1528_P17_14n I1_I1528_P17_16 XI1_I1528_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I111_XP_MN1 (XI1_I1528_I111_XP_n1 I1_I1528_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I111_XP_MN0 (I1_I1528_P15_12n I1_I1528_P15_14 XI1_I1528_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I109_XP_MN1 (XI1_I1528_I109_XP_n1 I1_I1528_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I109_XP_MN0 (I1_I1528_P13_10n I1_I1528_P13_12 XI1_I1528_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I107_XP_MN1 (XI1_I1528_I107_XP_n1 I1_I1528_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I107_XP_MN0 (I1_I1528_P11_8n I1_I1528_P11_10 XI1_I1528_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I178_XP_MN1 (XI1_I1574_I178_XP_n1 I1_I1574_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I178_XP_MN0 (I1_I1574_P27_12n I1_I1574_P27_20 XI1_I1574_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I170_XP_MN1 (XI1_I1574_I170_XP_n1 I1_I1574_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I170_XP_MN0 (I1_I1574_P19_4n I1_I1574_P19_12 XI1_I1574_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I111_XP_MN1 (XI1_I1574_I111_XP_n1 I1_I1574_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I111_XP_MN0 (I1_I1574_P15_12n I1_I1574_P15_14 XI1_I1574_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I109_XP_MN1 (XI1_I1574_I109_XP_n1 I1_I1574_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I109_XP_MN0 (I1_I1574_P13_10n I1_I1574_P13_12 XI1_I1574_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I107_XP_MN1 (XI1_I1574_I107_XP_n1 I1_I1574_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I107_XP_MN0 (I1_I1574_P11_8n I1_I1574_P11_10 XI1_I1574_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I6_MN1 (XI1_I1574_I6_n1 I1_b22_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I6_MN0 (I1_I1574_gn6 I1_p21_5 XI1_I1574_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I5_MN1 (XI1_I1574_I5_n1 I1_b22_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I5_MN0 (I1_I1574_gn5 I1_p21_4 XI1_I1574_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I128_MN1 (XI1_I128_n1 I1_B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I128_MN0 (I1_nbkn1 I1_B_31_b3_0 XI1_I128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I303_MN1 (XI2_I3_I303_n1 DIVQ_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I303_MN0 (I2_I3_n18_5 I2_I3_SEL_DIV_b3_3 XI2_I3_I303_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I306_MN1 (XI2_I3_I306_n1 I2_I3_n18_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I306_MN0 (I2_I3_o18_2 I2_I3_n18_4 XI2_I3_I306_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I318_MN1 (XI2_I3_I318_n1 I2_I3_n19_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I318_MN0 (I2_I3_o19_2 I2_I3_n19_4 XI2_I3_I318_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I330_MN1 (XI2_I3_I330_n1 I2_I3_n20_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I330_MN0 (I2_I3_o20_2 I2_I3_n20_4 XI2_I3_I330_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I342_MN1 (XI2_I3_I342_n1 I2_I3_n21_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I342_MN0 (I2_I3_o21_2 I2_I3_n21_4 XI2_I3_I342_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I334_MN1 (XI2_I3_I334_n1 I2_AND_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I334_MN0 (I2_I3_n21_0 I2_I3_SEL_AND_b3_3 XI2_I3_I334_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I340_MN1 (XI2_I3_I340_n1 I2_I3_n21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I340_MN0 (I2_I3_o21_0 I2_I3_n21_0 XI2_I3_I340_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I341_MN1 (XI2_I3_I341_n1 I2_I3_n21_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I341_MN0 (I2_I3_o21_1 I2_I3_n21_2 XI2_I3_I341_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I336_MN1 (XI2_I3_I336_n1 I2_XOR_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I336_MN0 (I2_I3_n21_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I309_MN1 (XI2_I3_I309_n1 I2_I3_q18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I309_MN0 (Y_18 I2_I3_q18_1 XI2_I3_I309_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I304_MN1 (XI2_I3_I304_n1 I2_I3_n18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I304_MN0 (I2_I3_o18_0 I2_I3_n18_0 XI2_I3_I304_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I299_MN1 (XI2_I3_I299_n1 I2_OR_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I299_MN0 (I2_I3_n18_1 I2_I3_SEL_OR_b3_3 XI2_I3_I299_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I277_MN1 (XI2_I3_I277_n1 I2_NOT_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I277_MN0 (I2_I3_n16_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I277_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I323_MN1 (XI2_I3_I323_n1 I2_OR_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I323_MN0 (I2_I3_n20_1 I2_I3_SEL_OR_b3_3 XI2_I3_I323_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I138_MN1 (XI2_I2_I138_n1 B_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I138_MN0 (I2_I2_nand23 A_23 XI2_I2_I138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I360_MN1 (XI2_I3_I360_n1 I2_XOR_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I360_MN0 (I2_I3_n23_2 I2_I3_SEL_XOR_b3_4 XI2_I3_I360_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I365_MN1 (XI2_I3_I365_n1 I2_I3_n23_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I365_MN0 (I2_I3_o23_1 I2_I3_n23_2 XI2_I3_I365_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I361_MN1 (XI2_I3_I361_n1 I2_NOT_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I361_MN0 (I2_I3_n23_3 I2_I3_SEL_NOT_b3_4 XI2_I3_I361_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I348_MN1 (XI2_I3_I348_n1 I2_XOR_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I348_MN0 (I2_I3_n22_2 I2_I3_SEL_XOR_b3_4 XI2_I3_I348_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I36_MN1 (XI2_I4_I36_n1 I2_I4_z0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I36_MN0 (I2_I4_z1_4 I2_I4_z0_8 XI2_I4_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I101_XP_MN1 (XI1_I562_I101_XP_n1 I1_I562_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I101_XP_MN0 (I1_I562_P5_2n I1_I562_P5_4 XI1_I562_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I105_XP_MN1 (XI1_I562_I105_XP_n1 I1_I562_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I105_XP_MN0 (I1_I562_P9_6n I1_I562_P9_8 XI1_I562_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I107_XP_MN1 (XI1_I562_I107_XP_n1 I1_I562_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I107_XP_MN0 (I1_I562_P11_8n I1_I562_P11_10 XI1_I562_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I16_MN1 (XI1_I562_I16_n1 I1_b0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I16_MN0 (I1_I562_gn16 VSS XI1_I562_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I18_MN1 (XI1_I562_I18_n1 I1_b0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I18_MN0 (I1_I562_gn18 VSS XI1_I562_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I22_MN1 (XI1_I562_I22_n1 I1_b0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I22_MN0 (I1_I562_gn22 VSS XI1_I562_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I23_MN1 (XI1_I562_I23_n1 I1_b0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I23_MN0 (I1_I562_gn23 VSS XI1_I562_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I25_MN1 (XI1_I562_I25_n1 I1_b0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I25_MN0 (I1_I562_gn25 VSS XI1_I562_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I123_XP_MN1 (XI1_I1712_I123_XP_n1 I1_I1712_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I123_XP_MN0 (I1_I1712_P27_24n I1_I1712_P27_26 XI1_I1712_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I178_XP_MN1 (XI1_I1712_I178_XP_n1 I1_I1712_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I178_XP_MN0 (I1_I1712_P27_12n I1_I1712_P27_20 XI1_I1712_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I182_XP_MN1 (XI1_I1712_I182_XP_n1 I1_I1712_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I182_XP_MN0 (I1_I1712_P31_16n I1_I1712_P31_24 XI1_I1712_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I170_XP_MN1 (XI1_I1712_I170_XP_n1 I1_I1712_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I170_XP_MN0 (I1_I1712_P19_4n I1_I1712_P19_12 XI1_I1712_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I182_XP_MN1 (XI1_I1528_I182_XP_n1 I1_I1528_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I182_XP_MN0 (I1_I1528_P31_16n I1_I1528_P31_24 XI1_I1528_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I174_XP_MN1 (XI1_I1528_I174_XP_n1 I1_I1528_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I174_XP_MN0 (I1_I1528_P23_8n I1_I1528_P23_16 XI1_I1528_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I178_XP_MN1 (XI1_I1528_I178_XP_n1 I1_I1528_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I178_XP_MN0 (I1_I1528_P27_12n I1_I1528_P27_20 XI1_I1528_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I172_XP_MN1 (XI1_I1528_I172_XP_n1 I1_I1528_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I172_XP_MN0 (I1_I1528_P21_6n I1_I1528_P21_14 XI1_I1528_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I176_XP_MN1 (XI1_I1528_I176_XP_n1 I1_I1528_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I176_XP_MN0 (I1_I1528_P25_10n I1_I1528_P25_18 XI1_I1528_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I170_XP_MN1 (XI1_I1528_I170_XP_n1 I1_I1528_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I170_XP_MN0 (I1_I1528_P19_4n I1_I1528_P19_12 XI1_I1528_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I168_XP_MN1 (XI1_I1528_I168_XP_n1 I1_I1528_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I168_XP_MN0 (I1_I1528_P17_2n I1_I1528_P17_10 XI1_I1528_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I174_XP_MN1 (XI1_I1574_I174_XP_n1 I1_I1574_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I174_XP_MN0 (I1_I1574_P23_8n I1_I1574_P23_16 XI1_I1574_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I14_MN1 (XI1_I1574_I14_n1 I1_b22_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I14_MN0 (I1_I1574_gn14 I1_p21_13 XI1_I1574_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I13_MN1 (XI1_I1574_I13_n1 I1_b22_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I13_MN0 (I1_I1574_gn13 I1_p21_12 XI1_I1574_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I105_XP_MN1 (XI1_I1574_I105_XP_n1 I1_I1574_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I105_XP_MN0 (I1_I1574_P9_6n I1_I1574_P9_8 XI1_I1574_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I4_MN1 (XI1_I1574_I4_n1 I1_b22_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I4_MN0 (I1_I1574_gn4 I1_p21_3 XI1_I1574_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I231_MN1 (XI2_I3_I231_n1 DIVQ_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I231_MN0 (I2_I3_n12_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I243_MN1 (XI2_I3_I243_n1 DIVQ_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I243_MN0 (I2_I3_n13_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I15_MN1 (XI2_I1_I42_I15_n1 I2_I1_bx15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I15_MN0 (I2_I1_I42_gn15 A_15 XI2_I1_I42_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I16_MN1 (XI2_I1_I42_I16_n1 I2_I1_bx16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I16_MN0 (I2_I1_I42_gn16 A_16 XI2_I1_I42_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I17_MN1 (XI2_I1_I42_I17_n1 I2_I1_bx17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I17_MN0 (I2_I1_I42_gn17 A_17 XI2_I1_I42_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I18_MN1 (XI2_I1_I42_I18_n1 I2_I1_bx18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I18_MN0 (I2_I1_I42_gn18 A_18 XI2_I1_I42_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I19_MN1 (XI2_I1_I42_I19_n1 I2_I1_bx19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I19_MN0 (I2_I1_I42_gn19 A_19 XI2_I1_I42_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I294_MN1 (XI2_I3_I294_n1 I2_I3_n17_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I294_MN0 (I2_I3_o17_2 I2_I3_n17_4 XI2_I3_I294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I20_MN1 (XI2_I1_I42_I20_n1 I2_I1_bx20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I20_MN0 (I2_I1_I42_gn20 A_20 XI2_I1_I42_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I23_MN1 (XI2_I1_I42_I23_n1 I2_I1_bx23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I23_MN0 (I2_I1_I42_gn23 A_23 XI2_I1_I42_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I354_MN1 (XI2_I3_I354_n1 I2_I3_n22_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I354_MN0 (I2_I3_o22_2 I2_I3_n22_4 XI2_I3_I354_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2284_MN1 (XI1_I2284_n1 I1_z0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2284_MN0 (I1_z1_6 I1_z0_12 XI1_I2284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2285_MN1 (XI1_I2285_n1 I1_z0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2285_MN0 (I1_z1_7 I1_z0_14 XI1_I2285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I286_MN1 (XI2_I3_I286_n1 I2_AND_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I286_MN0 (I2_I3_n17_0 I2_I3_SEL_AND_b3_3 XI2_I3_I286_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I102_MN1 (XI2_I2_I102_n1 B_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I102_MN0 (I2_I2_nand17 A_17 XI2_I2_I102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I287_MN1 (XI2_I3_I287_n1 I2_OR_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I287_MN0 (I2_I3_n17_1 I2_I3_SEL_OR_b3_3 XI2_I3_I287_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I292_MN1 (XI2_I3_I292_n1 I2_I3_n17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I292_MN0 (I2_I3_o17_0 I2_I3_n17_0 XI2_I3_I292_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I297_MN1 (XI2_I3_I297_n1 I2_I3_q17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I297_MN0 (Y_17 I2_I3_q17_1 XI2_I3_I297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I293_MN1 (XI2_I3_I293_n1 I2_I3_n17_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I293_MN0 (I2_I3_o17_1 I2_I3_n17_2 XI2_I3_I293_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I337_MN1 (XI2_I3_I337_n1 I2_NOT_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I337_MN0 (I2_I3_n21_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I288_MN1 (XI2_I3_I288_n1 I2_XOR_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I288_MN0 (I2_I3_n17_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I288_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I280_MN1 (XI2_I3_I280_n1 I2_I3_n16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I280_MN0 (I2_I3_o16_0 I2_I3_n16_0 XI2_I3_I280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I274_MN1 (XI2_I3_I274_n1 I2_AND_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I274_MN0 (I2_I3_n16_0 I2_I3_SEL_AND_b3_3 XI2_I3_I274_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I285_MN1 (XI2_I3_I285_n1 I2_I3_q16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I285_MN0 (Y_16 I2_I3_q16_1 XI2_I3_I285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I281_MN1 (XI2_I3_I281_n1 I2_I3_n16_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I281_MN0 (I2_I3_o16_1 I2_I3_n16_2 XI2_I3_I281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I276_MN1 (XI2_I3_I276_n1 I2_XOR_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I276_MN0 (I2_I3_n16_2 I2_I3_SEL_XOR_b3_3 XI2_I3_I276_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I358_MN1 (XI2_I3_I358_n1 I2_AND_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I358_MN0 (I2_I3_n23_0 I2_I3_SEL_AND_b3_4 XI2_I3_I358_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I364_MN1 (XI2_I3_I364_n1 I2_I3_n23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I364_MN0 (I2_I3_o23_0 I2_I3_n23_0 XI2_I3_I364_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I359_MN1 (XI2_I3_I359_n1 I2_OR_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I359_MN0 (I2_I3_n23_1 I2_I3_SEL_OR_b3_4 XI2_I3_I359_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I385_MN1 (XI2_I3_I385_n1 I2_NOT_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I385_MN0 (I2_I3_n25_3 I2_I3_SEL_NOT_b3_4 XI2_I3_I385_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I347_MN1 (XI2_I3_I347_n1 I2_OR_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I347_MN0 (I2_I3_n22_1 I2_I3_SEL_OR_b3_4 XI2_I3_I347_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I357_MN1 (XI2_I3_I357_n1 I2_I3_q22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I357_MN0 (Y_22 I2_I3_q22_1 XI2_I3_I357_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I162_MN1 (XI2_I2_I162_n1 B_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I162_MN0 (I2_I2_nand27 A_27 XI2_I2_I162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I103_XP_MN1 (XI1_I562_I103_XP_n1 I1_I562_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I103_XP_MN0 (I1_I562_P7_4n I1_I562_P7_6 XI1_I562_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I174_MN1 (XI2_I2_I174_n1 B_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I174_MN0 (I2_I2_nand29 A_29 XI2_I2_I174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I168_XP_MN1 (XI1_I562_I168_XP_n1 I1_I562_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I168_XP_MN0 (I1_I562_P17_2n I1_I562_P17_10 XI1_I562_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I109_XP_MN1 (XI1_I562_I109_XP_n1 I1_I562_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I109_XP_MN0 (I1_I562_P13_10n I1_I562_P13_12 XI1_I562_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I176_XP_MN1 (XI1_I562_I176_XP_n1 I1_I562_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I176_XP_MN0 (I1_I562_P25_10n I1_I562_P25_18 XI1_I562_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I111_XP_MN1 (XI1_I562_I111_XP_n1 I1_I562_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I111_XP_MN0 (I1_I562_P15_12n I1_I562_P15_14 XI1_I562_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I113_XP_MN1 (XI1_I562_I113_XP_n1 I1_I562_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I113_XP_MN0 (I1_I562_P17_14n I1_I562_P17_16 XI1_I562_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I180_XP_MN1 (XI1_I562_I180_XP_n1 I1_I562_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I180_XP_MN0 (I1_I562_P29_14n I1_I562_P29_22 XI1_I562_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I24_MN1 (XI1_I562_I24_n1 I1_b0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I24_MN0 (I1_I562_gn24 VSS XI1_I562_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I26_MN1 (XI1_I562_I26_n1 I1_b0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I26_MN0 (I1_I562_gn26 VSS XI1_I562_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I127_XP_MN1 (XI1_I1712_I127_XP_n1 I1_I1712_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I127_XP_MN0 (I1_I1712_P31_28n I1_I1712_P31_30 XI1_I1712_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I125_XP_MN1 (XI1_I1712_I125_XP_n1 I1_I1712_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I125_XP_MN0 (I1_I1712_P29_26n I1_I1712_P29_28 XI1_I1712_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I121_XP_MN1 (XI1_I1712_I121_XP_n1 I1_I1712_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I121_XP_MN0 (I1_I1712_P25_22n I1_I1712_P25_24 XI1_I1712_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I119_XP_MN1 (XI1_I1712_I119_XP_n1 I1_I1712_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I119_XP_MN0 (I1_I1712_P23_20n I1_I1712_P23_22 XI1_I1712_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I117_XP_MN1 (XI1_I1712_I117_XP_n1 I1_I1712_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I117_XP_MN0 (I1_I1712_P21_18n I1_I1712_P21_20 XI1_I1712_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I115_XP_MN1 (XI1_I1712_I115_XP_n1 I1_I1712_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I115_XP_MN0 (I1_I1712_P19_16n I1_I1712_P19_18 XI1_I1712_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I113_XP_MN1 (XI1_I1712_I113_XP_n1 I1_I1712_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I113_XP_MN0 (I1_I1712_P17_14n I1_I1712_P17_16 XI1_I1712_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I111_XP_MN1 (XI1_I1712_I111_XP_n1 I1_I1712_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I111_XP_MN0 (I1_I1712_P15_12n I1_I1712_P15_14 XI1_I1712_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I109_XP_MN1 (XI1_I1712_I109_XP_n1 I1_I1712_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I109_XP_MN0 (I1_I1712_P13_10n I1_I1712_P13_12 XI1_I1712_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I168_XP_MN1 (XI1_I1712_I168_XP_n1 I1_I1712_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I168_XP_MN0 (I1_I1712_P17_2n I1_I1712_P17_10 XI1_I1712_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I107_XP_MN1 (XI1_I1712_I107_XP_n1 I1_I1712_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I107_XP_MN0 (I1_I1712_P11_8n I1_I1712_P11_10 XI1_I1712_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I105_XP_MN1 (XI1_I1712_I105_XP_n1 I1_I1712_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I105_XP_MN0 (I1_I1712_P9_6n I1_I1712_P9_8 XI1_I1712_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I103_XP_MN1 (XI1_I1712_I103_XP_n1 I1_I1712_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I103_XP_MN0 (I1_I1712_P7_4n I1_I1712_P7_6 XI1_I1712_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I180_XP_MN1 (XI1_I1528_I180_XP_n1 I1_I1528_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I180_XP_MN0 (I1_I1528_P29_14n I1_I1528_P29_22 XI1_I1528_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I127_XP_MN1 (XI1_I1574_I127_XP_n1 I1_I1574_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I127_XP_MN0 (I1_I1574_P31_28n I1_I1574_P31_30 XI1_I1574_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I182_XP_MN1 (XI1_I1574_I182_XP_n1 I1_I1574_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I182_XP_MN0 (I1_I1574_P31_16n I1_I1574_P31_24 XI1_I1574_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I180_XP_MN1 (XI1_I1574_I180_XP_n1 I1_I1574_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I180_XP_MN0 (I1_I1574_P29_14n I1_I1574_P29_22 XI1_I1574_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I115_XP_MN1 (XI1_I1574_I115_XP_n1 I1_I1574_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I115_XP_MN0 (I1_I1574_P19_16n I1_I1574_P19_18 XI1_I1574_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I113_XP_MN1 (XI1_I1574_I113_XP_n1 I1_I1574_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I113_XP_MN0 (I1_I1574_P17_14n I1_I1574_P17_16 XI1_I1574_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I15_MN1 (XI1_I1574_I15_n1 I1_b22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I15_MN0 (I1_I1574_gn15 I1_p21_14 XI1_I1574_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I172_XP_MN1 (XI1_I1574_I172_XP_n1 I1_I1574_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I172_XP_MN0 (I1_I1574_P21_6n I1_I1574_P21_14 XI1_I1574_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I176_XP_MN1 (XI1_I1574_I176_XP_n1 I1_I1574_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I176_XP_MN0 (I1_I1574_P25_10n I1_I1574_P25_18 XI1_I1574_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I168_XP_MN1 (XI1_I1574_I168_XP_n1 I1_I1574_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I168_XP_MN0 (I1_I1574_P17_2n I1_I1574_P17_10 XI1_I1574_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I103_XP_MN1 (XI1_I1574_I103_XP_n1 I1_I1574_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I103_XP_MN0 (I1_I1574_P7_4n I1_I1574_P7_6 XI1_I1574_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I101_XP_MN1 (XI1_I1574_I101_XP_n1 I1_I1574_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I101_XP_MN0 (I1_I1574_P5_2n I1_I1574_P5_4 XI1_I1574_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I3_MN1 (XI1_I1574_I3_n1 I1_b22_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I3_MN0 (I1_I1574_gn3 I1_p21_2 XI1_I1574_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I240_MN1 (XI2_I3_I240_n1 I2_XOR_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I240_MN0 (I2_I3_n13_2 I2_I3_SEL_XOR_b3_2 XI2_I3_I240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I265_MN1 (XI2_I3_I265_n1 I2_NOT_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I265_MN0 (I2_I3_n15_3 I2_I3_SEL_NOT_b3_2 XI2_I3_I265_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I264_MN1 (XI2_I3_I264_n1 I2_XOR_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I264_MN0 (I2_I3_n15_2 I2_I3_SEL_XOR_b3_2 XI2_I3_I264_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2280_MN1 (XI1_I2280_n1 I1_z0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2280_MN0 (I1_z1_2 I1_z0_4 XI1_I2280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2281_MN1 (XI1_I2281_n1 I1_z0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2281_MN0 (I1_z1_3 I1_z0_6 XI1_I2281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I255_MN1 (XI2_I3_I255_n1 DIVQ_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I255_MN0 (I2_I3_n14_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I255_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I267_MN1 (XI2_I3_I267_n1 DIVQ_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I267_MN0 (I2_I3_n15_5 I2_I3_SEL_DIV_b3_2 XI2_I3_I267_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I13_MN1 (XI2_I1_I42_I13_n1 I2_I1_bx13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I13_MN0 (I2_I1_I42_gn13 A_13 XI2_I1_I42_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I14_MN1 (XI2_I1_I42_I14_n1 I2_I1_bx14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I14_MN0 (I2_I1_I42_gn14 A_14 XI2_I1_I42_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I116_XP_MN1 (XI2_I1_I42_I116_XP_n1 I2_I1_I42_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I116_XP_MN0 (I2_I1_I42_P20_17n I2_I1_I42_P20_19 XI2_I1_I42_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I282_MN1 (XI2_I3_I282_n1 I2_I3_n16_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I282_MN0 (I2_I3_o16_2 I2_I3_n16_4 XI2_I3_I282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I21_MN1 (XI2_I1_I42_I21_n1 I2_I1_bx21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I21_MN0 (I2_I1_I42_gn21 A_21 XI2_I1_I42_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I22_MN1 (XI2_I1_I42_I22_n1 I2_I1_bx22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I22_MN0 (I2_I1_I42_gn22 A_22 XI2_I1_I42_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I375_MN1 (XI2_I3_I375_n1 DIVQ_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I375_MN0 (I2_I3_n24_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I387_MN1 (XI2_I3_I387_n1 DIVQ_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I387_MN0 (I2_I3_n25_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I387_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2291_MN1 (XI1_I2291_n1 I1_z2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2291_MN0 (I1_z3_1 I1_z2_2 XI1_I2291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I289_MN1 (XI2_I3_I289_n1 I2_NOT_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I289_MN0 (I2_I3_n17_3 I2_I3_SEL_NOT_b3_3 XI2_I3_I289_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I275_MN1 (XI2_I3_I275_n1 I2_OR_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I275_MN0 (I2_I3_n16_1 I2_I3_SEL_OR_b3_3 XI2_I3_I275_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I423_MN1 (XI2_I3_I423_n1 DIVQ_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I423_MN0 (I2_I3_n28_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I423_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I96_MN1 (XI2_I2_I96_n1 B_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I96_MN0 (I2_I2_nand16 A_16 XI2_I2_I96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2283_MN1 (XI1_I2283_n1 I1_z0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2283_MN0 (I1_z1_5 I1_z0_10 XI1_I2283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I150_MN1 (XI2_I2_I150_n1 B_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I150_MN0 (I2_I2_nand25 A_25 XI2_I2_I150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I383_MN1 (XI2_I3_I383_n1 I2_OR_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I383_MN0 (I2_I3_n25_1 I2_I3_SEL_OR_b3_4 XI2_I3_I383_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I373_MN1 (XI2_I3_I373_n1 I2_NOT_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I373_MN0 (I2_I3_n24_3 I2_I3_SEL_NOT_b3_4 XI2_I3_I373_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I397_MN1 (XI2_I3_I397_n1 I2_NOT_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I397_MN0 (I2_I3_n26_3 I2_I3_SEL_NOT_b3_4 XI2_I3_I397_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I407_MN1 (XI2_I3_I407_n1 I2_OR_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I407_MN0 (I2_I3_n27_1 I2_I3_SEL_OR_b3_5 XI2_I3_I407_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I412_MN1 (XI2_I3_I412_n1 I2_I3_n27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I412_MN0 (I2_I3_o27_0 I2_I3_n27_0 XI2_I3_I412_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I406_MN1 (XI2_I3_I406_n1 I2_AND_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I406_MN0 (I2_I3_n27_0 I2_I3_SEL_AND_b3_5 XI2_I3_I406_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I431_MN1 (XI2_I3_I431_n1 I2_OR_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I431_MN0 (I2_I3_n29_1 I2_I3_SEL_OR_b3_5 XI2_I3_I431_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I430_MN1 (XI2_I3_I430_n1 I2_AND_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I430_MN0 (I2_I3_n29_0 I2_I3_SEL_AND_b3_5 XI2_I3_I430_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I436_MN1 (XI2_I3_I436_n1 I2_I3_n29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I436_MN0 (I2_I3_o29_0 I2_I3_n29_0 XI2_I3_I436_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I433_MN1 (XI2_I3_I433_n1 I2_NOT_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I433_MN0 (I2_I3_n29_3 I2_I3_SEL_NOT_b3_5 XI2_I3_I433_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I437_MN1 (XI2_I3_I437_n1 I2_I3_n29_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I437_MN0 (I2_I3_o29_1 I2_I3_n29_2 XI2_I3_I437_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I432_MN1 (XI2_I3_I432_n1 I2_XOR_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I432_MN0 (I2_I3_n29_2 I2_I3_SEL_XOR_b3_5 XI2_I3_I432_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I170_XP_MN1 (XI1_I562_I170_XP_n1 I1_I562_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I170_XP_MN0 (I1_I562_P19_4n I1_I562_P19_12 XI1_I562_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I172_XP_MN1 (XI1_I562_I172_XP_n1 I1_I562_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I172_XP_MN0 (I1_I562_P21_6n I1_I562_P21_14 XI1_I562_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I115_XP_MN1 (XI1_I562_I115_XP_n1 I1_I562_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I115_XP_MN0 (I1_I562_P19_16n I1_I562_P19_18 XI1_I562_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I117_XP_MN1 (XI1_I562_I117_XP_n1 I1_I562_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I117_XP_MN0 (I1_I562_P21_18n I1_I562_P21_20 XI1_I562_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I119_XP_MN1 (XI1_I562_I119_XP_n1 I1_I562_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I119_XP_MN0 (I1_I562_P23_20n I1_I562_P23_22 XI1_I562_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I121_XP_MN1 (XI1_I562_I121_XP_n1 I1_I562_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I121_XP_MN0 (I1_I562_P25_22n I1_I562_P25_24 XI1_I562_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I123_XP_MN1 (XI1_I562_I123_XP_n1 I1_I562_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I123_XP_MN0 (I1_I562_P27_24n I1_I562_P27_26 XI1_I562_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I125_XP_MN1 (XI1_I562_I125_XP_n1 I1_I562_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I125_XP_MN0 (I1_I562_P29_26n I1_I562_P29_28 XI1_I562_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I180_XP_MN1 (XI1_I1712_I180_XP_n1 I1_I1712_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I180_XP_MN0 (I1_I1712_P29_14n I1_I1712_P29_22 XI1_I1712_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I176_XP_MN1 (XI1_I1712_I176_XP_n1 I1_I1712_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I176_XP_MN0 (I1_I1712_P25_10n I1_I1712_P25_18 XI1_I1712_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I172_XP_MN1 (XI1_I1712_I172_XP_n1 I1_I1712_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I172_XP_MN0 (I1_I1712_P21_6n I1_I1712_P21_14 XI1_I1712_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I101_XP_MN1 (XI1_I1712_I101_XP_n1 I1_I1712_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I101_XP_MN0 (I1_I1712_P5_2n I1_I1712_P5_4 XI1_I1712_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I3_MN1 (XI1_I1712_I3_n1 I1_b25_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I3_MN0 (I1_I1712_gn3 I1_p24_2 XI1_I1712_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I31_MN1 (XI1_I1574_I31_n1 I1_b22_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I31_MN0 (I1_I1574_gn31 I1_p21_30 XI1_I1574_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I30_MN1 (XI1_I1574_I30_n1 I1_b22_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I30_MN0 (I1_I1574_gn30 I1_p21_29 XI1_I1574_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I29_MN1 (XI1_I1574_I29_n1 I1_b22_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I29_MN0 (I1_I1574_gn29 I1_p21_28 XI1_I1574_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I28_MN1 (XI1_I1574_I28_n1 I1_b22_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I28_MN0 (I1_I1574_gn28 I1_p21_27 XI1_I1574_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I125_XP_MN1 (XI1_I1574_I125_XP_n1 I1_I1574_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I125_XP_MN0 (I1_I1574_P29_26n I1_I1574_P29_28 XI1_I1574_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I123_XP_MN1 (XI1_I1574_I123_XP_n1 I1_I1574_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I123_XP_MN0 (I1_I1574_P27_24n I1_I1574_P27_26 XI1_I1574_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I121_XP_MN1 (XI1_I1574_I121_XP_n1 I1_I1574_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I121_XP_MN0 (I1_I1574_P25_22n I1_I1574_P25_24 XI1_I1574_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I119_XP_MN1 (XI1_I1574_I119_XP_n1 I1_I1574_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I119_XP_MN0 (I1_I1574_P23_20n I1_I1574_P23_22 XI1_I1574_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I117_XP_MN1 (XI1_I1574_I117_XP_n1 I1_I1574_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I117_XP_MN0 (I1_I1574_P21_18n I1_I1574_P21_20 XI1_I1574_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I16_MN1 (XI1_I1574_I16_n1 I1_b22_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I16_MN0 (I1_I1574_gn16 I1_p21_15 XI1_I1574_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I2_MN1 (XI1_I1574_I2_n1 I1_b22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I2_MN0 (I1_I1574_gn2 I1_p21_1 XI1_I1574_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I249_MN1 (XI2_I3_I249_n1 I2_I3_q13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I249_MN0 (Y_13 I2_I3_q13_1 XI2_I3_I249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I245_MN1 (XI2_I3_I245_n1 I2_I3_n13_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I245_MN0 (I2_I3_o13_1 I2_I3_n13_2 XI2_I3_I245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I241_MN1 (XI2_I3_I241_n1 I2_NOT_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I241_MN0 (I2_I3_n13_3 I2_I3_SEL_NOT_b3_2 XI2_I3_I241_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I90_MN1 (XI2_I2_I90_n1 B_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I90_MN0 (I2_I2_nand15 A_15 XI2_I2_I90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I269_MN1 (XI2_I3_I269_n1 I2_I3_n15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I269_MN0 (I2_I3_o15_1 I2_I3_n15_2 XI2_I3_I269_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I252_MN1 (XI2_I3_I252_n1 I2_XOR_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I252_MN0 (I2_I3_n14_2 I2_I3_SEL_XOR_b3_2 XI2_I3_I252_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2290_MN1 (XI1_I2290_n1 I1_z2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2290_MN0 (I1_z3_0 I1_z2_0 XI1_I2290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I246_MN1 (XI2_I3_I246_n1 I2_I3_n13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I246_MN0 (I2_I3_o13_2 I2_I3_n13_4 XI2_I3_I246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I12_MN1 (XI2_I1_I42_I12_n1 I2_I1_bx12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I12_MN0 (I2_I1_I42_gn12 A_12 XI2_I1_I42_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I171_XP_MN1 (XI2_I1_I42_I171_XP_n1 I2_I1_I42_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I171_XP_MN0 (I2_I1_I42_P20_5n I2_I1_I42_P20_13 XI2_I1_I42_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I112_XP_MN1 (XI2_I1_I42_I112_XP_n1 I2_I1_I42_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I112_XP_MN0 (I2_I1_I42_P16_13n I2_I1_I42_P16_15 XI2_I1_I42_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I114_XP_MN1 (XI2_I1_I42_I114_XP_n1 I2_I1_I42_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I114_XP_MN0 (I2_I1_I42_P18_15n I2_I1_I42_P18_17 XI2_I1_I42_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I179_XP_MN1 (XI2_I1_I42_I179_XP_n1 I2_I1_I42_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I179_XP_MN0 (I2_I1_I42_P28_13n I2_I1_I42_P28_21 XI2_I1_I42_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I118_XP_MN1 (XI2_I1_I42_I118_XP_n1 I2_I1_I42_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I118_XP_MN0 (I2_I1_I42_P22_19n I2_I1_I42_P22_21 XI2_I1_I42_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I120_XP_MN1 (XI2_I1_I42_I120_XP_n1 I2_I1_I42_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I120_XP_MN0 (I2_I1_I42_P24_21n I2_I1_I42_P24_23 XI2_I1_I42_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I122_XP_MN1 (XI2_I1_I42_I122_XP_n1 I2_I1_I42_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I122_XP_MN0 (I2_I1_I42_P26_23n I2_I1_I42_P26_25 XI2_I1_I42_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I124_XP_MN1 (XI2_I1_I42_I124_XP_n1 I2_I1_I42_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I124_XP_MN0 (I2_I1_I42_P28_25n I2_I1_I42_P28_27 XI2_I1_I42_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I24_MN1 (XI2_I1_I42_I24_n1 I2_I1_bx24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I24_MN0 (I2_I1_I42_gn24 A_24 XI2_I1_I42_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I25_MN1 (XI2_I1_I42_I25_n1 I2_I1_bx25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I25_MN0 (I2_I1_I42_gn25 A_25 XI2_I1_I42_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I26_MN1 (XI2_I1_I42_I26_n1 I2_I1_bx26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I26_MN0 (I2_I1_I42_gn26 A_26 XI2_I1_I42_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I27_MN1 (XI2_I1_I42_I27_n1 I2_I1_bx27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I27_MN0 (I2_I1_I42_gn27 A_27 XI2_I1_I42_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I378_MN1 (XI2_I3_I378_n1 I2_I3_n24_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I378_MN0 (I2_I3_o24_2 I2_I3_n24_4 XI2_I3_I378_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I390_MN1 (XI2_I3_I390_n1 I2_I3_n25_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I390_MN0 (I2_I3_o25_2 I2_I3_n25_4 XI2_I3_I390_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I399_MN1 (XI2_I3_I399_n1 DIVQ_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I399_MN0 (I2_I3_n26_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I399_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I411_MN1 (XI2_I3_I411_n1 DIVQ_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I411_MN0 (I2_I3_n27_5 I2_I3_SEL_DIV_b3_4 XI2_I3_I411_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I438_MN1 (XI2_I3_I438_n1 I2_I3_n29_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I438_MN0 (I2_I3_o29_2 I2_I3_n29_4 XI2_I3_I438_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I70_MN1 (XI2_I4_I70_n1 DIVDZ VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I70_MN0 (I2_I4_dzn I2_SEL_DIV XI2_I4_I70_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2282_MN1 (XI1_I2282_n1 I1_z0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2282_MN0 (I1_z1_4 I1_z0_8 XI1_I2282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I144_MN1 (XI2_I2_I144_n1 B_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I144_MN0 (I2_I2_nand24 A_24 XI2_I2_I144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I370_MN1 (XI2_I3_I370_n1 I2_AND_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I370_MN0 (I2_I3_n24_0 I2_I3_SEL_AND_b3_4 XI2_I3_I370_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I376_MN1 (XI2_I3_I376_n1 I2_I3_n24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I376_MN0 (I2_I3_o24_0 I2_I3_n24_0 XI2_I3_I376_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I393_MN1 (XI2_I3_I393_n1 I2_I3_q25_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I393_MN0 (Y_25 I2_I3_q25_1 XI2_I3_I393_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I401_MN1 (XI2_I3_I401_n1 I2_I3_n26_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I401_MN0 (I2_I3_o26_1 I2_I3_n26_2 XI2_I3_I401_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I396_MN1 (XI2_I3_I396_n1 I2_XOR_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I396_MN0 (I2_I3_n26_2 I2_I3_SEL_XOR_b3_4 XI2_I3_I396_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I445_MN1 (XI2_I3_I445_n1 I2_NOT_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I445_MN0 (I2_I3_n30_3 I2_I3_SEL_NOT_b3_5 XI2_I3_I445_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I419_MN1 (XI2_I3_I419_n1 I2_OR_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I419_MN0 (I2_I3_n28_1 I2_I3_SEL_OR_b3_5 XI2_I3_I419_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I408_MN1 (XI2_I3_I408_n1 I2_XOR_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I408_MN0 (I2_I3_n27_2 I2_I3_SEL_XOR_b3_5 XI2_I3_I408_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I418_MN1 (XI2_I3_I418_n1 I2_AND_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I418_MN0 (I2_I3_n28_0 I2_I3_SEL_AND_b3_5 XI2_I3_I418_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I424_MN1 (XI2_I3_I424_n1 I2_I3_n28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I424_MN0 (I2_I3_o28_0 I2_I3_n28_0 XI2_I3_I424_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I168_MN1 (XI2_I2_I168_n1 B_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I168_MN0 (I2_I2_nand28 A_28 XI2_I2_I168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I441_MN1 (XI2_I3_I441_n1 I2_I3_q29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I441_MN0 (Y_29 I2_I3_q29_1 XI2_I3_I441_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I421_MN1 (XI2_I3_I421_n1 I2_NOT_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I421_MN0 (I2_I3_n28_3 I2_I3_SEL_NOT_b3_5 XI2_I3_I421_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I425_MN1 (XI2_I3_I425_n1 I2_I3_n28_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I425_MN0 (I2_I3_o28_1 I2_I3_n28_2 XI2_I3_I425_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I420_MN1 (XI2_I3_I420_n1 I2_XOR_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I420_MN0 (I2_I3_n28_2 I2_I3_SEL_XOR_b3_5 XI2_I3_I420_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I178_XP_MN1 (XI1_I562_I178_XP_n1 I1_I562_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I178_XP_MN0 (I1_I562_P27_12n I1_I562_P27_20 XI1_I562_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I174_XP_MN1 (XI1_I562_I174_XP_n1 I1_I562_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I174_XP_MN0 (I1_I562_P23_8n I1_I562_P23_16 XI1_I562_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I182_XP_MN1 (XI1_I562_I182_XP_n1 I1_I562_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I182_XP_MN0 (I1_I562_P31_16n I1_I562_P31_24 XI1_I562_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I127_XP_MN1 (XI1_I562_I127_XP_n1 I1_I562_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I127_XP_MN0 (I1_I562_P31_28n I1_I562_P31_30 XI1_I562_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I28_MN1 (XI1_I1712_I28_n1 I1_b25_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I28_MN0 (I1_I1712_gn28 I1_p24_27 XI1_I1712_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I124_XP_MN1 (XI1_I1712_I124_XP_n1 I1_I1712_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I124_XP_MN0 (I1_I1712_P28_25n I1_I1712_P28_27 XI1_I1712_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I179_XP_MN1 (XI1_I1712_I179_XP_n1 I1_I1712_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I179_XP_MN0 (I1_I1712_P28_13n I1_I1712_P28_21 XI1_I1712_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I171_XP_MN1 (XI1_I1712_I171_XP_n1 I1_I1712_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I171_XP_MN0 (I1_I1712_P20_5n I1_I1712_P20_13 XI1_I1712_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I4_MN1 (XI1_I1712_I4_n1 I1_b25_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I4_MN0 (I1_I1712_gn4 I1_p24_3 XI1_I1712_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I27_MN1 (XI1_I1574_I27_n1 I1_b22_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I27_MN0 (I1_I1574_gn27 I1_p21_26 XI1_I1574_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I26_MN1 (XI1_I1574_I26_n1 I1_b22_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I26_MN0 (I1_I1574_gn26 I1_p21_25 XI1_I1574_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I112_XP_MN1 (XI1_I1574_I112_XP_n1 I1_I1574_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I112_XP_MN0 (I1_I1574_P16_13n I1_I1574_P16_15 XI1_I1574_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I110_XP_MN1 (XI1_I1574_I110_XP_n1 I1_I1574_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I110_XP_MN0 (I1_I1574_P14_11n I1_I1574_P14_13 XI1_I1574_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I108_XP_MN1 (XI1_I1574_I108_XP_n1 I1_I1574_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I108_XP_MN0 (I1_I1574_P12_9n I1_I1574_P12_11 XI1_I1574_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I106_XP_MN1 (XI1_I1574_I106_XP_n1 I1_I1574_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I106_XP_MN0 (I1_I1574_P10_7n I1_I1574_P10_9 XI1_I1574_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I104_XP_MN1 (XI1_I1574_I104_XP_n1 I1_I1574_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I104_XP_MN0 (I1_I1574_P8_5n I1_I1574_P8_7 XI1_I1574_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I78_MN1 (XI2_I2_I78_n1 B_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I78_MN0 (I2_I2_nand13 A_13 XI2_I2_I78_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I239_MN1 (XI2_I3_I239_n1 I2_OR_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I239_MN0 (I2_I3_n13_1 I2_I3_SEL_OR_b3_2 XI2_I3_I239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I238_MN1 (XI2_I3_I238_n1 I2_AND_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I238_MN0 (I2_I3_n13_0 I2_I3_SEL_AND_b3_2 XI2_I3_I238_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I244_MN1 (XI2_I3_I244_n1 I2_I3_n13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I244_MN0 (I2_I3_o13_0 I2_I3_n13_0 XI2_I3_I244_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I262_MN1 (XI2_I3_I262_n1 I2_AND_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I262_MN0 (I2_I3_n15_0 I2_I3_SEL_AND_b3_2 XI2_I3_I262_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I268_MN1 (XI2_I3_I268_n1 I2_I3_n15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I268_MN0 (I2_I3_o15_0 I2_I3_n15_0 XI2_I3_I268_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I273_MN1 (XI2_I3_I273_n1 I2_I3_q15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I273_MN0 (Y_15 I2_I3_q15_1 XI2_I3_I273_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I217_MN1 (XI2_I3_I217_n1 I2_NOT_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I217_MN0 (I2_I3_n11_3 I2_I3_SEL_NOT_b3_2 XI2_I3_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I263_MN1 (XI2_I3_I263_n1 I2_OR_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I263_MN0 (I2_I3_n15_1 I2_I3_SEL_OR_b3_2 XI2_I3_I263_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I258_MN1 (XI2_I3_I258_n1 I2_I3_n14_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I258_MN0 (I2_I3_o14_2 I2_I3_n14_4 XI2_I3_I258_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I270_MN1 (XI2_I3_I270_n1 I2_I3_n15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I270_MN0 (I2_I3_o15_2 I2_I3_n15_4 XI2_I3_I270_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I11_MN1 (XI2_I1_I42_I11_n1 I2_I1_bx11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I11_MN0 (I2_I1_I42_gn11 A_11 XI2_I1_I42_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I110_XP_MN1 (XI2_I1_I42_I110_XP_n1 I2_I1_I42_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I110_XP_MN0 (I2_I1_I42_P14_11n I2_I1_I42_P14_13 XI2_I1_I42_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I173_XP_MN1 (XI2_I1_I42_I173_XP_n1 I2_I1_I42_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I173_XP_MN0 (I2_I1_I42_P22_7n I2_I1_I42_P22_15 XI2_I1_I42_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I177_XP_MN1 (XI2_I1_I42_I177_XP_n1 I2_I1_I42_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I177_XP_MN0 (I2_I1_I42_P26_11n I2_I1_I42_P26_19 XI2_I1_I42_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I181_XP_MN1 (XI2_I1_I42_I181_XP_n1 I2_I1_I42_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I181_XP_MN0 (I2_I1_I42_P30_15n I2_I1_I42_P30_23 XI2_I1_I42_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I126_XP_MN1 (XI2_I1_I42_I126_XP_n1 I2_I1_I42_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I126_XP_MN0 (I2_I1_I42_P30_27n I2_I1_I42_P30_29 XI2_I1_I42_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I28_MN1 (XI2_I1_I42_I28_n1 I2_I1_bx28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I28_MN0 (I2_I1_I42_gn28 A_28 XI2_I1_I42_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I402_MN1 (XI2_I3_I402_n1 I2_I3_n26_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I402_MN0 (I2_I3_o26_2 I2_I3_n26_4 XI2_I3_I402_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I414_MN1 (XI2_I3_I414_n1 I2_I3_n27_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I414_MN0 (I2_I3_o27_2 I2_I3_n27_4 XI2_I3_I414_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I69_MN1 (XI2_I4_I69_n1 I2_I4_v2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I69_MN0 (V I2_I4_v1 XI2_I4_I69_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I395_MN1 (XI2_I3_I395_n1 I2_OR_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I395_MN0 (I2_I3_n26_1 I2_I3_SEL_OR_b3_4 XI2_I3_I395_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I405_MN1 (XI2_I3_I405_n1 I2_I3_q26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I405_MN0 (Y_26 I2_I3_q26_1 XI2_I3_I405_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I443_MN1 (XI2_I3_I443_n1 I2_OR_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I443_MN0 (I2_I3_n30_1 I2_I3_SEL_OR_b3_5 XI2_I3_I443_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I448_MN1 (XI2_I3_I448_n1 I2_I3_n30_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I448_MN0 (I2_I3_o30_0 I2_I3_n30_0 XI2_I3_I448_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I417_MN1 (XI2_I3_I417_n1 I2_I3_q27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I417_MN0 (Y_27 I2_I3_q27_1 XI2_I3_I417_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I455_MN1 (XI2_I3_I455_n1 I2_OR_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I455_MN0 (I2_I3_n31_1 I2_I3_SEL_OR_b3_5 XI2_I3_I455_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I429_MN1 (XI2_I3_I429_n1 I2_I3_q28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I429_MN0 (Y_28 I2_I3_q28_1 XI2_I3_I429_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I457_MN1 (XI2_I3_I457_n1 I2_NOT_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I457_MN0 (I2_I3_n31_3 I2_I3_SEL_NOT_b3_5 XI2_I3_I457_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I461_MN1 (XI2_I3_I461_n1 I2_I3_n31_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I461_MN0 (I2_I3_o31_1 I2_I3_n31_2 XI2_I3_I461_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I456_MN1 (XI2_I3_I456_n1 I2_XOR_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I456_MN0 (I2_I3_n31_2 I2_I3_SEL_XOR_b3_5 XI2_I3_I456_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I29_MN1 (XI1_I1712_I29_n1 I1_b25_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I29_MN0 (I1_I1712_gn29 I1_p24_28 XI1_I1712_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I27_MN1 (XI1_I1712_I27_n1 I1_b25_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I27_MN0 (I1_I1712_gn27 I1_p24_26 XI1_I1712_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I126_XP_MN1 (XI1_I1712_I126_XP_n1 I1_I1712_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I126_XP_MN0 (I1_I1712_P30_27n I1_I1712_P30_29 XI1_I1712_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I122_XP_MN1 (XI1_I1712_I122_XP_n1 I1_I1712_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I122_XP_MN0 (I1_I1712_P26_23n I1_I1712_P26_25 XI1_I1712_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I120_XP_MN1 (XI1_I1712_I120_XP_n1 I1_I1712_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I120_XP_MN0 (I1_I1712_P24_21n I1_I1712_P24_23 XI1_I1712_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I177_XP_MN1 (XI1_I1712_I177_XP_n1 I1_I1712_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I177_XP_MN0 (I1_I1712_P26_11n I1_I1712_P26_19 XI1_I1712_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I175_XP_MN1 (XI1_I1712_I175_XP_n1 I1_I1712_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I175_XP_MN0 (I1_I1712_P24_9n I1_I1712_P24_17 XI1_I1712_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I169_XP_MN1 (XI1_I1712_I169_XP_n1 I1_I1712_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I169_XP_MN0 (I1_I1712_P18_3n I1_I1712_P18_11 XI1_I1712_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I167_XP_MN1 (XI1_I1712_I167_XP_n1 I1_I1712_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I167_XP_MN0 (I1_I1712_P16_1n I1_I1712_P16_9 XI1_I1712_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I104_XP_MN1 (XI1_I1712_I104_XP_n1 I1_I1712_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I104_XP_MN0 (I1_I1712_P8_5n I1_I1712_P8_7 XI1_I1712_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I102_XP_MN1 (XI1_I1712_I102_XP_n1 I1_I1712_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I102_XP_MN0 (I1_I1712_P6_3n I1_I1712_P6_5 XI1_I1712_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I100_XP_MN1 (XI1_I1712_I100_XP_n1 I1_I1712_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I100_XP_MN0 (I1_I1712_P4_1n I1_I1712_P4_3 XI1_I1712_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I1_MN1 (XI1_I1712_I1_n1 I1_b25_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I1_MN0 (I1_I1712_gn1 I1_p24_0 XI1_I1712_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I2_MN1 (XI1_I1712_I2_n1 I1_b25_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I2_MN0 (I1_I1712_gn2 I1_p24_1 XI1_I1712_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I5_MN1 (XI1_I1712_I5_n1 I1_b25_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I5_MN0 (I1_I1712_gn5 I1_p24_4 XI1_I1712_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I25_MN1 (XI1_I1574_I25_n1 I1_b22_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I25_MN0 (I1_I1574_gn25 I1_p21_24 XI1_I1574_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I24_MN1 (XI1_I1574_I24_n1 I1_b22_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I24_MN0 (I1_I1574_gn24 I1_p21_23 XI1_I1574_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I126_XP_MN1 (XI1_I1574_I126_XP_n1 I1_I1574_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I126_XP_MN0 (I1_I1574_P30_27n I1_I1574_P30_29 XI1_I1574_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I124_XP_MN1 (XI1_I1574_I124_XP_n1 I1_I1574_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I124_XP_MN0 (I1_I1574_P28_25n I1_I1574_P28_27 XI1_I1574_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I18_MN1 (XI1_I1574_I18_n1 I1_b22_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I18_MN0 (I1_I1574_gn18 I1_p21_17 XI1_I1574_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I17_MN1 (XI1_I1574_I17_n1 I1_b22_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I17_MN0 (I1_I1574_gn17 I1_p21_16 XI1_I1574_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I179_XP_MN1 (XI1_I1574_I179_XP_n1 I1_I1574_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I179_XP_MN0 (I1_I1574_P28_13n I1_I1574_P28_21 XI1_I1574_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I171_XP_MN1 (XI1_I1574_I171_XP_n1 I1_I1574_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I171_XP_MN0 (I1_I1574_P20_5n I1_I1574_P20_13 XI1_I1574_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I102_XP_MN1 (XI1_I1574_I102_XP_n1 I1_I1574_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I102_XP_MN0 (I1_I1574_P6_3n I1_I1574_P6_5 XI1_I1574_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I100_XP_MN1 (XI1_I1574_I100_XP_n1 I1_I1574_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I100_XP_MN0 (I1_I1574_P4_1n I1_I1574_P4_3 XI1_I1574_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I1_MN1 (XI1_I1574_I1_n1 I1_b22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I1_MN0 (I1_I1574_gn1 I1_p21_0 XI1_I1574_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I35_MN1 (XI2_I4_I35_n1 I2_I4_z0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I35_MN0 (I2_I4_z1_3 I2_I4_z0_6 XI2_I4_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I228_MN1 (XI2_I3_I228_n1 I2_XOR_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I228_MN0 (I2_I3_n12_2 I2_I3_SEL_XOR_b3_2 XI2_I3_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I233_MN1 (XI2_I3_I233_n1 I2_I3_n12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I233_MN0 (I2_I3_o12_1 I2_I3_n12_2 XI2_I3_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I229_MN1 (XI2_I3_I229_n1 I2_NOT_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I229_MN0 (I2_I3_n12_3 I2_I3_SEL_NOT_b3_2 XI2_I3_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I216_MN1 (XI2_I3_I216_n1 I2_XOR_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I216_MN0 (I2_I3_n11_2 I2_I3_SEL_XOR_b3_2 XI2_I3_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I250_MN1 (XI2_I3_I250_n1 I2_AND_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I250_MN0 (I2_I3_n14_0 I2_I3_SEL_AND_b3_2 XI2_I3_I250_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I261_MN1 (XI2_I3_I261_n1 I2_I3_q14_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I261_MN0 (Y_14 I2_I3_q14_1 XI2_I3_I261_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I234_MN1 (XI2_I3_I234_n1 I2_I3_n12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I234_MN0 (I2_I3_o12_2 I2_I3_n12_4 XI2_I3_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I175_XP_MN1 (XI2_I1_I42_I175_XP_n1 I2_I1_I42_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I175_XP_MN0 (I2_I1_I42_P24_9n I2_I1_I42_P24_17 XI2_I1_I42_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I111_XP_MN1 (XI2_I1_I42_I111_XP_n1 I2_I1_I42_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I111_XP_MN0 (I2_I1_I42_P15_12n I2_I1_I42_P15_14 XI2_I1_I42_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I113_XP_MN1 (XI2_I1_I42_I113_XP_n1 I2_I1_I42_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I113_XP_MN0 (I2_I1_I42_P17_14n I2_I1_I42_P17_16 XI2_I1_I42_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I115_XP_MN1 (XI2_I1_I42_I115_XP_n1 I2_I1_I42_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I115_XP_MN0 (I2_I1_I42_P19_16n I2_I1_I42_P19_18 XI2_I1_I42_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I117_XP_MN1 (XI2_I1_I42_I117_XP_n1 I2_I1_I42_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I117_XP_MN0 (I2_I1_I42_P21_18n I2_I1_I42_P21_20 XI2_I1_I42_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I178_XP_MN1 (XI2_I1_I42_I178_XP_n1 I2_I1_I42_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I178_XP_MN0 (I2_I1_I42_P27_12n I2_I1_I42_P27_20 XI2_I1_I42_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I119_XP_MN1 (XI2_I1_I42_I119_XP_n1 I2_I1_I42_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I119_XP_MN0 (I2_I1_I42_P23_20n I2_I1_I42_P23_22 XI2_I1_I42_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I121_XP_MN1 (XI2_I1_I42_I121_XP_n1 I2_I1_I42_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I121_XP_MN0 (I2_I1_I42_P25_22n I2_I1_I42_P25_24 XI2_I1_I42_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I123_XP_MN1 (XI2_I1_I42_I123_XP_n1 I2_I1_I42_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I123_XP_MN0 (I2_I1_I42_P27_24n I2_I1_I42_P27_26 XI2_I1_I42_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I125_XP_MN1 (XI2_I1_I42_I125_XP_n1 I2_I1_I42_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I125_XP_MN0 (I2_I1_I42_P29_26n I2_I1_I42_P29_28 XI2_I1_I42_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I30_MN1 (XI2_I1_I42_I30_n1 I2_I1_bx30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I30_MN0 (I2_I1_I42_gn30 A_30 XI2_I1_I42_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I29_MN1 (XI2_I1_I42_I29_n1 I2_I1_bx29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I29_MN0 (I2_I1_I42_gn29 A_29 XI2_I1_I42_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I64_MN1 (XI2_I4_I64_n1 I2_SEL_AS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I64_MN0 (I2_I4_cn I2_CO XI2_I4_I64_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I67_MN1 (XI2_I4_I67_n1 I2_I4_ovf VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I67_MN0 (I2_I4_v1 I2_SEL_AS XI2_I4_I67_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I450_MN1 (XI2_I3_I450_n1 I2_I3_n30_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I450_MN0 (I2_I3_o30_2 I2_I3_n30_4 XI2_I3_I450_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I447_MN1 (XI2_I3_I447_n1 DIVQ_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I447_MN0 (I2_I3_n30_5 I2_I3_SEL_DIV_b3_5 XI2_I3_I447_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I10_MN1 (XI2_I0_I10_n1 OP_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I10_MN0 (I2_I0_l11 OP_1 XI2_I0_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I8_MN1 (XI2_I0_I8_n1 OP_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I8_MN0 (I2_I0_l01 I2_I0_opn1 XI2_I0_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I7_MN1 (XI2_I0_I7_n1 I2_I0_opn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I7_MN0 (I2_I0_l00 I2_I0_opn1 XI2_I0_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I9_MN1 (XI2_I0_I9_n1 I2_I0_opn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I9_MN0 (I2_I0_l10 OP_1 XI2_I0_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I6_MN1 (XI2_I0_I6_n1 I2_I0_opn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I6_MN0 (I2_I0_h10 OP_3 XI2_I0_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I156_MN1 (XI2_I2_I156_n1 B_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I156_MN0 (I2_I2_nand26 A_26 XI2_I2_I156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I453_MN1 (XI2_I3_I453_n1 I2_I3_q30_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I453_MN0 (Y_30 I2_I3_q30_1 XI2_I3_I453_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I442_MN1 (XI2_I3_I442_n1 I2_AND_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I442_MN0 (I2_I3_n30_0 I2_I3_SEL_AND_b3_5 XI2_I3_I442_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I180_MN1 (XI2_I2_I180_n1 B_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I180_MN0 (I2_I2_nand30 A_30 XI2_I2_I180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I186_MN1 (XI2_I2_I186_n1 B_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I186_MN0 (I2_I2_nand31 A_31 XI2_I2_I186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I465_MN1 (XI2_I3_I465_n1 I2_I3_q31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I465_MN0 (Y_31 I2_I3_q31_1 XI2_I3_I465_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I181_XP_MN1 (XI1_I1712_I181_XP_n1 I1_I1712_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I181_XP_MN0 (I1_I1712_P30_15n I1_I1712_P30_23 XI1_I1712_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I173_XP_MN1 (XI1_I1712_I173_XP_n1 I1_I1712_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I173_XP_MN0 (I1_I1712_P22_7n I1_I1712_P22_15 XI1_I1712_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I108_XP_MN1 (XI1_I1712_I108_XP_n1 I1_I1712_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I108_XP_MN0 (I1_I1712_P12_9n I1_I1712_P12_11 XI1_I1712_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I106_XP_MN1 (XI1_I1712_I106_XP_n1 I1_I1712_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I106_XP_MN0 (I1_I1712_P10_7n I1_I1712_P10_9 XI1_I1712_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I6_MN1 (XI1_I1712_I6_n1 I1_b25_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I6_MN0 (I1_I1712_gn6 I1_p24_5 XI1_I1712_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I0_MN1 (XI1_I1666_I0_n1 I1_b24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I0_MN0 (I1_I1666_gn0 I1_aa7 XI1_I1666_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I23_MN1 (XI1_I1574_I23_n1 I1_b22_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I23_MN0 (I1_I1574_gn23 I1_p21_22 XI1_I1574_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I22_MN1 (XI1_I1574_I22_n1 I1_b22_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I22_MN0 (I1_I1574_gn22 I1_p21_21 XI1_I1574_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I122_XP_MN1 (XI1_I1574_I122_XP_n1 I1_I1574_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I122_XP_MN0 (I1_I1574_P26_23n I1_I1574_P26_25 XI1_I1574_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I120_XP_MN1 (XI1_I1574_I120_XP_n1 I1_I1574_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I120_XP_MN0 (I1_I1574_P24_21n I1_I1574_P24_23 XI1_I1574_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I116_XP_MN1 (XI1_I1574_I116_XP_n1 I1_I1574_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I116_XP_MN0 (I1_I1574_P20_17n I1_I1574_P20_19 XI1_I1574_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I114_XP_MN1 (XI1_I1574_I114_XP_n1 I1_I1574_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I114_XP_MN0 (I1_I1574_P18_15n I1_I1574_P18_17 XI1_I1574_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I175_XP_MN1 (XI1_I1574_I175_XP_n1 I1_I1574_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I175_XP_MN0 (I1_I1574_P24_9n I1_I1574_P24_17 XI1_I1574_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I167_XP_MN1 (XI1_I1574_I167_XP_n1 I1_I1574_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I167_XP_MN0 (I1_I1574_P16_1n I1_I1574_P16_9 XI1_I1574_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I232_MN1 (XI2_I3_I232_n1 I2_I3_n12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I232_MN0 (I2_I3_o12_0 I2_I3_n12_0 XI2_I3_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I227_MN1 (XI2_I3_I227_n1 I2_OR_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I227_MN0 (I2_I3_n12_1 I2_I3_SEL_OR_b3_2 XI2_I3_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I226_MN1 (XI2_I3_I226_n1 I2_AND_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I226_MN0 (I2_I3_n12_0 I2_I3_SEL_AND_b3_2 XI2_I3_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I237_MN1 (XI2_I3_I237_n1 I2_I3_q12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I237_MN0 (Y_12 I2_I3_q12_1 XI2_I3_I237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I215_MN1 (XI2_I3_I215_n1 I2_OR_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I215_MN0 (I2_I3_n11_1 I2_I3_SEL_OR_b3_2 XI2_I3_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I220_MN1 (XI2_I3_I220_n1 I2_I3_n11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I220_MN0 (I2_I3_o11_0 I2_I3_n11_0 XI2_I3_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I221_MN1 (XI2_I3_I221_n1 I2_I3_n11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I221_MN0 (I2_I3_o11_1 I2_I3_n11_2 XI2_I3_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I225_MN1 (XI2_I3_I225_n1 I2_I3_q11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I225_MN0 (Y_11 I2_I3_q11_1 XI2_I3_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I84_MN1 (XI2_I2_I84_n1 B_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I84_MN0 (I2_I2_nand14 A_14 XI2_I2_I84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I10_MN1 (XI2_I1_I42_I10_n1 I2_I1_bx10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I10_MN0 (I2_I1_I42_gn10 A_10 XI2_I1_I42_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I108_XP_MN1 (XI2_I1_I42_I108_XP_n1 I2_I1_I42_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I108_XP_MN0 (I2_I1_I42_P12_9n I2_I1_I42_P12_11 XI2_I1_I42_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I169_XP_MN1 (XI2_I1_I42_I169_XP_n1 I2_I1_I42_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I169_XP_MN0 (I2_I1_I42_P18_3n I2_I1_I42_P18_11 XI2_I1_I42_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I172_XP_MN1 (XI2_I1_I42_I172_XP_n1 I2_I1_I42_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I172_XP_MN0 (I2_I1_I42_P21_6n I2_I1_I42_P21_14 XI2_I1_I42_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I174_XP_MN1 (XI2_I1_I42_I174_XP_n1 I2_I1_I42_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I174_XP_MN0 (I2_I1_I42_P23_8n I2_I1_I42_P23_16 XI2_I1_I42_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I180_XP_MN1 (XI2_I1_I42_I180_XP_n1 I2_I1_I42_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I180_XP_MN0 (I2_I1_I42_P29_14n I2_I1_I42_P29_22 XI2_I1_I42_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I182_XP_MN1 (XI2_I1_I42_I182_XP_n1 I2_I1_I42_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I182_XP_MN0 (I2_I1_I42_P31_16n I2_I1_I42_P31_24 XI2_I1_I42_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I127_XP_MN1 (XI2_I1_I42_I127_XP_n1 I2_I1_I42_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I127_XP_MN0 (I2_I1_I42_P31_28n I2_I1_I42_P31_30 XI2_I1_I42_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I31_MN1 (XI2_I1_I42_I31_n1 I2_I1_bx31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I31_MN0 (I2_I1_I42_gn31 A_31 XI2_I1_I42_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I462_MN1 (XI2_I3_I462_n1 I2_I3_n31_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I462_MN0 (I2_I3_o31_2 I2_I3_n31_4 XI2_I3_I462_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I459_MN1 (XI2_I3_I459_n1 DIVQ_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I459_MN0 (I2_I3_n31_5 I2_I3_SEL_DIV_b3_5 XI2_I3_I459_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I30_MN1 (XI1_I1712_I30_n1 I1_b25_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I30_MN0 (I1_I1712_gn30 I1_p24_29 XI1_I1712_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I26_MN1 (XI1_I1712_I26_n1 I1_b25_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I26_MN0 (I1_I1712_gn26 I1_p24_25 XI1_I1712_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I24_MN1 (XI1_I1712_I24_n1 I1_b25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I24_MN0 (I1_I1712_gn24 I1_p24_23 XI1_I1712_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I118_XP_MN1 (XI1_I1712_I118_XP_n1 I1_I1712_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I118_XP_MN0 (I1_I1712_P22_19n I1_I1712_P22_21 XI1_I1712_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I116_XP_MN1 (XI1_I1712_I116_XP_n1 I1_I1712_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I116_XP_MN0 (I1_I1712_P20_17n I1_I1712_P20_19 XI1_I1712_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I114_XP_MN1 (XI1_I1712_I114_XP_n1 I1_I1712_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I114_XP_MN0 (I1_I1712_P18_15n I1_I1712_P18_17 XI1_I1712_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I112_XP_MN1 (XI1_I1712_I112_XP_n1 I1_I1712_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I112_XP_MN0 (I1_I1712_P16_13n I1_I1712_P16_15 XI1_I1712_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I110_XP_MN1 (XI1_I1712_I110_XP_n1 I1_I1712_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I110_XP_MN0 (I1_I1712_P14_11n I1_I1712_P14_13 XI1_I1712_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I8_MN1 (XI1_I1712_I8_n1 I1_b25_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I8_MN0 (I1_I1712_gn8 I1_p24_7 XI1_I1712_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I7_MN1 (XI1_I1712_I7_n1 I1_b25_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I7_MN0 (I1_I1712_gn7 I1_p24_6 XI1_I1712_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I0_MN1 (XI1_I1712_I0_n1 I1_b25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I0_MN0 (I1_I1712_gn0 I1_aa6 XI1_I1712_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I21_MN1 (XI1_I1574_I21_n1 I1_b22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I21_MN0 (I1_I1574_gn21 I1_p21_20 XI1_I1574_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I20_MN1 (XI1_I1574_I20_n1 I1_b22_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I20_MN0 (I1_I1574_gn20 I1_p21_19 XI1_I1574_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I19_MN1 (XI1_I1574_I19_n1 I1_b22_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I19_MN0 (I1_I1574_gn19 I1_p21_18 XI1_I1574_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I118_XP_MN1 (XI1_I1574_I118_XP_n1 I1_I1574_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I118_XP_MN0 (I1_I1574_P22_19n I1_I1574_P22_21 XI1_I1574_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I177_XP_MN1 (XI1_I1574_I177_XP_n1 I1_I1574_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I177_XP_MN0 (I1_I1574_P26_11n I1_I1574_P26_19 XI1_I1574_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I169_XP_MN1 (XI1_I1574_I169_XP_n1 I1_I1574_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I169_XP_MN0 (I1_I1574_P18_3n I1_I1574_P18_11 XI1_I1574_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I72_MN1 (XI2_I2_I72_n1 B_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I72_MN0 (I2_I2_nand12 A_12 XI2_I2_I72_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I66_MN1 (XI2_I2_I66_n1 B_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I66_MN0 (I2_I2_nand11 A_11 XI2_I2_I66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I214_MN1 (XI2_I3_I214_n1 I2_AND_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I214_MN0 (I2_I3_n11_0 I2_I3_SEL_AND_b3_2 XI2_I3_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2278_MN1 (XI1_I2278_n1 I1_z0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2278_MN0 (I1_z1_0 I1_z0_0 XI1_I2278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2279_MN1 (XI1_I2279_n1 I1_z0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2279_MN0 (I1_z1_1 I1_z0_2 XI1_I2279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I9_MN1 (XI2_I1_I42_I9_n1 I2_I1_bx9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I9_MN0 (I2_I1_I42_gn9 A_9 XI2_I1_I42_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I106_XP_MN1 (XI2_I1_I42_I106_XP_n1 I2_I1_I42_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I106_XP_MN0 (I2_I1_I42_P10_7n I2_I1_I42_P10_9 XI2_I1_I42_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I167_XP_MN1 (XI2_I1_I42_I167_XP_n1 I2_I1_I42_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I167_XP_MN0 (I2_I1_I42_P16_1n I2_I1_I42_P16_9 XI2_I1_I42_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I107_XP_MN1 (XI2_I1_I42_I107_XP_n1 I2_I1_I42_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I107_XP_MN0 (I2_I1_I42_P11_8n I2_I1_I42_P11_10 XI2_I1_I42_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I109_XP_MN1 (XI2_I1_I42_I109_XP_n1 I2_I1_I42_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I109_XP_MN0 (I2_I1_I42_P13_10n I2_I1_I42_P13_12 XI2_I1_I42_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I170_XP_MN1 (XI2_I1_I42_I170_XP_n1 I2_I1_I42_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I170_XP_MN0 (I2_I1_I42_P19_4n I2_I1_I42_P19_12 XI2_I1_I42_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I176_XP_MN1 (XI2_I1_I42_I176_XP_n1 I2_I1_I42_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I176_XP_MN0 (I2_I1_I42_P25_10n I2_I1_I42_P25_18 XI2_I1_I42_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I25_MN1 (XI1_I1712_I25_n1 I1_b25_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I25_MN0 (I1_I1712_gn25 I1_p24_24 XI1_I1712_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I11_MN1 (XI1_I1712_I11_n1 I1_b25_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I11_MN0 (I1_I1712_gn11 I1_p24_10 XI1_I1712_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I10_MN1 (XI1_I1712_I10_n1 I1_b25_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I10_MN0 (I1_I1712_gn10 I1_p24_9 XI1_I1712_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I9_MN1 (XI1_I1712_I9_n1 I1_b25_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I9_MN0 (I1_I1712_gn9 I1_p24_8 XI1_I1712_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I1_MN1 (XI1_I1666_I1_n1 I1_b24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I1_MN0 (I1_I1666_gn1 I1_p23_0 XI1_I1666_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I2_MN1 (XI1_I1666_I2_n1 I1_b24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I2_MN0 (I1_I1666_gn2 I1_p23_1 XI1_I1666_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I3_MN1 (XI1_I1666_I3_n1 I1_b24_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I3_MN0 (I1_I1666_gn3 I1_p23_2 XI1_I1666_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I181_XP_MN1 (XI1_I1574_I181_XP_n1 I1_I1574_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I181_XP_MN0 (I1_I1574_P30_15n I1_I1574_P30_23 XI1_I1574_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I173_XP_MN1 (XI1_I1574_I173_XP_n1 I1_I1574_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I173_XP_MN0 (I1_I1574_P22_7n I1_I1574_P22_15 XI1_I1574_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I4_MN1 (XI1_I1620_I4_n1 I1_b23_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I4_MN0 (I1_I1620_gn4 I1_p22_3 XI1_I1620_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I0_MN1 (XI1_I1574_I0_n1 I1_b22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I0_MN0 (I1_I1574_gn0 I1_aa9 XI1_I1574_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I8_MN1 (XI2_I1_I42_I8_n1 I2_I1_bx8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I8_MN0 (I2_I1_I42_gn8 A_8 XI2_I1_I42_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I104_XP_MN1 (XI2_I1_I42_I104_XP_n1 I2_I1_I42_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I104_XP_MN0 (I2_I1_I42_P8_5n I2_I1_I42_P8_7 XI2_I1_I42_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I105_XP_MN1 (XI2_I1_I42_I105_XP_n1 I2_I1_I42_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I105_XP_MN0 (I2_I1_I42_P9_6n I2_I1_I42_P9_8 XI2_I1_I42_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I168_XP_MN1 (XI2_I1_I42_I168_XP_n1 I2_I1_I42_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I168_XP_MN0 (I2_I1_I42_P17_2n I2_I1_I42_P17_10 XI2_I1_I42_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I31_MN1 (XI1_I1712_I31_n1 I1_b25_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I31_MN0 (I1_I1712_gn31 I1_p24_30 XI1_I1712_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I22_MN1 (XI1_I1712_I22_n1 I1_b25_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I22_MN0 (I1_I1712_gn22 I1_p24_21 XI1_I1712_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I20_MN1 (XI1_I1712_I20_n1 I1_b25_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I20_MN0 (I1_I1712_gn20 I1_p24_19 XI1_I1712_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I18_MN1 (XI1_I1712_I18_n1 I1_b25_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I18_MN0 (I1_I1712_gn18 I1_p24_17 XI1_I1712_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I15_MN1 (XI1_I1712_I15_n1 I1_b25_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I15_MN0 (I1_I1712_gn15 I1_p24_14 XI1_I1712_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I12_MN1 (XI1_I1712_I12_n1 I1_b25_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I12_MN0 (I1_I1712_gn12 I1_p24_11 XI1_I1712_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I167_XP_MN1 (XI1_I1666_I167_XP_n1 I1_I1666_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I167_XP_MN0 (I1_I1666_P16_1n I1_I1666_P16_9 XI1_I1666_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I100_XP_MN1 (XI1_I1666_I100_XP_n1 I1_I1666_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I100_XP_MN0 (I1_I1666_P4_1n I1_I1666_P4_3 XI1_I1666_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I102_XP_MN1 (XI1_I1666_I102_XP_n1 I1_I1666_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I102_XP_MN0 (I1_I1666_P6_3n I1_I1666_P6_5 XI1_I1666_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I101_XP_MN1 (XI1_I1666_I101_XP_n1 I1_I1666_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I101_XP_MN0 (I1_I1666_P5_2n I1_I1666_P5_4 XI1_I1666_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I4_MN1 (XI1_I1666_I4_n1 I1_b24_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I4_MN0 (I1_I1666_gn4 I1_p23_3 XI1_I1666_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I8_MN1 (XI1_I1620_I8_n1 I1_b23_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I8_MN0 (I1_I1620_gn8 I1_p22_7 XI1_I1620_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I3_MN1 (XI1_I1620_I3_n1 I1_b23_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I3_MN0 (I1_I1620_gn3 I1_p22_2 XI1_I1620_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I7_MN1 (XI2_I1_I42_I7_n1 I2_I1_bx7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I7_MN0 (I2_I1_I42_gn7 A_7 XI2_I1_I42_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I6_MN1 (XI2_I1_I42_I6_n1 I2_I1_bx6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I6_MN0 (I2_I1_I42_gn6 A_6 XI2_I1_I42_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I102_XP_MN1 (XI2_I1_I42_I102_XP_n1 I2_I1_I42_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I102_XP_MN0 (I2_I1_I42_P6_3n I2_I1_I42_P6_5 XI2_I1_I42_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I103_XP_MN1 (XI2_I1_I42_I103_XP_n1 I2_I1_I42_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I103_XP_MN0 (I2_I1_I42_P7_4n I2_I1_I42_P7_6 XI2_I1_I42_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I28_MN1 (XI1_I1758_I28_n1 I1_b26_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I28_MN0 (I1_I1758_gn28 I1_p25_27 XI1_I1758_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I27_MN1 (XI1_I1758_I27_n1 I1_b26_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I27_MN0 (I1_I1758_gn27 I1_p25_26 XI1_I1758_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I23_MN1 (XI1_I1712_I23_n1 I1_b25_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I23_MN0 (I1_I1712_gn23 I1_p24_22 XI1_I1712_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I21_MN1 (XI1_I1712_I21_n1 I1_b25_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I21_MN0 (I1_I1712_gn21 I1_p24_20 XI1_I1712_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I19_MN1 (XI1_I1712_I19_n1 I1_b25_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I19_MN0 (I1_I1712_gn19 I1_p24_18 XI1_I1712_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I17_MN1 (XI1_I1712_I17_n1 I1_b25_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I17_MN0 (I1_I1712_gn17 I1_p24_16 XI1_I1712_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I16_MN1 (XI1_I1712_I16_n1 I1_b25_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I16_MN0 (I1_I1712_gn16 I1_p24_15 XI1_I1712_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I14_MN1 (XI1_I1712_I14_n1 I1_b25_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I14_MN0 (I1_I1712_gn14 I1_p24_13 XI1_I1712_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I169_XP_MN1 (XI1_I1666_I169_XP_n1 I1_I1666_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I169_XP_MN0 (I1_I1666_P18_3n I1_I1666_P18_11 XI1_I1666_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I104_XP_MN1 (XI1_I1666_I104_XP_n1 I1_I1666_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I104_XP_MN0 (I1_I1666_P8_5n I1_I1666_P8_7 XI1_I1666_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I103_XP_MN1 (XI1_I1666_I103_XP_n1 I1_I1666_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I103_XP_MN0 (I1_I1666_P7_4n I1_I1666_P7_6 XI1_I1666_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I5_MN1 (XI1_I1666_I5_n1 I1_b24_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I5_MN0 (I1_I1666_gn5 I1_p23_4 XI1_I1666_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I6_MN1 (XI1_I1666_I6_n1 I1_b24_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I6_MN0 (I1_I1666_gn6 I1_p23_5 XI1_I1666_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I8_MN1 (XI1_I1666_I8_n1 I1_b24_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I8_MN0 (I1_I1666_gn8 I1_p23_7 XI1_I1666_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I13_MN1 (XI1_I1620_I13_n1 I1_b23_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I13_MN0 (I1_I1620_gn13 I1_p22_12 XI1_I1620_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I11_MN1 (XI1_I1620_I11_n1 I1_b23_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I11_MN0 (I1_I1620_gn11 I1_p22_10 XI1_I1620_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I9_MN1 (XI1_I1620_I9_n1 I1_b23_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I9_MN0 (I1_I1620_gn9 I1_p22_8 XI1_I1620_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I6_MN1 (XI1_I1620_I6_n1 I1_b23_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I6_MN0 (I1_I1620_gn6 I1_p22_5 XI1_I1620_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I5_MN1 (XI1_I1620_I5_n1 I1_b23_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I5_MN0 (I1_I1620_gn5 I1_p22_4 XI1_I1620_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I0_MN1 (XI1_I1620_I0_n1 I1_b23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I0_MN0 (I1_I1620_gn0 I1_aa8 XI1_I1620_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I219_MN1 (XI2_I3_I219_n1 DIVQ_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I219_MN0 (I2_I3_n11_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I222_MN1 (XI2_I3_I222_n1 I2_I3_n11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I222_MN0 (I2_I3_o11_2 I2_I3_n11_4 XI2_I3_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I5_MN1 (XI2_I1_I42_I5_n1 I2_I1_bx5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I5_MN0 (I2_I1_I42_gn5 A_5 XI2_I1_I42_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I100_XP_MN1 (XI2_I1_I42_I100_XP_n1 I2_I1_I42_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I100_XP_MN0 (I2_I1_I42_P4_1n I2_I1_I42_P4_3 XI2_I1_I42_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I101_XP_MN1 (XI2_I1_I42_I101_XP_n1 I2_I1_I42_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I101_XP_MN0 (I2_I1_I42_P5_2n I2_I1_I42_P5_4 XI2_I1_I42_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I29_MN1 (XI1_I1758_I29_n1 I1_b26_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I29_MN0 (I1_I1758_gn29 I1_p25_28 XI1_I1758_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I25_MN1 (XI1_I1758_I25_n1 I1_b26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I25_MN0 (I1_I1758_gn25 I1_p25_24 XI1_I1758_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I24_MN1 (XI1_I1758_I24_n1 I1_b26_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I24_MN0 (I1_I1758_gn24 I1_p25_23 XI1_I1758_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I13_MN1 (XI1_I1712_I13_n1 I1_b25_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I13_MN0 (I1_I1712_gn13 I1_p24_12 XI1_I1712_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I106_XP_MN1 (XI1_I1666_I106_XP_n1 I1_I1666_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I106_XP_MN0 (I1_I1666_P10_7n I1_I1666_P10_9 XI1_I1666_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I108_XP_MN1 (XI1_I1666_I108_XP_n1 I1_I1666_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I108_XP_MN0 (I1_I1666_P12_9n I1_I1666_P12_11 XI1_I1666_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I168_XP_MN1 (XI1_I1666_I168_XP_n1 I1_I1666_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I168_XP_MN0 (I1_I1666_P17_2n I1_I1666_P17_10 XI1_I1666_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I105_XP_MN1 (XI1_I1666_I105_XP_n1 I1_I1666_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I105_XP_MN0 (I1_I1666_P9_6n I1_I1666_P9_8 XI1_I1666_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I7_MN1 (XI1_I1666_I7_n1 I1_b24_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I7_MN0 (I1_I1666_gn7 I1_p23_6 XI1_I1666_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I9_MN1 (XI1_I1666_I9_n1 I1_b24_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I9_MN0 (I1_I1666_gn9 I1_p23_8 XI1_I1666_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I10_MN1 (XI1_I1620_I10_n1 I1_b23_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I10_MN0 (I1_I1620_gn10 I1_p22_9 XI1_I1620_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I7_MN1 (XI1_I1620_I7_n1 I1_b23_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I7_MN0 (I1_I1620_gn7 I1_p22_6 XI1_I1620_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I2_MN1 (XI1_I1620_I2_n1 I1_b23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I2_MN0 (I1_I1620_gn2 I1_p22_1 XI1_I1620_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I1_MN1 (XI1_I1620_I1_n1 I1_b23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I1_MN0 (I1_I1620_gn1 I1_p22_0 XI1_I1620_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I54_MN1 (XI2_I2_I54_n1 B_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I54_MN0 (I2_I2_nand9 A_9 XI2_I2_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I191_MN1 (XI2_I3_I191_n1 I2_OR_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I191_MN0 (I2_I3_n9_1 I2_I3_SEL_OR_b3_1 XI2_I3_I191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I48_MN1 (XI2_I2_I48_n1 B_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I48_MN0 (I2_I2_nand8 A_8 XI2_I2_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I26_MN1 (XI1_I1758_I26_n1 I1_b26_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I26_MN0 (I1_I1758_gn26 I1_p25_25 XI1_I1758_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I23_MN1 (XI1_I1758_I23_n1 I1_b26_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I23_MN0 (I1_I1758_gn23 I1_p25_22 XI1_I1758_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I20_MN1 (XI1_I1758_I20_n1 I1_b26_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I20_MN0 (I1_I1758_gn20 I1_p25_19 XI1_I1758_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I21_MN1 (XI1_I1758_I21_n1 I1_b26_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I21_MN0 (I1_I1758_gn21 I1_p25_20 XI1_I1758_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I19_MN1 (XI1_I1758_I19_n1 I1_b26_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I19_MN0 (I1_I1758_gn19 I1_p25_18 XI1_I1758_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I18_MN1 (XI1_I1758_I18_n1 I1_b26_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I18_MN0 (I1_I1758_gn18 I1_p25_17 XI1_I1758_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I16_MN1 (XI1_I1758_I16_n1 I1_b26_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I16_MN0 (I1_I1758_gn16 I1_p25_15 XI1_I1758_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I15_MN1 (XI1_I1758_I15_n1 I1_b26_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I15_MN0 (I1_I1758_gn15 I1_p25_14 XI1_I1758_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I14_MN1 (XI1_I1758_I14_n1 I1_b26_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I14_MN0 (I1_I1758_gn14 I1_p25_13 XI1_I1758_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I13_MN1 (XI1_I1758_I13_n1 I1_b26_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I13_MN0 (I1_I1758_gn13 I1_p25_12 XI1_I1758_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I12_MN1 (XI1_I1758_I12_n1 I1_b26_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I12_MN0 (I1_I1758_gn12 I1_p25_11 XI1_I1758_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I171_XP_MN1 (XI1_I1666_I171_XP_n1 I1_I1666_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I171_XP_MN0 (I1_I1666_P20_5n I1_I1666_P20_13 XI1_I1666_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I175_XP_MN1 (XI1_I1666_I175_XP_n1 I1_I1666_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I175_XP_MN0 (I1_I1666_P24_9n I1_I1666_P24_17 XI1_I1666_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I170_XP_MN1 (XI1_I1666_I170_XP_n1 I1_I1666_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I170_XP_MN0 (I1_I1666_P19_4n I1_I1666_P19_12 XI1_I1666_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I109_XP_MN1 (XI1_I1666_I109_XP_n1 I1_I1666_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I109_XP_MN0 (I1_I1666_P13_10n I1_I1666_P13_12 XI1_I1666_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I107_XP_MN1 (XI1_I1666_I107_XP_n1 I1_I1666_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I107_XP_MN0 (I1_I1666_P11_8n I1_I1666_P11_10 XI1_I1666_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I11_MN1 (XI1_I1666_I11_n1 I1_b24_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I11_MN0 (I1_I1666_gn11 I1_p23_10 XI1_I1666_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I10_MN1 (XI1_I1666_I10_n1 I1_b24_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I10_MN0 (I1_I1666_gn10 I1_p23_9 XI1_I1666_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I15_MN1 (XI1_I1620_I15_n1 I1_b23_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I15_MN0 (I1_I1620_gn15 I1_p22_14 XI1_I1620_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I16_MN1 (XI1_I1620_I16_n1 I1_b23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I16_MN0 (I1_I1620_gn16 I1_p22_15 XI1_I1620_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I14_MN1 (XI1_I1620_I14_n1 I1_b23_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I14_MN0 (I1_I1620_gn14 I1_p22_13 XI1_I1620_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I12_MN1 (XI1_I1620_I12_n1 I1_b23_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I12_MN0 (I1_I1620_gn12 I1_p22_11 XI1_I1620_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I60_MN1 (XI2_I2_I60_n1 B_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I60_MN0 (I2_I2_nand10 A_10 XI2_I2_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I190_MN1 (XI2_I3_I190_n1 I2_AND_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I190_MN0 (I2_I3_n9_0 I2_I3_SEL_AND_b3_1 XI2_I3_I190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I202_MN1 (XI2_I3_I202_n1 I2_AND_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I202_MN0 (I2_I3_n10_0 I2_I3_SEL_AND_b3_1 XI2_I3_I202_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I196_MN1 (XI2_I3_I196_n1 I2_I3_n9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I196_MN0 (I2_I3_o9_0 I2_I3_n9_0 XI2_I3_I196_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I178_MN1 (XI2_I3_I178_n1 I2_AND_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I178_MN0 (I2_I3_n8_0 I2_I3_SEL_AND_b3_1 XI2_I3_I178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I42_MN1 (XI2_I2_I42_n1 B_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I42_MN0 (I2_I2_nand7 A_7 XI2_I2_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I184_MN1 (XI2_I3_I184_n1 I2_I3_n8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I184_MN0 (I2_I3_o8_0 I2_I3_n8_0 XI2_I3_I184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I179_MN1 (XI2_I3_I179_n1 I2_OR_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I179_MN0 (I2_I3_n8_1 I2_I3_SEL_OR_b3_1 XI2_I3_I179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I36_MN1 (XI2_I2_I36_n1 B_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I36_MN0 (I2_I2_nand6 A_6 XI2_I2_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I31_MN1 (XI1_I1758_I31_n1 I1_b26_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I31_MN0 (I1_I1758_gn31 I1_p25_30 XI1_I1758_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I22_MN1 (XI1_I1758_I22_n1 I1_b26_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I22_MN0 (I1_I1758_gn22 I1_p25_21 XI1_I1758_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I17_MN1 (XI1_I1758_I17_n1 I1_b26_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I17_MN0 (I1_I1758_gn17 I1_p25_16 XI1_I1758_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I11_MN1 (XI1_I1758_I11_n1 I1_b26_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I11_MN0 (I1_I1758_gn11 I1_p25_10 XI1_I1758_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I177_XP_MN1 (XI1_I1666_I177_XP_n1 I1_I1666_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I177_XP_MN0 (I1_I1666_P26_11n I1_I1666_P26_19 XI1_I1666_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I112_XP_MN1 (XI1_I1666_I112_XP_n1 I1_I1666_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I112_XP_MN0 (I1_I1666_P16_13n I1_I1666_P16_15 XI1_I1666_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I110_XP_MN1 (XI1_I1666_I110_XP_n1 I1_I1666_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I110_XP_MN0 (I1_I1666_P14_11n I1_I1666_P14_13 XI1_I1666_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I176_XP_MN1 (XI1_I1666_I176_XP_n1 I1_I1666_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I176_XP_MN0 (I1_I1666_P25_10n I1_I1666_P25_18 XI1_I1666_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I12_MN1 (XI1_I1666_I12_n1 I1_b24_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I12_MN0 (I1_I1666_gn12 I1_p23_11 XI1_I1666_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I13_MN1 (XI1_I1666_I13_n1 I1_b24_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I13_MN0 (I1_I1666_gn13 I1_p23_12 XI1_I1666_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I17_MN1 (XI1_I1620_I17_n1 I1_b23_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I17_MN0 (I1_I1620_gn17 I1_p22_16 XI1_I1620_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I106_XP_MN1 (XI1_I1620_I106_XP_n1 I1_I1620_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I106_XP_MN0 (I1_I1620_P10_7n I1_I1620_P10_9 XI1_I1620_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I104_XP_MN1 (XI1_I1620_I104_XP_n1 I1_I1620_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I104_XP_MN0 (I1_I1620_P8_5n I1_I1620_P8_7 XI1_I1620_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I102_XP_MN1 (XI1_I1620_I102_XP_n1 I1_I1620_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I102_XP_MN0 (I1_I1620_P6_3n I1_I1620_P6_5 XI1_I1620_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I100_XP_MN1 (XI1_I1620_I100_XP_n1 I1_I1620_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I100_XP_MN0 (I1_I1620_P4_1n I1_I1620_P4_3 XI1_I1620_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I208_MN1 (XI2_I3_I208_n1 I2_I3_n10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I208_MN0 (I2_I3_o10_0 I2_I3_n10_0 XI2_I3_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I203_MN1 (XI2_I3_I203_n1 I2_OR_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I203_MN0 (I2_I3_n10_1 I2_I3_SEL_OR_b3_1 XI2_I3_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I166_MN1 (XI2_I3_I166_n1 I2_AND_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I166_MN0 (I2_I3_n7_0 I2_I3_SEL_AND_b3_1 XI2_I3_I166_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I167_MN1 (XI2_I3_I167_n1 I2_OR_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I167_MN0 (I2_I3_n7_1 I2_I3_SEL_OR_b3_1 XI2_I3_I167_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I172_MN1 (XI2_I3_I172_n1 I2_I3_n7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I172_MN0 (I2_I3_o7_0 I2_I3_n7_0 XI2_I3_I172_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I154_MN1 (XI2_I3_I154_n1 I2_AND_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I154_MN0 (I2_I3_n6_0 I2_I3_SEL_AND_b3_1 XI2_I3_I154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I160_MN1 (XI2_I3_I160_n1 I2_I3_n6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I160_MN0 (I2_I3_o6_0 I2_I3_n6_0 XI2_I3_I160_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I155_MN1 (XI2_I3_I155_n1 I2_OR_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I155_MN0 (I2_I3_n6_1 I2_I3_SEL_OR_b3_1 XI2_I3_I155_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I2_MN1 (XI2_I1_I42_I2_n1 I2_I1_bx2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I2_MN0 (I2_I1_I42_gn2 A_2 XI2_I1_I42_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I1_MN1 (XI2_I1_I42_I1_n1 I2_I1_bx1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I1_MN0 (I2_I1_I42_gn1 A_1 XI2_I1_I42_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I30_MN1 (XI1_I1758_I30_n1 I1_b26_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I30_MN0 (I1_I1758_gn30 I1_p25_29 XI1_I1758_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I125_XP_MN1 (XI1_I1758_I125_XP_n1 I1_I1758_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I125_XP_MN0 (I1_I1758_P29_26n I1_I1758_P29_28 XI1_I1758_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I123_XP_MN1 (XI1_I1758_I123_XP_n1 I1_I1758_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I123_XP_MN0 (I1_I1758_P27_24n I1_I1758_P27_26 XI1_I1758_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I121_XP_MN1 (XI1_I1758_I121_XP_n1 I1_I1758_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I121_XP_MN0 (I1_I1758_P25_22n I1_I1758_P25_24 XI1_I1758_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I119_XP_MN1 (XI1_I1758_I119_XP_n1 I1_I1758_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I119_XP_MN0 (I1_I1758_P23_20n I1_I1758_P23_22 XI1_I1758_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I117_XP_MN1 (XI1_I1758_I117_XP_n1 I1_I1758_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I117_XP_MN0 (I1_I1758_P21_18n I1_I1758_P21_20 XI1_I1758_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I10_MN1 (XI1_I1758_I10_n1 I1_b26_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I10_MN0 (I1_I1758_gn10 I1_p25_9 XI1_I1758_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I8_MN1 (XI1_I1758_I8_n1 I1_b26_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I8_MN0 (I1_I1758_gn8 I1_p25_7 XI1_I1758_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I179_XP_MN1 (XI1_I1666_I179_XP_n1 I1_I1666_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I179_XP_MN0 (I1_I1666_P28_13n I1_I1666_P28_21 XI1_I1666_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I114_XP_MN1 (XI1_I1666_I114_XP_n1 I1_I1666_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I114_XP_MN0 (I1_I1666_P18_15n I1_I1666_P18_17 XI1_I1666_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I178_XP_MN1 (XI1_I1666_I178_XP_n1 I1_I1666_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I178_XP_MN0 (I1_I1666_P27_12n I1_I1666_P27_20 XI1_I1666_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I172_XP_MN1 (XI1_I1666_I172_XP_n1 I1_I1666_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I172_XP_MN0 (I1_I1666_P21_6n I1_I1666_P21_14 XI1_I1666_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I111_XP_MN1 (XI1_I1666_I111_XP_n1 I1_I1666_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I111_XP_MN0 (I1_I1666_P15_12n I1_I1666_P15_14 XI1_I1666_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I113_XP_MN1 (XI1_I1666_I113_XP_n1 I1_I1666_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I113_XP_MN0 (I1_I1666_P17_14n I1_I1666_P17_16 XI1_I1666_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I14_MN1 (XI1_I1666_I14_n1 I1_b24_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I14_MN0 (I1_I1666_gn14 I1_p23_13 XI1_I1666_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I16_MN1 (XI1_I1666_I16_n1 I1_b24_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I16_MN0 (I1_I1666_gn16 I1_p23_15 XI1_I1666_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I169_XP_MN1 (XI1_I1620_I169_XP_n1 I1_I1620_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I169_XP_MN0 (I1_I1620_P18_3n I1_I1620_P18_11 XI1_I1620_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I110_XP_MN1 (XI1_I1620_I110_XP_n1 I1_I1620_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I110_XP_MN0 (I1_I1620_P14_11n I1_I1620_P14_13 XI1_I1620_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I108_XP_MN1 (XI1_I1620_I108_XP_n1 I1_I1620_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I108_XP_MN0 (I1_I1620_P12_9n I1_I1620_P12_11 XI1_I1620_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I103_XP_MN1 (XI1_I1620_I103_XP_n1 I1_I1620_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I103_XP_MN0 (I1_I1620_P7_4n I1_I1620_P7_6 XI1_I1620_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I101_XP_MN1 (XI1_I1620_I101_XP_n1 I1_I1620_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I101_XP_MN0 (I1_I1620_P5_2n I1_I1620_P5_4 XI1_I1620_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I205_MN1 (XI2_I3_I205_n1 I2_NOT_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I205_MN0 (I2_I3_n10_3 I2_I3_SEL_NOT_b3_1 XI2_I3_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I209_MN1 (XI2_I3_I209_n1 I2_I3_n10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I209_MN0 (I2_I3_o10_1 I2_I3_n10_2 XI2_I3_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I173_MN1 (XI2_I3_I173_n1 I2_I3_n7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I173_MN0 (I2_I3_o7_1 I2_I3_n7_2 XI2_I3_I173_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I169_MN1 (XI2_I3_I169_n1 I2_NOT_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I169_MN0 (I2_I3_n7_3 I2_I3_SEL_NOT_b3_1 XI2_I3_I169_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I168_MN1 (XI2_I3_I168_n1 I2_XOR_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I168_MN0 (I2_I3_n7_2 I2_I3_SEL_XOR_b3_1 XI2_I3_I168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I157_MN1 (XI2_I3_I157_n1 I2_NOT_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I157_MN0 (I2_I3_n6_3 I2_I3_SEL_NOT_b3_1 XI2_I3_I157_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I161_MN1 (XI2_I3_I161_n1 I2_I3_n6_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I161_MN0 (I2_I3_o6_1 I2_I3_n6_2 XI2_I3_I161_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I127_XP_MN1 (XI1_I1758_I127_XP_n1 I1_I1758_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I127_XP_MN0 (I1_I1758_P31_28n I1_I1758_P31_30 XI1_I1758_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I176_XP_MN1 (XI1_I1758_I176_XP_n1 I1_I1758_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I176_XP_MN0 (I1_I1758_P25_10n I1_I1758_P25_18 XI1_I1758_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I115_XP_MN1 (XI1_I1758_I115_XP_n1 I1_I1758_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I115_XP_MN0 (I1_I1758_P19_16n I1_I1758_P19_18 XI1_I1758_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I113_XP_MN1 (XI1_I1758_I113_XP_n1 I1_I1758_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I113_XP_MN0 (I1_I1758_P17_14n I1_I1758_P17_16 XI1_I1758_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I111_XP_MN1 (XI1_I1758_I111_XP_n1 I1_I1758_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I111_XP_MN0 (I1_I1758_P15_12n I1_I1758_P15_14 XI1_I1758_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I9_MN1 (XI1_I1758_I9_n1 I1_b26_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I9_MN0 (I1_I1758_gn9 I1_p25_8 XI1_I1758_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I7_MN1 (XI1_I1758_I7_n1 I1_b26_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I7_MN0 (I1_I1758_gn7 I1_p25_6 XI1_I1758_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I6_MN1 (XI1_I1758_I6_n1 I1_b26_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I6_MN0 (I1_I1758_gn6 I1_p25_5 XI1_I1758_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I173_XP_MN1 (XI1_I1666_I173_XP_n1 I1_I1666_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I173_XP_MN0 (I1_I1666_P22_7n I1_I1666_P22_15 XI1_I1666_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I116_XP_MN1 (XI1_I1666_I116_XP_n1 I1_I1666_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I116_XP_MN0 (I1_I1666_P20_17n I1_I1666_P20_19 XI1_I1666_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I180_XP_MN1 (XI1_I1666_I180_XP_n1 I1_I1666_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I180_XP_MN0 (I1_I1666_P29_14n I1_I1666_P29_22 XI1_I1666_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I117_XP_MN1 (XI1_I1666_I117_XP_n1 I1_I1666_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I117_XP_MN0 (I1_I1666_P21_18n I1_I1666_P21_20 XI1_I1666_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I115_XP_MN1 (XI1_I1666_I115_XP_n1 I1_I1666_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I115_XP_MN0 (I1_I1666_P19_16n I1_I1666_P19_18 XI1_I1666_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I15_MN1 (XI1_I1666_I15_n1 I1_b24_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I15_MN0 (I1_I1666_gn15 I1_p23_14 XI1_I1666_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I18_MN1 (XI1_I1666_I18_n1 I1_b24_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I18_MN0 (I1_I1666_gn18 I1_p23_17 XI1_I1666_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I17_MN1 (XI1_I1666_I17_n1 I1_b24_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I17_MN0 (I1_I1666_gn17 I1_p23_16 XI1_I1666_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I177_XP_MN1 (XI1_I1620_I177_XP_n1 I1_I1620_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I177_XP_MN0 (I1_I1620_P26_11n I1_I1620_P26_19 XI1_I1620_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I114_XP_MN1 (XI1_I1620_I114_XP_n1 I1_I1620_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I114_XP_MN0 (I1_I1620_P18_15n I1_I1620_P18_17 XI1_I1620_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I112_XP_MN1 (XI1_I1620_I112_XP_n1 I1_I1620_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I112_XP_MN0 (I1_I1620_P16_13n I1_I1620_P16_15 XI1_I1620_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I107_XP_MN1 (XI1_I1620_I107_XP_n1 I1_I1620_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I107_XP_MN0 (I1_I1620_P11_8n I1_I1620_P11_10 XI1_I1620_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I105_XP_MN1 (XI1_I1620_I105_XP_n1 I1_I1620_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I105_XP_MN0 (I1_I1620_P9_6n I1_I1620_P9_8 XI1_I1620_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I167_XP_MN1 (XI1_I1620_I167_XP_n1 I1_I1620_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I167_XP_MN0 (I1_I1620_P16_1n I1_I1620_P16_9 XI1_I1620_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I204_MN1 (XI2_I3_I204_n1 I2_XOR_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I204_MN0 (I2_I3_n10_2 I2_I3_SEL_XOR_b3_1 XI2_I3_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I197_MN1 (XI2_I3_I197_n1 I2_I3_n9_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I197_MN0 (I2_I3_o9_1 I2_I3_n9_2 XI2_I3_I197_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I193_MN1 (XI2_I3_I193_n1 I2_NOT_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I193_MN0 (I2_I3_n9_3 I2_I3_SEL_NOT_b3_1 XI2_I3_I193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I181_MN1 (XI2_I3_I181_n1 I2_NOT_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I181_MN0 (I2_I3_n8_3 I2_I3_SEL_NOT_b3_1 XI2_I3_I181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I156_MN1 (XI2_I3_I156_n1 I2_XOR_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I156_MN0 (I2_I3_n6_2 I2_I3_SEL_XOR_b3_1 XI2_I3_I156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I177_MN1 (XI2_I3_I177_n1 I2_I3_q7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I177_MN0 (Y_7 I2_I3_q7_1 XI2_I3_I177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I213_MN1 (XI2_I3_I213_n1 I2_I3_q10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I213_MN0 (Y_10 I2_I3_q10_1 XI2_I3_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I0_MN1 (XI2_I1_I42_I0_n1 I2_I1_bx0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I0_MN0 (I2_I1_I42_gn0 A_0 XI2_I1_I42_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I182_XP_MN1 (XI1_I1758_I182_XP_n1 I1_I1758_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I182_XP_MN0 (I1_I1758_P31_16n I1_I1758_P31_24 XI1_I1758_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I180_XP_MN1 (XI1_I1758_I180_XP_n1 I1_I1758_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I180_XP_MN0 (I1_I1758_P29_14n I1_I1758_P29_22 XI1_I1758_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I174_XP_MN1 (XI1_I1758_I174_XP_n1 I1_I1758_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I174_XP_MN0 (I1_I1758_P23_8n I1_I1758_P23_16 XI1_I1758_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I178_XP_MN1 (XI1_I1758_I178_XP_n1 I1_I1758_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I178_XP_MN0 (I1_I1758_P27_12n I1_I1758_P27_20 XI1_I1758_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I172_XP_MN1 (XI1_I1758_I172_XP_n1 I1_I1758_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I172_XP_MN0 (I1_I1758_P21_6n I1_I1758_P21_14 XI1_I1758_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I170_XP_MN1 (XI1_I1758_I170_XP_n1 I1_I1758_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I170_XP_MN0 (I1_I1758_P19_4n I1_I1758_P19_12 XI1_I1758_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I109_XP_MN1 (XI1_I1758_I109_XP_n1 I1_I1758_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I109_XP_MN0 (I1_I1758_P13_10n I1_I1758_P13_12 XI1_I1758_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I107_XP_MN1 (XI1_I1758_I107_XP_n1 I1_I1758_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I107_XP_MN0 (I1_I1758_P11_8n I1_I1758_P11_10 XI1_I1758_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I105_XP_MN1 (XI1_I1758_I105_XP_n1 I1_I1758_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I105_XP_MN0 (I1_I1758_P9_6n I1_I1758_P9_8 XI1_I1758_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I181_XP_MN1 (XI1_I1666_I181_XP_n1 I1_I1666_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I181_XP_MN0 (I1_I1666_P30_15n I1_I1666_P30_23 XI1_I1666_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I118_XP_MN1 (XI1_I1666_I118_XP_n1 I1_I1666_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I118_XP_MN0 (I1_I1666_P22_19n I1_I1666_P22_21 XI1_I1666_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I174_XP_MN1 (XI1_I1666_I174_XP_n1 I1_I1666_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I174_XP_MN0 (I1_I1666_P23_8n I1_I1666_P23_16 XI1_I1666_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I119_XP_MN1 (XI1_I1666_I119_XP_n1 I1_I1666_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I119_XP_MN0 (I1_I1666_P23_20n I1_I1666_P23_22 XI1_I1666_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I19_MN1 (XI1_I1666_I19_n1 I1_b24_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I19_MN0 (I1_I1666_gn19 I1_p23_18 XI1_I1666_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I173_XP_MN1 (XI1_I1620_I173_XP_n1 I1_I1620_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I173_XP_MN0 (I1_I1620_P22_7n I1_I1620_P22_15 XI1_I1620_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I18_MN1 (XI1_I1620_I18_n1 I1_b23_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I18_MN0 (I1_I1620_gn18 I1_p22_17 XI1_I1620_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I171_XP_MN1 (XI1_I1620_I171_XP_n1 I1_I1620_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I171_XP_MN0 (I1_I1620_P20_5n I1_I1620_P20_13 XI1_I1620_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I111_XP_MN1 (XI1_I1620_I111_XP_n1 I1_I1620_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I111_XP_MN0 (I1_I1620_P15_12n I1_I1620_P15_14 XI1_I1620_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I109_XP_MN1 (XI1_I1620_I109_XP_n1 I1_I1620_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I109_XP_MN0 (I1_I1620_P13_10n I1_I1620_P13_12 XI1_I1620_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I185_MN1 (XI2_I3_I185_n1 I2_I3_n8_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I185_MN0 (I2_I3_o8_1 I2_I3_n8_2 XI2_I3_I185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I180_MN1 (XI2_I3_I180_n1 I2_XOR_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I180_MN0 (I2_I3_n8_2 I2_I3_SEL_XOR_b3_1 XI2_I3_I180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I189_MN1 (XI2_I3_I189_n1 I2_I3_q8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I189_MN0 (Y_8 I2_I3_q8_1 XI2_I3_I189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I201_MN1 (XI2_I3_I201_n1 I2_I3_q9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I201_MN0 (Y_9 I2_I3_q9_1 XI2_I3_I201_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I210_MN1 (XI2_I3_I210_n1 I2_I3_n10_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I210_MN0 (I2_I3_o10_2 I2_I3_n10_4 XI2_I3_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I168_XP_MN1 (XI1_I1758_I168_XP_n1 I1_I1758_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I168_XP_MN0 (I1_I1758_P17_2n I1_I1758_P17_10 XI1_I1758_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I103_XP_MN1 (XI1_I1758_I103_XP_n1 I1_I1758_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I103_XP_MN0 (I1_I1758_P7_4n I1_I1758_P7_6 XI1_I1758_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I120_XP_MN1 (XI1_I1666_I120_XP_n1 I1_I1666_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I120_XP_MN0 (I1_I1666_P24_21n I1_I1666_P24_23 XI1_I1666_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I182_XP_MN1 (XI1_I1666_I182_XP_n1 I1_I1666_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I182_XP_MN0 (I1_I1666_P31_16n I1_I1666_P31_24 XI1_I1666_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I121_XP_MN1 (XI1_I1666_I121_XP_n1 I1_I1666_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I121_XP_MN0 (I1_I1666_P25_22n I1_I1666_P25_24 XI1_I1666_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I20_MN1 (XI1_I1666_I20_n1 I1_b24_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I20_MN0 (I1_I1666_gn20 I1_p23_19 XI1_I1666_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I20_MN1 (XI1_I1620_I20_n1 I1_b23_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I20_MN0 (I1_I1620_gn20 I1_p22_19 XI1_I1620_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I19_MN1 (XI1_I1620_I19_n1 I1_b23_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I19_MN0 (I1_I1620_gn19 I1_p22_18 XI1_I1620_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I118_XP_MN1 (XI1_I1620_I118_XP_n1 I1_I1620_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I118_XP_MN0 (I1_I1620_P22_19n I1_I1620_P22_21 XI1_I1620_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I116_XP_MN1 (XI1_I1620_I116_XP_n1 I1_I1620_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I116_XP_MN0 (I1_I1620_P20_17n I1_I1620_P20_19 XI1_I1620_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I175_XP_MN1 (XI1_I1620_I175_XP_n1 I1_I1620_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I175_XP_MN0 (I1_I1620_P24_9n I1_I1620_P24_17 XI1_I1620_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I113_XP_MN1 (XI1_I1620_I113_XP_n1 I1_I1620_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I113_XP_MN0 (I1_I1620_P17_14n I1_I1620_P17_16 XI1_I1620_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I168_XP_MN1 (XI1_I1620_I168_XP_n1 I1_I1620_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I168_XP_MN0 (I1_I1620_P17_2n I1_I1620_P17_10 XI1_I1620_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I171_MN1 (XI2_I3_I171_n1 DIVQ_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I171_MN0 (I2_I3_n7_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I171_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I195_MN1 (XI2_I3_I195_n1 DIVQ_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I195_MN0 (I2_I3_n9_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I30_MN1 (XI2_I2_I30_n1 B_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I30_MN0 (I2_I2_nand5 A_5 XI2_I2_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I34_MN1 (XI2_I4_I34_n1 I2_I4_z0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I34_MN0 (I2_I4_z1_2 I2_I4_z0_4 XI2_I4_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I198_MN1 (XI2_I3_I198_n1 I2_I3_n9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I198_MN0 (I2_I3_o9_2 I2_I3_n9_4 XI2_I3_I198_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I165_MN1 (XI2_I3_I165_n1 I2_I3_q6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I165_MN0 (Y_6 I2_I3_q6_1 XI2_I3_I165_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I174_MN1 (XI2_I3_I174_n1 I2_I3_n7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I174_MN0 (I2_I3_o7_2 I2_I3_n7_4 XI2_I3_I174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I126_XP_MN1 (XI1_I1758_I126_XP_n1 I1_I1758_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I126_XP_MN0 (I1_I1758_P30_27n I1_I1758_P30_29 XI1_I1758_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I124_XP_MN1 (XI1_I1758_I124_XP_n1 I1_I1758_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I124_XP_MN0 (I1_I1758_P28_25n I1_I1758_P28_27 XI1_I1758_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I122_XP_MN1 (XI1_I1758_I122_XP_n1 I1_I1758_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I122_XP_MN0 (I1_I1758_P26_23n I1_I1758_P26_25 XI1_I1758_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I120_XP_MN1 (XI1_I1758_I120_XP_n1 I1_I1758_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I120_XP_MN0 (I1_I1758_P24_21n I1_I1758_P24_23 XI1_I1758_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I118_XP_MN1 (XI1_I1758_I118_XP_n1 I1_I1758_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I118_XP_MN0 (I1_I1758_P22_19n I1_I1758_P22_21 XI1_I1758_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I116_XP_MN1 (XI1_I1758_I116_XP_n1 I1_I1758_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I116_XP_MN0 (I1_I1758_P20_17n I1_I1758_P20_19 XI1_I1758_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I114_XP_MN1 (XI1_I1758_I114_XP_n1 I1_I1758_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I114_XP_MN0 (I1_I1758_P18_15n I1_I1758_P18_17 XI1_I1758_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I112_XP_MN1 (XI1_I1758_I112_XP_n1 I1_I1758_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I112_XP_MN0 (I1_I1758_P16_13n I1_I1758_P16_15 XI1_I1758_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I110_XP_MN1 (XI1_I1758_I110_XP_n1 I1_I1758_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I110_XP_MN0 (I1_I1758_P14_11n I1_I1758_P14_13 XI1_I1758_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I101_XP_MN1 (XI1_I1758_I101_XP_n1 I1_I1758_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I101_XP_MN0 (I1_I1758_P5_2n I1_I1758_P5_4 XI1_I1758_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I5_MN1 (XI1_I1758_I5_n1 I1_b26_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I5_MN0 (I1_I1758_gn5 I1_p25_4 XI1_I1758_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I4_MN1 (XI1_I1758_I4_n1 I1_b26_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I4_MN0 (I1_I1758_gn4 I1_p25_3 XI1_I1758_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I122_XP_MN1 (XI1_I1666_I122_XP_n1 I1_I1666_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I122_XP_MN0 (I1_I1666_P26_23n I1_I1666_P26_25 XI1_I1666_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I124_XP_MN1 (XI1_I1666_I124_XP_n1 I1_I1666_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I124_XP_MN0 (I1_I1666_P28_25n I1_I1666_P28_27 XI1_I1666_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I125_XP_MN1 (XI1_I1666_I125_XP_n1 I1_I1666_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I125_XP_MN0 (I1_I1666_P29_26n I1_I1666_P29_28 XI1_I1666_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I123_XP_MN1 (XI1_I1666_I123_XP_n1 I1_I1666_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I123_XP_MN0 (I1_I1666_P27_24n I1_I1666_P27_26 XI1_I1666_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I22_MN1 (XI1_I1666_I22_n1 I1_b24_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I22_MN0 (I1_I1666_gn22 I1_p23_21 XI1_I1666_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I21_MN1 (XI1_I1666_I21_n1 I1_b24_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I21_MN0 (I1_I1666_gn21 I1_p23_20 XI1_I1666_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I181_XP_MN1 (XI1_I1620_I181_XP_n1 I1_I1620_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I181_XP_MN0 (I1_I1620_P30_15n I1_I1620_P30_23 XI1_I1620_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I179_XP_MN1 (XI1_I1620_I179_XP_n1 I1_I1620_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I179_XP_MN0 (I1_I1620_P28_13n I1_I1620_P28_21 XI1_I1620_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I117_XP_MN1 (XI1_I1620_I117_XP_n1 I1_I1620_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I117_XP_MN0 (I1_I1620_P21_18n I1_I1620_P21_20 XI1_I1620_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I115_XP_MN1 (XI1_I1620_I115_XP_n1 I1_I1620_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I115_XP_MN0 (I1_I1620_P19_16n I1_I1620_P19_18 XI1_I1620_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I170_XP_MN1 (XI1_I1620_I170_XP_n1 I1_I1620_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I170_XP_MN0 (I1_I1620_P19_4n I1_I1620_P19_12 XI1_I1620_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I172_XP_MN1 (XI1_I1620_I172_XP_n1 I1_I1620_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I172_XP_MN0 (I1_I1620_P21_6n I1_I1620_P21_14 XI1_I1620_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I159_MN1 (XI2_I3_I159_n1 DIVQ_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I159_MN0 (I2_I3_n6_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I159_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I183_MN1 (XI2_I3_I183_n1 DIVQ_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I183_MN0 (I2_I3_n8_5 I2_I3_SEL_DIV_b3_1 XI2_I3_I183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I143_MN1 (XI2_I3_I143_n1 I2_OR_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I143_MN0 (I2_I3_n5_1 I2_I3_SEL_OR_b3_0 XI2_I3_I143_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I144_MN1 (XI2_I3_I144_n1 I2_XOR_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I144_MN0 (I2_I3_n5_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I148_MN1 (XI2_I3_I148_n1 I2_I3_n5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I148_MN0 (I2_I3_o5_0 I2_I3_n5_0 XI2_I3_I148_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I142_MN1 (XI2_I3_I142_n1 I2_AND_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I142_MN0 (I2_I3_n5_0 I2_I3_SEL_AND_b3_0 XI2_I3_I142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I85_MN1 (XI2_I3_I85_n1 I2_NOT_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I85_MN0 (I2_I3_n0_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I85_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I89_MN1 (XI2_I3_I89_n1 I2_I3_n0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I89_MN0 (I2_I3_o0_1 I2_I3_n0_2 XI2_I3_I89_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I84_MN1 (XI2_I3_I84_n1 I2_XOR_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I84_MN0 (I2_I3_n0_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I162_MN1 (XI2_I3_I162_n1 I2_I3_n6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I162_MN0 (I2_I3_o6_2 I2_I3_n6_4 XI2_I3_I162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I186_MN1 (XI2_I3_I186_n1 I2_I3_n8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I186_MN0 (I2_I3_o8_2 I2_I3_n8_4 XI2_I3_I186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I181_XP_MN1 (XI1_I1758_I181_XP_n1 I1_I1758_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I181_XP_MN0 (I1_I1758_P30_15n I1_I1758_P30_23 XI1_I1758_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I179_XP_MN1 (XI1_I1758_I179_XP_n1 I1_I1758_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I179_XP_MN0 (I1_I1758_P28_13n I1_I1758_P28_21 XI1_I1758_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I177_XP_MN1 (XI1_I1758_I177_XP_n1 I1_I1758_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I177_XP_MN0 (I1_I1758_P26_11n I1_I1758_P26_19 XI1_I1758_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I173_XP_MN1 (XI1_I1758_I173_XP_n1 I1_I1758_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I173_XP_MN0 (I1_I1758_P22_7n I1_I1758_P22_15 XI1_I1758_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I108_XP_MN1 (XI1_I1758_I108_XP_n1 I1_I1758_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I108_XP_MN0 (I1_I1758_P12_9n I1_I1758_P12_11 XI1_I1758_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I106_XP_MN1 (XI1_I1758_I106_XP_n1 I1_I1758_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I106_XP_MN0 (I1_I1758_P10_7n I1_I1758_P10_9 XI1_I1758_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I3_MN1 (XI1_I1758_I3_n1 I1_b26_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I3_MN0 (I1_I1758_gn3 I1_p25_2 XI1_I1758_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I126_XP_MN1 (XI1_I1666_I126_XP_n1 I1_I1666_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I126_XP_MN0 (I1_I1666_P30_27n I1_I1666_P30_29 XI1_I1666_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I127_XP_MN1 (XI1_I1666_I127_XP_n1 I1_I1666_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I127_XP_MN0 (I1_I1666_P31_28n I1_I1666_P31_30 XI1_I1666_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I23_MN1 (XI1_I1666_I23_n1 I1_b24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I23_MN0 (I1_I1666_gn23 I1_p23_22 XI1_I1666_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I21_MN1 (XI1_I1620_I21_n1 I1_b23_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I21_MN0 (I1_I1620_gn21 I1_p22_20 XI1_I1620_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I22_MN1 (XI1_I1620_I22_n1 I1_b23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I22_MN0 (I1_I1620_gn22 I1_p22_21 XI1_I1620_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I120_XP_MN1 (XI1_I1620_I120_XP_n1 I1_I1620_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I120_XP_MN0 (I1_I1620_P24_21n I1_I1620_P24_23 XI1_I1620_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I119_XP_MN1 (XI1_I1620_I119_XP_n1 I1_I1620_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I119_XP_MN0 (I1_I1620_P23_20n I1_I1620_P23_22 XI1_I1620_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I174_XP_MN1 (XI1_I1620_I174_XP_n1 I1_I1620_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I174_XP_MN0 (I1_I1620_P23_8n I1_I1620_P23_16 XI1_I1620_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I176_XP_MN1 (XI1_I1620_I176_XP_n1 I1_I1620_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I176_XP_MN0 (I1_I1620_P25_10n I1_I1620_P25_18 XI1_I1620_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I6_MN1 (XI2_I2_I6_n1 B_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I6_MN0 (I2_I2_nand1 A_1 XI2_I2_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I94_MN1 (XI2_I3_I94_n1 I2_AND_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I94_MN0 (I2_I3_n1_0 I2_I3_SEL_AND_b3_0 XI2_I3_I94_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I18_MN1 (XI2_I2_I18_n1 B_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I18_MN0 (I2_I2_nand3 A_3 XI2_I2_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I106_MN1 (XI2_I3_I106_n1 I2_AND_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I106_MN0 (I2_I3_n2_0 I2_I3_SEL_AND_b3_0 XI2_I3_I106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I83_MN1 (XI2_I3_I83_n1 I2_OR_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I83_MN0 (I2_I3_n0_1 I2_I3_SEL_OR_b3_0 XI2_I3_I83_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I12_MN1 (XI2_I2_I12_n1 B_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I12_MN0 (I2_I2_nand2 A_2 XI2_I2_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I88_MN1 (XI2_I3_I88_n1 I2_I3_n0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I88_MN0 (I2_I3_o0_0 I2_I3_n0_0 XI2_I3_I88_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I130_MN1 (XI2_I3_I130_n1 I2_AND_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I130_MN0 (I2_I3_n4_0 I2_I3_SEL_AND_b3_0 XI2_I3_I130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I82_MN1 (XI2_I3_I82_n1 I2_AND_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I82_MN0 (I2_I3_n0_0 I2_I3_SEL_AND_b3_0 XI2_I3_I82_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I24_MN1 (XI2_I2_I24_n1 B_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I24_MN0 (I2_I2_nand4 A_4 XI2_I2_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I0_MN1 (XI2_I2_I0_n1 B_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I0_MN0 (I2_I2_nand0 A_0 XI2_I2_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I175_XP_MN1 (XI1_I1758_I175_XP_n1 I1_I1758_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I175_XP_MN0 (I1_I1758_P24_9n I1_I1758_P24_17 XI1_I1758_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I171_XP_MN1 (XI1_I1758_I171_XP_n1 I1_I1758_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I171_XP_MN0 (I1_I1758_P20_5n I1_I1758_P20_13 XI1_I1758_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I169_XP_MN1 (XI1_I1758_I169_XP_n1 I1_I1758_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I169_XP_MN0 (I1_I1758_P18_3n I1_I1758_P18_11 XI1_I1758_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I167_XP_MN1 (XI1_I1758_I167_XP_n1 I1_I1758_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I167_XP_MN0 (I1_I1758_P16_1n I1_I1758_P16_9 XI1_I1758_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I104_XP_MN1 (XI1_I1758_I104_XP_n1 I1_I1758_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I104_XP_MN0 (I1_I1758_P8_5n I1_I1758_P8_7 XI1_I1758_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I102_XP_MN1 (XI1_I1758_I102_XP_n1 I1_I1758_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I102_XP_MN0 (I1_I1758_P6_3n I1_I1758_P6_5 XI1_I1758_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I100_XP_MN1 (XI1_I1758_I100_XP_n1 I1_I1758_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I100_XP_MN0 (I1_I1758_P4_1n I1_I1758_P4_3 XI1_I1758_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I1_MN1 (XI1_I1758_I1_n1 I1_b26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I1_MN0 (I1_I1758_gn1 I1_p25_0 XI1_I1758_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I2_MN1 (XI1_I1758_I2_n1 I1_b26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I2_MN0 (I1_I1758_gn2 I1_p25_1 XI1_I1758_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I30_MN1 (XI1_I1666_I30_n1 I1_b24_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I30_MN0 (I1_I1666_gn30 I1_p23_29 XI1_I1666_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I25_MN1 (XI1_I1666_I25_n1 I1_b24_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I25_MN0 (I1_I1666_gn25 I1_p23_24 XI1_I1666_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I24_MN1 (XI1_I1666_I24_n1 I1_b24_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I24_MN0 (I1_I1666_gn24 I1_p23_23 XI1_I1666_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I31_MN1 (XI1_I1620_I31_n1 I1_b23_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I31_MN0 (I1_I1620_gn31 I1_p22_30 XI1_I1620_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I23_MN1 (XI1_I1620_I23_n1 I1_b23_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I23_MN0 (I1_I1620_gn23 I1_p22_22 XI1_I1620_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I122_XP_MN1 (XI1_I1620_I122_XP_n1 I1_I1620_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I122_XP_MN0 (I1_I1620_P26_23n I1_I1620_P26_25 XI1_I1620_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I121_XP_MN1 (XI1_I1620_I121_XP_n1 I1_I1620_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I121_XP_MN0 (I1_I1620_P25_22n I1_I1620_P25_24 XI1_I1620_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I182_XP_MN1 (XI1_I1620_I182_XP_n1 I1_I1620_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I182_XP_MN0 (I1_I1620_P31_16n I1_I1620_P31_24 XI1_I1620_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I100_MN1 (XI2_I3_I100_n1 I2_I3_n1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I100_MN0 (I2_I3_o1_0 I2_I3_n1_0 XI2_I3_I100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I95_MN1 (XI2_I3_I95_n1 I2_OR_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I95_MN0 (I2_I3_n1_1 I2_I3_SEL_OR_b3_0 XI2_I3_I95_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I119_MN1 (XI2_I3_I119_n1 I2_OR_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I119_MN0 (I2_I3_n3_1 I2_I3_SEL_OR_b3_0 XI2_I3_I119_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I107_MN1 (XI2_I3_I107_n1 I2_OR_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I107_MN0 (I2_I3_n2_1 I2_I3_SEL_OR_b3_0 XI2_I3_I107_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I112_MN1 (XI2_I3_I112_n1 I2_I3_n2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I112_MN0 (I2_I3_o2_0 I2_I3_n2_0 XI2_I3_I112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I131_MN1 (XI2_I3_I131_n1 I2_OR_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I131_MN0 (I2_I3_n4_1 I2_I3_SEL_OR_b3_0 XI2_I3_I131_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I136_MN1 (XI2_I3_I136_n1 I2_I3_n4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I136_MN0 (I2_I3_o4_0 I2_I3_n4_0 XI2_I3_I136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I93_MN1 (XI2_I3_I93_n1 I2_I3_q0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I93_MN0 (Y_0 I2_I3_q0_1 XI2_I3_I93_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I153_MN1 (XI2_I3_I153_n1 I2_I3_q5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I153_MN0 (Y_5 I2_I3_q5_1 XI2_I3_I153_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I30_MN1 (XI1_I1804_I30_n1 I1_b27_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I30_MN0 (I1_I1804_gn30 I1_p26_29 XI1_I1804_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I15_MN1 (XI1_I1804_I15_n1 I1_b27_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I15_MN0 (I1_I1804_gn15 I1_p26_14 XI1_I1804_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I13_MN1 (XI1_I1804_I13_n1 I1_b27_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I13_MN0 (I1_I1804_gn13 I1_p26_12 XI1_I1804_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I12_MN1 (XI1_I1804_I12_n1 I1_b27_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I12_MN0 (I1_I1804_gn12 I1_p26_11 XI1_I1804_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I10_MN1 (XI1_I1804_I10_n1 I1_b27_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I10_MN0 (I1_I1804_gn10 I1_p26_9 XI1_I1804_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I0_MN1 (XI1_I1758_I0_n1 I1_b26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I0_MN0 (I1_I1758_gn0 I1_aa5 XI1_I1758_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I31_MN1 (XI1_I1666_I31_n1 I1_b24_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I31_MN0 (I1_I1666_gn31 I1_p23_30 XI1_I1666_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I28_MN1 (XI1_I1666_I28_n1 I1_b24_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I28_MN0 (I1_I1666_gn28 I1_p23_27 XI1_I1666_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I26_MN1 (XI1_I1666_I26_n1 I1_b24_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I26_MN0 (I1_I1666_gn26 I1_p23_25 XI1_I1666_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I30_MN1 (XI1_I1620_I30_n1 I1_b23_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I30_MN0 (I1_I1620_gn30 I1_p22_29 XI1_I1620_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I25_MN1 (XI1_I1620_I25_n1 I1_b23_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I25_MN0 (I1_I1620_gn25 I1_p22_24 XI1_I1620_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I126_XP_MN1 (XI1_I1620_I126_XP_n1 I1_I1620_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I126_XP_MN0 (I1_I1620_P30_27n I1_I1620_P30_29 XI1_I1620_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I124_XP_MN1 (XI1_I1620_I124_XP_n1 I1_I1620_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I124_XP_MN0 (I1_I1620_P28_25n I1_I1620_P28_27 XI1_I1620_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I24_MN1 (XI1_I1620_I24_n1 I1_b23_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I24_MN0 (I1_I1620_gn24 I1_p22_23 XI1_I1620_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I123_XP_MN1 (XI1_I1620_I123_XP_n1 I1_I1620_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I123_XP_MN0 (I1_I1620_P27_24n I1_I1620_P27_26 XI1_I1620_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I178_XP_MN1 (XI1_I1620_I178_XP_n1 I1_I1620_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I178_XP_MN0 (I1_I1620_P27_12n I1_I1620_P27_20 XI1_I1620_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I180_XP_MN1 (XI1_I1620_I180_XP_n1 I1_I1620_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I180_XP_MN0 (I1_I1620_P29_14n I1_I1620_P29_22 XI1_I1620_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I101_MN1 (XI2_I3_I101_n1 I2_I3_n1_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I101_MN0 (I2_I3_o1_1 I2_I3_n1_2 XI2_I3_I101_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I96_MN1 (XI2_I3_I96_n1 I2_XOR_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I96_MN0 (I2_I3_n1_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I109_MN1 (XI2_I3_I109_n1 I2_NOT_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I109_MN0 (I2_I3_n2_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I133_MN1 (XI2_I3_I133_n1 I2_NOT_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I133_MN0 (I2_I3_n4_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I132_MN1 (XI2_I3_I132_n1 I2_XOR_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I132_MN0 (I2_I3_n4_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I137_MN1 (XI2_I3_I137_n1 I2_I3_n4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I137_MN0 (I2_I3_o4_1 I2_I3_n4_2 XI2_I3_I137_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I141_MN1 (XI2_I3_I141_n1 I2_I3_q4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I141_MN0 (Y_4 I2_I3_q4_1 XI2_I3_I141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I0_MN1 (XI0_I1660_I0_n1 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I0_MN0 (I0_I1660_gn0 I0_pp0_0 XI0_I1660_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I26_MN1 (XI1_I1804_I26_n1 I1_b27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I26_MN0 (I1_I1804_gn26 I1_p26_25 XI1_I1804_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I24_MN1 (XI1_I1804_I24_n1 I1_b27_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I24_MN0 (I1_I1804_gn24 I1_p26_23 XI1_I1804_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I23_MN1 (XI1_I1804_I23_n1 I1_b27_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I23_MN0 (I1_I1804_gn23 I1_p26_22 XI1_I1804_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I22_MN1 (XI1_I1804_I22_n1 I1_b27_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I22_MN0 (I1_I1804_gn22 I1_p26_21 XI1_I1804_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I21_MN1 (XI1_I1804_I21_n1 I1_b27_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I21_MN0 (I1_I1804_gn21 I1_p26_20 XI1_I1804_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I19_MN1 (XI1_I1804_I19_n1 I1_b27_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I19_MN0 (I1_I1804_gn19 I1_p26_18 XI1_I1804_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I18_MN1 (XI1_I1804_I18_n1 I1_b27_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I18_MN0 (I1_I1804_gn18 I1_p26_17 XI1_I1804_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I17_MN1 (XI1_I1804_I17_n1 I1_b27_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I17_MN0 (I1_I1804_gn17 I1_p26_16 XI1_I1804_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I16_MN1 (XI1_I1804_I16_n1 I1_b27_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I16_MN0 (I1_I1804_gn16 I1_p26_15 XI1_I1804_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I14_MN1 (XI1_I1804_I14_n1 I1_b27_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I14_MN0 (I1_I1804_gn14 I1_p26_13 XI1_I1804_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I9_MN1 (XI1_I1804_I9_n1 I1_b27_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I9_MN0 (I1_I1804_gn9 I1_p26_8 XI1_I1804_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I8_MN1 (XI1_I1804_I8_n1 I1_b27_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I8_MN0 (I1_I1804_gn8 I1_p26_7 XI1_I1804_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I6_MN1 (XI1_I1804_I6_n1 I1_b27_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I6_MN0 (I1_I1804_gn6 I1_p26_5 XI1_I1804_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I7_MN1 (XI1_I1804_I7_n1 I1_b27_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I7_MN0 (I1_I1804_gn7 I1_p26_6 XI1_I1804_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I5_MN1 (XI1_I1804_I5_n1 I1_b27_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I5_MN0 (I1_I1804_gn5 I1_p26_4 XI1_I1804_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I4_MN1 (XI1_I1804_I4_n1 I1_b27_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I4_MN0 (I1_I1804_gn4 I1_p26_3 XI1_I1804_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I29_MN1 (XI1_I1666_I29_n1 I1_b24_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I29_MN0 (I1_I1666_gn29 I1_p23_28 XI1_I1666_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I27_MN1 (XI1_I1666_I27_n1 I1_b24_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I27_MN0 (I1_I1666_gn27 I1_p23_26 XI1_I1666_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I28_MN1 (XI1_I1620_I28_n1 I1_b23_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I28_MN0 (I1_I1620_gn28 I1_p22_27 XI1_I1620_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I26_MN1 (XI1_I1620_I26_n1 I1_b23_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I26_MN0 (I1_I1620_gn26 I1_p22_25 XI1_I1620_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I127_XP_MN1 (XI1_I1620_I127_XP_n1 I1_I1620_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I127_XP_MN0 (I1_I1620_P31_28n I1_I1620_P31_30 XI1_I1620_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I125_XP_MN1 (XI1_I1620_I125_XP_n1 I1_I1620_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I125_XP_MN0 (I1_I1620_P29_26n I1_I1620_P29_28 XI1_I1620_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I36_MN1 (XI1_I36_n1 A_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I36_MN0 (I1_nakn1 I1_A_31_b3_0 XI1_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I97_MN1 (XI2_I3_I97_n1 I2_NOT_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I97_MN0 (I2_I3_n1_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I97_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I121_MN1 (XI2_I3_I121_n1 I2_NOT_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I121_MN0 (I2_I3_n3_3 I2_I3_SEL_NOT_b3_0 XI2_I3_I121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I113_MN1 (XI2_I3_I113_n1 I2_I3_n2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I113_MN0 (I2_I3_o2_1 I2_I3_n2_2 XI2_I3_I113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I108_MN1 (XI2_I3_I108_n1 I2_XOR_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I108_MN0 (I2_I3_n2_2 I2_I3_SEL_XOR_b3_0 XI2_I3_I108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I147_MN1 (XI2_I3_I147_n1 DIVQ_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I147_MN0 (I2_I3_n5_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I147_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I117_MN1 (XI2_I3_I117_n1 I2_I3_q2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I117_MN0 (Y_2 I2_I3_q2_1 XI2_I3_I117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I129_MN1 (XI2_I3_I129_n1 I2_I3_q3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I129_MN0 (Y_3 I2_I3_q3_1 XI2_I3_I129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I105_MN1 (XI2_I3_I105_n1 I2_I3_q1_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I105_MN0 (Y_1 I2_I3_q1_1 XI2_I3_I105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I150_MN1 (XI2_I3_I150_n1 I2_I3_n5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I150_MN0 (I2_I3_o5_2 I2_I3_n5_4 XI2_I3_I150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I27_MN1 (XI1_I1804_I27_n1 I1_b27_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I27_MN0 (I1_I1804_gn27 I1_p26_26 XI1_I1804_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I25_MN1 (XI1_I1804_I25_n1 I1_b27_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I25_MN0 (I1_I1804_gn25 I1_p26_24 XI1_I1804_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I20_MN1 (XI1_I1804_I20_n1 I1_b27_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I20_MN0 (I1_I1804_gn20 I1_p26_19 XI1_I1804_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I11_MN1 (XI1_I1804_I11_n1 I1_b27_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I11_MN0 (I1_I1804_gn11 I1_p26_10 XI1_I1804_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I3_MN1 (XI1_I1804_I3_n1 I1_b27_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I3_MN0 (I1_I1804_gn3 I1_p26_2 XI1_I1804_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I2_MN1 (XI1_I1804_I2_n1 I1_b27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I2_MN0 (I1_I1804_gn2 I1_p26_1 XI1_I1804_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I1_MN1 (XI1_I1804_I1_n1 I1_b27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I1_MN0 (I1_I1804_gn1 I1_p26_0 XI1_I1804_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I0_MN1 (XI1_I1804_I0_n1 I1_b27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I0_MN0 (I1_I1804_gn0 I1_aa4 XI1_I1804_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I0_MN1 (XI1_I1850_I0_n1 I1_b28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I0_MN0 (I1_I1850_gn0 I1_aa3 XI1_I1850_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I29_MN1 (XI1_I1620_I29_n1 I1_b23_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I29_MN0 (I1_I1620_gn29 I1_p22_28 XI1_I1620_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I27_MN1 (XI1_I1620_I27_n1 I1_b23_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I27_MN0 (I1_I1620_gn27 I1_p22_26 XI1_I1620_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I0_MN1 (XI1_I1896_I0_n1 I1_b29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I0_MN0 (I1_I1896_gn0 I1_aa2 XI1_I1896_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I0_MN1 (XI1_I1942_I0_n1 I1_b30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I0_MN0 (I1_I1942_gn0 I1_aa1 XI1_I1942_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2078_MN1 (XI1_I2078_n1 DIVQ_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2078_MN0 (I1_nqkn1 I1_sq_b3_0 XI1_I2078_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I87_MN1 (XI2_I3_I87_n1 DIVQ_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I87_MN0 (I2_I3_n0_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I87_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I111_MN1 (XI2_I3_I111_n1 DIVQ_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I111_MN0 (I2_I3_n2_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I56_MN1 (XI2_I4_I56_n1 I2_I4_z2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I56_MN0 (I2_I4_z3_0 I2_I4_z2_0 XI2_I4_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I114_MN1 (XI2_I3_I114_n1 I2_I3_n2_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I114_MN0 (I2_I3_o2_2 I2_I3_n2_4 XI2_I3_I114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I90_MN1 (XI2_I3_I90_n1 I2_I3_n0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I90_MN0 (I2_I3_o0_2 I2_I3_n0_4 XI2_I3_I90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I86_MN1 (XI2_I3_I86_n1 MULP_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I86_MN0 (I2_I3_n0_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I86_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I230_MN1 (XI2_I3_I230_n1 MULP_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I230_MN0 (I2_I3_n12_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I11_MN1 (XI0_I1660_I11_n1 I0_ha255_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I11_MN0 (I0_I1660_gn11 I0_ha254_1 XI0_I1660_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I242_MN1 (XI2_I3_I242_n1 MULP_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I242_MN0 (I2_I3_n13_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I12_MN1 (XI0_I1660_I12_n1 I0_ha256_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I12_MN0 (I0_I1660_gn12 I0_ha255_1 XI0_I1660_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I266_MN1 (XI2_I3_I266_n1 MULP_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I266_MN0 (I2_I3_n15_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I266_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I290_MN1 (XI2_I3_I290_n1 MULP_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I290_MN0 (I2_I3_n17_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I278_MN1 (XI2_I3_I278_n1 MULP_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I278_MN0 (I2_I3_n16_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I16_MN1 (XI0_I1660_I16_n1 I0_ha260_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I16_MN0 (I0_I1660_gn16 I0_ha259_1 XI0_I1660_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I302_MN1 (XI2_I3_I302_n1 MULP_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I302_MN0 (I2_I3_n18_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I302_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I314_MN1 (XI2_I3_I314_n1 MULP_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I314_MN0 (I2_I3_n19_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I314_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I326_MN1 (XI2_I3_I326_n1 MULP_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I326_MN0 (I2_I3_n20_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I326_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I338_MN1 (XI2_I3_I338_n1 MULP_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I338_MN0 (I2_I3_n21_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I338_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I362_MN1 (XI2_I3_I362_n1 MULP_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I362_MN0 (I2_I3_n23_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I350_MN1 (XI2_I3_I350_n1 MULP_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I350_MN0 (I2_I3_n22_4 I2_I3_SEL_MUL_b3_3 XI2_I3_I350_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I31_MN1 (XI1_I1804_I31_n1 I1_b27_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I31_MN0 (I1_I1804_gn31 I1_p26_30 XI1_I1804_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I28_MN1 (XI1_I1804_I28_n1 I1_b27_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I28_MN0 (I1_I1804_gn28 I1_p26_27 XI1_I1804_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I120_XP_MN1 (XI1_I1804_I120_XP_n1 I1_I1804_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I120_XP_MN0 (I1_I1804_P24_21n I1_I1804_P24_23 XI1_I1804_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I118_XP_MN1 (XI1_I1804_I118_XP_n1 I1_I1804_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I118_XP_MN0 (I1_I1804_P22_19n I1_I1804_P22_21 XI1_I1804_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I116_XP_MN1 (XI1_I1804_I116_XP_n1 I1_I1804_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I116_XP_MN0 (I1_I1804_P20_17n I1_I1804_P20_19 XI1_I1804_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I114_XP_MN1 (XI1_I1804_I114_XP_n1 I1_I1804_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I114_XP_MN0 (I1_I1804_P18_15n I1_I1804_P18_17 XI1_I1804_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I112_XP_MN1 (XI1_I1804_I112_XP_n1 I1_I1804_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I112_XP_MN0 (I1_I1804_P16_13n I1_I1804_P16_15 XI1_I1804_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I110_XP_MN1 (XI1_I1804_I110_XP_n1 I1_I1804_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I110_XP_MN0 (I1_I1804_P14_11n I1_I1804_P14_13 XI1_I1804_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I108_XP_MN1 (XI1_I1804_I108_XP_n1 I1_I1804_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I108_XP_MN0 (I1_I1804_P12_9n I1_I1804_P12_11 XI1_I1804_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I106_XP_MN1 (XI1_I1804_I106_XP_n1 I1_I1804_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I106_XP_MN0 (I1_I1804_P10_7n I1_I1804_P10_9 XI1_I1804_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I1_MN1 (XI1_I1850_I1_n1 I1_b28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I1_MN0 (I1_I1850_gn1 I1_p27_0 XI1_I1850_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I1_MN1 (XI1_I1896_I1_n1 I1_b29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I1_MN0 (I1_I1896_gn1 I1_p28_0 XI1_I1896_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I2_MN1 (XI1_I1942_I2_n1 I1_b30_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I2_MN0 (I1_I1942_gn2 I1_p29_1 XI1_I1942_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I1_MN1 (XI1_I1942_I1_n1 I1_b30_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I1_MN0 (I1_I1942_gn1 I1_p29_0 XI1_I1942_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2006_MN1 (XI1_I2006_n1 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2006_MN0 (I1_dmn2 I1_dd2_b3_5 XI1_I2006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2002_MN1 (XI1_I2002_n1 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2002_MN0 (I1_dmn0 I1_B_0_b3_5 XI1_I2002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I123_MN1 (XI2_I3_I123_n1 DIVQ_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I123_MN0 (I2_I3_n3_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I99_MN1 (XI2_I3_I99_n1 DIVQ_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I99_MN0 (I2_I3_n1_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I99_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I135_MN1 (XI2_I3_I135_n1 DIVQ_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I135_MN0 (I2_I3_n4_5 I2_I3_SEL_DIV_b3_0 XI2_I3_I135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I32_MN1 (XI2_I4_I32_n1 I2_I4_z0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I32_MN0 (I2_I4_z1_0 I2_I4_z0_0 XI2_I4_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I33_MN1 (XI2_I4_I33_n1 I2_I4_z0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I33_MN0 (I2_I4_z1_1 I2_I4_z0_2 XI2_I4_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I126_MN1 (XI2_I3_I126_n1 I2_I3_n3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I126_MN0 (I2_I3_o3_2 I2_I3_n3_4 XI2_I3_I126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I134_MN1 (XI2_I3_I134_n1 MULP_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I134_MN0 (I2_I3_n4_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I134_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I110_MN1 (XI2_I3_I110_n1 MULP_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I110_MN0 (I2_I3_n2_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I218_MN1 (XI2_I3_I218_n1 MULP_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I218_MN0 (I2_I3_n11_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I158_MN1 (XI2_I3_I158_n1 MULP_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I158_MN0 (I2_I3_n6_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I158_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I182_MN1 (XI2_I3_I182_n1 MULP_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I182_MN0 (I2_I3_n8_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I194_MN1 (XI2_I3_I194_n1 MULP_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I194_MN0 (I2_I3_n9_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I6_MN1 (XI0_I1660_I6_n1 I0_ha250_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I6_MN0 (I0_I1660_gn6 I0_fa249_1 XI0_I1660_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I7_MN1 (XI0_I1660_I7_n1 I0_ha251_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I7_MN0 (I0_I1660_gn7 I0_ha250_1 XI0_I1660_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I8_MN1 (XI0_I1660_I8_n1 I0_ha252_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I8_MN0 (I0_I1660_gn8 I0_ha251_1 XI0_I1660_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I9_MN1 (XI0_I1660_I9_n1 I0_ha253_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I9_MN0 (I0_I1660_gn9 I0_ha252_1 XI0_I1660_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I10_MN1 (XI0_I1660_I10_n1 I0_ha254_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I10_MN0 (I0_I1660_gn10 I0_ha253_1 XI0_I1660_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I13_MN1 (XI0_I1660_I13_n1 I0_ha257_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I13_MN0 (I0_I1660_gn13 I0_ha256_1 XI0_I1660_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I14_MN1 (XI0_I1660_I14_n1 I0_ha258_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I14_MN0 (I0_I1660_gn14 I0_ha257_1 XI0_I1660_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I254_MN1 (XI2_I3_I254_n1 MULP_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I254_MN0 (I2_I3_n14_4 I2_I3_SEL_MUL_b3_2 XI2_I3_I254_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I15_MN1 (XI0_I1660_I15_n1 I0_ha259_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I15_MN0 (I0_I1660_gn15 I0_ha258_1 XI0_I1660_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I17_MN1 (XI0_I1660_I17_n1 I0_ha261_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I17_MN0 (I0_I1660_gn17 I0_ha260_1 XI0_I1660_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I19_MN1 (XI0_I1660_I19_n1 I0_ha263_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I19_MN0 (I0_I1660_gn19 I0_ha262_1 XI0_I1660_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I20_MN1 (XI0_I1660_I20_n1 I0_ha264_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
