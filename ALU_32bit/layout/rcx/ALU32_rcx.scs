    I_MXI1_I1574_I82_XG_MP0 (XI1_I1574_I82_XG_p1 I1_I1574_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I82_XG_MP1 (I1_I1574_G16_15 I1_I1574_gn15 XI1_I1574_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I190_XG_MP2 (VDD I1_I1574_G21_6n I1_I1574_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I190_XG_MP0 (XI1_I1574_I190_XG_p1 I1_I1574_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I190_XG_MP1 (I1_I1574_G21_0 I1_I1574_G5_0n XI1_I1574_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I196_XG_MP2 (VDD I1_I1574_G25_10n I1_I1574_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I196_XG_MP0 (XI1_I1574_I196_XG_p1 I1_I1574_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I196_XG_MP1 (I1_I1574_G25_0 I1_I1574_G9_0n XI1_I1574_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I184_XG_MP2 (VDD I1_I1574_G17_2n I1_I1574_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I184_XG_MP0 (XI1_I1574_I184_XG_p1 I1_I1574_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I184_XG_MP1 (I1_I1574_G17_0 I1_I1574_G1_0n XI1_I1574_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I69_XG_MP2 (VDD I1_I1574_gn3 I1_I1574_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I69_XG_MP0 (XI1_I1574_I69_XG_p1 I1_I1574_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I69_XG_MP1 (I1_I1574_G3_2 I1_I1574_gn2 XI1_I1574_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I149_XG_MP2 (VDD I2_I1_I42_G24_21n I2_I1_I42_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I149_XG_MP0 (XI2_I1_I42_I149_XG_p1 I2_I1_I42_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I149_XG_MP1 (I2_I1_I42_G24_17 I2_I1_I42_G20_17n XI2_I1_I42_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I192_XG_MP2 (VDD I2_I1_I42_G22_7n I2_I1_I42_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I192_XG_MP0 (XI2_I1_I42_I192_XG_p1 I2_I1_I42_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I192_XG_MP1 (I2_I1_I42_G22_0 I2_I1_I42_G6_0n XI2_I1_I42_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I199_XG_MP2 (VDD I2_I1_I42_G28_13n I2_I1_I42_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I199_XG_MP0 (XI2_I1_I42_I199_XG_p1 I2_I1_I42_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I199_XG_MP1 (I2_I1_I42_G28_0 I2_I1_I42_G12_0n XI2_I1_I42_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I147_XG_MP2 (VDD I2_I1_I42_G22_19n I2_I1_I42_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I147_XG_MP0 (XI2_I1_I42_I147_XG_p1 I2_I1_I42_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I147_XG_MP1 (I2_I1_I42_G22_15 I2_I1_I42_G18_15n XI2_I1_I42_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I151_XG_MP2 (VDD I2_I1_I42_G26_23n I2_I1_I42_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I151_XG_MP0 (XI2_I1_I42_I151_XG_p1 I2_I1_I42_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I151_XG_MP1 (I2_I1_I42_G26_19 I2_I1_I42_G22_19n XI2_I1_I42_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I153_XG_MP2 (VDD I2_I1_I42_G28_25n I2_I1_I42_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I153_XG_MP0 (XI2_I1_I42_I153_XG_p1 I2_I1_I42_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I153_XG_MP1 (I2_I1_I42_G28_21 I2_I1_I42_G24_21n XI2_I1_I42_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I90_XG_MP2 (VDD I2_I1_I42_gn24 I2_I1_I42_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I90_XG_MP0 (XI2_I1_I42_I90_XG_p1 I2_I1_I42_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I90_XG_MP1 (I2_I1_I42_G24_23 I2_I1_I42_gn23 XI2_I1_I42_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I91_XG_MP2 (VDD I2_I1_I42_gn25 I2_I1_I42_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I91_XG_MP0 (XI2_I1_I42_I91_XG_p1 I2_I1_I42_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I91_XG_MP1 (I2_I1_I42_G25_24 I2_I1_I42_gn24 XI2_I1_I42_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I92_XG_MP2 (VDD I2_I1_I42_gn26 I2_I1_I42_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I92_XG_MP0 (XI2_I1_I42_I92_XG_p1 I2_I1_I42_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I92_XG_MP1 (I2_I1_I42_G26_25 I2_I1_I42_gn25 XI2_I1_I42_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I93_XG_MP2 (VDD I2_I1_I42_gn27 I2_I1_I42_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I93_XG_MP0 (XI2_I1_I42_I93_XG_p1 I2_I1_I42_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I93_XG_MP1 (I2_I1_I42_G27_26 I2_I1_I42_gn26 XI2_I1_I42_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I144_XG_MP2 (VDD I1_I562_G19_16n I1_I562_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I144_XG_MP0 (XI1_I562_I144_XG_p1 I1_I562_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I144_XG_MP1 (I1_I562_G19_12 I1_I562_G15_12n XI1_I562_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I148_XG_MP2 (VDD I1_I562_G23_20n I1_I562_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I148_XG_MP0 (XI1_I562_I148_XG_p1 I1_I562_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I148_XG_MP1 (I1_I562_G23_16 I1_I562_G19_16n XI1_I562_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I152_XG_MP2 (VDD I1_I562_G27_24n I1_I562_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I152_XG_MP0 (XI1_I562_I152_XG_p1 I1_I562_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I152_XG_MP1 (I1_I562_G27_20 I1_I562_G23_20n XI1_I562_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I156_XG_MP2 (VDD I1_I562_G31_28n I1_I562_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I156_XG_MP0 (XI1_I562_I156_XG_p1 I1_I562_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I156_XG_MP1 (I1_I562_G31_24 I1_I562_G27_24n XI1_I562_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I94_XG_MP2 (VDD I1_I1712_gn28 I1_I1712_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I94_XG_MP0 (XI1_I1712_I94_XG_p1 I1_I1712_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I94_XG_MP1 (I1_I1712_G28_27 I1_I1712_gn27 XI1_I1712_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I93_XG_MP2 (VDD I1_I1712_gn27 I1_I1712_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I93_XG_MP0 (XI1_I1712_I93_XG_p1 I1_I1712_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I93_XG_MP1 (I1_I1712_G27_26 I1_I1712_gn26 XI1_I1712_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I153_XG_MP2 (VDD I1_I1712_G28_25n I1_I1712_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I153_XG_MP0 (XI1_I1712_I153_XG_p1 I1_I1712_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I153_XG_MP1 (I1_I1712_G28_21 I1_I1712_G24_21n XI1_I1712_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I199_XG_MP2 (VDD I1_I1712_G28_13n I1_I1712_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I199_XG_MP0 (XI1_I1712_I199_XG_p1 I1_I1712_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I199_XG_MP1 (I1_I1712_G28_0 I1_I1712_G12_0n XI1_I1712_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I188_XG_MP2 (VDD I1_I1712_G20_5n I1_I1712_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I188_XG_MP0 (XI1_I1712_I188_XG_p1 I1_I1712_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I188_XG_MP1 (I1_I1712_G20_0 I1_I1712_G4_0n XI1_I1712_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I137_XG_MP2 (VDD I1_I1712_G12_9n I1_I1712_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I137_XG_MP0 (XI1_I1712_I137_XG_p1 I1_I1712_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I137_XG_MP1 (I1_I1712_G12_5 I1_I1712_G8_5n XI1_I1712_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I128_XG_MP2 (VDD I1_I1712_G4_1n I1_I1712_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I128_XG_MP0 (XI1_I1712_I128_XG_p1 I1_I1712_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I128_XG_MP1 (I1_I1712_G4_0 I1_I1712_G0_0n XI1_I1712_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I71_XG_MP2 (VDD I1_I1712_gn5 I1_I1712_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I71_XG_MP0 (XI1_I1712_I71_XG_p1 I1_I1712_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I71_XG_MP1 (I1_I1712_G5_4 I1_I1712_gn4 XI1_I1712_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I70_XG_MP2 (VDD I1_I1712_gn4 I1_I1712_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I70_XG_MP0 (XI1_I1712_I70_XG_p1 I1_I1712_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I70_XG_MP1 (I1_I1712_G4_3 I1_I1712_gn3 XI1_I1712_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I94_XG_MP2 (VDD I1_I1574_gn28 I1_I1574_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I94_XG_MP0 (XI1_I1574_I94_XG_p1 I1_I1574_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I94_XG_MP1 (I1_I1574_G28_27 I1_I1574_gn27 XI1_I1574_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I93_XG_MP2 (VDD I1_I1574_gn27 I1_I1574_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I93_XG_MP0 (XI1_I1574_I93_XG_p1 I1_I1574_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I93_XG_MP1 (I1_I1574_G27_26 I1_I1574_gn26 XI1_I1574_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I83_XG_MP2 (VDD I1_I1574_gn17 I1_I1574_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I83_XG_MP0 (XI1_I1574_I83_XG_p1 I1_I1574_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I83_XG_MP1 (I1_I1574_G17_16 I1_I1574_gn16 XI1_I1574_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I141_XG_MP2 (VDD I1_I1574_G16_13n I1_I1574_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I141_XG_MP0 (XI1_I1574_I141_XG_p1 I1_I1574_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I141_XG_MP1 (I1_I1574_G16_9 I1_I1574_G12_9n XI1_I1574_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I78_XG_MP2 (VDD I2_I1_I42_gn12 I2_I1_I42_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I78_XG_MP0 (XI2_I1_I42_I78_XG_p1 I2_I1_I42_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I78_XG_MP1 (I2_I1_I42_G12_11 I2_I1_I42_gn11 XI2_I1_I42_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I79_XG_MP2 (VDD I2_I1_I42_gn13 I2_I1_I42_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I79_XG_MP0 (XI2_I1_I42_I79_XG_p1 I2_I1_I42_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I79_XG_MP1 (I2_I1_I42_G13_12 I2_I1_I42_gn12 XI2_I1_I42_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I139_XG_MP2 (VDD I2_I1_I42_G14_11n I2_I1_I42_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I139_XG_MP0 (XI2_I1_I42_I139_XG_p1 I2_I1_I42_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I139_XG_MP1 (I2_I1_I42_G14_7 I2_I1_I42_G10_7n XI2_I1_I42_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I143_XG_MP2 (VDD I2_I1_I42_G18_15n I2_I1_I42_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I143_XG_MP0 (XI2_I1_I42_I143_XG_p1 I2_I1_I42_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I143_XG_MP1 (I2_I1_I42_G18_11 I2_I1_I42_G14_11n XI2_I1_I42_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I197_XG_MP2 (VDD I2_I1_I42_G26_11n I2_I1_I42_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I197_XG_MP0 (XI2_I1_I42_I197_XG_p1 I2_I1_I42_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I197_XG_MP1 (I2_I1_I42_G26_0 I2_I1_I42_G10_0n XI2_I1_I42_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I201_XG_MP2 (VDD I2_I1_I42_G30_15n I2_CM VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I201_XG_MP0 (XI2_I1_I42_I201_XG_p1 I2_I1_I42_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I201_XG_MP1 (I2_CM I2_I1_I42_G14_0n XI2_I1_I42_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I155_XG_MP2 (VDD I2_I1_I42_G30_27n I2_I1_I42_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I155_XG_MP0 (XI2_I1_I42_I155_XG_p1 I2_I1_I42_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I155_XG_MP1 (I2_I1_I42_G30_23 I2_I1_I42_G26_23n XI2_I1_I42_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I94_XG_MP2 (VDD I2_I1_I42_gn28 I2_I1_I42_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I94_XG_MP0 (XI2_I1_I42_I94_XG_p1 I2_I1_I42_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I94_XG_MP1 (I2_I1_I42_G28_27 I2_I1_I42_gn27 XI2_I1_I42_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I194_XG_MP2 (VDD I1_I562_G23_8n I1_I562_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I194_XG_MP0 (XI1_I562_I194_XG_p1 I1_I562_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I194_XG_MP1 (I1_I562_G23_0 I1_I562_G7_0n XI1_I562_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I562_I202_XG_MP2 (VDD I1_I562_G31_16n I1_c0_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I562_I202_XG_MP0 (XI1_I562_I202_XG_p1 I1_I562_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I562_I202_XG_MP1 (I1_c0_o I1_I562_G15_0n XI1_I562_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I96_XG_MP2 (VDD I1_I1712_gn30 I1_I1712_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I96_XG_MP0 (XI1_I1712_I96_XG_p1 I1_I1712_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I96_XG_MP1 (I1_I1712_G30_29 I1_I1712_gn29 XI1_I1712_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I92_XG_MP2 (VDD I1_I1712_gn26 I1_I1712_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I92_XG_MP0 (XI1_I1712_I92_XG_p1 I1_I1712_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I92_XG_MP1 (I1_I1712_G26_25 I1_I1712_gn25 XI1_I1712_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I155_XG_MP2 (VDD I1_I1712_G30_27n I1_I1712_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I155_XG_MP0 (XI1_I1712_I155_XG_p1 I1_I1712_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I155_XG_MP1 (I1_I1712_G30_23 I1_I1712_G26_23n XI1_I1712_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I195_XG_MP2 (VDD I1_I1712_G24_9n I1_I1712_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I195_XG_MP0 (XI1_I1712_I195_XG_p1 I1_I1712_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I195_XG_MP1 (I1_I1712_G24_0 I1_I1712_G8_0n XI1_I1712_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I141_XG_MP2 (VDD I1_I1712_G16_13n I1_I1712_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I141_XG_MP0 (XI1_I1712_I141_XG_p1 I1_I1712_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I141_XG_MP1 (I1_I1712_G16_9 I1_I1712_G12_9n XI1_I1712_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I183_XG_MP2 (VDD I1_I1712_G16_1n I1_I1712_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I183_XG_MP0 (XI1_I1712_I183_XG_p1 I1_I1712_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I183_XG_MP1 (I1_I1712_G16_0 I1_I1712_G0_0n XI1_I1712_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I133_XG_MP2 (VDD I1_I1712_G8_5n I1_I1712_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I133_XG_MP0 (XI1_I1712_I133_XG_p1 I1_I1712_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I133_XG_MP1 (I1_I1712_G8_1 I1_I1712_G4_1n XI1_I1712_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I67_XG_MP2 (VDD I1_I1712_gn1 I1_I1712_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I67_XG_MP0 (XI1_I1712_I67_XG_p1 I1_I1712_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I67_XG_MP1 (I1_I1712_G1_0 I1_I1712_G0_0n XI1_I1712_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I68_XG_MP2 (VDD I1_I1712_gn2 I1_I1712_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I68_XG_MP0 (XI1_I1712_I68_XG_p1 I1_I1712_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I68_XG_MP1 (I1_I1712_G2_1 I1_I1712_gn1 XI1_I1712_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I92_XG_MP2 (VDD I1_I1574_gn26 I1_I1574_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I92_XG_MP0 (XI1_I1574_I92_XG_p1 I1_I1574_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I92_XG_MP1 (I1_I1574_G26_25 I1_I1574_gn25 XI1_I1574_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I91_XG_MP2 (VDD I1_I1574_gn25 I1_I1574_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I91_XG_MP0 (XI1_I1574_I91_XG_p1 I1_I1574_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I91_XG_MP1 (I1_I1574_G25_24 I1_I1574_gn24 XI1_I1574_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I153_XG_MP2 (VDD I1_I1574_G28_25n I1_I1574_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I153_XG_MP0 (XI1_I1574_I153_XG_p1 I1_I1574_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I153_XG_MP1 (I1_I1574_G28_21 I1_I1574_G24_21n XI1_I1574_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I199_XG_MP2 (VDD I1_I1574_G28_13n I1_I1574_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I199_XG_MP0 (XI1_I1574_I199_XG_p1 I1_I1574_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I199_XG_MP1 (I1_I1574_G28_0 I1_I1574_G12_0n XI1_I1574_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I145_XG_MP2 (VDD I1_I1574_G20_17n I1_I1574_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I145_XG_MP0 (XI1_I1574_I145_XG_p1 I1_I1574_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I145_XG_MP1 (I1_I1574_G20_13 I1_I1574_G16_13n XI1_I1574_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I137_XG_MP2 (VDD I1_I1574_G12_9n I1_I1574_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I137_XG_MP0 (XI1_I1574_I137_XG_p1 I1_I1574_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I137_XG_MP1 (I1_I1574_G12_5 I1_I1574_G8_5n XI1_I1574_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I133_XG_MP2 (VDD I1_I1574_G8_5n I1_I1574_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I133_XG_MP0 (XI1_I1574_I133_XG_p1 I1_I1574_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I133_XG_MP1 (I1_I1574_G8_1 I1_I1574_G4_1n XI1_I1574_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I128_XG_MP2 (VDD I1_I1574_G4_1n I1_I1574_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I128_XG_MP0 (XI1_I1574_I128_XG_p1 I1_I1574_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I128_XG_MP1 (I1_I1574_G4_0 I1_I1574_G0_0n XI1_I1574_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I68_XG_MP2 (VDD I1_I1574_gn2 I1_I1574_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I68_XG_MP0 (XI1_I1574_I68_XG_p1 I1_I1574_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I68_XG_MP1 (I1_I1574_G2_1 I1_I1574_gn1 XI1_I1574_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I67_XG_MP2 (VDD I1_I1574_gn1 I1_I1574_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I67_XG_MP0 (XI1_I1574_I67_XG_p1 I1_I1574_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I67_XG_MP1 (I1_I1574_G1_0 I1_I1574_G0_0n XI1_I1574_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I137_XG_MP2 (VDD I2_I1_I42_G12_9n I2_I1_I42_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I137_XG_MP0 (XI2_I1_I42_I137_XG_p1 I2_I1_I42_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I137_XG_MP1 (I2_I1_I42_G12_5 I2_I1_I42_G8_5n XI2_I1_I42_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I141_XG_MP2 (VDD I2_I1_I42_G16_13n I2_I1_I42_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I141_XG_MP0 (XI2_I1_I42_I141_XG_p1 I2_I1_I42_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I141_XG_MP1 (I2_I1_I42_G16_9 I2_I1_I42_G12_9n XI2_I1_I42_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I195_XG_MP2 (VDD I2_I1_I42_G24_9n I2_I1_I42_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I195_XG_MP0 (XI2_I1_I42_I195_XG_p1 I2_I1_I42_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I195_XG_MP1 (I2_I1_I42_G24_0 I2_I1_I42_G8_0n XI2_I1_I42_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I140_XG_MP2 (VDD I2_I1_I42_G15_12n I2_I1_I42_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I140_XG_MP0 (XI2_I1_I42_I140_XG_p1 I2_I1_I42_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I140_XG_MP1 (I2_I1_I42_G15_8 I2_I1_I42_G11_8n XI2_I1_I42_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I144_XG_MP2 (VDD I2_I1_I42_G19_16n I2_I1_I42_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I144_XG_MP0 (XI2_I1_I42_I144_XG_p1 I2_I1_I42_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I144_XG_MP1 (I2_I1_I42_G19_12 I2_I1_I42_G15_12n XI2_I1_I42_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I198_XG_MP2 (VDD I2_I1_I42_G27_12n I2_I1_I42_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I198_XG_MP0 (XI2_I1_I42_I198_XG_p1 I2_I1_I42_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I198_XG_MP1 (I2_I1_I42_G27_0 I2_I1_I42_G11_0n XI2_I1_I42_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I202_XG_MP2 (VDD I2_I1_I42_G31_16n I2_CO VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I202_XG_MP0 (XI2_I1_I42_I202_XG_p1 I2_I1_I42_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I202_XG_MP1 (I2_CO I2_I1_I42_G15_0n XI2_I1_I42_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I154_XG_MP2 (VDD I2_I1_I42_G29_26n I2_I1_I42_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I154_XG_MP0 (XI2_I1_I42_I154_XG_p1 I2_I1_I42_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I154_XG_MP1 (I2_I1_I42_G29_22 I2_I1_I42_G25_22n XI2_I1_I42_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I95_XG_MP2 (VDD I2_I1_I42_gn29 I2_I1_I42_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I95_XG_MP0 (XI2_I1_I42_I95_XG_p1 I2_I1_I42_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I95_XG_MP1 (I2_I1_I42_G29_28 I2_I1_I42_gn28 XI2_I1_I42_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I96_XG_MP2 (VDD I2_I1_I42_gn30 I2_I1_I42_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I96_XG_MP0 (XI2_I1_I42_I96_XG_p1 I2_I1_I42_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I96_XG_MP1 (I2_I1_I42_G30_29 I2_I1_I42_gn29 XI2_I1_I42_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I91_XG_MP2 (VDD I1_I1712_gn25 I1_I1712_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I91_XG_MP0 (XI1_I1712_I91_XG_p1 I1_I1712_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I91_XG_MP1 (I1_I1712_G25_24 I1_I1712_gn24 XI1_I1712_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I90_XG_MP2 (VDD I1_I1712_gn24 I1_I1712_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I90_XG_MP0 (XI1_I1712_I90_XG_p1 I1_I1712_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I90_XG_MP1 (I1_I1712_G24_23 I1_I1712_gn23 XI1_I1712_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I151_XG_MP2 (VDD I1_I1712_G26_23n I1_I1712_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I151_XG_MP0 (XI1_I1712_I151_XG_p1 I1_I1712_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I151_XG_MP1 (I1_I1712_G26_19 I1_I1712_G22_19n XI1_I1712_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I147_XG_MP2 (VDD I1_I1712_G22_19n I1_I1712_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I147_XG_MP0 (XI1_I1712_I147_XG_p1 I1_I1712_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I147_XG_MP1 (I1_I1712_G22_15 I1_I1712_G18_15n XI1_I1712_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I197_XG_MP2 (VDD I1_I1712_G26_11n I1_I1712_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I197_XG_MP0 (XI1_I1712_I197_XG_p1 I1_I1712_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I197_XG_MP1 (I1_I1712_G26_0 I1_I1712_G10_0n XI1_I1712_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I185_XG_MP2 (VDD I1_I1712_G18_3n I1_I1712_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I185_XG_MP0 (XI1_I1712_I185_XG_p1 I1_I1712_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I185_XG_MP1 (I1_I1712_G18_0 I1_I1712_G2_0n XI1_I1712_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I139_XG_MP2 (VDD I1_I1712_G14_11n I1_I1712_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I139_XG_MP0 (XI1_I1712_I139_XG_p1 I1_I1712_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I139_XG_MP1 (I1_I1712_G14_7 I1_I1712_G10_7n XI1_I1712_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I135_XG_MP2 (VDD I1_I1712_G10_7n I1_I1712_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I135_XG_MP0 (XI1_I1712_I135_XG_p1 I1_I1712_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I135_XG_MP1 (I1_I1712_G10_3 I1_I1712_G6_3n XI1_I1712_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I131_XG_MP2 (VDD I1_I1712_G6_3n I1_I1712_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I131_XG_MP0 (XI1_I1712_I131_XG_p1 I1_I1712_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I131_XG_MP1 (I1_I1712_G6_0 I1_I1712_G2_0n XI1_I1712_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I74_XG_MP2 (VDD I1_I1712_gn8 I1_I1712_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I74_XG_MP0 (XI1_I1712_I74_XG_p1 I1_I1712_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I74_XG_MP1 (I1_I1712_G8_7 I1_I1712_gn7 XI1_I1712_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I73_XG_MP2 (VDD I1_I1712_gn7 I1_I1712_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I73_XG_MP0 (XI1_I1712_I73_XG_p1 I1_I1712_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I73_XG_MP1 (I1_I1712_G7_6 I1_I1712_gn6 XI1_I1712_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I72_XG_MP2 (VDD I1_I1712_gn6 I1_I1712_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I72_XG_MP0 (XI1_I1712_I72_XG_p1 I1_I1712_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I72_XG_MP1 (I1_I1712_G6_5 I1_I1712_gn5 XI1_I1712_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I65_XG_MP2 (VDD I1_I1666_gn0 I1_I1666_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I65_XG_MP0 (XI1_I1666_I65_XG_p1 I1_I1666_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I65_XG_MP1 (I1_I1666_G0_0 I1_I1666_cinn XI1_I1666_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I90_XG_MP2 (VDD I1_I1574_gn24 I1_I1574_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I90_XG_MP0 (XI1_I1574_I90_XG_p1 I1_I1574_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I90_XG_MP1 (I1_I1574_G24_23 I1_I1574_gn23 XI1_I1574_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I89_XG_MP2 (VDD I1_I1574_gn23 I1_I1574_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I89_XG_MP0 (XI1_I1574_I89_XG_p1 I1_I1574_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I89_XG_MP1 (I1_I1574_G23_22 I1_I1574_gn22 XI1_I1574_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I88_XG_MP2 (VDD I1_I1574_gn22 I1_I1574_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I88_XG_MP0 (XI1_I1574_I88_XG_p1 I1_I1574_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I88_XG_MP1 (I1_I1574_G22_21 I1_I1574_gn21 XI1_I1574_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I155_XG_MP2 (VDD I1_I1574_G30_27n I1_I1574_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I155_XG_MP0 (XI1_I1574_I155_XG_p1 I1_I1574_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I155_XG_MP1 (I1_I1574_G30_23 I1_I1574_G26_23n XI1_I1574_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I149_XG_MP2 (VDD I1_I1574_G24_21n I1_I1574_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I149_XG_MP0 (XI1_I1574_I149_XG_p1 I1_I1574_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I149_XG_MP1 (I1_I1574_G24_17 I1_I1574_G20_17n XI1_I1574_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I188_XG_MP2 (VDD I1_I1574_G20_5n I1_I1574_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I188_XG_MP0 (XI1_I1574_I188_XG_p1 I1_I1574_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I188_XG_MP1 (I1_I1574_G20_0 I1_I1574_G4_0n XI1_I1574_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I183_XG_MP2 (VDD I1_I1574_G16_1n I1_I1574_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I183_XG_MP0 (XI1_I1574_I183_XG_p1 I1_I1574_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I183_XG_MP1 (I1_I1574_G16_0 I1_I1574_G0_0n XI1_I1574_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I131_XG_MP2 (VDD I1_I1574_G6_3n I1_I1574_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I131_XG_MP0 (XI1_I1574_I131_XG_p1 I1_I1574_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I131_XG_MP1 (I1_I1574_G6_0 I1_I1574_G2_0n XI1_I1574_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I76_XG_MP2 (VDD I2_I1_I42_gn10 I2_I1_I42_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I76_XG_MP0 (XI2_I1_I42_I76_XG_p1 I2_I1_I42_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I76_XG_MP1 (I2_I1_I42_G10_9 I2_I1_I42_gn9 XI2_I1_I42_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I77_XG_MP2 (VDD I2_I1_I42_gn11 I2_I1_I42_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I77_XG_MP0 (XI2_I1_I42_I77_XG_p1 I2_I1_I42_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I77_XG_MP1 (I2_I1_I42_G11_10 I2_I1_I42_gn10 XI2_I1_I42_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I135_XG_MP2 (VDD I2_I1_I42_G10_7n I2_I1_I42_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I135_XG_MP0 (XI2_I1_I42_I135_XG_p1 I2_I1_I42_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I135_XG_MP1 (I2_I1_I42_G10_3 I2_I1_I42_G6_3n XI2_I1_I42_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I185_XG_MP2 (VDD I2_I1_I42_G18_3n I2_I1_I42_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I185_XG_MP0 (XI2_I1_I42_I185_XG_p1 I2_I1_I42_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I185_XG_MP1 (I2_I1_I42_G18_0 I2_I1_I42_G2_0n XI2_I1_I42_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I138_XG_MP2 (VDD I2_I1_I42_G13_10n I2_I1_I42_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I138_XG_MP0 (XI2_I1_I42_I138_XG_p1 I2_I1_I42_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I138_XG_MP1 (I2_I1_I42_G13_6 I2_I1_I42_G9_6n XI2_I1_I42_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I142_XG_MP2 (VDD I2_I1_I42_G17_14n I2_I1_I42_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I142_XG_MP0 (XI2_I1_I42_I142_XG_p1 I2_I1_I42_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I142_XG_MP1 (I2_I1_I42_G17_10 I2_I1_I42_G13_10n XI2_I1_I42_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I190_XG_MP2 (VDD I2_I1_I42_G21_6n I2_I1_I42_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I190_XG_MP0 (XI2_I1_I42_I190_XG_p1 I2_I1_I42_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I190_XG_MP1 (I2_I1_I42_G21_0 I2_I1_I42_G5_0n XI2_I1_I42_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I146_XG_MP2 (VDD I2_I1_I42_G21_18n I2_I1_I42_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I146_XG_MP0 (XI2_I1_I42_I146_XG_p1 I2_I1_I42_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I146_XG_MP1 (I2_I1_I42_G21_14 I2_I1_I42_G17_14n XI2_I1_I42_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I150_XG_MP2 (VDD I2_I1_I42_G25_22n I2_I1_I42_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I150_XG_MP0 (XI2_I1_I42_I150_XG_p1 I2_I1_I42_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I150_XG_MP1 (I2_I1_I42_G25_18 I2_I1_I42_G21_18n XI2_I1_I42_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I194_XG_MP2 (VDD I2_I1_I42_G23_8n I2_I1_I42_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I194_XG_MP0 (XI2_I1_I42_I194_XG_p1 I2_I1_I42_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I194_XG_MP1 (I2_I1_I42_G23_0 I2_I1_I42_G7_0n XI2_I1_I42_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I200_XG_MP2 (VDD I2_I1_I42_G29_14n I2_I1_I42_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I200_XG_MP0 (XI2_I1_I42_I200_XG_p1 I2_I1_I42_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I200_XG_MP1 (I2_I1_I42_G29_0 I2_I1_I42_G13_0n XI2_I1_I42_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I156_XG_MP2 (VDD I2_I1_I42_G31_28n I2_I1_I42_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I156_XG_MP0 (XI2_I1_I42_I156_XG_p1 I2_I1_I42_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I156_XG_MP1 (I2_I1_I42_G31_24 I2_I1_I42_G27_24n XI2_I1_I42_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I97_XG_MP2 (VDD I2_I1_I42_gn31 I2_I1_I42_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I97_XG_MP0 (XI2_I1_I42_I97_XG_p1 I2_I1_I42_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I97_XG_MP1 (I2_I1_I42_G31_30 I2_I1_I42_gn30 XI2_I1_I42_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I97_XG_MP2 (VDD I1_I1712_gn31 I1_I1712_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I97_XG_MP0 (XI1_I1712_I97_XG_p1 I1_I1712_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I97_XG_MP1 (I1_I1712_G31_30 I1_I1712_gn30 XI1_I1712_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I89_XG_MP2 (VDD I1_I1712_gn23 I1_I1712_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I89_XG_MP0 (XI1_I1712_I89_XG_p1 I1_I1712_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I89_XG_MP1 (I1_I1712_G23_22 I1_I1712_gn22 XI1_I1712_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I88_XG_MP2 (VDD I1_I1712_gn22 I1_I1712_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I88_XG_MP0 (XI1_I1712_I88_XG_p1 I1_I1712_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I88_XG_MP1 (I1_I1712_G22_21 I1_I1712_gn21 XI1_I1712_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I201_XG_MP2 (VDD I1_I1712_G30_15n I1_c25_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I201_XG_MP0 (XI1_I1712_I201_XG_p1 I1_I1712_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I201_XG_MP1 (I1_c25_m I1_I1712_G14_0n XI1_I1712_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I192_XG_MP2 (VDD I1_I1712_G22_7n I1_I1712_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I192_XG_MP0 (XI1_I1712_I192_XG_p1 I1_I1712_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I192_XG_MP1 (I1_I1712_G22_0 I1_I1712_G6_0n XI1_I1712_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I143_XG_MP2 (VDD I1_I1712_G18_15n I1_I1712_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I143_XG_MP0 (XI1_I1712_I143_XG_p1 I1_I1712_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I143_XG_MP1 (I1_I1712_G18_11 I1_I1712_G14_11n XI1_I1712_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I76_XG_MP2 (VDD I1_I1712_gn10 I1_I1712_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I76_XG_MP0 (XI1_I1712_I76_XG_p1 I1_I1712_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I76_XG_MP1 (I1_I1712_G10_9 I1_I1712_gn9 XI1_I1712_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I75_XG_MP2 (VDD I1_I1712_gn9 I1_I1712_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I75_XG_MP0 (XI1_I1712_I75_XG_p1 I1_I1712_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I75_XG_MP1 (I1_I1712_G9_8 I1_I1712_gn8 XI1_I1712_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I65_XG_MP2 (VDD I1_I1712_gn0 I1_I1712_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I65_XG_MP0 (XI1_I1712_I65_XG_p1 I1_I1712_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I65_XG_MP1 (I1_I1712_G0_0 I1_I1712_cinn XI1_I1712_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I87_XG_MP2 (VDD I1_I1574_gn21 I1_I1574_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I87_XG_MP0 (XI1_I1574_I87_XG_p1 I1_I1574_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I87_XG_MP1 (I1_I1574_G21_20 I1_I1574_gn20 XI1_I1574_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I86_XG_MP2 (VDD I1_I1574_gn20 I1_I1574_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I86_XG_MP0 (XI1_I1574_I86_XG_p1 I1_I1574_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I86_XG_MP1 (I1_I1574_G20_19 I1_I1574_gn19 XI1_I1574_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I151_XG_MP2 (VDD I1_I1574_G26_23n I1_I1574_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I151_XG_MP0 (XI1_I1574_I151_XG_p1 I1_I1574_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I151_XG_MP1 (I1_I1574_G26_19 I1_I1574_G22_19n XI1_I1574_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I147_XG_MP2 (VDD I1_I1574_G22_19n I1_I1574_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I147_XG_MP0 (XI1_I1574_I147_XG_p1 I1_I1574_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I147_XG_MP1 (I1_I1574_G22_15 I1_I1574_G18_15n XI1_I1574_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I143_XG_MP2 (VDD I1_I1574_G18_15n I1_I1574_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I143_XG_MP0 (XI1_I1574_I143_XG_p1 I1_I1574_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I143_XG_MP1 (I1_I1574_G18_11 I1_I1574_G14_11n XI1_I1574_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I185_XG_MP2 (VDD I1_I1574_G18_3n I1_I1574_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I185_XG_MP0 (XI1_I1574_I185_XG_p1 I1_I1574_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I185_XG_MP1 (I1_I1574_G18_0 I1_I1574_G2_0n XI1_I1574_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I135_XG_MP2 (VDD I1_I1574_G10_7n I1_I1574_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I135_XG_MP0 (XI1_I1574_I135_XG_p1 I1_I1574_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I135_XG_MP1 (I1_I1574_G10_3 I1_I1574_G6_3n XI1_I1574_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I131_XG_MP2 (VDD I2_I1_I42_G6_3n I2_I1_I42_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I131_XG_MP0 (XI2_I1_I42_I131_XG_p1 I2_I1_I42_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I131_XG_MP1 (I2_I1_I42_G6_0 I2_I1_I42_G2_0n XI2_I1_I42_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I183_XG_MP2 (VDD I2_I1_I42_G16_1n I2_I1_I42_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I183_XG_MP0 (XI2_I1_I42_I183_XG_p1 I2_I1_I42_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I183_XG_MP1 (I2_I1_I42_G16_0 I2_I1_I42_G0_0n XI2_I1_I42_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I136_XG_MP2 (VDD I2_I1_I42_G11_8n I2_I1_I42_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I136_XG_MP0 (XI2_I1_I42_I136_XG_p1 I2_I1_I42_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I136_XG_MP1 (I2_I1_I42_G11_4 I2_I1_I42_G7_4n XI2_I1_I42_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I186_XG_MP2 (VDD I2_I1_I42_G19_4n I2_I1_I42_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I186_XG_MP0 (XI2_I1_I42_I186_XG_p1 I2_I1_I42_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I186_XG_MP1 (I2_I1_I42_G19_0 I2_I1_I42_G3_0n XI2_I1_I42_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I196_XG_MP2 (VDD I2_I1_I42_G25_10n I2_I1_I42_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I196_XG_MP0 (XI2_I1_I42_I196_XG_p1 I2_I1_I42_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I196_XG_MP1 (I2_I1_I42_G25_0 I2_I1_I42_G9_0n XI2_I1_I42_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I87_XG_MP2 (VDD I1_I1712_gn21 I1_I1712_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I87_XG_MP0 (XI1_I1712_I87_XG_p1 I1_I1712_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I87_XG_MP1 (I1_I1712_G21_20 I1_I1712_gn20 XI1_I1712_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I86_XG_MP2 (VDD I1_I1712_gn20 I1_I1712_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I86_XG_MP0 (XI1_I1712_I86_XG_p1 I1_I1712_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I86_XG_MP1 (I1_I1712_G20_19 I1_I1712_gn19 XI1_I1712_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I85_XG_MP2 (VDD I1_I1712_gn19 I1_I1712_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I85_XG_MP0 (XI1_I1712_I85_XG_p1 I1_I1712_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I85_XG_MP1 (I1_I1712_G19_18 I1_I1712_gn18 XI1_I1712_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I79_XG_MP2 (VDD I1_I1712_gn13 I1_I1712_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I79_XG_MP0 (XI1_I1712_I79_XG_p1 I1_I1712_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I79_XG_MP1 (I1_I1712_G13_12 I1_I1712_gn12 XI1_I1712_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I78_XG_MP2 (VDD I1_I1712_gn12 I1_I1712_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I78_XG_MP0 (XI1_I1712_I78_XG_p1 I1_I1712_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I78_XG_MP1 (I1_I1712_G12_11 I1_I1712_gn11 XI1_I1712_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I77_XG_MP2 (VDD I1_I1712_gn11 I1_I1712_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I77_XG_MP0 (XI1_I1712_I77_XG_p1 I1_I1712_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I77_XG_MP1 (I1_I1712_G11_10 I1_I1712_gn10 XI1_I1712_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I67_XG_MP2 (VDD I1_I1666_gn1 I1_I1666_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I67_XG_MP0 (XI1_I1666_I67_XG_p1 I1_I1666_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I67_XG_MP1 (I1_I1666_G1_0 I1_I1666_G0_0n XI1_I1666_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I68_XG_MP2 (VDD I1_I1666_gn2 I1_I1666_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I68_XG_MP0 (XI1_I1666_I68_XG_p1 I1_I1666_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I68_XG_MP1 (I1_I1666_G2_1 I1_I1666_gn1 XI1_I1666_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I69_XG_MP2 (VDD I1_I1666_gn3 I1_I1666_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I69_XG_MP0 (XI1_I1666_I69_XG_p1 I1_I1666_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I69_XG_MP1 (I1_I1666_G3_2 I1_I1666_gn2 XI1_I1666_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I201_XG_MP2 (VDD I1_I1574_G30_15n I1_c22_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I201_XG_MP0 (XI1_I1574_I201_XG_p1 I1_I1574_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I201_XG_MP1 (I1_c22_m I1_I1574_G14_0n XI1_I1574_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I192_XG_MP2 (VDD I1_I1574_G22_7n I1_I1574_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I192_XG_MP0 (XI1_I1574_I192_XG_p1 I1_I1574_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I192_XG_MP1 (I1_I1574_G22_0 I1_I1574_G6_0n XI1_I1574_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I197_XG_MP2 (VDD I1_I1574_G26_11n I1_I1574_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I197_XG_MP0 (XI1_I1574_I197_XG_p1 I1_I1574_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I197_XG_MP1 (I1_I1574_G26_0 I1_I1574_G10_0n XI1_I1574_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1574_I65_XG_MP2 (VDD I1_I1574_gn0 I1_I1574_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1574_I65_XG_MP0 (XI1_I1574_I65_XG_p1 I1_I1574_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1574_I65_XG_MP1 (I1_I1574_G0_0 I1_I1574_cinn XI1_I1574_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I74_XG_MP2 (VDD I2_I1_I42_gn8 I2_I1_I42_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I74_XG_MP0 (XI2_I1_I42_I74_XG_p1 I2_I1_I42_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I74_XG_MP1 (I2_I1_I42_G8_7 I2_I1_I42_gn7 XI2_I1_I42_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I75_XG_MP2 (VDD I2_I1_I42_gn9 I2_I1_I42_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I75_XG_MP0 (XI2_I1_I42_I75_XG_p1 I2_I1_I42_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I75_XG_MP1 (I2_I1_I42_G9_8 I2_I1_I42_gn8 XI2_I1_I42_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I133_XG_MP2 (VDD I2_I1_I42_G8_5n I2_I1_I42_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I133_XG_MP0 (XI2_I1_I42_I133_XG_p1 I2_I1_I42_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I133_XG_MP1 (I2_I1_I42_G8_1 I2_I1_I42_G4_1n XI2_I1_I42_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I132_XG_MP2 (VDD I2_I1_I42_G7_4n I2_I1_I42_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I132_XG_MP0 (XI2_I1_I42_I132_XG_p1 I2_I1_I42_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I132_XG_MP1 (I2_I1_I42_G7_0 I2_I1_I42_G3_0n XI2_I1_I42_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I134_XG_MP2 (VDD I2_I1_I42_G9_6n I2_I1_I42_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I134_XG_MP0 (XI2_I1_I42_I134_XG_p1 I2_I1_I42_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I134_XG_MP1 (I2_I1_I42_G9_2 I2_I1_I42_G5_2n XI2_I1_I42_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I184_XG_MP2 (VDD I2_I1_I42_G17_2n I2_I1_I42_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I184_XG_MP0 (XI2_I1_I42_I184_XG_p1 I2_I1_I42_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I184_XG_MP1 (I2_I1_I42_G17_0 I2_I1_I42_G1_0n XI2_I1_I42_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I81_XG_MP2 (VDD I1_I1712_gn15 I1_I1712_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I81_XG_MP0 (XI1_I1712_I81_XG_p1 I1_I1712_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I81_XG_MP1 (I1_I1712_G15_14 I1_I1712_gn14 XI1_I1712_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1712_I80_XG_MP2 (VDD I1_I1712_gn14 I1_I1712_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1712_I80_XG_MP0 (XI1_I1712_I80_XG_p1 I1_I1712_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1712_I80_XG_MP1 (I1_I1712_G14_13 I1_I1712_gn13 XI1_I1712_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I185_XG_MP2 (VDD I1_I1666_G18_3n I1_I1666_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I185_XG_MP0 (XI1_I1666_I185_XG_p1 I1_I1666_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I185_XG_MP1 (I1_I1666_G18_0 I1_I1666_G2_0n XI1_I1666_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I183_XG_MP2 (VDD I1_I1666_G16_1n I1_I1666_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I183_XG_MP0 (XI1_I1666_I183_XG_p1 I1_I1666_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I183_XG_MP1 (I1_I1666_G16_0 I1_I1666_G0_0n XI1_I1666_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I128_XG_MP2 (VDD I1_I1666_G4_1n I1_I1666_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I128_XG_MP0 (XI1_I1666_I128_XG_p1 I1_I1666_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I128_XG_MP1 (I1_I1666_G4_0 I1_I1666_G0_0n XI1_I1666_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I70_XG_MP2 (VDD I1_I1666_gn4 I1_I1666_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I70_XG_MP0 (XI1_I1666_I70_XG_p1 I1_I1666_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I70_XG_MP1 (I1_I1666_G4_3 I1_I1666_gn3 XI1_I1666_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I71_XG_MP2 (VDD I1_I1666_gn5 I1_I1666_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I71_XG_MP0 (XI1_I1666_I71_XG_p1 I1_I1666_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I71_XG_MP1 (I1_I1666_G5_4 I1_I1666_gn4 XI1_I1666_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I73_XG_MP2 (VDD I2_I1_I42_gn7 I2_I1_I42_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I73_XG_MP0 (XI2_I1_I42_I73_XG_p1 I2_I1_I42_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I73_XG_MP1 (I2_I1_I42_G7_6 I2_I1_I42_gn6 XI2_I1_I42_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I72_XG_MP2 (VDD I2_I1_I42_gn6 I2_I1_I42_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I72_XG_MP0 (XI2_I1_I42_I72_XG_p1 I2_I1_I42_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I72_XG_MP1 (I2_I1_I42_G6_5 I2_I1_I42_gn5 XI2_I1_I42_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I130_XG_MP2 (VDD I2_I1_I42_G5_2n I2_I1_I42_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I130_XG_MP0 (XI2_I1_I42_I130_XG_p1 I2_I1_I42_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I130_XG_MP1 (I2_I1_I42_G5_0 I2_I1_I42_G1_0n XI2_I1_I42_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I131_XG_MP2 (VDD I1_I1666_G6_3n I1_I1666_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I131_XG_MP0 (XI1_I1666_I131_XG_p1 I1_I1666_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I131_XG_MP1 (I1_I1666_G6_0 I1_I1666_G2_0n XI1_I1666_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I133_XG_MP2 (VDD I1_I1666_G8_5n I1_I1666_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I133_XG_MP0 (XI1_I1666_I133_XG_p1 I1_I1666_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I133_XG_MP1 (I1_I1666_G8_1 I1_I1666_G4_1n XI1_I1666_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I130_XG_MP2 (VDD I1_I1666_G5_2n I1_I1666_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I130_XG_MP0 (XI1_I1666_I130_XG_p1 I1_I1666_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I130_XG_MP1 (I1_I1666_G5_0 I1_I1666_G1_0n XI1_I1666_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I72_XG_MP2 (VDD I1_I1666_gn6 I1_I1666_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I72_XG_MP0 (XI1_I1666_I72_XG_p1 I1_I1666_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I72_XG_MP1 (I1_I1666_G6_5 I1_I1666_gn5 XI1_I1666_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I73_XG_MP2 (VDD I1_I1666_gn7 I1_I1666_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I73_XG_MP0 (XI1_I1666_I73_XG_p1 I1_I1666_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I73_XG_MP1 (I1_I1666_G7_6 I1_I1666_gn6 XI1_I1666_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I74_XG_MP2 (VDD I1_I1666_gn8 I1_I1666_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I74_XG_MP0 (XI1_I1666_I74_XG_p1 I1_I1666_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I74_XG_MP1 (I1_I1666_G8_7 I1_I1666_gn7 XI1_I1666_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I65_XG_MP2 (VDD I1_I1620_gn0 I1_I1620_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I65_XG_MP0 (XI1_I1620_I65_XG_p1 I1_I1620_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I65_XG_MP1 (I1_I1620_G0_0 I1_I1620_cinn XI1_I1620_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I71_XG_MP2 (VDD I2_I1_I42_gn5 I2_I1_I42_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I71_XG_MP0 (XI2_I1_I42_I71_XG_p1 I2_I1_I42_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I71_XG_MP1 (I2_I1_I42_G5_4 I2_I1_I42_gn4 XI2_I1_I42_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I128_XG_MP2 (VDD I2_I1_I42_G4_1n I2_I1_I42_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I128_XG_MP0 (XI2_I1_I42_I128_XG_p1 I2_I1_I42_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I128_XG_MP1 (I2_I1_I42_G4_0 I2_I1_I42_G0_0n XI2_I1_I42_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I135_XG_MP2 (VDD I1_I1666_G10_7n I1_I1666_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I135_XG_MP0 (XI1_I1666_I135_XG_p1 I1_I1666_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I135_XG_MP1 (I1_I1666_G10_3 I1_I1666_G6_3n XI1_I1666_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I195_XG_MP2 (VDD I1_I1666_G24_9n I1_I1666_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I195_XG_MP0 (XI1_I1666_I195_XG_p1 I1_I1666_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I195_XG_MP1 (I1_I1666_G24_0 I1_I1666_G8_0n XI1_I1666_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I132_XG_MP2 (VDD I1_I1666_G7_4n I1_I1666_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I132_XG_MP0 (XI1_I1666_I132_XG_p1 I1_I1666_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I132_XG_MP1 (I1_I1666_G7_0 I1_I1666_G3_0n XI1_I1666_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I184_XG_MP2 (VDD I1_I1666_G17_2n I1_I1666_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I184_XG_MP0 (XI1_I1666_I184_XG_p1 I1_I1666_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I184_XG_MP1 (I1_I1666_G17_0 I1_I1666_G1_0n XI1_I1666_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I134_XG_MP2 (VDD I1_I1666_G9_6n I1_I1666_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I134_XG_MP0 (XI1_I1666_I134_XG_p1 I1_I1666_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I134_XG_MP1 (I1_I1666_G9_2 I1_I1666_G5_2n XI1_I1666_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I75_XG_MP2 (VDD I1_I1666_gn9 I1_I1666_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I75_XG_MP0 (XI1_I1666_I75_XG_p1 I1_I1666_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I75_XG_MP1 (I1_I1666_G9_8 I1_I1666_gn8 XI1_I1666_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I76_XG_MP2 (VDD I1_I1666_gn10 I1_I1666_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I76_XG_MP0 (XI1_I1666_I76_XG_p1 I1_I1666_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I76_XG_MP1 (I1_I1666_G10_9 I1_I1666_gn9 XI1_I1666_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I75_XG_MP2 (VDD I1_I1620_gn9 I1_I1620_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I75_XG_MP0 (XI1_I1620_I75_XG_p1 I1_I1620_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I75_XG_MP1 (I1_I1620_G9_8 I1_I1620_gn8 XI1_I1620_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I74_XG_MP2 (VDD I1_I1620_gn8 I1_I1620_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I74_XG_MP0 (XI1_I1620_I74_XG_p1 I1_I1620_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I74_XG_MP1 (I1_I1620_G8_7 I1_I1620_gn7 XI1_I1620_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I73_XG_MP2 (VDD I1_I1620_gn7 I1_I1620_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I73_XG_MP0 (XI1_I1620_I73_XG_p1 I1_I1620_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I73_XG_MP1 (I1_I1620_G7_6 I1_I1620_gn6 XI1_I1620_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I70_XG_MP2 (VDD I2_I1_I42_gn4 I2_I1_I42_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I70_XG_MP0 (XI2_I1_I42_I70_XG_p1 I2_I1_I42_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I70_XG_MP1 (I2_I1_I42_G4_3 I2_I1_I42_gn3 XI2_I1_I42_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I69_XG_MP2 (VDD I2_I1_I42_gn3 I2_I1_I42_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I69_XG_MP0 (XI2_I1_I42_I69_XG_p1 I2_I1_I42_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I69_XG_MP1 (I2_I1_I42_G3_2 I2_I1_I42_gn2 XI2_I1_I42_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I95_XG_MP2 (VDD I1_I1758_gn29 I1_I1758_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I95_XG_MP0 (XI1_I1758_I95_XG_p1 I1_I1758_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I95_XG_MP1 (I1_I1758_G29_28 I1_I1758_gn28 XI1_I1758_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I94_XG_MP2 (VDD I1_I1758_gn28 I1_I1758_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I94_XG_MP0 (XI1_I1758_I94_XG_p1 I1_I1758_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I94_XG_MP1 (I1_I1758_G28_27 I1_I1758_gn27 XI1_I1758_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I93_XG_MP2 (VDD I1_I1758_gn27 I1_I1758_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I93_XG_MP0 (XI1_I1758_I93_XG_p1 I1_I1758_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I93_XG_MP1 (I1_I1758_G27_26 I1_I1758_gn26 XI1_I1758_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I188_XG_MP2 (VDD I1_I1666_G20_5n I1_I1666_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I188_XG_MP0 (XI1_I1666_I188_XG_p1 I1_I1666_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I188_XG_MP1 (I1_I1666_G20_0 I1_I1666_G4_0n XI1_I1666_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I141_XG_MP2 (VDD I1_I1666_G16_13n I1_I1666_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I141_XG_MP0 (XI1_I1666_I141_XG_p1 I1_I1666_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I141_XG_MP1 (I1_I1666_G16_9 I1_I1666_G12_9n XI1_I1666_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I137_XG_MP2 (VDD I1_I1666_G12_9n I1_I1666_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I137_XG_MP0 (XI1_I1666_I137_XG_p1 I1_I1666_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I137_XG_MP1 (I1_I1666_G12_5 I1_I1666_G8_5n XI1_I1666_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I186_XG_MP2 (VDD I1_I1666_G19_4n I1_I1666_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I186_XG_MP0 (XI1_I1666_I186_XG_p1 I1_I1666_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I186_XG_MP1 (I1_I1666_G19_0 I1_I1666_G3_0n XI1_I1666_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I136_XG_MP2 (VDD I1_I1666_G11_8n I1_I1666_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I136_XG_MP0 (XI1_I1666_I136_XG_p1 I1_I1666_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I136_XG_MP1 (I1_I1666_G11_4 I1_I1666_G7_4n XI1_I1666_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I77_XG_MP2 (VDD I1_I1666_gn11 I1_I1666_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I77_XG_MP0 (XI1_I1666_I77_XG_p1 I1_I1666_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I77_XG_MP1 (I1_I1666_G11_10 I1_I1666_gn10 XI1_I1666_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I78_XG_MP2 (VDD I1_I1666_gn12 I1_I1666_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I78_XG_MP0 (XI1_I1666_I78_XG_p1 I1_I1666_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I78_XG_MP1 (I1_I1666_G12_11 I1_I1666_gn11 XI1_I1666_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I80_XG_MP2 (VDD I1_I1620_gn14 I1_I1620_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I80_XG_MP0 (XI1_I1620_I80_XG_p1 I1_I1620_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I80_XG_MP1 (I1_I1620_G14_13 I1_I1620_gn13 XI1_I1620_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I79_XG_MP2 (VDD I1_I1620_gn13 I1_I1620_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I79_XG_MP0 (XI1_I1620_I79_XG_p1 I1_I1620_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I79_XG_MP1 (I1_I1620_G13_12 I1_I1620_gn12 XI1_I1620_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I78_XG_MP2 (VDD I1_I1620_gn12 I1_I1620_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I78_XG_MP0 (XI1_I1620_I78_XG_p1 I1_I1620_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I78_XG_MP1 (I1_I1620_G12_11 I1_I1620_gn11 XI1_I1620_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I72_XG_MP2 (VDD I1_I1620_gn6 I1_I1620_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I72_XG_MP0 (XI1_I1620_I72_XG_p1 I1_I1620_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I72_XG_MP1 (I1_I1620_G6_5 I1_I1620_gn5 XI1_I1620_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I69_XG_MP2 (VDD I1_I1620_gn3 I1_I1620_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I69_XG_MP0 (XI1_I1620_I69_XG_p1 I1_I1620_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I69_XG_MP1 (I1_I1620_G3_2 I1_I1620_gn2 XI1_I1620_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I68_XG_MP2 (VDD I1_I1620_gn2 I1_I1620_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I68_XG_MP0 (XI1_I1620_I68_XG_p1 I1_I1620_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I68_XG_MP1 (I1_I1620_G2_1 I1_I1620_gn1 XI1_I1620_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I67_XG_MP2 (VDD I1_I1620_gn1 I1_I1620_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I67_XG_MP0 (XI1_I1620_I67_XG_p1 I1_I1620_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I67_XG_MP1 (I1_I1620_G1_0 I1_I1620_G0_0n XI1_I1620_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I92_XG_MP2 (VDD I1_I1758_gn26 I1_I1758_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I92_XG_MP0 (XI1_I1758_I92_XG_p1 I1_I1758_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I92_XG_MP1 (I1_I1758_G26_25 I1_I1758_gn25 XI1_I1758_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I91_XG_MP2 (VDD I1_I1758_gn25 I1_I1758_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I91_XG_MP0 (XI1_I1758_I91_XG_p1 I1_I1758_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I91_XG_MP1 (I1_I1758_G25_24 I1_I1758_gn24 XI1_I1758_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I89_XG_MP2 (VDD I1_I1758_gn23 I1_I1758_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I89_XG_MP0 (XI1_I1758_I89_XG_p1 I1_I1758_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I89_XG_MP1 (I1_I1758_G23_22 I1_I1758_gn22 XI1_I1758_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I90_XG_MP2 (VDD I1_I1758_gn24 I1_I1758_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I90_XG_MP0 (XI1_I1758_I90_XG_p1 I1_I1758_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I90_XG_MP1 (I1_I1758_G24_23 I1_I1758_gn23 XI1_I1758_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I88_XG_MP2 (VDD I1_I1758_gn22 I1_I1758_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I88_XG_MP0 (XI1_I1758_I88_XG_p1 I1_I1758_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I88_XG_MP1 (I1_I1758_G22_21 I1_I1758_gn21 XI1_I1758_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I85_XG_MP2 (VDD I1_I1758_gn19 I1_I1758_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I85_XG_MP0 (XI1_I1758_I85_XG_p1 I1_I1758_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I85_XG_MP1 (I1_I1758_G19_18 I1_I1758_gn18 XI1_I1758_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I84_XG_MP2 (VDD I1_I1758_gn18 I1_I1758_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I84_XG_MP0 (XI1_I1758_I84_XG_p1 I1_I1758_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I84_XG_MP1 (I1_I1758_G18_17 I1_I1758_gn17 XI1_I1758_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I83_XG_MP2 (VDD I1_I1758_gn17 I1_I1758_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I83_XG_MP0 (XI1_I1758_I83_XG_p1 I1_I1758_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I83_XG_MP1 (I1_I1758_G17_16 I1_I1758_gn16 XI1_I1758_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I81_XG_MP2 (VDD I1_I1758_gn15 I1_I1758_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I81_XG_MP0 (XI1_I1758_I81_XG_p1 I1_I1758_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I81_XG_MP1 (I1_I1758_G15_14 I1_I1758_gn14 XI1_I1758_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I79_XG_MP2 (VDD I1_I1758_gn13 I1_I1758_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I79_XG_MP0 (XI1_I1758_I79_XG_p1 I1_I1758_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I79_XG_MP1 (I1_I1758_G13_12 I1_I1758_gn12 XI1_I1758_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I197_XG_MP2 (VDD I1_I1666_G26_11n I1_I1666_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I197_XG_MP0 (XI1_I1666_I197_XG_p1 I1_I1666_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I197_XG_MP1 (I1_I1666_G26_0 I1_I1666_G10_0n XI1_I1666_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I139_XG_MP2 (VDD I1_I1666_G14_11n I1_I1666_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I139_XG_MP0 (XI1_I1666_I139_XG_p1 I1_I1666_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I139_XG_MP1 (I1_I1666_G14_7 I1_I1666_G10_7n XI1_I1666_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I143_XG_MP2 (VDD I1_I1666_G18_15n I1_I1666_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I143_XG_MP0 (XI1_I1666_I143_XG_p1 I1_I1666_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I143_XG_MP1 (I1_I1666_G18_11 I1_I1666_G14_11n XI1_I1666_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I196_XG_MP2 (VDD I1_I1666_G25_10n I1_I1666_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I196_XG_MP0 (XI1_I1666_I196_XG_p1 I1_I1666_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I196_XG_MP1 (I1_I1666_G25_0 I1_I1666_G9_0n XI1_I1666_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I142_XG_MP2 (VDD I1_I1666_G17_14n I1_I1666_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I142_XG_MP0 (XI1_I1666_I142_XG_p1 I1_I1666_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I142_XG_MP1 (I1_I1666_G17_10 I1_I1666_G13_10n XI1_I1666_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I138_XG_MP2 (VDD I1_I1666_G13_10n I1_I1666_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I138_XG_MP0 (XI1_I1666_I138_XG_p1 I1_I1666_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I138_XG_MP1 (I1_I1666_G13_6 I1_I1666_G9_6n XI1_I1666_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I80_XG_MP2 (VDD I1_I1666_gn14 I1_I1666_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I80_XG_MP0 (XI1_I1666_I80_XG_p1 I1_I1666_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I80_XG_MP1 (I1_I1666_G14_13 I1_I1666_gn13 XI1_I1666_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I79_XG_MP2 (VDD I1_I1666_gn13 I1_I1666_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I79_XG_MP0 (XI1_I1666_I79_XG_p1 I1_I1666_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I79_XG_MP1 (I1_I1666_G13_12 I1_I1666_gn12 XI1_I1666_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I82_XG_MP2 (VDD I1_I1620_gn16 I1_I1620_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I82_XG_MP0 (XI1_I1620_I82_XG_p1 I1_I1620_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I82_XG_MP1 (I1_I1620_G16_15 I1_I1620_gn15 XI1_I1620_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I131_XG_MP2 (VDD I1_I1620_G6_3n I1_I1620_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I131_XG_MP0 (XI1_I1620_I131_XG_p1 I1_I1620_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I131_XG_MP1 (I1_I1620_G6_0 I1_I1620_G2_0n XI1_I1620_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I81_XG_MP2 (VDD I1_I1620_gn15 I1_I1620_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I81_XG_MP0 (XI1_I1620_I81_XG_p1 I1_I1620_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I81_XG_MP1 (I1_I1620_G15_14 I1_I1620_gn14 XI1_I1620_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I128_XG_MP2 (VDD I1_I1620_G4_1n I1_I1620_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I128_XG_MP0 (XI1_I1620_I128_XG_p1 I1_I1620_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I128_XG_MP1 (I1_I1620_G4_0 I1_I1620_G0_0n XI1_I1620_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I97_XG_MP2 (VDD I1_I1758_gn31 I1_I1758_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I97_XG_MP0 (XI1_I1758_I97_XG_p1 I1_I1758_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I97_XG_MP1 (I1_I1758_G31_30 I1_I1758_gn30 XI1_I1758_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I96_XG_MP2 (VDD I1_I1758_gn30 I1_I1758_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I96_XG_MP0 (XI1_I1758_I96_XG_p1 I1_I1758_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I96_XG_MP1 (I1_I1758_G30_29 I1_I1758_gn29 XI1_I1758_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I144_XG_MP2 (VDD I1_I1758_G19_16n I1_I1758_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I144_XG_MP0 (XI1_I1758_I144_XG_p1 I1_I1758_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I144_XG_MP1 (I1_I1758_G19_12 I1_I1758_G15_12n XI1_I1758_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I77_XG_MP2 (VDD I1_I1758_gn11 I1_I1758_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I77_XG_MP0 (XI1_I1758_I77_XG_p1 I1_I1758_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I77_XG_MP1 (I1_I1758_G11_10 I1_I1758_gn10 XI1_I1758_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I199_XG_MP2 (VDD I1_I1666_G28_13n I1_I1666_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I199_XG_MP0 (XI1_I1666_I199_XG_p1 I1_I1666_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I199_XG_MP1 (I1_I1666_G28_0 I1_I1666_G12_0n XI1_I1666_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I145_XG_MP2 (VDD I1_I1666_G20_17n I1_I1666_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I145_XG_MP0 (XI1_I1666_I145_XG_p1 I1_I1666_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I145_XG_MP1 (I1_I1666_G20_13 I1_I1666_G16_13n XI1_I1666_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I198_XG_MP2 (VDD I1_I1666_G27_12n I1_I1666_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I198_XG_MP0 (XI1_I1666_I198_XG_p1 I1_I1666_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I198_XG_MP1 (I1_I1666_G27_0 I1_I1666_G11_0n XI1_I1666_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I190_XG_MP2 (VDD I1_I1666_G21_6n I1_I1666_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I190_XG_MP0 (XI1_I1666_I190_XG_p1 I1_I1666_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I190_XG_MP1 (I1_I1666_G21_0 I1_I1666_G5_0n XI1_I1666_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I140_XG_MP2 (VDD I1_I1666_G15_12n I1_I1666_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I140_XG_MP0 (XI1_I1666_I140_XG_p1 I1_I1666_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I140_XG_MP1 (I1_I1666_G15_8 I1_I1666_G11_8n XI1_I1666_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I81_XG_MP2 (VDD I1_I1666_gn15 I1_I1666_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I81_XG_MP0 (XI1_I1666_I81_XG_p1 I1_I1666_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I81_XG_MP1 (I1_I1666_G15_14 I1_I1666_gn14 XI1_I1666_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I185_XG_MP2 (VDD I1_I1620_G18_3n I1_I1620_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I185_XG_MP0 (XI1_I1620_I185_XG_p1 I1_I1620_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I185_XG_MP1 (I1_I1620_G18_0 I1_I1620_G2_0n XI1_I1620_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I83_XG_MP2 (VDD I1_I1620_gn17 I1_I1620_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I83_XG_MP0 (XI1_I1620_I83_XG_p1 I1_I1620_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I83_XG_MP1 (I1_I1620_G17_16 I1_I1620_gn16 XI1_I1620_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I135_XG_MP2 (VDD I1_I1620_G10_7n I1_I1620_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I135_XG_MP0 (XI1_I1620_I135_XG_p1 I1_I1620_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I135_XG_MP1 (I1_I1620_G10_3 I1_I1620_G6_3n XI1_I1620_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I137_XG_MP2 (VDD I1_I1620_G12_9n I1_I1620_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I137_XG_MP0 (XI1_I1620_I137_XG_p1 I1_I1620_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I137_XG_MP1 (I1_I1620_G12_5 I1_I1620_G8_5n XI1_I1620_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I133_XG_MP2 (VDD I1_I1620_G8_5n I1_I1620_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I133_XG_MP0 (XI1_I1620_I133_XG_p1 I1_I1620_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I133_XG_MP1 (I1_I1620_G8_1 I1_I1620_G4_1n XI1_I1620_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I156_XG_MP2 (VDD I1_I1758_G31_28n I1_I1758_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I156_XG_MP0 (XI1_I1758_I156_XG_p1 I1_I1758_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I156_XG_MP1 (I1_I1758_G31_24 I1_I1758_G27_24n XI1_I1758_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I154_XG_MP2 (VDD I1_I1758_G29_26n I1_I1758_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I154_XG_MP0 (XI1_I1758_I154_XG_p1 I1_I1758_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I154_XG_MP1 (I1_I1758_G29_22 I1_I1758_G25_22n XI1_I1758_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I152_XG_MP2 (VDD I1_I1758_G27_24n I1_I1758_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I152_XG_MP0 (XI1_I1758_I152_XG_p1 I1_I1758_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I152_XG_MP1 (I1_I1758_G27_20 I1_I1758_G23_20n XI1_I1758_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I140_XG_MP2 (VDD I1_I1758_G15_12n I1_I1758_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I140_XG_MP0 (XI1_I1758_I140_XG_p1 I1_I1758_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I140_XG_MP1 (I1_I1758_G15_8 I1_I1758_G11_8n XI1_I1758_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I142_XG_MP2 (VDD I1_I1758_G17_14n I1_I1758_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I142_XG_MP0 (XI1_I1758_I142_XG_p1 I1_I1758_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I142_XG_MP1 (I1_I1758_G17_10 I1_I1758_G13_10n XI1_I1758_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I76_XG_MP2 (VDD I1_I1758_gn10 I1_I1758_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I76_XG_MP0 (XI1_I1758_I76_XG_p1 I1_I1758_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I76_XG_MP1 (I1_I1758_G10_9 I1_I1758_gn9 XI1_I1758_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I75_XG_MP2 (VDD I1_I1758_gn9 I1_I1758_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I75_XG_MP0 (XI1_I1758_I75_XG_p1 I1_I1758_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I75_XG_MP1 (I1_I1758_G9_8 I1_I1758_gn8 XI1_I1758_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I74_XG_MP2 (VDD I1_I1758_gn8 I1_I1758_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I74_XG_MP0 (XI1_I1758_I74_XG_p1 I1_I1758_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I74_XG_MP1 (I1_I1758_G8_7 I1_I1758_gn7 XI1_I1758_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I192_XG_MP2 (VDD I1_I1666_G22_7n I1_I1666_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I192_XG_MP0 (XI1_I1666_I192_XG_p1 I1_I1666_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I192_XG_MP1 (I1_I1666_G22_0 I1_I1666_G6_0n XI1_I1666_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I149_XG_MP2 (VDD I1_I1666_G24_21n I1_I1666_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I149_XG_MP0 (XI1_I1666_I149_XG_p1 I1_I1666_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I149_XG_MP1 (I1_I1666_G24_17 I1_I1666_G20_17n XI1_I1666_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I200_XG_MP2 (VDD I1_I1666_G29_14n I1_I1666_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I200_XG_MP0 (XI1_I1666_I200_XG_p1 I1_I1666_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I200_XG_MP1 (I1_I1666_G29_0 I1_I1666_G13_0n XI1_I1666_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I144_XG_MP2 (VDD I1_I1666_G19_16n I1_I1666_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I144_XG_MP0 (XI1_I1666_I144_XG_p1 I1_I1666_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I144_XG_MP1 (I1_I1666_G19_12 I1_I1666_G15_12n XI1_I1666_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I146_XG_MP2 (VDD I1_I1666_G21_18n I1_I1666_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I146_XG_MP0 (XI1_I1666_I146_XG_p1 I1_I1666_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I146_XG_MP1 (I1_I1666_G21_14 I1_I1666_G17_14n XI1_I1666_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I84_XG_MP2 (VDD I1_I1666_gn18 I1_I1666_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I84_XG_MP0 (XI1_I1666_I84_XG_p1 I1_I1666_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I84_XG_MP1 (I1_I1666_G18_17 I1_I1666_gn17 XI1_I1666_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I82_XG_MP2 (VDD I1_I1666_gn16 I1_I1666_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I82_XG_MP0 (XI1_I1666_I82_XG_p1 I1_I1666_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I82_XG_MP1 (I1_I1666_G16_15 I1_I1666_gn15 XI1_I1666_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I83_XG_MP2 (VDD I1_I1666_gn17 I1_I1666_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I83_XG_MP0 (XI1_I1666_I83_XG_p1 I1_I1666_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I83_XG_MP1 (I1_I1666_G17_16 I1_I1666_gn16 XI1_I1666_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I143_XG_MP2 (VDD I1_I1620_G18_15n I1_I1620_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I143_XG_MP0 (XI1_I1620_I143_XG_p1 I1_I1620_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I143_XG_MP1 (I1_I1620_G18_11 I1_I1620_G14_11n XI1_I1620_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I139_XG_MP2 (VDD I1_I1620_G14_11n I1_I1620_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I139_XG_MP0 (XI1_I1620_I139_XG_p1 I1_I1620_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I139_XG_MP1 (I1_I1620_G14_7 I1_I1620_G10_7n XI1_I1620_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I141_XG_MP2 (VDD I1_I1620_G16_13n I1_I1620_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I141_XG_MP0 (XI1_I1620_I141_XG_p1 I1_I1620_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I141_XG_MP1 (I1_I1620_G16_9 I1_I1620_G12_9n XI1_I1620_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I130_XG_MP2 (VDD I1_I1620_G5_2n I1_I1620_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I130_XG_MP0 (XI1_I1620_I130_XG_p1 I1_I1620_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I130_XG_MP1 (I1_I1620_G5_0 I1_I1620_G1_0n XI1_I1620_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I183_XG_MP2 (VDD I1_I1620_G16_1n I1_I1620_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I183_XG_MP0 (XI1_I1620_I183_XG_p1 I1_I1620_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I183_XG_MP1 (I1_I1620_G16_0 I1_I1620_G0_0n XI1_I1620_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI2_I1_I42_I65_XG_MP2 (VDD I2_I1_I42_gn0 I2_I1_I42_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI2_I1_I42_I65_XG_MP0 (XI2_I1_I42_I65_XG_p1 I2_I1_I42_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI2_I1_I42_I65_XG_MP1 (I2_I1_I42_G0_0 I2_I1_I42_cinn XI2_I1_I42_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I202_XG_MP2 (VDD I1_I1758_G31_16n I1_c26_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I202_XG_MP0 (XI1_I1758_I202_XG_p1 I1_I1758_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I202_XG_MP1 (I1_c26_o I1_I1758_G15_0n XI1_I1758_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I200_XG_MP2 (VDD I1_I1758_G29_14n I1_I1758_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I200_XG_MP0 (XI1_I1758_I200_XG_p1 I1_I1758_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I200_XG_MP1 (I1_I1758_G29_0 I1_I1758_G13_0n XI1_I1758_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I194_XG_MP2 (VDD I1_I1758_G23_8n I1_I1758_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I194_XG_MP0 (XI1_I1758_I194_XG_p1 I1_I1758_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I194_XG_MP1 (I1_I1758_G23_0 I1_I1758_G7_0n XI1_I1758_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I196_XG_MP2 (VDD I1_I1758_G25_10n I1_I1758_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I196_XG_MP0 (XI1_I1758_I196_XG_p1 I1_I1758_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I196_XG_MP1 (I1_I1758_G25_0 I1_I1758_G9_0n XI1_I1758_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I138_XG_MP2 (VDD I1_I1758_G13_10n I1_I1758_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I138_XG_MP0 (XI1_I1758_I138_XG_p1 I1_I1758_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I138_XG_MP1 (I1_I1758_G13_6 I1_I1758_G9_6n XI1_I1758_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I136_XG_MP2 (VDD I1_I1758_G11_8n I1_I1758_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I136_XG_MP0 (XI1_I1758_I136_XG_p1 I1_I1758_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I136_XG_MP1 (I1_I1758_G11_4 I1_I1758_G7_4n XI1_I1758_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I132_XG_MP2 (VDD I1_I1758_G7_4n I1_I1758_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I132_XG_MP0 (XI1_I1758_I132_XG_p1 I1_I1758_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I132_XG_MP1 (I1_I1758_G7_0 I1_I1758_G3_0n XI1_I1758_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I73_XG_MP2 (VDD I1_I1758_gn7 I1_I1758_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I73_XG_MP0 (XI1_I1758_I73_XG_p1 I1_I1758_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I73_XG_MP1 (I1_I1758_G7_6 I1_I1758_gn6 XI1_I1758_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I201_XG_MP2 (VDD I1_I1666_G30_15n I1_c24_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I201_XG_MP0 (XI1_I1666_I201_XG_p1 I1_I1666_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I201_XG_MP1 (I1_c24_m I1_I1666_G14_0n XI1_I1666_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I151_XG_MP2 (VDD I1_I1666_G26_23n I1_I1666_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I151_XG_MP0 (XI1_I1666_I151_XG_p1 I1_I1666_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I151_XG_MP1 (I1_I1666_G26_19 I1_I1666_G22_19n XI1_I1666_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I147_XG_MP2 (VDD I1_I1666_G22_19n I1_I1666_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I147_XG_MP0 (XI1_I1666_I147_XG_p1 I1_I1666_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I147_XG_MP1 (I1_I1666_G22_15 I1_I1666_G18_15n XI1_I1666_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I194_XG_MP2 (VDD I1_I1666_G23_8n I1_I1666_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I194_XG_MP0 (XI1_I1666_I194_XG_p1 I1_I1666_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I194_XG_MP1 (I1_I1666_G23_0 I1_I1666_G7_0n XI1_I1666_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I150_XG_MP2 (VDD I1_I1666_G25_22n I1_I1666_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I150_XG_MP0 (XI1_I1666_I150_XG_p1 I1_I1666_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I150_XG_MP1 (I1_I1666_G25_18 I1_I1666_G21_18n XI1_I1666_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I86_XG_MP2 (VDD I1_I1666_gn20 I1_I1666_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I86_XG_MP0 (XI1_I1666_I86_XG_p1 I1_I1666_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I86_XG_MP1 (I1_I1666_G20_19 I1_I1666_gn19 XI1_I1666_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I85_XG_MP2 (VDD I1_I1666_gn19 I1_I1666_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I85_XG_MP0 (XI1_I1666_I85_XG_p1 I1_I1666_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I85_XG_MP1 (I1_I1666_G19_18 I1_I1666_gn18 XI1_I1666_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I192_XG_MP2 (VDD I1_I1620_G22_7n I1_I1620_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I192_XG_MP0 (XI1_I1620_I192_XG_p1 I1_I1620_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I192_XG_MP1 (I1_I1620_G22_0 I1_I1620_G6_0n XI1_I1620_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I197_XG_MP2 (VDD I1_I1620_G26_11n I1_I1620_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I197_XG_MP0 (XI1_I1620_I197_XG_p1 I1_I1620_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I197_XG_MP1 (I1_I1620_G26_0 I1_I1620_G10_0n XI1_I1620_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I147_XG_MP2 (VDD I1_I1620_G22_19n I1_I1620_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I147_XG_MP0 (XI1_I1620_I147_XG_p1 I1_I1620_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I147_XG_MP1 (I1_I1620_G22_15 I1_I1620_G18_15n XI1_I1620_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I84_XG_MP2 (VDD I1_I1620_gn18 I1_I1620_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I84_XG_MP0 (XI1_I1620_I84_XG_p1 I1_I1620_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I84_XG_MP1 (I1_I1620_G18_17 I1_I1620_gn17 XI1_I1620_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I188_XG_MP2 (VDD I1_I1620_G20_5n I1_I1620_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I188_XG_MP0 (XI1_I1620_I188_XG_p1 I1_I1620_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I188_XG_MP1 (I1_I1620_G20_0 I1_I1620_G4_0n XI1_I1620_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I136_XG_MP2 (VDD I1_I1620_G11_8n I1_I1620_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I136_XG_MP0 (XI1_I1620_I136_XG_p1 I1_I1620_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I136_XG_MP1 (I1_I1620_G11_4 I1_I1620_G7_4n XI1_I1620_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I142_XG_MP2 (VDD I1_I1620_G17_14n I1_I1620_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I142_XG_MP0 (XI1_I1620_I142_XG_p1 I1_I1620_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I142_XG_MP1 (I1_I1620_G17_10 I1_I1620_G13_10n XI1_I1620_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I138_XG_MP2 (VDD I1_I1620_G13_10n I1_I1620_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I138_XG_MP0 (XI1_I1620_I138_XG_p1 I1_I1620_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I138_XG_MP1 (I1_I1620_G13_6 I1_I1620_G9_6n XI1_I1620_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I184_XG_MP2 (VDD I1_I1620_G17_2n I1_I1620_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I184_XG_MP0 (XI1_I1620_I184_XG_p1 I1_I1620_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I184_XG_MP1 (I1_I1620_G17_0 I1_I1620_G1_0n XI1_I1620_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I198_XG_MP2 (VDD I1_I1758_G27_12n I1_I1758_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I198_XG_MP0 (XI1_I1758_I198_XG_p1 I1_I1758_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I198_XG_MP1 (I1_I1758_G27_0 I1_I1758_G11_0n XI1_I1758_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I190_XG_MP2 (VDD I1_I1758_G21_6n I1_I1758_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I190_XG_MP0 (XI1_I1758_I190_XG_p1 I1_I1758_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I190_XG_MP1 (I1_I1758_G21_0 I1_I1758_G5_0n XI1_I1758_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I186_XG_MP2 (VDD I1_I1758_G19_4n I1_I1758_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I186_XG_MP0 (XI1_I1758_I186_XG_p1 I1_I1758_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I186_XG_MP1 (I1_I1758_G19_0 I1_I1758_G3_0n XI1_I1758_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I184_XG_MP2 (VDD I1_I1758_G17_2n I1_I1758_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I184_XG_MP0 (XI1_I1758_I184_XG_p1 I1_I1758_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I184_XG_MP1 (I1_I1758_G17_0 I1_I1758_G1_0n XI1_I1758_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I134_XG_MP2 (VDD I1_I1758_G9_6n I1_I1758_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I134_XG_MP0 (XI1_I1758_I134_XG_p1 I1_I1758_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I134_XG_MP1 (I1_I1758_G9_2 I1_I1758_G5_2n XI1_I1758_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I153_XG_MP2 (VDD I1_I1666_G28_25n I1_I1666_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I153_XG_MP0 (XI1_I1666_I153_XG_p1 I1_I1666_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I153_XG_MP1 (I1_I1666_G28_21 I1_I1666_G24_21n XI1_I1666_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I202_XG_MP2 (VDD I1_I1666_G31_16n I1_c24_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I202_XG_MP0 (XI1_I1666_I202_XG_p1 I1_I1666_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I202_XG_MP1 (I1_c24_o I1_I1666_G15_0n XI1_I1666_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I87_XG_MP2 (VDD I1_I1666_gn21 I1_I1666_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I87_XG_MP0 (XI1_I1666_I87_XG_p1 I1_I1666_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I87_XG_MP1 (I1_I1666_G21_20 I1_I1666_gn20 XI1_I1666_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I86_XG_MP2 (VDD I1_I1620_gn20 I1_I1620_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I86_XG_MP0 (XI1_I1620_I86_XG_p1 I1_I1620_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I86_XG_MP1 (I1_I1620_G20_19 I1_I1620_gn19 XI1_I1620_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I85_XG_MP2 (VDD I1_I1620_gn19 I1_I1620_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I85_XG_MP0 (XI1_I1620_I85_XG_p1 I1_I1620_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I85_XG_MP1 (I1_I1620_G19_18 I1_I1620_gn18 XI1_I1620_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I145_XG_MP2 (VDD I1_I1620_G20_17n I1_I1620_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I145_XG_MP0 (XI1_I1620_I145_XG_p1 I1_I1620_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I145_XG_MP1 (I1_I1620_G20_13 I1_I1620_G16_13n XI1_I1620_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I195_XG_MP2 (VDD I1_I1620_G24_9n I1_I1620_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I195_XG_MP0 (XI1_I1620_I195_XG_p1 I1_I1620_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I195_XG_MP1 (I1_I1620_G24_0 I1_I1620_G8_0n XI1_I1620_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I140_XG_MP2 (VDD I1_I1620_G15_12n I1_I1620_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I140_XG_MP0 (XI1_I1620_I140_XG_p1 I1_I1620_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I140_XG_MP1 (I1_I1620_G15_8 I1_I1620_G11_8n XI1_I1620_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I155_XG_MP2 (VDD I1_I1758_G30_27n I1_I1758_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I155_XG_MP0 (XI1_I1758_I155_XG_p1 I1_I1758_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I155_XG_MP1 (I1_I1758_G30_23 I1_I1758_G26_23n XI1_I1758_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I153_XG_MP2 (VDD I1_I1758_G28_25n I1_I1758_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I153_XG_MP0 (XI1_I1758_I153_XG_p1 I1_I1758_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I153_XG_MP1 (I1_I1758_G28_21 I1_I1758_G24_21n XI1_I1758_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I151_XG_MP2 (VDD I1_I1758_G26_23n I1_I1758_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I151_XG_MP0 (XI1_I1758_I151_XG_p1 I1_I1758_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I151_XG_MP1 (I1_I1758_G26_19 I1_I1758_G22_19n XI1_I1758_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I147_XG_MP2 (VDD I1_I1758_G22_19n I1_I1758_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I147_XG_MP0 (XI1_I1758_I147_XG_p1 I1_I1758_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I147_XG_MP1 (I1_I1758_G22_15 I1_I1758_G18_15n XI1_I1758_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I149_XG_MP2 (VDD I1_I1758_G24_21n I1_I1758_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I149_XG_MP0 (XI1_I1758_I149_XG_p1 I1_I1758_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I149_XG_MP1 (I1_I1758_G24_17 I1_I1758_G20_17n XI1_I1758_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I130_XG_MP2 (VDD I1_I1758_G5_2n I1_I1758_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I130_XG_MP0 (XI1_I1758_I130_XG_p1 I1_I1758_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I130_XG_MP1 (I1_I1758_G5_0 I1_I1758_G1_0n XI1_I1758_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I72_XG_MP2 (VDD I1_I1758_gn6 I1_I1758_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I72_XG_MP0 (XI1_I1758_I72_XG_p1 I1_I1758_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I72_XG_MP1 (I1_I1758_G6_5 I1_I1758_gn5 XI1_I1758_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I71_XG_MP2 (VDD I1_I1758_gn5 I1_I1758_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I71_XG_MP0 (XI1_I1758_I71_XG_p1 I1_I1758_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I71_XG_MP1 (I1_I1758_G5_4 I1_I1758_gn4 XI1_I1758_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I155_XG_MP2 (VDD I1_I1666_G30_27n I1_I1666_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I155_XG_MP0 (XI1_I1666_I155_XG_p1 I1_I1666_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I155_XG_MP1 (I1_I1666_G30_23 I1_I1666_G26_23n XI1_I1666_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I156_XG_MP2 (VDD I1_I1666_G31_28n I1_I1666_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I156_XG_MP0 (XI1_I1666_I156_XG_p1 I1_I1666_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I156_XG_MP1 (I1_I1666_G31_24 I1_I1666_G27_24n XI1_I1666_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I154_XG_MP2 (VDD I1_I1666_G29_26n I1_I1666_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I154_XG_MP0 (XI1_I1666_I154_XG_p1 I1_I1666_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I154_XG_MP1 (I1_I1666_G29_22 I1_I1666_G25_22n XI1_I1666_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I201_XG_MP2 (VDD I1_I1620_G30_15n I1_c23_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I201_XG_MP0 (XI1_I1620_I201_XG_p1 I1_I1620_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I201_XG_MP1 (I1_c23_m I1_I1620_G14_0n XI1_I1620_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I151_XG_MP2 (VDD I1_I1620_G26_23n I1_I1620_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I151_XG_MP0 (XI1_I1620_I151_XG_p1 I1_I1620_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I151_XG_MP1 (I1_I1620_G26_19 I1_I1620_G22_19n XI1_I1620_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I199_XG_MP2 (VDD I1_I1620_G28_13n I1_I1620_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I199_XG_MP0 (XI1_I1620_I199_XG_p1 I1_I1620_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I199_XG_MP1 (I1_I1620_G28_0 I1_I1620_G12_0n XI1_I1620_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I149_XG_MP2 (VDD I1_I1620_G24_21n I1_I1620_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I149_XG_MP0 (XI1_I1620_I149_XG_p1 I1_I1620_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I149_XG_MP1 (I1_I1620_G24_17 I1_I1620_G20_17n XI1_I1620_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I144_XG_MP2 (VDD I1_I1620_G19_16n I1_I1620_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I144_XG_MP0 (XI1_I1620_I144_XG_p1 I1_I1620_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I144_XG_MP1 (I1_I1620_G19_12 I1_I1620_G15_12n XI1_I1620_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I186_XG_MP2 (VDD I1_I1620_G19_4n I1_I1620_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I186_XG_MP0 (XI1_I1620_I186_XG_p1 I1_I1620_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I186_XG_MP1 (I1_I1620_G19_0 I1_I1620_G3_0n XI1_I1620_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I201_XG_MP2 (VDD I1_I1758_G30_15n I1_c26_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I201_XG_MP0 (XI1_I1758_I201_XG_p1 I1_I1758_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I201_XG_MP1 (I1_c26_m I1_I1758_G14_0n XI1_I1758_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I145_XG_MP2 (VDD I1_I1758_G20_17n I1_I1758_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I145_XG_MP0 (XI1_I1758_I145_XG_p1 I1_I1758_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I145_XG_MP1 (I1_I1758_G20_13 I1_I1758_G16_13n XI1_I1758_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I143_XG_MP2 (VDD I1_I1758_G18_15n I1_I1758_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I143_XG_MP0 (XI1_I1758_I143_XG_p1 I1_I1758_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I143_XG_MP1 (I1_I1758_G18_11 I1_I1758_G14_11n XI1_I1758_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I137_XG_MP2 (VDD I1_I1758_G12_9n I1_I1758_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I137_XG_MP0 (XI1_I1758_I137_XG_p1 I1_I1758_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I137_XG_MP1 (I1_I1758_G12_5 I1_I1758_G8_5n XI1_I1758_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I135_XG_MP2 (VDD I1_I1758_G10_7n I1_I1758_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I135_XG_MP0 (XI1_I1758_I135_XG_p1 I1_I1758_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I135_XG_MP1 (I1_I1758_G10_3 I1_I1758_G6_3n XI1_I1758_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I70_XG_MP2 (VDD I1_I1758_gn4 I1_I1758_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I70_XG_MP0 (XI1_I1758_I70_XG_p1 I1_I1758_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I70_XG_MP1 (I1_I1758_G4_3 I1_I1758_gn3 XI1_I1758_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I69_XG_MP2 (VDD I1_I1758_gn3 I1_I1758_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I69_XG_MP0 (XI1_I1758_I69_XG_p1 I1_I1758_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I69_XG_MP1 (I1_I1758_G3_2 I1_I1758_gn2 XI1_I1758_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I91_XG_MP2 (VDD I1_I1666_gn25 I1_I1666_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I91_XG_MP0 (XI1_I1666_I91_XG_p1 I1_I1666_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I91_XG_MP1 (I1_I1666_G25_24 I1_I1666_gn24 XI1_I1666_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I90_XG_MP2 (VDD I1_I1666_gn24 I1_I1666_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I90_XG_MP0 (XI1_I1666_I90_XG_p1 I1_I1666_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I90_XG_MP1 (I1_I1666_G24_23 I1_I1666_gn23 XI1_I1666_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I87_XG_MP2 (VDD I1_I1620_gn21 I1_I1620_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I87_XG_MP0 (XI1_I1620_I87_XG_p1 I1_I1620_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I87_XG_MP1 (I1_I1620_G21_20 I1_I1620_gn20 XI1_I1620_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I88_XG_MP2 (VDD I1_I1620_gn22 I1_I1620_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I88_XG_MP0 (XI1_I1620_I88_XG_p1 I1_I1620_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I88_XG_MP1 (I1_I1620_G22_21 I1_I1620_gn21 XI1_I1620_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I202_XG_MP2 (VDD I1_I1620_G31_16n I1_c23_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I202_XG_MP0 (XI1_I1620_I202_XG_p1 I1_I1620_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I202_XG_MP1 (I1_c23_o I1_I1620_G15_0n XI1_I1620_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I146_XG_MP2 (VDD I1_I1620_G21_18n I1_I1620_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I146_XG_MP0 (XI1_I1620_I146_XG_p1 I1_I1620_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I146_XG_MP1 (I1_I1620_G21_14 I1_I1620_G17_14n XI1_I1620_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I190_XG_MP2 (VDD I1_I1620_G21_6n I1_I1620_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I190_XG_MP0 (XI1_I1620_I190_XG_p1 I1_I1620_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I190_XG_MP1 (I1_I1620_G21_0 I1_I1620_G5_0n XI1_I1620_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I199_XG_MP2 (VDD I1_I1758_G28_13n I1_I1758_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I199_XG_MP0 (XI1_I1758_I199_XG_p1 I1_I1758_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I199_XG_MP1 (I1_I1758_G28_0 I1_I1758_G12_0n XI1_I1758_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I197_XG_MP2 (VDD I1_I1758_G26_11n I1_I1758_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I197_XG_MP0 (XI1_I1758_I197_XG_p1 I1_I1758_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I197_XG_MP1 (I1_I1758_G26_0 I1_I1758_G10_0n XI1_I1758_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I192_XG_MP2 (VDD I1_I1758_G22_7n I1_I1758_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I192_XG_MP0 (XI1_I1758_I192_XG_p1 I1_I1758_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I192_XG_MP1 (I1_I1758_G22_0 I1_I1758_G6_0n XI1_I1758_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I188_XG_MP2 (VDD I1_I1758_G20_5n I1_I1758_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I188_XG_MP0 (XI1_I1758_I188_XG_p1 I1_I1758_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I188_XG_MP1 (I1_I1758_G20_0 I1_I1758_G4_0n XI1_I1758_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I185_XG_MP2 (VDD I1_I1758_G18_3n I1_I1758_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I185_XG_MP0 (XI1_I1758_I185_XG_p1 I1_I1758_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I185_XG_MP1 (I1_I1758_G18_0 I1_I1758_G2_0n XI1_I1758_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I133_XG_MP2 (VDD I1_I1758_G8_5n I1_I1758_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I133_XG_MP0 (XI1_I1758_I133_XG_p1 I1_I1758_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I133_XG_MP1 (I1_I1758_G8_1 I1_I1758_G4_1n XI1_I1758_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I131_XG_MP2 (VDD I1_I1758_G6_3n I1_I1758_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I131_XG_MP0 (XI1_I1758_I131_XG_p1 I1_I1758_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I131_XG_MP1 (I1_I1758_G6_0 I1_I1758_G2_0n XI1_I1758_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I68_XG_MP2 (VDD I1_I1758_gn2 I1_I1758_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I68_XG_MP0 (XI1_I1758_I68_XG_p1 I1_I1758_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I68_XG_MP1 (I1_I1758_G2_1 I1_I1758_gn1 XI1_I1758_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I67_XG_MP2 (VDD I1_I1758_gn1 I1_I1758_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I67_XG_MP0 (XI1_I1758_I67_XG_p1 I1_I1758_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I67_XG_MP1 (I1_I1758_G1_0 I1_I1758_G0_0n XI1_I1758_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I97_XG_MP2 (VDD I1_I1666_gn31 I1_I1666_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I97_XG_MP0 (XI1_I1666_I97_XG_p1 I1_I1666_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I97_XG_MP1 (I1_I1666_G31_30 I1_I1666_gn30 XI1_I1666_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I96_XG_MP2 (VDD I1_I1666_gn30 I1_I1666_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I96_XG_MP0 (XI1_I1666_I96_XG_p1 I1_I1666_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I96_XG_MP1 (I1_I1666_G30_29 I1_I1666_gn29 XI1_I1666_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I92_XG_MP2 (VDD I1_I1666_gn26 I1_I1666_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I92_XG_MP0 (XI1_I1666_I92_XG_p1 I1_I1666_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I92_XG_MP1 (I1_I1666_G26_25 I1_I1666_gn25 XI1_I1666_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I155_XG_MP2 (VDD I1_I1620_G30_27n I1_I1620_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I155_XG_MP0 (XI1_I1620_I155_XG_p1 I1_I1620_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I155_XG_MP1 (I1_I1620_G30_23 I1_I1620_G26_23n XI1_I1620_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I89_XG_MP2 (VDD I1_I1620_gn23 I1_I1620_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I89_XG_MP0 (XI1_I1620_I89_XG_p1 I1_I1620_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I89_XG_MP1 (I1_I1620_G23_22 I1_I1620_gn22 XI1_I1620_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I90_XG_MP2 (VDD I1_I1620_gn24 I1_I1620_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I90_XG_MP0 (XI1_I1620_I90_XG_p1 I1_I1620_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I90_XG_MP1 (I1_I1620_G24_23 I1_I1620_gn23 XI1_I1620_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I153_XG_MP2 (VDD I1_I1620_G28_25n I1_I1620_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I153_XG_MP0 (XI1_I1620_I153_XG_p1 I1_I1620_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I153_XG_MP1 (I1_I1620_G28_21 I1_I1620_G24_21n XI1_I1620_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I148_XG_MP2 (VDD I1_I1620_G23_20n I1_I1620_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I148_XG_MP0 (XI1_I1620_I148_XG_p1 I1_I1620_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I148_XG_MP1 (I1_I1620_G23_16 I1_I1620_G19_16n XI1_I1620_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I194_XG_MP2 (VDD I1_I1620_G23_8n I1_I1620_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I194_XG_MP0 (XI1_I1620_I194_XG_p1 I1_I1620_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I194_XG_MP1 (I1_I1620_G23_0 I1_I1620_G7_0n XI1_I1620_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I150_XG_MP2 (VDD I1_I1620_G25_22n I1_I1620_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I150_XG_MP0 (XI1_I1620_I150_XG_p1 I1_I1620_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I150_XG_MP1 (I1_I1620_G25_18 I1_I1620_G21_18n XI1_I1620_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I196_XG_MP2 (VDD I1_I1620_G25_10n I1_I1620_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I196_XG_MP0 (XI1_I1620_I196_XG_p1 I1_I1620_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I196_XG_MP1 (I1_I1620_G25_0 I1_I1620_G9_0n XI1_I1620_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I195_XG_MP2 (VDD I1_I1758_G24_9n I1_I1758_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I195_XG_MP0 (XI1_I1758_I195_XG_p1 I1_I1758_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I195_XG_MP1 (I1_I1758_G24_0 I1_I1758_G8_0n XI1_I1758_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I183_XG_MP2 (VDD I1_I1758_G16_1n I1_I1758_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I183_XG_MP0 (XI1_I1758_I183_XG_p1 I1_I1758_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I183_XG_MP1 (I1_I1758_G16_0 I1_I1758_G0_0n XI1_I1758_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I128_XG_MP2 (VDD I1_I1758_G4_1n I1_I1758_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I128_XG_MP0 (XI1_I1758_I128_XG_p1 I1_I1758_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I128_XG_MP1 (I1_I1758_G4_0 I1_I1758_G0_0n XI1_I1758_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1758_I65_XG_MP2 (VDD I1_I1758_gn0 I1_I1758_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1758_I65_XG_MP0 (XI1_I1758_I65_XG_p1 I1_I1758_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1758_I65_XG_MP1 (I1_I1758_G0_0 I1_I1758_cinn XI1_I1758_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1666_I95_XG_MP2 (VDD I1_I1666_gn29 I1_I1666_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1666_I95_XG_MP0 (XI1_I1666_I95_XG_p1 I1_I1666_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1666_I95_XG_MP1 (I1_I1666_G29_28 I1_I1666_gn28 XI1_I1666_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I97_XG_MP2 (VDD I1_I1620_gn31 I1_I1620_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I97_XG_MP0 (XI1_I1620_I97_XG_p1 I1_I1620_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I97_XG_MP1 (I1_I1620_G31_30 I1_I1620_gn30 XI1_I1620_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I92_XG_MP2 (VDD I1_I1620_gn26 I1_I1620_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I92_XG_MP0 (XI1_I1620_I92_XG_p1 I1_I1620_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I92_XG_MP1 (I1_I1620_G26_25 I1_I1620_gn25 XI1_I1620_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I91_XG_MP2 (VDD I1_I1620_gn25 I1_I1620_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I91_XG_MP0 (XI1_I1620_I91_XG_p1 I1_I1620_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I91_XG_MP1 (I1_I1620_G25_24 I1_I1620_gn24 XI1_I1620_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I152_XG_MP2 (VDD I1_I1620_G27_24n I1_I1620_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I152_XG_MP0 (XI1_I1620_I152_XG_p1 I1_I1620_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I152_XG_MP1 (I1_I1620_G27_20 I1_I1620_G23_20n XI1_I1620_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I198_XG_MP2 (VDD I1_I1620_G27_12n I1_I1620_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I198_XG_MP0 (XI1_I1620_I198_XG_p1 I1_I1620_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I198_XG_MP1 (I1_I1620_G27_0 I1_I1620_G11_0n XI1_I1620_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I200_XG_MP2 (VDD I1_I1620_G29_14n I1_I1620_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I200_XG_MP0 (XI1_I1620_I200_XG_p1 I1_I1620_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I200_XG_MP1 (I1_I1620_G29_0 I1_I1620_G13_0n XI1_I1620_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I81_XG_MP2 (VDD I1_I1804_gn15 I1_I1804_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I81_XG_MP0 (XI1_I1804_I81_XG_p1 I1_I1804_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I81_XG_MP1 (I1_I1804_G15_14 I1_I1804_gn14 XI1_I1804_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I79_XG_MP2 (VDD I1_I1804_gn13 I1_I1804_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I79_XG_MP0 (XI1_I1804_I79_XG_p1 I1_I1804_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I79_XG_MP1 (I1_I1804_G13_12 I1_I1804_gn12 XI1_I1804_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I96_XG_MP2 (VDD I1_I1620_gn30 I1_I1620_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I96_XG_MP0 (XI1_I1620_I96_XG_p1 I1_I1620_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I96_XG_MP1 (I1_I1620_G30_29 I1_I1620_gn29 XI1_I1620_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I95_XG_MP2 (VDD I1_I1620_gn29 I1_I1620_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I95_XG_MP0 (XI1_I1620_I95_XG_p1 I1_I1620_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I95_XG_MP1 (I1_I1620_G29_28 I1_I1620_gn28 XI1_I1620_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I156_XG_MP2 (VDD I1_I1620_G31_28n I1_I1620_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I156_XG_MP0 (XI1_I1620_I156_XG_p1 I1_I1620_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I156_XG_MP1 (I1_I1620_G31_24 I1_I1620_G27_24n XI1_I1620_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I154_XG_MP2 (VDD I1_I1620_G29_26n I1_I1620_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I154_XG_MP0 (XI1_I1620_I154_XG_p1 I1_I1620_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I154_XG_MP1 (I1_I1620_G29_22 I1_I1620_G25_22n XI1_I1620_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I129_XG_MP2 (VDD I0_I1660_gn0 I0_I1660_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I129_XG_MP0 (XI0_I1660_I129_XG_p1 I0_I1660_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I129_XG_MP1 (I0_I1660_G0_0 I0_I1660_cinn XI0_I1660_I129_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I89_XG_MP2 (VDD I1_I1804_gn23 I1_I1804_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I89_XG_MP0 (XI1_I1804_I89_XG_p1 I1_I1804_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I89_XG_MP1 (I1_I1804_G23_22 I1_I1804_gn22 XI1_I1804_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I86_XG_MP2 (VDD I1_I1804_gn20 I1_I1804_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I86_XG_MP0 (XI1_I1804_I86_XG_p1 I1_I1804_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I86_XG_MP1 (I1_I1804_G20_19 I1_I1804_gn19 XI1_I1804_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I85_XG_MP2 (VDD I1_I1804_gn19 I1_I1804_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I85_XG_MP0 (XI1_I1804_I85_XG_p1 I1_I1804_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I85_XG_MP1 (I1_I1804_G19_18 I1_I1804_gn18 XI1_I1804_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I84_XG_MP2 (VDD I1_I1804_gn18 I1_I1804_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I84_XG_MP0 (XI1_I1804_I84_XG_p1 I1_I1804_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I84_XG_MP1 (I1_I1804_G18_17 I1_I1804_gn17 XI1_I1804_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I83_XG_MP2 (VDD I1_I1804_gn17 I1_I1804_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I83_XG_MP0 (XI1_I1804_I83_XG_p1 I1_I1804_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I83_XG_MP1 (I1_I1804_G17_16 I1_I1804_gn16 XI1_I1804_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I82_XG_MP2 (VDD I1_I1804_gn16 I1_I1804_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I82_XG_MP0 (XI1_I1804_I82_XG_p1 I1_I1804_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I82_XG_MP1 (I1_I1804_G16_15 I1_I1804_gn15 XI1_I1804_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I80_XG_MP2 (VDD I1_I1804_gn14 I1_I1804_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I80_XG_MP0 (XI1_I1804_I80_XG_p1 I1_I1804_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I80_XG_MP1 (I1_I1804_G14_13 I1_I1804_gn13 XI1_I1804_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I78_XG_MP2 (VDD I1_I1804_gn12 I1_I1804_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I78_XG_MP0 (XI1_I1804_I78_XG_p1 I1_I1804_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I78_XG_MP1 (I1_I1804_G12_11 I1_I1804_gn11 XI1_I1804_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I77_XG_MP2 (VDD I1_I1804_gn11 I1_I1804_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I77_XG_MP0 (XI1_I1804_I77_XG_p1 I1_I1804_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I77_XG_MP1 (I1_I1804_G11_10 I1_I1804_gn10 XI1_I1804_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I76_XG_MP2 (VDD I1_I1804_gn10 I1_I1804_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I76_XG_MP0 (XI1_I1804_I76_XG_p1 I1_I1804_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I76_XG_MP1 (I1_I1804_G10_9 I1_I1804_gn9 XI1_I1804_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I75_XG_MP2 (VDD I1_I1804_gn9 I1_I1804_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I75_XG_MP0 (XI1_I1804_I75_XG_p1 I1_I1804_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I75_XG_MP1 (I1_I1804_G9_8 I1_I1804_gn8 XI1_I1804_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I74_XG_MP2 (VDD I1_I1804_gn8 I1_I1804_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I74_XG_MP0 (XI1_I1804_I74_XG_p1 I1_I1804_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I74_XG_MP1 (I1_I1804_G8_7 I1_I1804_gn7 XI1_I1804_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I73_XG_MP2 (VDD I1_I1804_gn7 I1_I1804_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I73_XG_MP0 (XI1_I1804_I73_XG_p1 I1_I1804_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I73_XG_MP1 (I1_I1804_G7_6 I1_I1804_gn6 XI1_I1804_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I72_XG_MP2 (VDD I1_I1804_gn6 I1_I1804_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I72_XG_MP0 (XI1_I1804_I72_XG_p1 I1_I1804_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I72_XG_MP1 (I1_I1804_G6_5 I1_I1804_gn5 XI1_I1804_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I65_XG_MP2 (VDD I1_I1804_gn0 I1_I1804_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I65_XG_MP0 (XI1_I1804_I65_XG_p1 I1_I1804_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I65_XG_MP1 (I1_I1804_G0_0 I1_I1804_cinn XI1_I1804_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I94_XG_MP2 (VDD I1_I1620_gn28 I1_I1620_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I94_XG_MP0 (XI1_I1620_I94_XG_p1 I1_I1620_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I94_XG_MP1 (I1_I1620_G28_27 I1_I1620_gn27 XI1_I1620_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1620_I93_XG_MP2 (VDD I1_I1620_gn27 I1_I1620_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1620_I93_XG_MP0 (XI1_I1620_I93_XG_p1 I1_I1620_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1620_I93_XG_MP1 (I1_I1620_G27_26 I1_I1620_gn26 XI1_I1620_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I97_XG_MP2 (VDD I1_I1804_gn31 I1_I1804_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I97_XG_MP0 (XI1_I1804_I97_XG_p1 I1_I1804_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I97_XG_MP1 (I1_I1804_G31_30 I1_I1804_gn30 XI1_I1804_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I92_XG_MP2 (VDD I1_I1804_gn26 I1_I1804_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I92_XG_MP0 (XI1_I1804_I92_XG_p1 I1_I1804_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I92_XG_MP1 (I1_I1804_G26_25 I1_I1804_gn25 XI1_I1804_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I93_XG_MP2 (VDD I1_I1804_gn27 I1_I1804_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I93_XG_MP0 (XI1_I1804_I93_XG_p1 I1_I1804_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I93_XG_MP1 (I1_I1804_G27_26 I1_I1804_gn26 XI1_I1804_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I91_XG_MP2 (VDD I1_I1804_gn25 I1_I1804_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I91_XG_MP0 (XI1_I1804_I91_XG_p1 I1_I1804_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I91_XG_MP1 (I1_I1804_G25_24 I1_I1804_gn24 XI1_I1804_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I90_XG_MP2 (VDD I1_I1804_gn24 I1_I1804_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I90_XG_MP0 (XI1_I1804_I90_XG_p1 I1_I1804_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I90_XG_MP1 (I1_I1804_G24_23 I1_I1804_gn23 XI1_I1804_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I149_XG_MP2 (VDD I1_I1804_G24_21n I1_I1804_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I149_XG_MP0 (XI1_I1804_I149_XG_p1 I1_I1804_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I149_XG_MP1 (I1_I1804_G24_17 I1_I1804_G20_17n XI1_I1804_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I145_XG_MP2 (VDD I1_I1804_G20_17n I1_I1804_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I145_XG_MP0 (XI1_I1804_I145_XG_p1 I1_I1804_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I145_XG_MP1 (I1_I1804_G20_13 I1_I1804_G16_13n XI1_I1804_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I141_XG_MP2 (VDD I1_I1804_G16_13n I1_I1804_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I141_XG_MP0 (XI1_I1804_I141_XG_p1 I1_I1804_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I141_XG_MP1 (I1_I1804_G16_9 I1_I1804_G12_9n XI1_I1804_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I137_XG_MP2 (VDD I1_I1804_G12_9n I1_I1804_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I137_XG_MP0 (XI1_I1804_I137_XG_p1 I1_I1804_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I137_XG_MP1 (I1_I1804_G12_5 I1_I1804_G8_5n XI1_I1804_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I65_XG_MP2 (VDD I1_I1850_gn0 I1_I1850_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I65_XG_MP0 (XI1_I1850_I65_XG_p1 I1_I1850_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I65_XG_MP1 (I1_I1850_G0_0 I1_I1850_cinn XI1_I1850_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I65_XG_MP2 (VDD I1_I1896_gn0 I1_I1896_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I65_XG_MP0 (XI1_I1896_I65_XG_p1 I1_I1896_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I65_XG_MP1 (I1_I1896_G0_0 I1_I1896_cinn XI1_I1896_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I65_XG_MP2 (VDD I1_I1942_gn0 I1_I1942_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I65_XG_MP0 (XI1_I1942_I65_XG_p1 I1_I1942_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I65_XG_MP1 (I1_I1942_G0_0 I1_I1942_cinn XI1_I1942_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I140_XG_MP2 (VDD I0_I1660_gn10 I0_I1660_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I140_XG_MP0 (XI0_I1660_I140_XG_p1 I0_I1660_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I140_XG_MP1 (I0_I1660_G10_9 I0_I1660_gn9 XI0_I1660_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I94_XG_MP2 (VDD I1_I1804_gn28 I1_I1804_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I94_XG_MP0 (XI1_I1804_I94_XG_p1 I1_I1804_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I94_XG_MP1 (I1_I1804_G28_27 I1_I1804_gn27 XI1_I1804_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I155_XG_MP2 (VDD I1_I1804_G30_27n I1_I1804_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I155_XG_MP0 (XI1_I1804_I155_XG_p1 I1_I1804_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I155_XG_MP1 (I1_I1804_G30_23 I1_I1804_G26_23n XI1_I1804_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I153_XG_MP2 (VDD I1_I1804_G28_25n I1_I1804_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I153_XG_MP0 (XI1_I1804_I153_XG_p1 I1_I1804_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I153_XG_MP1 (I1_I1804_G28_21 I1_I1804_G24_21n XI1_I1804_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I143_XG_MP2 (VDD I1_I1804_G18_15n I1_I1804_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I143_XG_MP0 (XI1_I1804_I143_XG_p1 I1_I1804_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I143_XG_MP1 (I1_I1804_G18_11 I1_I1804_G14_11n XI1_I1804_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I139_XG_MP2 (VDD I1_I1804_G14_11n I1_I1804_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I139_XG_MP0 (XI1_I1804_I139_XG_p1 I1_I1804_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I139_XG_MP1 (I1_I1804_G14_7 I1_I1804_G10_7n XI1_I1804_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I195_XG_MP2 (VDD I1_I1804_G24_9n I1_I1804_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I195_XG_MP0 (XI1_I1804_I195_XG_p1 I1_I1804_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I195_XG_MP1 (I1_I1804_G24_0 I1_I1804_G8_0n XI1_I1804_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I133_XG_MP2 (VDD I1_I1804_G8_5n I1_I1804_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I133_XG_MP0 (XI1_I1804_I133_XG_p1 I1_I1804_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I133_XG_MP1 (I1_I1804_G8_1 I1_I1804_G4_1n XI1_I1804_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I128_XG_MP2 (VDD I1_I1804_G4_1n I1_I1804_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I128_XG_MP0 (XI1_I1804_I128_XG_p1 I1_I1804_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I128_XG_MP1 (I1_I1804_G4_0 I1_I1804_G0_0n XI1_I1804_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I67_XG_MP2 (VDD I1_I1804_gn1 I1_I1804_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I67_XG_MP0 (XI1_I1804_I67_XG_p1 I1_I1804_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I67_XG_MP1 (I1_I1804_G1_0 I1_I1804_G0_0n XI1_I1804_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I68_XG_MP2 (VDD I1_I1896_gn2 I1_I1896_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I68_XG_MP0 (XI1_I1896_I68_XG_p1 I1_I1896_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I68_XG_MP1 (I1_I1896_G2_1 I1_I1896_gn1 XI1_I1896_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I67_XG_MP2 (VDD I1_I1896_gn1 I1_I1896_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I67_XG_MP0 (XI1_I1896_I67_XG_p1 I1_I1896_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I67_XG_MP1 (I1_I1896_G1_0 I1_I1896_G0_0n XI1_I1896_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I70_XG_MP2 (VDD I1_I1942_gn4 I1_I1942_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I70_XG_MP0 (XI1_I1942_I70_XG_p1 I1_I1942_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I70_XG_MP1 (I1_I1942_G4_3 I1_I1942_gn3 XI1_I1942_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I69_XG_MP2 (VDD I1_I1942_gn3 I1_I1942_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I69_XG_MP0 (XI1_I1942_I69_XG_p1 I1_I1942_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I69_XG_MP1 (I1_I1942_G3_2 I1_I1942_gn2 XI1_I1942_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I68_XG_MP2 (VDD I1_I1942_gn2 I1_I1942_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I68_XG_MP0 (XI1_I1942_I68_XG_p1 I1_I1942_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I68_XG_MP1 (I1_I1942_G2_1 I1_I1942_gn1 XI1_I1942_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I67_XG_MP2 (VDD I1_I1942_gn1 I1_I1942_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I67_XG_MP0 (XI1_I1942_I67_XG_p1 I1_I1942_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I67_XG_MP1 (I1_I1942_G1_0 I1_I1942_G0_0n XI1_I1942_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I69_XG_MP2 (VDD I1_I1988_gn3 I1_I1988_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I69_XG_MP0 (XI1_I1988_I69_XG_p1 I1_I1988_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I69_XG_MP1 (I1_I1988_G3_2 I1_I1988_gn2 XI1_I1988_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I68_XG_MP2 (VDD I1_I1988_gn2 I1_I1988_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I68_XG_MP0 (XI1_I1988_I68_XG_p1 I1_I1988_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I68_XG_MP1 (I1_I1988_G2_1 I1_I1988_gn1 XI1_I1988_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I65_XG_MP2 (VDD I1_I1988_gn0 I1_I1988_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I65_XG_MP0 (XI1_I1988_I65_XG_p1 I1_I1988_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I65_XG_MP1 (I1_I1988_G0_0 I1_I1988_cinn XI1_I1988_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I65_XG_MP2 (VDD I1_I2066_gn0 I1_I2066_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I65_XG_MP0 (XI1_I2066_I65_XG_p1 I1_I2066_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I65_XG_MP1 (I1_I2066_G0_0 I1_I2066_cinn XI1_I2066_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I137_XG_MP2 (VDD I0_I1660_gn7 I0_I1660_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I137_XG_MP0 (XI0_I1660_I137_XG_p1 I0_I1660_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I137_XG_MP1 (I0_I1660_G7_6 I0_I1660_gn6 XI0_I1660_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I138_XG_MP2 (VDD I0_I1660_gn8 I0_I1660_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I138_XG_MP0 (XI0_I1660_I138_XG_p1 I0_I1660_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I138_XG_MP1 (I0_I1660_G8_7 I0_I1660_gn7 XI0_I1660_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I139_XG_MP2 (VDD I0_I1660_gn9 I0_I1660_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I139_XG_MP0 (XI0_I1660_I139_XG_p1 I0_I1660_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I139_XG_MP1 (I0_I1660_G9_8 I0_I1660_gn8 XI0_I1660_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I141_XG_MP2 (VDD I0_I1660_gn11 I0_I1660_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I141_XG_MP0 (XI0_I1660_I141_XG_p1 I0_I1660_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I141_XG_MP1 (I0_I1660_G11_10 I0_I1660_gn10 XI0_I1660_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I145_XG_MP2 (VDD I0_I1660_gn15 I0_I1660_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I145_XG_MP0 (XI0_I1660_I145_XG_p1 I0_I1660_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I145_XG_MP1 (I0_I1660_G15_14 I0_I1660_gn14 XI0_I1660_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I146_XG_MP2 (VDD I0_I1660_gn16 I0_I1660_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I146_XG_MP0 (XI0_I1660_I146_XG_p1 I0_I1660_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I146_XG_MP1 (I0_I1660_G16_15 I0_I1660_gn15 XI0_I1660_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I147_XG_MP2 (VDD I0_I1660_gn17 I0_I1660_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I147_XG_MP0 (XI0_I1660_I147_XG_p1 I0_I1660_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I147_XG_MP1 (I0_I1660_G17_16 I0_I1660_gn16 XI0_I1660_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I148_XG_MP2 (VDD I0_I1660_gn18 I0_I1660_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I148_XG_MP0 (XI0_I1660_I148_XG_p1 I0_I1660_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I148_XG_MP1 (I0_I1660_G18_17 I0_I1660_gn17 XI0_I1660_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I149_XG_MP2 (VDD I0_I1660_gn19 I0_I1660_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I149_XG_MP0 (XI0_I1660_I149_XG_p1 I0_I1660_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I149_XG_MP1 (I0_I1660_G19_18 I0_I1660_gn18 XI0_I1660_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I152_XG_MP2 (VDD I0_I1660_gn22 I0_I1660_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I152_XG_MP0 (XI0_I1660_I152_XG_p1 I0_I1660_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I152_XG_MP1 (I0_I1660_G22_21 I0_I1660_gn21 XI0_I1660_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I153_XG_MP2 (VDD I0_I1660_gn23 I0_I1660_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I153_XG_MP0 (XI0_I1660_I153_XG_p1 I0_I1660_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I153_XG_MP1 (I0_I1660_G23_22 I0_I1660_gn22 XI0_I1660_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I154_XG_MP2 (VDD I0_I1660_gn24 I0_I1660_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I154_XG_MP0 (XI0_I1660_I154_XG_p1 I0_I1660_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I154_XG_MP1 (I0_I1660_G24_23 I0_I1660_gn23 XI0_I1660_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I155_XG_MP2 (VDD I0_I1660_gn25 I0_I1660_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I155_XG_MP0 (XI0_I1660_I155_XG_p1 I0_I1660_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I155_XG_MP1 (I0_I1660_G25_24 I0_I1660_gn24 XI0_I1660_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I156_XG_MP2 (VDD I0_I1660_gn26 I0_I1660_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I156_XG_MP0 (XI0_I1660_I156_XG_p1 I0_I1660_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I156_XG_MP1 (I0_I1660_G26_25 I0_I1660_gn25 XI0_I1660_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I96_XG_MP2 (VDD I1_I1804_gn30 I1_I1804_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I96_XG_MP0 (XI1_I1804_I96_XG_p1 I1_I1804_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I96_XG_MP1 (I1_I1804_G30_29 I1_I1804_gn29 XI1_I1804_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I95_XG_MP2 (VDD I1_I1804_gn29 I1_I1804_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I95_XG_MP0 (XI1_I1804_I95_XG_p1 I1_I1804_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I95_XG_MP1 (I1_I1804_G29_28 I1_I1804_gn28 XI1_I1804_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I201_XG_MP2 (VDD I1_I1804_G30_15n I1_c27_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I201_XG_MP0 (XI1_I1804_I201_XG_p1 I1_I1804_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I201_XG_MP1 (I1_c27_m I1_I1804_G14_0n XI1_I1804_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I199_XG_MP2 (VDD I1_I1804_G28_13n I1_I1804_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I199_XG_MP0 (XI1_I1804_I199_XG_p1 I1_I1804_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I199_XG_MP1 (I1_I1804_G28_0 I1_I1804_G12_0n XI1_I1804_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I192_XG_MP2 (VDD I1_I1804_G22_7n I1_I1804_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I192_XG_MP0 (XI1_I1804_I192_XG_p1 I1_I1804_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I192_XG_MP1 (I1_I1804_G22_0 I1_I1804_G6_0n XI1_I1804_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I197_XG_MP2 (VDD I1_I1804_G26_11n I1_I1804_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I197_XG_MP0 (XI1_I1804_I197_XG_p1 I1_I1804_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I197_XG_MP1 (I1_I1804_G26_0 I1_I1804_G10_0n XI1_I1804_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I188_XG_MP2 (VDD I1_I1804_G20_5n I1_I1804_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I188_XG_MP0 (XI1_I1804_I188_XG_p1 I1_I1804_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I188_XG_MP1 (I1_I1804_G20_0 I1_I1804_G4_0n XI1_I1804_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I185_XG_MP2 (VDD I1_I1804_G18_3n I1_I1804_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I185_XG_MP0 (XI1_I1804_I185_XG_p1 I1_I1804_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I185_XG_MP1 (I1_I1804_G18_0 I1_I1804_G2_0n XI1_I1804_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I131_XG_MP2 (VDD I1_I1804_G6_3n I1_I1804_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I131_XG_MP0 (XI1_I1804_I131_XG_p1 I1_I1804_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I131_XG_MP1 (I1_I1804_G6_0 I1_I1804_G2_0n XI1_I1804_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I69_XG_MP2 (VDD I1_I1850_gn3 I1_I1850_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I69_XG_MP0 (XI1_I1850_I69_XG_p1 I1_I1850_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I69_XG_MP1 (I1_I1850_G3_2 I1_I1850_gn2 XI1_I1850_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I67_XG_MP2 (VDD I1_I1850_gn1 I1_I1850_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I67_XG_MP0 (XI1_I1850_I67_XG_p1 I1_I1850_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I67_XG_MP1 (I1_I1850_G1_0 I1_I1850_G0_0n XI1_I1850_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I68_XG_MP2 (VDD I1_I1850_gn2 I1_I1850_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I68_XG_MP0 (XI1_I1850_I68_XG_p1 I1_I1850_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I68_XG_MP1 (I1_I1850_G2_1 I1_I1850_gn1 XI1_I1850_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I70_XG_MP2 (VDD I1_I1896_gn4 I1_I1896_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I70_XG_MP0 (XI1_I1896_I70_XG_p1 I1_I1896_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I70_XG_MP1 (I1_I1896_G4_3 I1_I1896_gn3 XI1_I1896_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I69_XG_MP2 (VDD I1_I1896_gn3 I1_I1896_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I69_XG_MP0 (XI1_I1896_I69_XG_p1 I1_I1896_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I69_XG_MP1 (I1_I1896_G3_2 I1_I1896_gn2 XI1_I1896_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I72_XG_MP2 (VDD I1_I1942_gn6 I1_I1942_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I72_XG_MP0 (XI1_I1942_I72_XG_p1 I1_I1942_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I72_XG_MP1 (I1_I1942_G6_5 I1_I1942_gn5 XI1_I1942_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I71_XG_MP2 (VDD I1_I1942_gn5 I1_I1942_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I71_XG_MP0 (XI1_I1942_I71_XG_p1 I1_I1942_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I71_XG_MP1 (I1_I1942_G5_4 I1_I1942_gn4 XI1_I1942_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I133_XG_MP2 (VDD I1_I1942_G8_5n I1_I1942_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I133_XG_MP0 (XI1_I1942_I133_XG_p1 I1_I1942_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I133_XG_MP1 (I1_I1942_G8_1 I1_I1942_G4_1n XI1_I1942_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I128_XG_MP2 (VDD I1_I1942_G4_1n I1_I1942_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I128_XG_MP0 (XI1_I1942_I128_XG_p1 I1_I1942_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I128_XG_MP1 (I1_I1942_G4_0 I1_I1942_G0_0n XI1_I1942_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I72_XG_MP2 (VDD I1_I1988_gn6 I1_I1988_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I72_XG_MP0 (XI1_I1988_I72_XG_p1 I1_I1988_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I72_XG_MP1 (I1_I1988_G6_5 I1_I1988_gn5 XI1_I1988_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I71_XG_MP2 (VDD I1_I1988_gn5 I1_I1988_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I71_XG_MP0 (XI1_I1988_I71_XG_p1 I1_I1988_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I71_XG_MP1 (I1_I1988_G5_4 I1_I1988_gn4 XI1_I1988_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I70_XG_MP2 (VDD I1_I1988_gn4 I1_I1988_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I70_XG_MP0 (XI1_I1988_I70_XG_p1 I1_I1988_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I70_XG_MP1 (I1_I1988_G4_3 I1_I1988_gn3 XI1_I1988_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I67_XG_MP2 (VDD I1_I1988_gn1 I1_I1988_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I67_XG_MP0 (XI1_I1988_I67_XG_p1 I1_I1988_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I67_XG_MP1 (I1_I1988_G1_0 I1_I1988_G0_0n XI1_I1988_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I135_XG_MP2 (VDD I0_I1660_gn5 I0_I1660_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I135_XG_MP0 (XI0_I1660_I135_XG_p1 I0_I1660_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I135_XG_MP1 (I0_I1660_G5_4 I0_I1660_gn4 XI0_I1660_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I136_XG_MP2 (VDD I0_I1660_gn6 I0_I1660_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I136_XG_MP0 (XI0_I1660_I136_XG_p1 I0_I1660_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I136_XG_MP1 (I0_I1660_G6_5 I0_I1660_gn5 XI0_I1660_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I70_XG_MP2 (VDD I1_I1850_gn4 I1_I1850_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I70_XG_MP0 (XI1_I1850_I70_XG_p1 I1_I1850_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I70_XG_MP1 (I1_I1850_G4_3 I1_I1850_gn3 XI1_I1850_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I71_XG_MP2 (VDD I1_I1896_gn5 I1_I1896_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I71_XG_MP0 (XI1_I1896_I71_XG_p1 I1_I1896_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I71_XG_MP1 (I1_I1896_G5_4 I1_I1896_gn4 XI1_I1896_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I73_XG_MP2 (VDD I1_I1942_gn7 I1_I1942_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I73_XG_MP0 (XI1_I1942_I73_XG_p1 I1_I1942_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I73_XG_MP1 (I1_I1942_G7_6 I1_I1942_gn6 XI1_I1942_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I74_XG_MP2 (VDD I1_I1942_gn8 I1_I1942_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I74_XG_MP0 (XI1_I1942_I74_XG_p1 I1_I1942_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I74_XG_MP1 (I1_I1942_G8_7 I1_I1942_gn7 XI1_I1942_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I130_XG_MP2 (VDD I1_I1942_G5_2n I1_I1942_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I130_XG_MP0 (XI1_I1942_I130_XG_p1 I1_I1942_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I130_XG_MP1 (I1_I1942_G5_0 I1_I1942_G1_0n XI1_I1942_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I183_XG_MP2 (VDD I1_I1942_G16_1n I1_I1942_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I183_XG_MP0 (XI1_I1942_I183_XG_p1 I1_I1942_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I183_XG_MP1 (I1_I1942_G16_0 I1_I1942_G0_0n XI1_I1942_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I74_XG_MP2 (VDD I1_I1988_gn8 I1_I1988_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I74_XG_MP0 (XI1_I1988_I74_XG_p1 I1_I1988_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I74_XG_MP1 (I1_I1988_G8_7 I1_I1988_gn7 XI1_I1988_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I73_XG_MP2 (VDD I1_I1988_gn7 I1_I1988_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I73_XG_MP0 (XI1_I1988_I73_XG_p1 I1_I1988_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I73_XG_MP1 (I1_I1988_G7_6 I1_I1988_gn6 XI1_I1988_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I130_XG_MP2 (VDD I1_I1988_G5_2n I1_I1988_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I130_XG_MP0 (XI1_I1988_I130_XG_p1 I1_I1988_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I130_XG_MP1 (I1_I1988_G5_0 I1_I1988_G1_0n XI1_I1988_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I128_XG_MP2 (VDD I1_I1988_G4_1n I1_I1988_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I128_XG_MP0 (XI1_I1988_I128_XG_p1 I1_I1988_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I128_XG_MP1 (I1_I1988_G4_0 I1_I1988_G0_0n XI1_I1988_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I70_XG_MP2 (VDD I1_I2066_gn4 I1_I2066_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I70_XG_MP0 (XI1_I2066_I70_XG_p1 I1_I2066_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I70_XG_MP1 (I1_I2066_G4_3 I1_I2066_gn3 XI1_I2066_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I133_XG_MP2 (VDD I0_I1660_gn3 I0_I1660_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I133_XG_MP0 (XI0_I1660_I133_XG_p1 I0_I1660_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I133_XG_MP1 (I0_I1660_G3_2 I0_I1660_gn2 XI0_I1660_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I134_XG_MP2 (VDD I0_I1660_gn4 I0_I1660_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I134_XG_MP0 (XI0_I1660_I134_XG_p1 I0_I1660_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I134_XG_MP1 (I0_I1660_G4_3 I0_I1660_gn3 XI0_I1660_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I260_XG_MP2 (VDD I0_I1660_G7_4n I0_I1660_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I260_XG_MP0 (XI0_I1660_I260_XG_p1 I0_I1660_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I260_XG_MP1 (I0_I1660_G7_0 I0_I1660_G3_0n XI0_I1660_I260_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I262_XG_MP2 (VDD I0_I1660_G9_6n I0_I1660_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I262_XG_MP0 (XI0_I1660_I262_XG_p1 I0_I1660_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I262_XG_MP1 (I0_I1660_G9_2 I0_I1660_G5_2n XI0_I1660_I262_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I264_XG_MP2 (VDD I0_I1660_G11_8n I0_I1660_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I264_XG_MP0 (XI0_I1660_I264_XG_p1 I0_I1660_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I264_XG_MP1 (I0_I1660_G11_4 I0_I1660_G7_4n XI0_I1660_I264_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I266_XG_MP2 (VDD I0_I1660_G13_10n I0_I1660_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I266_XG_MP0 (XI0_I1660_I266_XG_p1 I0_I1660_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I266_XG_MP1 (I0_I1660_G13_6 I0_I1660_G9_6n XI0_I1660_I266_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I268_XG_MP2 (VDD I0_I1660_G15_12n I0_I1660_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I268_XG_MP0 (XI0_I1660_I268_XG_p1 I0_I1660_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I268_XG_MP1 (I0_I1660_G15_8 I0_I1660_G11_8n XI0_I1660_I268_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I270_XG_MP2 (VDD I0_I1660_G17_14n I0_I1660_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I270_XG_MP0 (XI0_I1660_I270_XG_p1 I0_I1660_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I270_XG_MP1 (I0_I1660_G17_10 I0_I1660_G13_10n XI0_I1660_I270_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I272_XG_MP2 (VDD I0_I1660_G19_16n I0_I1660_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I272_XG_MP0 (XI0_I1660_I272_XG_p1 I0_I1660_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I272_XG_MP1 (I0_I1660_G19_12 I0_I1660_G15_12n XI0_I1660_I272_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I274_XG_MP2 (VDD I0_I1660_G21_18n I0_I1660_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I274_XG_MP0 (XI0_I1660_I274_XG_p1 I0_I1660_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I274_XG_MP1 (I0_I1660_G21_14 I0_I1660_G17_14n XI0_I1660_I274_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I276_XG_MP2 (VDD I0_I1660_G23_20n I0_I1660_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I276_XG_MP0 (XI0_I1660_I276_XG_p1 I0_I1660_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I276_XG_MP1 (I0_I1660_G23_16 I0_I1660_G19_16n XI0_I1660_I276_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I278_XG_MP2 (VDD I0_I1660_G25_22n I0_I1660_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I278_XG_MP0 (XI0_I1660_I278_XG_p1 I0_I1660_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I278_XG_MP1 (I0_I1660_G25_18 I0_I1660_G21_18n XI0_I1660_I278_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I282_XG_MP2 (VDD I0_I1660_G29_26n I0_I1660_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I282_XG_MP0 (XI0_I1660_I282_XG_p1 I0_I1660_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I282_XG_MP1 (I0_I1660_G29_22 I0_I1660_G25_22n XI0_I1660_I282_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I280_XG_MP2 (VDD I0_I1660_G27_24n I0_I1660_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I280_XG_MP0 (XI0_I1660_I280_XG_p1 I0_I1660_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I280_XG_MP1 (I0_I1660_G27_20 I0_I1660_G23_20n XI0_I1660_I280_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I159_XG_MP2 (VDD I0_I1660_gn29 I0_I1660_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I159_XG_MP0 (XI0_I1660_I159_XG_p1 I0_I1660_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I159_XG_MP1 (I0_I1660_G29_28 I0_I1660_gn28 XI0_I1660_I159_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I160_XG_MP2 (VDD I0_I1660_gn30 I0_I1660_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I160_XG_MP0 (XI0_I1660_I160_XG_p1 I0_I1660_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I160_XG_MP1 (I0_I1660_G30_29 I0_I1660_gn29 XI0_I1660_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I154_XG_MP2 (VDD I1_I1804_G29_26n I1_I1804_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I154_XG_MP0 (XI1_I1804_I154_XG_p1 I1_I1804_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I154_XG_MP1 (I1_I1804_G29_22 I1_I1804_G25_22n XI1_I1804_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I150_XG_MP2 (VDD I1_I1804_G25_22n I1_I1804_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I150_XG_MP0 (XI1_I1804_I150_XG_p1 I1_I1804_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I150_XG_MP1 (I1_I1804_G25_18 I1_I1804_G21_18n XI1_I1804_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I146_XG_MP2 (VDD I1_I1804_G21_18n I1_I1804_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I146_XG_MP0 (XI1_I1804_I146_XG_p1 I1_I1804_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I146_XG_MP1 (I1_I1804_G21_14 I1_I1804_G17_14n XI1_I1804_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I142_XG_MP2 (VDD I1_I1804_G17_14n I1_I1804_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I142_XG_MP0 (XI1_I1804_I142_XG_p1 I1_I1804_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I142_XG_MP1 (I1_I1804_G17_10 I1_I1804_G13_10n XI1_I1804_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I138_XG_MP2 (VDD I1_I1804_G13_10n I1_I1804_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I138_XG_MP0 (XI1_I1804_I138_XG_p1 I1_I1804_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I138_XG_MP1 (I1_I1804_G13_6 I1_I1804_G9_6n XI1_I1804_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I134_XG_MP2 (VDD I1_I1804_G9_6n I1_I1804_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I134_XG_MP0 (XI1_I1804_I134_XG_p1 I1_I1804_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I134_XG_MP1 (I1_I1804_G9_2 I1_I1804_G5_2n XI1_I1804_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I130_XG_MP2 (VDD I1_I1804_G5_2n I1_I1804_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I130_XG_MP0 (XI1_I1804_I130_XG_p1 I1_I1804_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I130_XG_MP1 (I1_I1804_G5_0 I1_I1804_G1_0n XI1_I1804_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I71_XG_MP2 (VDD I1_I1850_gn5 I1_I1850_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I71_XG_MP0 (XI1_I1850_I71_XG_p1 I1_I1850_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I71_XG_MP1 (I1_I1850_G5_4 I1_I1850_gn4 XI1_I1850_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I73_XG_MP2 (VDD I1_I1896_gn7 I1_I1896_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I73_XG_MP0 (XI1_I1896_I73_XG_p1 I1_I1896_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I73_XG_MP1 (I1_I1896_G7_6 I1_I1896_gn6 XI1_I1896_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I72_XG_MP2 (VDD I1_I1896_gn6 I1_I1896_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I72_XG_MP0 (XI1_I1896_I72_XG_p1 I1_I1896_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I72_XG_MP1 (I1_I1896_G6_5 I1_I1896_gn5 XI1_I1896_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I131_XG_MP2 (VDD I1_I1896_G6_3n I1_I1896_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I131_XG_MP0 (XI1_I1896_I131_XG_p1 I1_I1896_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I131_XG_MP1 (I1_I1896_G6_0 I1_I1896_G2_0n XI1_I1896_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I128_XG_MP2 (VDD I1_I1896_G4_1n I1_I1896_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I128_XG_MP0 (XI1_I1896_I128_XG_p1 I1_I1896_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I128_XG_MP1 (I1_I1896_G4_0 I1_I1896_G0_0n XI1_I1896_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I75_XG_MP2 (VDD I1_I1942_gn9 I1_I1942_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I75_XG_MP0 (XI1_I1942_I75_XG_p1 I1_I1942_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I75_XG_MP1 (I1_I1942_G9_8 I1_I1942_gn8 XI1_I1942_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I134_XG_MP2 (VDD I1_I1942_G9_6n I1_I1942_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I134_XG_MP0 (XI1_I1942_I134_XG_p1 I1_I1942_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I134_XG_MP1 (I1_I1942_G9_2 I1_I1942_G5_2n XI1_I1942_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I132_XG_MP2 (VDD I1_I1942_G7_4n I1_I1942_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I132_XG_MP0 (XI1_I1942_I132_XG_p1 I1_I1942_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I132_XG_MP1 (I1_I1942_G7_0 I1_I1942_G3_0n XI1_I1942_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I131_XG_MP2 (VDD I1_I1942_G6_3n I1_I1942_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I131_XG_MP0 (XI1_I1942_I131_XG_p1 I1_I1942_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I131_XG_MP1 (I1_I1942_G6_0 I1_I1942_G2_0n XI1_I1942_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I75_XG_MP2 (VDD I1_I1988_gn9 I1_I1988_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I75_XG_MP0 (XI1_I1988_I75_XG_p1 I1_I1988_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I75_XG_MP1 (I1_I1988_G9_8 I1_I1988_gn8 XI1_I1988_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I134_XG_MP2 (VDD I1_I1988_G9_6n I1_I1988_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I134_XG_MP0 (XI1_I1988_I134_XG_p1 I1_I1988_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I134_XG_MP1 (I1_I1988_G9_2 I1_I1988_G5_2n XI1_I1988_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I184_XG_MP2 (VDD I1_I1988_G17_2n I1_I1988_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I184_XG_MP0 (XI1_I1988_I184_XG_p1 I1_I1988_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I184_XG_MP1 (I1_I1988_G17_0 I1_I1988_G1_0n XI1_I1988_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I133_XG_MP2 (VDD I1_I1988_G8_5n I1_I1988_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I133_XG_MP0 (XI1_I1988_I133_XG_p1 I1_I1988_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I133_XG_MP1 (I1_I1988_G8_1 I1_I1988_G4_1n XI1_I1988_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I183_XG_MP2 (VDD I1_I1988_G16_1n I1_I1988_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I183_XG_MP0 (XI1_I1988_I183_XG_p1 I1_I1988_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I183_XG_MP1 (I1_I1988_G16_0 I1_I1988_G0_0n XI1_I1988_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I72_XG_MP2 (VDD I1_I2066_gn6 I1_I2066_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I72_XG_MP0 (XI1_I2066_I72_XG_p1 I1_I2066_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I72_XG_MP1 (I1_I2066_G6_5 I1_I2066_gn5 XI1_I2066_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I71_XG_MP2 (VDD I1_I2066_gn5 I1_I2066_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I71_XG_MP0 (XI1_I2066_I71_XG_p1 I1_I2066_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I71_XG_MP1 (I1_I2066_G5_4 I1_I2066_gn4 XI1_I2066_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I68_XG_MP2 (VDD I1_I2066_gn2 I1_I2066_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I68_XG_MP0 (XI1_I2066_I68_XG_p1 I1_I2066_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I68_XG_MP1 (I1_I2066_G2_1 I1_I2066_gn1 XI1_I2066_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I69_XG_MP2 (VDD I1_I2066_gn3 I1_I2066_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I69_XG_MP0 (XI1_I2066_I69_XG_p1 I1_I2066_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I69_XG_MP1 (I1_I2066_G3_2 I1_I2066_gn2 XI1_I2066_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I131_XG_MP2 (VDD I0_I1660_gn1 I0_I1660_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I131_XG_MP0 (XI0_I1660_I131_XG_p1 I0_I1660_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I131_XG_MP1 (I0_I1660_G1_0 I0_I1660_G0_0n XI0_I1660_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I132_XG_MP2 (VDD I0_I1660_gn2 I0_I1660_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I132_XG_MP0 (XI0_I1660_I132_XG_p1 I0_I1660_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I132_XG_MP1 (I0_I1660_G2_1 I0_I1660_gn1 XI0_I1660_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I258_XG_MP2 (VDD I0_I1660_G5_2n I0_I1660_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I258_XG_MP0 (XI0_I1660_I258_XG_p1 I0_I1660_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I258_XG_MP1 (I0_I1660_G5_0 I0_I1660_G1_0n XI0_I1660_I258_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I376_XG_MP2 (VDD I0_I1660_G17_2n I0_I1660_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I376_XG_MP0 (XI0_I1660_I376_XG_p1 I0_I1660_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I376_XG_MP1 (I0_I1660_G17_0 I0_I1660_G1_0n XI0_I1660_I376_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I277_XG_MP2 (VDD I0_I1660_G24_21n I0_I1660_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I277_XG_MP0 (XI0_I1660_I277_XG_p1 I0_I1660_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I277_XG_MP1 (I0_I1660_G24_17 I0_I1660_G20_17n XI0_I1660_I277_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I378_XG_MP2 (VDD I0_I1660_G19_4n I0_I1660_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I378_XG_MP0 (XI0_I1660_I378_XG_p1 I0_I1660_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I378_XG_MP1 (I0_I1660_G19_0 I0_I1660_G3_0n XI0_I1660_I378_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I382_XG_MP2 (VDD I0_I1660_G21_6n I0_I1660_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I382_XG_MP0 (XI0_I1660_I382_XG_p1 I0_I1660_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I382_XG_MP1 (I0_I1660_G21_0 I0_I1660_G5_0n XI0_I1660_I382_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I386_XG_MP2 (VDD I0_I1660_G23_8n I0_I1660_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I386_XG_MP0 (XI0_I1660_I386_XG_p1 I0_I1660_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I386_XG_MP1 (I0_I1660_G23_0 I0_I1660_G7_0n XI0_I1660_I386_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I284_XG_MP2 (VDD I0_I1660_G31_28n I0_I1660_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I284_XG_MP0 (XI0_I1660_I284_XG_p1 I0_I1660_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I284_XG_MP1 (I0_I1660_G31_24 I0_I1660_G27_24n XI0_I1660_I284_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I286_XG_MP2 (VDD I0_I1660_G33_30n I0_I1660_G33_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I286_XG_MP0 (XI0_I1660_I286_XG_p1 I0_I1660_P33_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I286_XG_MP1 (I0_I1660_G33_26 I0_I1660_G29_26n XI0_I1660_I286_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I161_XG_MP2 (VDD I0_I1660_gn31 I0_I1660_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I161_XG_MP0 (XI0_I1660_I161_XG_p1 I0_I1660_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I161_XG_MP1 (I0_I1660_G31_30 I0_I1660_gn30 XI0_I1660_I161_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I156_XG_MP2 (VDD I1_I1804_G31_28n I1_I1804_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I156_XG_MP0 (XI1_I1804_I156_XG_p1 I1_I1804_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I156_XG_MP1 (I1_I1804_G31_24 I1_I1804_G27_24n XI1_I1804_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I190_XG_MP2 (VDD I1_I1804_G21_6n I1_I1804_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I190_XG_MP0 (XI1_I1804_I190_XG_p1 I1_I1804_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I190_XG_MP1 (I1_I1804_G21_0 I1_I1804_G5_0n XI1_I1804_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I196_XG_MP2 (VDD I1_I1804_G25_10n I1_I1804_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I196_XG_MP0 (XI1_I1804_I196_XG_p1 I1_I1804_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I196_XG_MP1 (I1_I1804_G25_0 I1_I1804_G9_0n XI1_I1804_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I136_XG_MP2 (VDD I1_I1804_G11_8n I1_I1804_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I136_XG_MP0 (XI1_I1804_I136_XG_p1 I1_I1804_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I136_XG_MP1 (I1_I1804_G11_4 I1_I1804_G7_4n XI1_I1804_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I184_XG_MP2 (VDD I1_I1804_G17_2n I1_I1804_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I184_XG_MP0 (XI1_I1804_I184_XG_p1 I1_I1804_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I184_XG_MP1 (I1_I1804_G17_0 I1_I1804_G1_0n XI1_I1804_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I132_XG_MP2 (VDD I1_I1804_G7_4n I1_I1804_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I132_XG_MP0 (XI1_I1804_I132_XG_p1 I1_I1804_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I132_XG_MP1 (I1_I1804_G7_0 I1_I1804_G3_0n XI1_I1804_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I72_XG_MP2 (VDD I1_I1850_gn6 I1_I1850_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I72_XG_MP0 (XI1_I1850_I72_XG_p1 I1_I1850_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I72_XG_MP1 (I1_I1850_G6_5 I1_I1850_gn5 XI1_I1850_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I74_XG_MP2 (VDD I1_I1896_gn8 I1_I1896_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I74_XG_MP0 (XI1_I1896_I74_XG_p1 I1_I1896_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I74_XG_MP1 (I1_I1896_G8_7 I1_I1896_gn7 XI1_I1896_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I132_XG_MP2 (VDD I1_I1896_G7_4n I1_I1896_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I132_XG_MP0 (XI1_I1896_I132_XG_p1 I1_I1896_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I132_XG_MP1 (I1_I1896_G7_0 I1_I1896_G3_0n XI1_I1896_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I130_XG_MP2 (VDD I1_I1896_G5_2n I1_I1896_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I130_XG_MP0 (XI1_I1896_I130_XG_p1 I1_I1896_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I130_XG_MP1 (I1_I1896_G5_0 I1_I1896_G1_0n XI1_I1896_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I133_XG_MP2 (VDD I1_I1896_G8_5n I1_I1896_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I133_XG_MP0 (XI1_I1896_I133_XG_p1 I1_I1896_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I133_XG_MP1 (I1_I1896_G8_1 I1_I1896_G4_1n XI1_I1896_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I77_XG_MP2 (VDD I1_I1942_gn11 I1_I1942_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I77_XG_MP0 (XI1_I1942_I77_XG_p1 I1_I1942_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I77_XG_MP1 (I1_I1942_G11_10 I1_I1942_gn10 XI1_I1942_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I76_XG_MP2 (VDD I1_I1942_gn10 I1_I1942_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I76_XG_MP0 (XI1_I1942_I76_XG_p1 I1_I1942_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I76_XG_MP1 (I1_I1942_G10_9 I1_I1942_gn9 XI1_I1942_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I184_XG_MP2 (VDD I1_I1942_G17_2n I1_I1942_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I184_XG_MP0 (XI1_I1942_I184_XG_p1 I1_I1942_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I184_XG_MP1 (I1_I1942_G17_0 I1_I1942_G1_0n XI1_I1942_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I135_XG_MP2 (VDD I1_I1942_G10_7n I1_I1942_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I135_XG_MP0 (XI1_I1942_I135_XG_p1 I1_I1942_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I135_XG_MP1 (I1_I1942_G10_3 I1_I1942_G6_3n XI1_I1942_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I185_XG_MP2 (VDD I1_I1942_G18_3n I1_I1942_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I185_XG_MP0 (XI1_I1942_I185_XG_p1 I1_I1942_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I185_XG_MP1 (I1_I1942_G18_0 I1_I1942_G2_0n XI1_I1942_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I77_XG_MP2 (VDD I1_I1988_gn11 I1_I1988_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I77_XG_MP0 (XI1_I1988_I77_XG_p1 I1_I1988_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I77_XG_MP1 (I1_I1988_G11_10 I1_I1988_gn10 XI1_I1988_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I76_XG_MP2 (VDD I1_I1988_gn10 I1_I1988_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I76_XG_MP0 (XI1_I1988_I76_XG_p1 I1_I1988_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I76_XG_MP1 (I1_I1988_G10_9 I1_I1988_gn9 XI1_I1988_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I136_XG_MP2 (VDD I1_I1988_G11_8n I1_I1988_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I136_XG_MP0 (XI1_I1988_I136_XG_p1 I1_I1988_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I136_XG_MP1 (I1_I1988_G11_4 I1_I1988_G7_4n XI1_I1988_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I132_XG_MP2 (VDD I1_I1988_G7_4n I1_I1988_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I132_XG_MP0 (XI1_I1988_I132_XG_p1 I1_I1988_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I132_XG_MP1 (I1_I1988_G7_0 I1_I1988_G3_0n XI1_I1988_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I135_XG_MP2 (VDD I1_I1988_G10_7n I1_I1988_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I135_XG_MP0 (XI1_I1988_I135_XG_p1 I1_I1988_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I135_XG_MP1 (I1_I1988_G10_3 I1_I1988_G6_3n XI1_I1988_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I131_XG_MP2 (VDD I1_I1988_G6_3n I1_I1988_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I131_XG_MP0 (XI1_I1988_I131_XG_p1 I1_I1988_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I131_XG_MP1 (I1_I1988_G6_0 I1_I1988_G2_0n XI1_I1988_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I75_XG_MP2 (VDD I1_I2066_gn9 I1_I2066_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I75_XG_MP0 (XI1_I2066_I75_XG_p1 I1_I2066_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I75_XG_MP1 (I1_I2066_G9_8 I1_I2066_gn8 XI1_I2066_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I74_XG_MP2 (VDD I1_I2066_gn8 I1_I2066_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I74_XG_MP0 (XI1_I2066_I74_XG_p1 I1_I2066_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I74_XG_MP1 (I1_I2066_G8_7 I1_I2066_gn7 XI1_I2066_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I73_XG_MP2 (VDD I1_I2066_gn7 I1_I2066_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I73_XG_MP0 (XI1_I2066_I73_XG_p1 I1_I2066_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I73_XG_MP1 (I1_I2066_G7_6 I1_I2066_gn6 XI1_I2066_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I67_XG_MP2 (VDD I1_I2066_gn1 I1_I2066_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I67_XG_MP0 (XI1_I2066_I67_XG_p1 I1_I2066_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I67_XG_MP1 (I1_I2066_G1_0 I1_I2066_G0_0n XI1_I2066_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I256_XG_MP2 (VDD I0_I1660_G4_1n I0_I1660_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I256_XG_MP0 (XI0_I1660_I256_XG_p1 I0_I1660_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I256_XG_MP1 (I0_I1660_G4_0 I0_I1660_G0_0n XI0_I1660_I256_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I261_XG_MP2 (VDD I0_I1660_G8_5n I0_I1660_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I261_XG_MP0 (XI0_I1660_I261_XG_p1 I0_I1660_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I261_XG_MP1 (I0_I1660_G8_1 I0_I1660_G4_1n XI0_I1660_I261_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I375_XG_MP2 (VDD I0_I1660_G16_1n I0_I1660_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I375_XG_MP0 (XI0_I1660_I375_XG_p1 I0_I1660_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I375_XG_MP1 (I0_I1660_G16_0 I0_I1660_G0_0n XI0_I1660_I375_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I265_XG_MP2 (VDD I0_I1660_G12_9n I0_I1660_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I265_XG_MP0 (XI0_I1660_I265_XG_p1 I0_I1660_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I265_XG_MP1 (I0_I1660_G12_5 I0_I1660_G8_5n XI0_I1660_I265_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I269_XG_MP2 (VDD I0_I1660_G16_13n I0_I1660_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I269_XG_MP0 (XI0_I1660_I269_XG_p1 I0_I1660_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I269_XG_MP1 (I0_I1660_G16_9 I0_I1660_G12_9n XI0_I1660_I269_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I398_XG_MP2 (VDD I0_I1660_G35_20n I0_I1660_G35_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I398_XG_MP0 (XI0_I1660_I398_XG_p1 I0_I1660_P35_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I398_XG_MP1 (I0_I1660_G35_4 I0_I1660_G19_4n XI0_I1660_I398_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I400_XG_MP2 (VDD I0_I1660_G37_22n I0_I1660_G37_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I400_XG_MP0 (XI0_I1660_I400_XG_p1 I0_I1660_P37_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I400_XG_MP1 (I0_I1660_G37_6 I0_I1660_G21_6n XI0_I1660_I400_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I412_XG_MP2 (VDD I0_I1660_G49_34n I0_I1660_G49_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I412_XG_MP0 (XI0_I1660_I412_XG_p1 I0_I1660_P49_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I412_XG_MP1 (I0_I1660_G49_18 I0_I1660_G33_18n XI0_I1660_I412_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I388_XG_MP2 (VDD I0_I1660_G25_10n I0_I1660_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I388_XG_MP0 (XI0_I1660_I388_XG_p1 I0_I1660_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I388_XG_MP1 (I0_I1660_G25_0 I0_I1660_G9_0n XI0_I1660_I388_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I402_XG_MP2 (VDD I0_I1660_G39_24n I0_I1660_G39_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I402_XG_MP0 (XI0_I1660_I402_XG_p1 I0_I1660_P39_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I402_XG_MP1 (I0_I1660_G39_8 I0_I1660_G23_8n XI0_I1660_I402_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I390_XG_MP2 (VDD I0_I1660_G27_12n I0_I1660_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I390_XG_MP0 (XI0_I1660_I390_XG_p1 I0_I1660_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I390_XG_MP1 (I0_I1660_G27_0 I0_I1660_G11_0n XI0_I1660_I390_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I288_XG_MP2 (VDD I0_I1660_G35_32n I0_I1660_G35_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I288_XG_MP0 (XI0_I1660_I288_XG_p1 I0_I1660_P35_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I288_XG_MP1 (I0_I1660_G35_28 I0_I1660_G31_28n XI0_I1660_I288_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I164_XG_MP2 (VDD I0_I1660_gn34 I0_I1660_G34_33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I164_XG_MP0 (XI0_I1660_I164_XG_p1 I0_I1660_pn34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I164_XG_MP1 (I0_I1660_G34_33 I0_I1660_gn33 XI0_I1660_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I202_XG_MP2 (VDD I1_I1804_G31_16n I1_c27_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I202_XG_MP0 (XI1_I1804_I202_XG_p1 I1_I1804_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I202_XG_MP1 (I1_c27_o I1_I1804_G15_0n XI1_I1804_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I198_XG_MP2 (VDD I1_I1804_G27_12n I1_I1804_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I198_XG_MP0 (XI1_I1804_I198_XG_p1 I1_I1804_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I198_XG_MP1 (I1_I1804_G27_0 I1_I1804_G11_0n XI1_I1804_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I194_XG_MP2 (VDD I1_I1804_G23_8n I1_I1804_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I194_XG_MP0 (XI1_I1804_I194_XG_p1 I1_I1804_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I194_XG_MP1 (I1_I1804_G23_0 I1_I1804_G7_0n XI1_I1804_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I144_XG_MP2 (VDD I1_I1804_G19_16n I1_I1804_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I144_XG_MP0 (XI1_I1804_I144_XG_p1 I1_I1804_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I144_XG_MP1 (I1_I1804_G19_12 I1_I1804_G15_12n XI1_I1804_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I186_XG_MP2 (VDD I1_I1804_G19_4n I1_I1804_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I186_XG_MP0 (XI1_I1804_I186_XG_p1 I1_I1804_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I186_XG_MP1 (I1_I1804_G19_0 I1_I1804_G3_0n XI1_I1804_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1804_I140_XG_MP2 (VDD I1_I1804_G15_12n I1_I1804_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1804_I140_XG_MP0 (XI1_I1804_I140_XG_p1 I1_I1804_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1804_I140_XG_MP1 (I1_I1804_G15_8 I1_I1804_G11_8n XI1_I1804_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I75_XG_MP2 (VDD I1_I1896_gn9 I1_I1896_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I75_XG_MP0 (XI1_I1896_I75_XG_p1 I1_I1896_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I75_XG_MP1 (I1_I1896_G9_8 I1_I1896_gn8 XI1_I1896_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I134_XG_MP2 (VDD I1_I1896_G9_6n I1_I1896_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I134_XG_MP0 (XI1_I1896_I134_XG_p1 I1_I1896_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I134_XG_MP1 (I1_I1896_G9_2 I1_I1896_G5_2n XI1_I1896_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I183_XG_MP2 (VDD I1_I1896_G16_1n I1_I1896_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I183_XG_MP0 (XI1_I1896_I183_XG_p1 I1_I1896_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I183_XG_MP1 (I1_I1896_G16_0 I1_I1896_G0_0n XI1_I1896_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I78_XG_MP2 (VDD I1_I1942_gn12 I1_I1942_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I78_XG_MP0 (XI1_I1942_I78_XG_p1 I1_I1942_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I78_XG_MP1 (I1_I1942_G12_11 I1_I1942_gn11 XI1_I1942_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I136_XG_MP2 (VDD I1_I1942_G11_8n I1_I1942_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I136_XG_MP0 (XI1_I1942_I136_XG_p1 I1_I1942_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I136_XG_MP1 (I1_I1942_G11_4 I1_I1942_G7_4n XI1_I1942_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I186_XG_MP2 (VDD I1_I1942_G19_4n I1_I1942_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I186_XG_MP0 (XI1_I1942_I186_XG_p1 I1_I1942_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I186_XG_MP1 (I1_I1942_G19_0 I1_I1942_G3_0n XI1_I1942_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I141_XG_MP2 (VDD I1_I1942_G16_13n I1_I1942_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I141_XG_MP0 (XI1_I1942_I141_XG_p1 I1_I1942_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I141_XG_MP1 (I1_I1942_G16_9 I1_I1942_G12_9n XI1_I1942_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I137_XG_MP2 (VDD I1_I1942_G12_9n I1_I1942_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I137_XG_MP0 (XI1_I1942_I137_XG_p1 I1_I1942_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I137_XG_MP1 (I1_I1942_G12_5 I1_I1942_G8_5n XI1_I1942_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I78_XG_MP2 (VDD I1_I1988_gn12 I1_I1988_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I78_XG_MP0 (XI1_I1988_I78_XG_p1 I1_I1988_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I78_XG_MP1 (I1_I1988_G12_11 I1_I1988_gn11 XI1_I1988_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I138_XG_MP2 (VDD I1_I1988_G13_10n I1_I1988_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I138_XG_MP0 (XI1_I1988_I138_XG_p1 I1_I1988_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I138_XG_MP1 (I1_I1988_G13_6 I1_I1988_G9_6n XI1_I1988_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I141_XG_MP2 (VDD I1_I1988_G16_13n I1_I1988_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I141_XG_MP0 (XI1_I1988_I141_XG_p1 I1_I1988_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I141_XG_MP1 (I1_I1988_G16_9 I1_I1988_G12_9n XI1_I1988_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I137_XG_MP2 (VDD I1_I1988_G12_9n I1_I1988_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I137_XG_MP0 (XI1_I1988_I137_XG_p1 I1_I1988_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I137_XG_MP1 (I1_I1988_G12_5 I1_I1988_G8_5n XI1_I1988_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I195_XG_MP2 (VDD I1_I1988_G24_9n I1_I1988_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I195_XG_MP0 (XI1_I1988_I195_XG_p1 I1_I1988_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I195_XG_MP1 (I1_I1988_G24_0 I1_I1988_G8_0n XI1_I1988_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I76_XG_MP2 (VDD I1_I2066_gn10 I1_I2066_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I76_XG_MP0 (XI1_I2066_I76_XG_p1 I1_I2066_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I76_XG_MP1 (I1_I2066_G10_9 I1_I2066_gn9 XI1_I2066_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I128_XG_MP2 (VDD I1_I2066_G4_1n I1_I2066_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I128_XG_MP0 (XI1_I2066_I128_XG_p1 I1_I2066_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I128_XG_MP1 (I1_I2066_G4_0 I1_I2066_G0_0n XI1_I2066_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I259_XG_MP2 (VDD I0_I1660_G6_3n I0_I1660_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I259_XG_MP0 (XI0_I1660_I259_XG_p1 I0_I1660_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I259_XG_MP1 (I0_I1660_G6_0 I0_I1660_G2_0n XI0_I1660_I259_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I263_XG_MP2 (VDD I0_I1660_G10_7n I0_I1660_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I263_XG_MP0 (XI0_I1660_I263_XG_p1 I0_I1660_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I263_XG_MP1 (I0_I1660_G10_3 I0_I1660_G6_3n XI0_I1660_I263_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I267_XG_MP2 (VDD I0_I1660_G14_11n I0_I1660_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I267_XG_MP0 (XI0_I1660_I267_XG_p1 I0_I1660_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I267_XG_MP1 (I0_I1660_G14_7 I0_I1660_G10_7n XI0_I1660_I267_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I271_XG_MP2 (VDD I0_I1660_G18_15n I0_I1660_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I271_XG_MP0 (XI0_I1660_I271_XG_p1 I0_I1660_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I271_XG_MP1 (I0_I1660_G18_11 I0_I1660_G14_11n XI0_I1660_I271_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I380_XG_MP2 (VDD I0_I1660_G20_5n I0_I1660_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I380_XG_MP0 (XI0_I1660_I380_XG_p1 I0_I1660_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I380_XG_MP1 (I0_I1660_G20_0 I0_I1660_G4_0n XI0_I1660_I380_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I387_XG_MP2 (VDD I0_I1660_G24_9n I0_I1660_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I387_XG_MP0 (XI0_I1660_I387_XG_p1 I0_I1660_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I387_XG_MP1 (I0_I1660_G24_0 I0_I1660_G8_0n XI0_I1660_I387_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I281_XG_MP2 (VDD I0_I1660_G28_25n I0_I1660_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I281_XG_MP0 (XI0_I1660_I281_XG_p1 I0_I1660_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I281_XG_MP1 (I0_I1660_G28_21 I0_I1660_G24_21n XI0_I1660_I281_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I285_XG_MP2 (VDD I0_I1660_G32_29n I0_I1660_G32_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I285_XG_MP0 (XI0_I1660_I285_XG_p1 I0_I1660_P32_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I285_XG_MP1 (I0_I1660_G32_25 I0_I1660_G28_25n XI0_I1660_I285_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I392_XG_MP2 (VDD I0_I1660_G29_14n I0_I1660_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I392_XG_MP0 (XI0_I1660_I392_XG_p1 I0_I1660_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I392_XG_MP1 (I0_I1660_G29_0 I0_I1660_G13_0n XI0_I1660_I392_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I406_XG_MP2 (VDD I0_I1660_G43_28n I0_I1660_G43_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I406_XG_MP0 (XI0_I1660_I406_XG_p1 I0_I1660_P43_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I406_XG_MP1 (I0_I1660_G43_12 I0_I1660_G27_12n XI0_I1660_I406_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I394_XG_MP2 (VDD I0_I1660_G31_16n I0_I1660_G31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I394_XG_MP0 (XI0_I1660_I394_XG_p1 I0_I1660_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I394_XG_MP1 (I0_I1660_G31_0 I0_I1660_G15_0n XI0_I1660_I394_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I290_XG_MP2 (VDD I0_I1660_G37_34n I0_I1660_G37_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I290_XG_MP0 (XI0_I1660_I290_XG_p1 I0_I1660_P37_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I290_XG_MP1 (I0_I1660_G37_30 I0_I1660_G33_30n XI0_I1660_I290_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I292_XG_MP2 (VDD I0_I1660_G39_36n I0_I1660_G39_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I292_XG_MP0 (XI0_I1660_I292_XG_p1 I0_I1660_P39_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I292_XG_MP1 (I0_I1660_G39_32 I0_I1660_G35_32n XI0_I1660_I292_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I166_XG_MP2 (VDD I0_I1660_gn36 I0_I1660_G36_35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I166_XG_MP0 (XI0_I1660_I166_XG_p1 I0_I1660_pn36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I166_XG_MP1 (I0_I1660_G36_35 I0_I1660_gn35 XI0_I1660_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I165_XG_MP2 (VDD I0_I1660_gn35 I0_I1660_G35_34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I165_XG_MP0 (XI0_I1660_I165_XG_p1 I0_I1660_pn35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I165_XG_MP1 (I0_I1660_G35_34 I0_I1660_gn34 XI0_I1660_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I167_XG_MP2 (VDD I0_I1660_gn37 I0_I1660_G37_36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I167_XG_MP0 (XI0_I1660_I167_XG_p1 I0_I1660_pn37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I167_XG_MP1 (I0_I1660_G37_36 I0_I1660_gn36 XI0_I1660_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I136_XG_MP2 (VDD I1_I1850_G11_8n I1_I1850_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I136_XG_MP0 (XI1_I1850_I136_XG_p1 I1_I1850_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I136_XG_MP1 (I1_I1850_G11_4 I1_I1850_G7_4n XI1_I1850_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I132_XG_MP2 (VDD I1_I1850_G7_4n I1_I1850_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I132_XG_MP0 (XI1_I1850_I132_XG_p1 I1_I1850_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I132_XG_MP1 (I1_I1850_G7_0 I1_I1850_G3_0n XI1_I1850_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I134_XG_MP2 (VDD I1_I1850_G9_6n I1_I1850_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I134_XG_MP0 (XI1_I1850_I134_XG_p1 I1_I1850_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I134_XG_MP1 (I1_I1850_G9_2 I1_I1850_G5_2n XI1_I1850_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I130_XG_MP2 (VDD I1_I1850_G5_2n I1_I1850_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I130_XG_MP0 (XI1_I1850_I130_XG_p1 I1_I1850_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I130_XG_MP1 (I1_I1850_G5_0 I1_I1850_G1_0n XI1_I1850_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I77_XG_MP2 (VDD I1_I1850_gn11 I1_I1850_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I77_XG_MP0 (XI1_I1850_I77_XG_p1 I1_I1850_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I77_XG_MP1 (I1_I1850_G11_10 I1_I1850_gn10 XI1_I1850_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I76_XG_MP2 (VDD I1_I1850_gn10 I1_I1850_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I76_XG_MP0 (XI1_I1850_I76_XG_p1 I1_I1850_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I76_XG_MP1 (I1_I1850_G10_9 I1_I1850_gn9 XI1_I1850_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I75_XG_MP2 (VDD I1_I1850_gn9 I1_I1850_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I75_XG_MP0 (XI1_I1850_I75_XG_p1 I1_I1850_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I75_XG_MP1 (I1_I1850_G9_8 I1_I1850_gn8 XI1_I1850_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I128_XG_MP2 (VDD I1_I1850_G4_1n I1_I1850_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I128_XG_MP0 (XI1_I1850_I128_XG_p1 I1_I1850_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I128_XG_MP1 (I1_I1850_G4_0 I1_I1850_G0_0n XI1_I1850_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I77_XG_MP2 (VDD I1_I1896_gn11 I1_I1896_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I77_XG_MP0 (XI1_I1896_I77_XG_p1 I1_I1896_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I77_XG_MP1 (I1_I1896_G11_10 I1_I1896_gn10 XI1_I1896_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I76_XG_MP2 (VDD I1_I1896_gn10 I1_I1896_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I76_XG_MP0 (XI1_I1896_I76_XG_p1 I1_I1896_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I76_XG_MP1 (I1_I1896_G10_9 I1_I1896_gn9 XI1_I1896_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I136_XG_MP2 (VDD I1_I1896_G11_8n I1_I1896_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I136_XG_MP0 (XI1_I1896_I136_XG_p1 I1_I1896_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I136_XG_MP1 (I1_I1896_G11_4 I1_I1896_G7_4n XI1_I1896_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I184_XG_MP2 (VDD I1_I1896_G17_2n I1_I1896_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I184_XG_MP0 (XI1_I1896_I184_XG_p1 I1_I1896_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I184_XG_MP1 (I1_I1896_G17_0 I1_I1896_G1_0n XI1_I1896_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I135_XG_MP2 (VDD I1_I1896_G10_7n I1_I1896_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I135_XG_MP0 (XI1_I1896_I135_XG_p1 I1_I1896_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I135_XG_MP1 (I1_I1896_G10_3 I1_I1896_G6_3n XI1_I1896_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I79_XG_MP2 (VDD I1_I1942_gn13 I1_I1942_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I79_XG_MP0 (XI1_I1942_I79_XG_p1 I1_I1942_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I79_XG_MP1 (I1_I1942_G13_12 I1_I1942_gn12 XI1_I1942_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I138_XG_MP2 (VDD I1_I1942_G13_10n I1_I1942_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I138_XG_MP0 (XI1_I1942_I138_XG_p1 I1_I1942_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I138_XG_MP1 (I1_I1942_G13_6 I1_I1942_G9_6n XI1_I1942_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I196_XG_MP2 (VDD I1_I1942_G25_10n I1_I1942_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I196_XG_MP0 (XI1_I1942_I196_XG_p1 I1_I1942_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I196_XG_MP1 (I1_I1942_G25_0 I1_I1942_G9_0n XI1_I1942_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I139_XG_MP2 (VDD I1_I1942_G14_11n I1_I1942_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I139_XG_MP0 (XI1_I1942_I139_XG_p1 I1_I1942_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I139_XG_MP1 (I1_I1942_G14_7 I1_I1942_G10_7n XI1_I1942_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I195_XG_MP2 (VDD I1_I1942_G24_9n I1_I1942_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I195_XG_MP0 (XI1_I1942_I195_XG_p1 I1_I1942_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I195_XG_MP1 (I1_I1942_G24_0 I1_I1942_G8_0n XI1_I1942_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I79_XG_MP2 (VDD I1_I1988_gn13 I1_I1988_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I79_XG_MP0 (XI1_I1988_I79_XG_p1 I1_I1988_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I79_XG_MP1 (I1_I1988_G13_12 I1_I1988_gn12 XI1_I1988_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I80_XG_MP2 (VDD I1_I1988_gn14 I1_I1988_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I80_XG_MP0 (XI1_I1988_I80_XG_p1 I1_I1988_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I80_XG_MP1 (I1_I1988_G14_13 I1_I1988_gn13 XI1_I1988_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I142_XG_MP2 (VDD I1_I1988_G17_14n I1_I1988_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I142_XG_MP0 (XI1_I1988_I142_XG_p1 I1_I1988_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I142_XG_MP1 (I1_I1988_G17_10 I1_I1988_G13_10n XI1_I1988_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I196_XG_MP2 (VDD I1_I1988_G25_10n I1_I1988_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I196_XG_MP0 (XI1_I1988_I196_XG_p1 I1_I1988_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I196_XG_MP1 (I1_I1988_G25_0 I1_I1988_G9_0n XI1_I1988_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I139_XG_MP2 (VDD I1_I1988_G14_11n I1_I1988_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I139_XG_MP0 (XI1_I1988_I139_XG_p1 I1_I1988_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I139_XG_MP1 (I1_I1988_G14_7 I1_I1988_G10_7n XI1_I1988_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I185_XG_MP2 (VDD I1_I1988_G18_3n I1_I1988_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I185_XG_MP0 (XI1_I1988_I185_XG_p1 I1_I1988_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I185_XG_MP1 (I1_I1988_G18_0 I1_I1988_G2_0n XI1_I1988_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I78_XG_MP2 (VDD I1_I2066_gn12 I1_I2066_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I78_XG_MP0 (XI1_I2066_I78_XG_p1 I1_I2066_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I78_XG_MP1 (I1_I2066_G12_11 I1_I2066_gn11 XI1_I2066_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I77_XG_MP2 (VDD I1_I2066_gn11 I1_I2066_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I77_XG_MP0 (XI1_I2066_I77_XG_p1 I1_I2066_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I77_XG_MP1 (I1_I2066_G11_10 I1_I2066_gn10 XI1_I2066_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I133_XG_MP2 (VDD I1_I2066_G8_5n I1_I2066_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I133_XG_MP0 (XI1_I2066_I133_XG_p1 I1_I2066_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I133_XG_MP1 (I1_I2066_G8_1 I1_I2066_G4_1n XI1_I2066_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I183_XG_MP2 (VDD I1_I2066_G16_1n I1_I2066_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I183_XG_MP0 (XI1_I2066_I183_XG_p1 I1_I2066_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I183_XG_MP1 (I1_I2066_G16_0 I1_I2066_G0_0n XI1_I2066_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I130_XG_MP2 (VDD I1_I2066_G5_2n I1_I2066_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I130_XG_MP0 (XI1_I2066_I130_XG_p1 I1_I2066_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I130_XG_MP1 (I1_I2066_G5_0 I1_I2066_G1_0n XI1_I2066_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I395_XG_MP2 (VDD I0_I1660_G32_17n I0_I1660_G32_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I395_XG_MP0 (XI0_I1660_I395_XG_p1 I0_I1660_P32_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I395_XG_MP1 (I0_I1660_G32_1 I0_I1660_G16_1n XI0_I1660_I395_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I399_XG_MP2 (VDD I0_I1660_G36_21n I0_I1660_G36_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I399_XG_MP0 (XI0_I1660_I399_XG_p1 I0_I1660_P36_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I399_XG_MP1 (I0_I1660_G36_5 I0_I1660_G20_5n XI0_I1660_I399_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I403_XG_MP2 (VDD I0_I1660_G40_25n I0_I1660_G40_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I403_XG_MP0 (XI0_I1660_I403_XG_p1 I0_I1660_P40_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I403_XG_MP1 (I0_I1660_G40_9 I0_I1660_G24_9n XI0_I1660_I403_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I391_XG_MP2 (VDD I0_I1660_G28_13n I0_I1660_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I391_XG_MP0 (XI0_I1660_I391_XG_p1 I0_I1660_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I391_XG_MP1 (I0_I1660_G28_0 I0_I1660_G12_0n XI0_I1660_I391_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I289_XG_MP2 (VDD I0_I1660_G36_33n I0_I1660_G36_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I289_XG_MP0 (XI0_I1660_I289_XG_p1 I0_I1660_P36_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I289_XG_MP1 (I0_I1660_G36_29 I0_I1660_G32_29n XI0_I1660_I289_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I404_XG_MP2 (VDD I0_I1660_G41_26n I0_I1660_G41_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I404_XG_MP0 (XI0_I1660_I404_XG_p1 I0_I1660_P41_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I404_XG_MP1 (I0_I1660_G41_10 I0_I1660_G25_10n XI0_I1660_I404_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I414_XG_MP2 (VDD I0_I1660_G51_36n I0_I1660_G51_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I414_XG_MP0 (XI0_I1660_I414_XG_p1 I0_I1660_P51_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I414_XG_MP1 (I0_I1660_G51_20 I0_I1660_G35_20n XI0_I1660_I414_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I410_XG_MP2 (VDD I0_I1660_G47_32n I0_I1660_G47_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I410_XG_MP0 (XI0_I1660_I410_XG_p1 I0_I1660_P47_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I410_XG_MP1 (I0_I1660_G47_16 I0_I1660_G31_16n XI0_I1660_I410_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I294_XG_MP2 (VDD I0_I1660_G41_38n I0_I1660_G41_34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I294_XG_MP0 (XI0_I1660_I294_XG_p1 I0_I1660_P41_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I294_XG_MP1 (I0_I1660_G41_34 I0_I1660_G37_34n XI0_I1660_I294_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I296_XG_MP2 (VDD I0_I1660_G43_40n I0_I1660_G43_36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I296_XG_MP0 (XI0_I1660_I296_XG_p1 I0_I1660_P43_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I296_XG_MP1 (I0_I1660_G43_36 I0_I1660_G39_36n XI0_I1660_I296_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I171_XG_MP2 (VDD I0_I1660_gn41 I0_I1660_G41_40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I171_XG_MP0 (XI0_I1660_I171_XG_p1 I0_I1660_pn41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I171_XG_MP1 (I0_I1660_G41_40 I0_I1660_gn40 XI0_I1660_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I170_XG_MP2 (VDD I0_I1660_gn40 I0_I1660_G40_39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I170_XG_MP0 (XI0_I1660_I170_XG_p1 I0_I1660_pn40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I170_XG_MP1 (I0_I1660_G40_39 I0_I1660_gn39 XI0_I1660_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I186_XG_MP2 (VDD I1_I1850_G19_4n I1_I1850_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I186_XG_MP0 (XI1_I1850_I186_XG_p1 I1_I1850_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I186_XG_MP1 (I1_I1850_G19_0 I1_I1850_G3_0n XI1_I1850_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I138_XG_MP2 (VDD I1_I1850_G13_10n I1_I1850_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I138_XG_MP0 (XI1_I1850_I138_XG_p1 I1_I1850_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I138_XG_MP1 (I1_I1850_G13_6 I1_I1850_G9_6n XI1_I1850_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I184_XG_MP2 (VDD I1_I1850_G17_2n I1_I1850_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I184_XG_MP0 (XI1_I1850_I184_XG_p1 I1_I1850_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I184_XG_MP1 (I1_I1850_G17_0 I1_I1850_G1_0n XI1_I1850_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I79_XG_MP2 (VDD I1_I1850_gn13 I1_I1850_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I79_XG_MP0 (XI1_I1850_I79_XG_p1 I1_I1850_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I79_XG_MP1 (I1_I1850_G13_12 I1_I1850_gn12 XI1_I1850_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I78_XG_MP2 (VDD I1_I1850_gn12 I1_I1850_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I78_XG_MP0 (XI1_I1850_I78_XG_p1 I1_I1850_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I78_XG_MP1 (I1_I1850_G12_11 I1_I1850_gn11 XI1_I1850_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I78_XG_MP2 (VDD I1_I1896_gn12 I1_I1896_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I78_XG_MP0 (XI1_I1896_I78_XG_p1 I1_I1896_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I78_XG_MP1 (I1_I1896_G12_11 I1_I1896_gn11 XI1_I1896_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I138_XG_MP2 (VDD I1_I1896_G13_10n I1_I1896_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I138_XG_MP0 (XI1_I1896_I138_XG_p1 I1_I1896_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I138_XG_MP1 (I1_I1896_G13_6 I1_I1896_G9_6n XI1_I1896_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I137_XG_MP2 (VDD I1_I1896_G12_9n I1_I1896_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I137_XG_MP0 (XI1_I1896_I137_XG_p1 I1_I1896_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I137_XG_MP1 (I1_I1896_G12_5 I1_I1896_G8_5n XI1_I1896_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I185_XG_MP2 (VDD I1_I1896_G18_3n I1_I1896_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I185_XG_MP0 (XI1_I1896_I185_XG_p1 I1_I1896_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I185_XG_MP1 (I1_I1896_G18_0 I1_I1896_G2_0n XI1_I1896_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I81_XG_MP2 (VDD I1_I1942_gn15 I1_I1942_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I81_XG_MP0 (XI1_I1942_I81_XG_p1 I1_I1942_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I81_XG_MP1 (I1_I1942_G15_14 I1_I1942_gn14 XI1_I1942_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I140_XG_MP2 (VDD I1_I1942_G15_12n I1_I1942_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I140_XG_MP0 (XI1_I1942_I140_XG_p1 I1_I1942_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I140_XG_MP1 (I1_I1942_G15_8 I1_I1942_G11_8n XI1_I1942_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I143_XG_MP2 (VDD I1_I1942_G18_15n I1_I1942_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I143_XG_MP0 (XI1_I1942_I143_XG_p1 I1_I1942_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I143_XG_MP1 (I1_I1942_G18_11 I1_I1942_G14_11n XI1_I1942_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I188_XG_MP2 (VDD I1_I1942_G20_5n I1_I1942_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I188_XG_MP0 (XI1_I1942_I188_XG_p1 I1_I1942_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I188_XG_MP1 (I1_I1942_G20_0 I1_I1942_G4_0n XI1_I1942_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I81_XG_MP2 (VDD I1_I1988_gn15 I1_I1988_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I81_XG_MP0 (XI1_I1988_I81_XG_p1 I1_I1988_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I81_XG_MP1 (I1_I1988_G15_14 I1_I1988_gn14 XI1_I1988_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I140_XG_MP2 (VDD I1_I1988_G15_12n I1_I1988_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I140_XG_MP0 (XI1_I1988_I140_XG_p1 I1_I1988_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I140_XG_MP1 (I1_I1988_G15_8 I1_I1988_G11_8n XI1_I1988_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I186_XG_MP2 (VDD I1_I1988_G19_4n I1_I1988_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I186_XG_MP0 (XI1_I1988_I186_XG_p1 I1_I1988_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I186_XG_MP1 (I1_I1988_G19_0 I1_I1988_G3_0n XI1_I1988_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I143_XG_MP2 (VDD I1_I1988_G18_15n I1_I1988_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I143_XG_MP0 (XI1_I1988_I143_XG_p1 I1_I1988_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I143_XG_MP1 (I1_I1988_G18_11 I1_I1988_G14_11n XI1_I1988_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I79_XG_MP2 (VDD I1_I2066_gn13 I1_I2066_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I79_XG_MP0 (XI1_I2066_I79_XG_p1 I1_I2066_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I79_XG_MP1 (I1_I2066_G13_12 I1_I2066_gn12 XI1_I2066_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I141_XG_MP2 (VDD I1_I2066_G16_13n I1_I2066_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I141_XG_MP0 (XI1_I2066_I141_XG_p1 I1_I2066_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I141_XG_MP1 (I1_I2066_G16_9 I1_I2066_G12_9n XI1_I2066_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I137_XG_MP2 (VDD I1_I2066_G12_9n I1_I2066_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I137_XG_MP0 (XI1_I2066_I137_XG_p1 I1_I2066_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I137_XG_MP1 (I1_I2066_G12_5 I1_I2066_G8_5n XI1_I2066_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I195_XG_MP2 (VDD I1_I2066_G24_9n I1_I2066_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I195_XG_MP0 (XI1_I2066_I195_XG_p1 I1_I2066_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I195_XG_MP1 (I1_I2066_G24_0 I1_I2066_G8_0n XI1_I2066_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I134_XG_MP2 (VDD I1_I2066_G9_6n I1_I2066_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I134_XG_MP0 (XI1_I2066_I134_XG_p1 I1_I2066_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I134_XG_MP1 (I1_I2066_G9_2 I1_I2066_G5_2n XI1_I2066_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I377_XG_MP2 (VDD I0_I1660_G18_3n I0_I1660_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I377_XG_MP0 (XI0_I1660_I377_XG_p1 I0_I1660_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I377_XG_MP1 (I0_I1660_G18_0 I0_I1660_G2_0n XI0_I1660_I377_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I397_XG_MP2 (VDD I0_I1660_G34_19n I0_I1660_G34_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I397_XG_MP0 (XI0_I1660_I397_XG_p1 I0_I1660_P34_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I397_XG_MP1 (I0_I1660_G34_3 I0_I1660_G18_3n XI0_I1660_I397_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I275_XG_MP2 (VDD I0_I1660_G22_19n I0_I1660_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I275_XG_MP0 (XI0_I1660_I275_XG_p1 I0_I1660_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I275_XG_MP1 (I0_I1660_G22_15 I0_I1660_G18_15n XI0_I1660_I275_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I411_XG_MP2 (VDD I0_I1660_G48_33n I0_I1660_G48_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I411_XG_MP0 (XI0_I1660_I411_XG_p1 I0_I1660_P48_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I411_XG_MP1 (I0_I1660_G48_17 I0_I1660_G32_17n XI0_I1660_I411_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I279_XG_MP2 (VDD I0_I1660_G26_23n I0_I1660_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I279_XG_MP0 (XI0_I1660_I279_XG_p1 I0_I1660_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I279_XG_MP1 (I0_I1660_G26_19 I0_I1660_G22_19n XI0_I1660_I279_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I283_XG_MP2 (VDD I0_I1660_G30_27n I0_I1660_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I283_XG_MP0 (XI0_I1660_I283_XG_p1 I0_I1660_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I283_XG_MP1 (I0_I1660_G30_23 I0_I1660_G26_23n XI0_I1660_I283_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I293_XG_MP2 (VDD I0_I1660_G40_37n I0_I1660_G40_33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I293_XG_MP0 (XI0_I1660_I293_XG_p1 I0_I1660_P40_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I293_XG_MP1 (I0_I1660_G40_33 I0_I1660_G36_33n XI0_I1660_I293_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I416_XG_MP2 (VDD I0_I1660_G53_38n I0_I1660_G53_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I416_XG_MP0 (XI0_I1660_I416_XG_p1 I0_I1660_P53_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I416_XG_MP1 (I0_I1660_G53_22 I0_I1660_G37_22n XI0_I1660_I416_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I418_XG_MP2 (VDD I0_I1660_G55_40n I0_I1660_G55_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I418_XG_MP0 (XI0_I1660_I418_XG_p1 I0_I1660_P55_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I418_XG_MP1 (I0_I1660_G55_24 I0_I1660_G39_24n XI0_I1660_I418_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I300_XG_MP2 (VDD I0_I1660_G47_44n I0_I1660_G47_40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I300_XG_MP0 (XI0_I1660_I300_XG_p1 I0_I1660_P47_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I300_XG_MP1 (I0_I1660_G47_40 I0_I1660_G43_40n XI0_I1660_I300_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I174_XG_MP2 (VDD I0_I1660_gn44 I0_I1660_G44_43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I174_XG_MP0 (XI0_I1660_I174_XG_p1 I0_I1660_pn44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I174_XG_MP1 (I0_I1660_G44_43 I0_I1660_gn43 XI0_I1660_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I173_XG_MP2 (VDD I0_I1660_gn43 I0_I1660_G43_42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I173_XG_MP0 (XI0_I1660_I173_XG_p1 I0_I1660_pn43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I173_XG_MP1 (I0_I1660_G43_42 I0_I1660_gn42 XI0_I1660_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I172_XG_MP2 (VDD I0_I1660_gn42 I0_I1660_G42_41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I172_XG_MP0 (XI0_I1660_I172_XG_p1 I0_I1660_pn42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I172_XG_MP1 (I0_I1660_G42_41 I0_I1660_gn41 XI0_I1660_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I140_XG_MP2 (VDD I1_I1850_G15_12n I1_I1850_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I140_XG_MP0 (XI1_I1850_I140_XG_p1 I1_I1850_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I140_XG_MP1 (I1_I1850_G15_8 I1_I1850_G11_8n XI1_I1850_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I81_XG_MP2 (VDD I1_I1850_gn15 I1_I1850_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I81_XG_MP0 (XI1_I1850_I81_XG_p1 I1_I1850_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I81_XG_MP1 (I1_I1850_G15_14 I1_I1850_gn14 XI1_I1850_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I80_XG_MP2 (VDD I1_I1850_gn14 I1_I1850_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I80_XG_MP0 (XI1_I1850_I80_XG_p1 I1_I1850_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I80_XG_MP1 (I1_I1850_G14_13 I1_I1850_gn13 XI1_I1850_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I133_XG_MP2 (VDD I1_I1850_G8_5n I1_I1850_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I133_XG_MP0 (XI1_I1850_I133_XG_p1 I1_I1850_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I133_XG_MP1 (I1_I1850_G8_1 I1_I1850_G4_1n XI1_I1850_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I131_XG_MP2 (VDD I1_I1850_G6_3n I1_I1850_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I131_XG_MP0 (XI1_I1850_I131_XG_p1 I1_I1850_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I131_XG_MP1 (I1_I1850_G6_0 I1_I1850_G2_0n XI1_I1850_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I80_XG_MP2 (VDD I1_I1896_gn14 I1_I1896_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I80_XG_MP0 (XI1_I1896_I80_XG_p1 I1_I1896_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I80_XG_MP1 (I1_I1896_G14_13 I1_I1896_gn13 XI1_I1896_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I79_XG_MP2 (VDD I1_I1896_gn13 I1_I1896_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I79_XG_MP0 (XI1_I1896_I79_XG_p1 I1_I1896_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I79_XG_MP1 (I1_I1896_G13_12 I1_I1896_gn12 XI1_I1896_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I142_XG_MP2 (VDD I1_I1896_G17_14n I1_I1896_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I142_XG_MP0 (XI1_I1896_I142_XG_p1 I1_I1896_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I142_XG_MP1 (I1_I1896_G17_10 I1_I1896_G13_10n XI1_I1896_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I186_XG_MP2 (VDD I1_I1896_G19_4n I1_I1896_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I186_XG_MP0 (XI1_I1896_I186_XG_p1 I1_I1896_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I186_XG_MP1 (I1_I1896_G19_0 I1_I1896_G3_0n XI1_I1896_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I141_XG_MP2 (VDD I1_I1896_G16_13n I1_I1896_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I141_XG_MP0 (XI1_I1896_I141_XG_p1 I1_I1896_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I141_XG_MP1 (I1_I1896_G16_9 I1_I1896_G12_9n XI1_I1896_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I83_XG_MP2 (VDD I1_I1942_gn17 I1_I1942_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I83_XG_MP0 (XI1_I1942_I83_XG_p1 I1_I1942_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I83_XG_MP1 (I1_I1942_G17_16 I1_I1942_gn16 XI1_I1942_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I82_XG_MP2 (VDD I1_I1942_gn16 I1_I1942_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I82_XG_MP0 (XI1_I1942_I82_XG_p1 I1_I1942_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I82_XG_MP1 (I1_I1942_G16_15 I1_I1942_gn15 XI1_I1942_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I144_XG_MP2 (VDD I1_I1942_G19_16n I1_I1942_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I144_XG_MP0 (XI1_I1942_I144_XG_p1 I1_I1942_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I144_XG_MP1 (I1_I1942_G19_12 I1_I1942_G15_12n XI1_I1942_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I190_XG_MP2 (VDD I1_I1942_G21_6n I1_I1942_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I190_XG_MP0 (XI1_I1942_I190_XG_p1 I1_I1942_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I190_XG_MP1 (I1_I1942_G21_0 I1_I1942_G5_0n XI1_I1942_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I145_XG_MP2 (VDD I1_I1942_G20_17n I1_I1942_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I145_XG_MP0 (XI1_I1942_I145_XG_p1 I1_I1942_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I145_XG_MP1 (I1_I1942_G20_13 I1_I1942_G16_13n XI1_I1942_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I82_XG_MP2 (VDD I1_I1988_gn16 I1_I1988_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I82_XG_MP0 (XI1_I1988_I82_XG_p1 I1_I1988_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I82_XG_MP1 (I1_I1988_G16_15 I1_I1988_gn15 XI1_I1988_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I83_XG_MP2 (VDD I1_I1988_gn17 I1_I1988_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I83_XG_MP0 (XI1_I1988_I83_XG_p1 I1_I1988_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I83_XG_MP1 (I1_I1988_G17_16 I1_I1988_gn16 XI1_I1988_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I144_XG_MP2 (VDD I1_I1988_G19_16n I1_I1988_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I144_XG_MP0 (XI1_I1988_I144_XG_p1 I1_I1988_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I144_XG_MP1 (I1_I1988_G19_12 I1_I1988_G15_12n XI1_I1988_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I190_XG_MP2 (VDD I1_I1988_G21_6n I1_I1988_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I190_XG_MP0 (XI1_I1988_I190_XG_p1 I1_I1988_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I190_XG_MP1 (I1_I1988_G21_0 I1_I1988_G5_0n XI1_I1988_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I145_XG_MP2 (VDD I1_I1988_G20_17n I1_I1988_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I145_XG_MP0 (XI1_I1988_I145_XG_p1 I1_I1988_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I145_XG_MP1 (I1_I1988_G20_13 I1_I1988_G16_13n XI1_I1988_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I188_XG_MP2 (VDD I1_I1988_G20_5n I1_I1988_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I188_XG_MP0 (XI1_I1988_I188_XG_p1 I1_I1988_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I188_XG_MP1 (I1_I1988_G20_0 I1_I1988_G4_0n XI1_I1988_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I81_XG_MP2 (VDD I1_I2066_gn15 I1_I2066_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I81_XG_MP0 (XI1_I2066_I81_XG_p1 I1_I2066_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I81_XG_MP1 (I1_I2066_G15_14 I1_I2066_gn14 XI1_I2066_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I80_XG_MP2 (VDD I1_I2066_gn14 I1_I2066_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I80_XG_MP0 (XI1_I2066_I80_XG_p1 I1_I2066_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I80_XG_MP1 (I1_I2066_G14_13 I1_I2066_gn13 XI1_I2066_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I135_XG_MP2 (VDD I1_I2066_G10_7n I1_I2066_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I135_XG_MP0 (XI1_I2066_I135_XG_p1 I1_I2066_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I135_XG_MP1 (I1_I2066_G10_3 I1_I2066_G6_3n XI1_I2066_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I131_XG_MP2 (VDD I1_I2066_G6_3n I1_I2066_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I131_XG_MP0 (XI1_I2066_I131_XG_p1 I1_I2066_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I131_XG_MP1 (I1_I2066_G6_0 I1_I2066_G2_0n XI1_I2066_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I184_XG_MP2 (VDD I1_I2066_G17_2n I1_I2066_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I184_XG_MP0 (XI1_I2066_I184_XG_p1 I1_I2066_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I184_XG_MP1 (I1_I2066_G17_0 I1_I2066_G1_0n XI1_I2066_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I389_XG_MP2 (VDD I0_I1660_G26_11n I0_I1660_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I389_XG_MP0 (XI0_I1660_I389_XG_p1 I0_I1660_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I389_XG_MP1 (I0_I1660_G26_0 I0_I1660_G10_0n XI0_I1660_I389_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I407_XG_MP2 (VDD I0_I1660_G44_29n I0_I1660_G44_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I407_XG_MP0 (XI0_I1660_I407_XG_p1 I0_I1660_P44_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I407_XG_MP1 (I0_I1660_G44_13 I0_I1660_G28_13n XI0_I1660_I407_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I287_XG_MP2 (VDD I0_I1660_G34_31n I0_I1660_G34_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I287_XG_MP0 (XI0_I1660_I287_XG_p1 I0_I1660_P34_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I287_XG_MP1 (I0_I1660_G34_27 I0_I1660_G30_27n XI0_I1660_I287_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I297_XG_MP2 (VDD I0_I1660_G44_41n I0_I1660_G44_37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I297_XG_MP0 (XI0_I1660_I297_XG_p1 I0_I1660_P44_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I297_XG_MP1 (I0_I1660_G44_37 I0_I1660_G40_37n XI0_I1660_I297_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I408_XG_MP2 (VDD I0_I1660_G45_30n I0_I1660_G45_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I408_XG_MP0 (XI0_I1660_I408_XG_p1 I0_I1660_P45_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I408_XG_MP1 (I0_I1660_G45_14 I0_I1660_G29_14n XI0_I1660_I408_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I426_XG_MP2 (VDD I0_I1660_G63_48n I0_I1660_G63_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I426_XG_MP0 (XI0_I1660_I426_XG_p1 I0_I1660_P63_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I426_XG_MP1 (I0_I1660_G63_32 I0_I1660_G47_32n XI0_I1660_I426_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I298_XG_MP2 (VDD I0_I1660_G45_42n I0_I1660_G45_38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I298_XG_MP0 (XI0_I1660_I298_XG_p1 I0_I1660_P45_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I298_XG_MP1 (I0_I1660_G45_38 I0_I1660_G41_38n XI0_I1660_I298_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I175_XG_MP2 (VDD I0_I1660_gn45 I0_I1660_G45_44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I175_XG_MP0 (XI0_I1660_I175_XG_p1 I0_I1660_pn45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I175_XG_MP1 (I0_I1660_G45_44 I0_I1660_gn44 XI0_I1660_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I202_XG_MP2 (VDD I1_I1850_G31_16n I1_c28_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I202_XG_MP0 (XI1_I1850_I202_XG_p1 I1_I1850_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I202_XG_MP1 (I1_c28_o I1_I1850_G15_0n XI1_I1850_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I144_XG_MP2 (VDD I1_I1850_G19_16n I1_I1850_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I144_XG_MP0 (XI1_I1850_I144_XG_p1 I1_I1850_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I144_XG_MP1 (I1_I1850_G19_12 I1_I1850_G15_12n XI1_I1850_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I142_XG_MP2 (VDD I1_I1850_G17_14n I1_I1850_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I142_XG_MP0 (XI1_I1850_I142_XG_p1 I1_I1850_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I142_XG_MP1 (I1_I1850_G17_10 I1_I1850_G13_10n XI1_I1850_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I141_XG_MP2 (VDD I1_I1850_G16_13n I1_I1850_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I141_XG_MP0 (XI1_I1850_I141_XG_p1 I1_I1850_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I141_XG_MP1 (I1_I1850_G16_9 I1_I1850_G12_9n XI1_I1850_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I183_XG_MP2 (VDD I1_I1850_G16_1n I1_I1850_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I183_XG_MP0 (XI1_I1850_I183_XG_p1 I1_I1850_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I183_XG_MP1 (I1_I1850_G16_0 I1_I1850_G0_0n XI1_I1850_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I83_XG_MP2 (VDD I1_I1896_gn17 I1_I1896_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I83_XG_MP0 (XI1_I1896_I83_XG_p1 I1_I1896_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I83_XG_MP1 (I1_I1896_G17_16 I1_I1896_gn16 XI1_I1896_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I82_XG_MP2 (VDD I1_I1896_gn16 I1_I1896_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I82_XG_MP0 (XI1_I1896_I82_XG_p1 I1_I1896_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I82_XG_MP1 (I1_I1896_G16_15 I1_I1896_gn15 XI1_I1896_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I81_XG_MP2 (VDD I1_I1896_gn15 I1_I1896_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I81_XG_MP0 (XI1_I1896_I81_XG_p1 I1_I1896_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I81_XG_MP1 (I1_I1896_G15_14 I1_I1896_gn14 XI1_I1896_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I140_XG_MP2 (VDD I1_I1896_G15_12n I1_I1896_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I140_XG_MP0 (XI1_I1896_I140_XG_p1 I1_I1896_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I140_XG_MP1 (I1_I1896_G15_8 I1_I1896_G11_8n XI1_I1896_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I139_XG_MP2 (VDD I1_I1896_G14_11n I1_I1896_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I139_XG_MP0 (XI1_I1896_I139_XG_p1 I1_I1896_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I139_XG_MP1 (I1_I1896_G14_7 I1_I1896_G10_7n XI1_I1896_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I84_XG_MP2 (VDD I1_I1942_gn18 I1_I1942_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I84_XG_MP0 (XI1_I1942_I84_XG_p1 I1_I1942_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I84_XG_MP1 (I1_I1942_G18_17 I1_I1942_gn17 XI1_I1942_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I146_XG_MP2 (VDD I1_I1942_G21_18n I1_I1942_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I146_XG_MP0 (XI1_I1942_I146_XG_p1 I1_I1942_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I146_XG_MP1 (I1_I1942_G21_14 I1_I1942_G17_14n XI1_I1942_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I149_XG_MP2 (VDD I1_I1942_G24_21n I1_I1942_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I149_XG_MP0 (XI1_I1942_I149_XG_p1 I1_I1942_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I149_XG_MP1 (I1_I1942_G24_17 I1_I1942_G20_17n XI1_I1942_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I197_XG_MP2 (VDD I1_I1942_G26_11n I1_I1942_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I197_XG_MP0 (XI1_I1942_I197_XG_p1 I1_I1942_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I197_XG_MP1 (I1_I1942_G26_0 I1_I1942_G10_0n XI1_I1942_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I84_XG_MP2 (VDD I1_I1988_gn18 I1_I1988_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I84_XG_MP0 (XI1_I1988_I84_XG_p1 I1_I1988_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I84_XG_MP1 (I1_I1988_G18_17 I1_I1988_gn17 XI1_I1988_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I85_XG_MP2 (VDD I1_I1988_gn19 I1_I1988_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I85_XG_MP0 (XI1_I1988_I85_XG_p1 I1_I1988_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I85_XG_MP1 (I1_I1988_G19_18 I1_I1988_gn18 XI1_I1988_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I146_XG_MP2 (VDD I1_I1988_G21_18n I1_I1988_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I146_XG_MP0 (XI1_I1988_I146_XG_p1 I1_I1988_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I146_XG_MP1 (I1_I1988_G21_14 I1_I1988_G17_14n XI1_I1988_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I198_XG_MP2 (VDD I1_I1988_G27_12n I1_I1988_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I198_XG_MP0 (XI1_I1988_I198_XG_p1 I1_I1988_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I198_XG_MP1 (I1_I1988_G27_0 I1_I1988_G11_0n XI1_I1988_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I149_XG_MP2 (VDD I1_I1988_G24_21n I1_I1988_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I149_XG_MP0 (XI1_I1988_I149_XG_p1 I1_I1988_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I149_XG_MP1 (I1_I1988_G24_17 I1_I1988_G20_17n XI1_I1988_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I197_XG_MP2 (VDD I1_I1988_G26_11n I1_I1988_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I197_XG_MP0 (XI1_I1988_I197_XG_p1 I1_I1988_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I197_XG_MP1 (I1_I1988_G26_0 I1_I1988_G10_0n XI1_I1988_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I82_XG_MP2 (VDD I1_I2066_gn16 I1_I2066_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I82_XG_MP0 (XI1_I2066_I82_XG_p1 I1_I2066_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I82_XG_MP1 (I1_I2066_G16_15 I1_I2066_gn15 XI1_I2066_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I139_XG_MP2 (VDD I1_I2066_G14_11n I1_I2066_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I139_XG_MP0 (XI1_I2066_I139_XG_p1 I1_I2066_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I139_XG_MP1 (I1_I2066_G14_7 I1_I2066_G10_7n XI1_I2066_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I185_XG_MP2 (VDD I1_I2066_G18_3n I1_I2066_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I185_XG_MP0 (XI1_I2066_I185_XG_p1 I1_I2066_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I185_XG_MP1 (I1_I2066_G18_0 I1_I2066_G2_0n XI1_I2066_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I142_XG_MP2 (VDD I1_I2066_G17_14n I1_I2066_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I142_XG_MP0 (XI1_I2066_I142_XG_p1 I1_I2066_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I142_XG_MP1 (I1_I2066_G17_10 I1_I2066_G13_10n XI1_I2066_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I138_XG_MP2 (VDD I1_I2066_G13_10n I1_I2066_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I138_XG_MP0 (XI1_I2066_I138_XG_p1 I1_I2066_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I138_XG_MP1 (I1_I2066_G13_6 I1_I2066_G9_6n XI1_I2066_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I136_XG_MP2 (VDD I1_I2066_G11_8n I1_I2066_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I136_XG_MP0 (XI1_I2066_I136_XG_p1 I1_I2066_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I136_XG_MP1 (I1_I2066_G11_4 I1_I2066_G7_4n XI1_I2066_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I132_XG_MP2 (VDD I1_I2066_G7_4n I1_I2066_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I132_XG_MP0 (XI1_I2066_I132_XG_p1 I1_I2066_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I132_XG_MP1 (I1_I2066_G7_0 I1_I2066_G3_0n XI1_I2066_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I384_XG_MP2 (VDD I0_I1660_G22_7n I0_I1660_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I384_XG_MP0 (XI0_I1660_I384_XG_p1 I0_I1660_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I384_XG_MP1 (I0_I1660_G22_0 I0_I1660_G6_0n XI0_I1660_I384_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I405_XG_MP2 (VDD I0_I1660_G42_27n I0_I1660_G42_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I405_XG_MP0 (XI0_I1660_I405_XG_p1 I0_I1660_P42_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I405_XG_MP1 (I0_I1660_G42_11 I0_I1660_G26_11n XI0_I1660_I405_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I415_XG_MP2 (VDD I0_I1660_G52_37n I0_I1660_G52_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I415_XG_MP0 (XI0_I1660_I415_XG_p1 I0_I1660_P52_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I415_XG_MP1 (I0_I1660_G52_21 I0_I1660_G36_21n XI0_I1660_I415_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I419_XG_MP2 (VDD I0_I1660_G56_41n I0_I1660_G56_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I419_XG_MP0 (XI0_I1660_I419_XG_p1 I0_I1660_P56_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I419_XG_MP1 (I0_I1660_G56_25 I0_I1660_G40_25n XI0_I1660_I419_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I291_XG_MP2 (VDD I0_I1660_G38_35n I0_I1660_G38_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I291_XG_MP0 (XI0_I1660_I291_XG_p1 I0_I1660_P38_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I291_XG_MP1 (I0_I1660_G38_31 I0_I1660_G34_31n XI0_I1660_I291_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I301_XG_MP2 (VDD I0_I1660_G48_45n I0_I1660_G48_41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I301_XG_MP0 (XI0_I1660_I301_XG_p1 I0_I1660_P48_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I301_XG_MP1 (I0_I1660_G48_41 I0_I1660_G44_41n XI0_I1660_I301_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I420_XG_MP2 (VDD I0_I1660_G57_42n I0_I1660_G57_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I420_XG_MP0 (XI0_I1660_I420_XG_p1 I0_I1660_P57_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I420_XG_MP1 (I0_I1660_G57_26 I0_I1660_G41_26n XI0_I1660_I420_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I422_XG_MP2 (VDD I0_I1660_G59_44n I0_I1660_G59_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I422_XG_MP0 (XI0_I1660_I422_XG_p1 I0_I1660_P59_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I422_XG_MP1 (I0_I1660_G59_28 I0_I1660_G43_28n XI0_I1660_I422_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I302_XG_MP2 (VDD I0_I1660_G49_46n I0_I1660_G49_42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I302_XG_MP0 (XI0_I1660_I302_XG_p1 I0_I1660_P49_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I302_XG_MP1 (I0_I1660_G49_42 I0_I1660_G45_42n XI0_I1660_I302_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I304_XG_MP2 (VDD I0_I1660_G51_48n I0_I1660_G51_44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I304_XG_MP0 (XI0_I1660_I304_XG_p1 I0_I1660_P51_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I304_XG_MP1 (I0_I1660_G51_44 I0_I1660_G47_44n XI0_I1660_I304_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I177_XG_MP2 (VDD I0_I1660_gn47 I0_I1660_G47_46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I177_XG_MP0 (XI0_I1660_I177_XG_p1 I0_I1660_pn47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I177_XG_MP1 (I0_I1660_G47_46 I0_I1660_gn46 XI0_I1660_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I176_XG_MP2 (VDD I0_I1660_gn46 I0_I1660_G46_45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I176_XG_MP0 (XI0_I1660_I176_XG_p1 I0_I1660_pn46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I176_XG_MP1 (I0_I1660_G46_45 I0_I1660_gn45 XI0_I1660_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I148_XG_MP2 (VDD I1_I1850_G23_20n I1_I1850_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I148_XG_MP0 (XI1_I1850_I148_XG_p1 I1_I1850_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I148_XG_MP1 (I1_I1850_G23_16 I1_I1850_G19_16n XI1_I1850_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I194_XG_MP2 (VDD I1_I1850_G23_8n I1_I1850_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I194_XG_MP0 (XI1_I1850_I194_XG_p1 I1_I1850_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I194_XG_MP1 (I1_I1850_G23_0 I1_I1850_G7_0n XI1_I1850_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I146_XG_MP2 (VDD I1_I1850_G21_18n I1_I1850_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I146_XG_MP0 (XI1_I1850_I146_XG_p1 I1_I1850_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I146_XG_MP1 (I1_I1850_G21_14 I1_I1850_G17_14n XI1_I1850_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I190_XG_MP2 (VDD I1_I1850_G21_6n I1_I1850_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I190_XG_MP0 (XI1_I1850_I190_XG_p1 I1_I1850_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I190_XG_MP1 (I1_I1850_G21_0 I1_I1850_G5_0n XI1_I1850_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I196_XG_MP2 (VDD I1_I1850_G25_10n I1_I1850_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I196_XG_MP0 (XI1_I1850_I196_XG_p1 I1_I1850_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I196_XG_MP1 (I1_I1850_G25_0 I1_I1850_G9_0n XI1_I1850_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I85_XG_MP2 (VDD I1_I1850_gn19 I1_I1850_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I85_XG_MP0 (XI1_I1850_I85_XG_p1 I1_I1850_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I85_XG_MP1 (I1_I1850_G19_18 I1_I1850_gn18 XI1_I1850_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I84_XG_MP2 (VDD I1_I1850_gn18 I1_I1850_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I84_XG_MP0 (XI1_I1850_I84_XG_p1 I1_I1850_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I84_XG_MP1 (I1_I1850_G18_17 I1_I1850_gn17 XI1_I1850_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I143_XG_MP2 (VDD I1_I1850_G18_15n I1_I1850_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I143_XG_MP0 (XI1_I1850_I143_XG_p1 I1_I1850_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I143_XG_MP1 (I1_I1850_G18_11 I1_I1850_G14_11n XI1_I1850_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I139_XG_MP2 (VDD I1_I1850_G14_11n I1_I1850_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I139_XG_MP0 (XI1_I1850_I139_XG_p1 I1_I1850_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I139_XG_MP1 (I1_I1850_G14_7 I1_I1850_G10_7n XI1_I1850_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I84_XG_MP2 (VDD I1_I1896_gn18 I1_I1896_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I84_XG_MP0 (XI1_I1896_I84_XG_p1 I1_I1896_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I84_XG_MP1 (I1_I1896_G18_17 I1_I1896_gn17 XI1_I1896_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I144_XG_MP2 (VDD I1_I1896_G19_16n I1_I1896_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I144_XG_MP0 (XI1_I1896_I144_XG_p1 I1_I1896_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I144_XG_MP1 (I1_I1896_G19_12 I1_I1896_G15_12n XI1_I1896_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I190_XG_MP2 (VDD I1_I1896_G21_6n I1_I1896_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I190_XG_MP0 (XI1_I1896_I190_XG_p1 I1_I1896_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I190_XG_MP1 (I1_I1896_G21_0 I1_I1896_G5_0n XI1_I1896_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I145_XG_MP2 (VDD I1_I1896_G20_17n I1_I1896_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I145_XG_MP0 (XI1_I1896_I145_XG_p1 I1_I1896_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I145_XG_MP1 (I1_I1896_G20_13 I1_I1896_G16_13n XI1_I1896_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I143_XG_MP2 (VDD I1_I1896_G18_15n I1_I1896_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I143_XG_MP0 (XI1_I1896_I143_XG_p1 I1_I1896_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I143_XG_MP1 (I1_I1896_G18_11 I1_I1896_G14_11n XI1_I1896_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I188_XG_MP2 (VDD I1_I1896_G20_5n I1_I1896_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I188_XG_MP0 (XI1_I1896_I188_XG_p1 I1_I1896_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I188_XG_MP1 (I1_I1896_G20_0 I1_I1896_G4_0n XI1_I1896_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I85_XG_MP2 (VDD I1_I1942_gn19 I1_I1942_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I85_XG_MP0 (XI1_I1942_I85_XG_p1 I1_I1942_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I85_XG_MP1 (I1_I1942_G19_18 I1_I1942_gn18 XI1_I1942_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I150_XG_MP2 (VDD I1_I1942_G25_22n I1_I1942_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I150_XG_MP0 (XI1_I1942_I150_XG_p1 I1_I1942_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I150_XG_MP1 (I1_I1942_G25_18 I1_I1942_G21_18n XI1_I1942_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I198_XG_MP2 (VDD I1_I1942_G27_12n I1_I1942_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I198_XG_MP0 (XI1_I1942_I198_XG_p1 I1_I1942_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I198_XG_MP1 (I1_I1942_G27_0 I1_I1942_G11_0n XI1_I1942_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I192_XG_MP2 (VDD I1_I1942_G22_7n I1_I1942_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I192_XG_MP0 (XI1_I1942_I192_XG_p1 I1_I1942_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I192_XG_MP1 (I1_I1942_G22_0 I1_I1942_G6_0n XI1_I1942_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I87_XG_MP2 (VDD I1_I1988_gn21 I1_I1988_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I87_XG_MP0 (XI1_I1988_I87_XG_p1 I1_I1988_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I87_XG_MP1 (I1_I1988_G21_20 I1_I1988_gn20 XI1_I1988_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I86_XG_MP2 (VDD I1_I1988_gn20 I1_I1988_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I86_XG_MP0 (XI1_I1988_I86_XG_p1 I1_I1988_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I86_XG_MP1 (I1_I1988_G20_19 I1_I1988_gn19 XI1_I1988_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I150_XG_MP2 (VDD I1_I1988_G25_22n I1_I1988_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I150_XG_MP0 (XI1_I1988_I150_XG_p1 I1_I1988_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I150_XG_MP1 (I1_I1988_G25_18 I1_I1988_G21_18n XI1_I1988_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I147_XG_MP2 (VDD I1_I1988_G22_19n I1_I1988_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I147_XG_MP0 (XI1_I1988_I147_XG_p1 I1_I1988_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I147_XG_MP1 (I1_I1988_G22_15 I1_I1988_G18_15n XI1_I1988_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I192_XG_MP2 (VDD I1_I1988_G22_7n I1_I1988_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I192_XG_MP0 (XI1_I1988_I192_XG_p1 I1_I1988_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I192_XG_MP1 (I1_I1988_G22_0 I1_I1988_G6_0n XI1_I1988_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I83_XG_MP2 (VDD I1_I2066_gn17 I1_I2066_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I83_XG_MP0 (XI1_I2066_I83_XG_p1 I1_I2066_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I83_XG_MP1 (I1_I2066_G17_16 I1_I2066_gn16 XI1_I2066_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I84_XG_MP2 (VDD I1_I2066_gn18 I1_I2066_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I84_XG_MP0 (XI1_I2066_I84_XG_p1 I1_I2066_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I84_XG_MP1 (I1_I2066_G18_17 I1_I2066_gn17 XI1_I2066_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I143_XG_MP2 (VDD I1_I2066_G18_15n I1_I2066_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I143_XG_MP0 (XI1_I2066_I143_XG_p1 I1_I2066_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I143_XG_MP1 (I1_I2066_G18_11 I1_I2066_G14_11n XI1_I2066_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I196_XG_MP2 (VDD I1_I2066_G25_10n I1_I2066_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I196_XG_MP0 (XI1_I2066_I196_XG_p1 I1_I2066_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I196_XG_MP1 (I1_I2066_G25_0 I1_I2066_G9_0n XI1_I2066_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I401_XG_MP2 (VDD I0_I1660_G38_23n I0_I1660_G38_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I401_XG_MP0 (XI0_I1660_I401_XG_p1 I0_I1660_P38_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I401_XG_MP1 (I0_I1660_G38_7 I0_I1660_G22_7n XI0_I1660_I401_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I413_XG_MP2 (VDD I0_I1660_G50_35n I0_I1660_G50_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I413_XG_MP0 (XI0_I1660_I413_XG_p1 I0_I1660_P50_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I413_XG_MP1 (I0_I1660_G50_19 I0_I1660_G34_19n XI0_I1660_I413_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I393_XG_MP2 (VDD I0_I1660_G30_15n I0_I1660_G30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I393_XG_MP0 (XI0_I1660_I393_XG_p1 I0_I1660_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I393_XG_MP1 (I0_I1660_G30_0 I0_I1660_G14_0n XI0_I1660_I393_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I295_XG_MP2 (VDD I0_I1660_G42_39n I0_I1660_G42_35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I295_XG_MP0 (XI0_I1660_I295_XG_p1 I0_I1660_P42_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I295_XG_MP1 (I0_I1660_G42_35 I0_I1660_G38_35n XI0_I1660_I295_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I423_XG_MP2 (VDD I0_I1660_G60_45n I0_I1660_G60_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I423_XG_MP0 (XI0_I1660_I423_XG_p1 I0_I1660_P60_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I423_XG_MP1 (I0_I1660_G60_29 I0_I1660_G44_29n XI0_I1660_I423_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I424_XG_MP2 (VDD I0_I1660_G61_46n I0_I1660_G61_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I424_XG_MP0 (XI0_I1660_I424_XG_p1 I0_I1660_P61_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I424_XG_MP1 (I0_I1660_G61_30 I0_I1660_G45_30n XI0_I1660_I424_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I306_XG_MP2 (VDD I0_I1660_G53_50n I0_I1660_G53_46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I306_XG_MP0 (XI0_I1660_I306_XG_p1 I0_I1660_P53_50n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I306_XG_MP1 (I0_I1660_G53_46 I0_I1660_G49_46n XI0_I1660_I306_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I178_XG_MP2 (VDD I0_I1660_gn48 I0_I1660_G48_47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I178_XG_MP0 (XI0_I1660_I178_XG_p1 I0_I1660_pn48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I178_XG_MP1 (I0_I1660_G48_47 I0_I1660_gn47 XI0_I1660_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I198_XG_MP2 (VDD I1_I1850_G27_12n I1_I1850_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I198_XG_MP0 (XI1_I1850_I198_XG_p1 I1_I1850_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I198_XG_MP1 (I1_I1850_G27_0 I1_I1850_G11_0n XI1_I1850_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I150_XG_MP2 (VDD I1_I1850_G25_22n I1_I1850_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I150_XG_MP0 (XI1_I1850_I150_XG_p1 I1_I1850_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I150_XG_MP1 (I1_I1850_G25_18 I1_I1850_G21_18n XI1_I1850_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I86_XG_MP2 (VDD I1_I1850_gn20 I1_I1850_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I86_XG_MP0 (XI1_I1850_I86_XG_p1 I1_I1850_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I86_XG_MP1 (I1_I1850_G20_19 I1_I1850_gn19 XI1_I1850_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I188_XG_MP2 (VDD I1_I1850_G20_5n I1_I1850_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I188_XG_MP0 (XI1_I1850_I188_XG_p1 I1_I1850_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I188_XG_MP1 (I1_I1850_G20_0 I1_I1850_G4_0n XI1_I1850_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I185_XG_MP2 (VDD I1_I1850_G18_3n I1_I1850_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I185_XG_MP0 (XI1_I1850_I185_XG_p1 I1_I1850_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I185_XG_MP1 (I1_I1850_G18_0 I1_I1850_G2_0n XI1_I1850_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I86_XG_MP2 (VDD I1_I1896_gn20 I1_I1896_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I86_XG_MP0 (XI1_I1896_I86_XG_p1 I1_I1896_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I86_XG_MP1 (I1_I1896_G20_19 I1_I1896_gn19 XI1_I1896_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I85_XG_MP2 (VDD I1_I1896_gn19 I1_I1896_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I85_XG_MP0 (XI1_I1896_I85_XG_p1 I1_I1896_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I85_XG_MP1 (I1_I1896_G19_18 I1_I1896_gn18 XI1_I1896_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I146_XG_MP2 (VDD I1_I1896_G21_18n I1_I1896_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I146_XG_MP0 (XI1_I1896_I146_XG_p1 I1_I1896_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I146_XG_MP1 (I1_I1896_G21_14 I1_I1896_G17_14n XI1_I1896_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I196_XG_MP2 (VDD I1_I1896_G25_10n I1_I1896_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I196_XG_MP0 (XI1_I1896_I196_XG_p1 I1_I1896_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I196_XG_MP1 (I1_I1896_G25_0 I1_I1896_G9_0n XI1_I1896_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I149_XG_MP2 (VDD I1_I1896_G24_21n I1_I1896_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I149_XG_MP0 (XI1_I1896_I149_XG_p1 I1_I1896_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I149_XG_MP1 (I1_I1896_G24_17 I1_I1896_G20_17n XI1_I1896_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I195_XG_MP2 (VDD I1_I1896_G24_9n I1_I1896_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I195_XG_MP0 (XI1_I1896_I195_XG_p1 I1_I1896_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I195_XG_MP1 (I1_I1896_G24_0 I1_I1896_G8_0n XI1_I1896_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I87_XG_MP2 (VDD I1_I1942_gn21 I1_I1942_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I87_XG_MP0 (XI1_I1942_I87_XG_p1 I1_I1942_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I87_XG_MP1 (I1_I1942_G21_20 I1_I1942_gn20 XI1_I1942_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I86_XG_MP2 (VDD I1_I1942_gn20 I1_I1942_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I86_XG_MP0 (XI1_I1942_I86_XG_p1 I1_I1942_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I86_XG_MP1 (I1_I1942_G20_19 I1_I1942_gn19 XI1_I1942_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I148_XG_MP2 (VDD I1_I1942_G23_20n I1_I1942_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I148_XG_MP0 (XI1_I1942_I148_XG_p1 I1_I1942_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I148_XG_MP1 (I1_I1942_G23_16 I1_I1942_G19_16n XI1_I1942_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I194_XG_MP2 (VDD I1_I1942_G23_8n I1_I1942_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I194_XG_MP0 (XI1_I1942_I194_XG_p1 I1_I1942_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I194_XG_MP1 (I1_I1942_G23_0 I1_I1942_G7_0n XI1_I1942_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I147_XG_MP2 (VDD I1_I1942_G22_19n I1_I1942_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I147_XG_MP0 (XI1_I1942_I147_XG_p1 I1_I1942_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I147_XG_MP1 (I1_I1942_G22_15 I1_I1942_G18_15n XI1_I1942_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I151_XG_MP2 (VDD I1_I1942_G26_23n I1_I1942_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I151_XG_MP0 (XI1_I1942_I151_XG_p1 I1_I1942_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I151_XG_MP1 (I1_I1942_G26_19 I1_I1942_G22_19n XI1_I1942_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I199_XG_MP2 (VDD I1_I1942_G28_13n I1_I1942_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I199_XG_MP0 (XI1_I1942_I199_XG_p1 I1_I1942_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I199_XG_MP1 (I1_I1942_G28_0 I1_I1942_G12_0n XI1_I1942_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I88_XG_MP2 (VDD I1_I1988_gn22 I1_I1988_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I88_XG_MP0 (XI1_I1988_I88_XG_p1 I1_I1988_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I88_XG_MP1 (I1_I1988_G22_21 I1_I1988_gn21 XI1_I1988_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I148_XG_MP2 (VDD I1_I1988_G23_20n I1_I1988_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I148_XG_MP0 (XI1_I1988_I148_XG_p1 I1_I1988_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I148_XG_MP1 (I1_I1988_G23_16 I1_I1988_G19_16n XI1_I1988_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I152_XG_MP2 (VDD I1_I1988_G27_24n I1_I1988_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I152_XG_MP0 (XI1_I1988_I152_XG_p1 I1_I1988_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I152_XG_MP1 (I1_I1988_G27_20 I1_I1988_G23_20n XI1_I1988_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I194_XG_MP2 (VDD I1_I1988_G23_8n I1_I1988_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I194_XG_MP0 (XI1_I1988_I194_XG_p1 I1_I1988_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I194_XG_MP1 (I1_I1988_G23_0 I1_I1988_G7_0n XI1_I1988_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I151_XG_MP2 (VDD I1_I1988_G26_23n I1_I1988_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I151_XG_MP0 (XI1_I1988_I151_XG_p1 I1_I1988_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I151_XG_MP1 (I1_I1988_G26_19 I1_I1988_G22_19n XI1_I1988_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I199_XG_MP2 (VDD I1_I1988_G28_13n I1_I1988_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I199_XG_MP0 (XI1_I1988_I199_XG_p1 I1_I1988_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I199_XG_MP1 (I1_I1988_G28_0 I1_I1988_G12_0n XI1_I1988_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I85_XG_MP2 (VDD I1_I2066_gn19 I1_I2066_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I85_XG_MP0 (XI1_I2066_I85_XG_p1 I1_I2066_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I85_XG_MP1 (I1_I2066_G19_18 I1_I2066_gn18 XI1_I2066_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I149_XG_MP2 (VDD I1_I2066_G24_21n I1_I2066_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I149_XG_MP0 (XI1_I2066_I149_XG_p1 I1_I2066_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I149_XG_MP1 (I1_I2066_G24_17 I1_I2066_G20_17n XI1_I2066_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I145_XG_MP2 (VDD I1_I2066_G20_17n I1_I2066_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I145_XG_MP0 (XI1_I2066_I145_XG_p1 I1_I2066_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I145_XG_MP1 (I1_I2066_G20_13 I1_I2066_G16_13n XI1_I2066_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I199_XG_MP2 (VDD I1_I2066_G28_13n I1_I2066_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I199_XG_MP0 (XI1_I2066_I199_XG_p1 I1_I2066_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I199_XG_MP1 (I1_I2066_G28_0 I1_I2066_G12_0n XI1_I2066_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I188_XG_MP2 (VDD I1_I2066_G20_5n I1_I2066_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I188_XG_MP0 (XI1_I2066_I188_XG_p1 I1_I2066_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I188_XG_MP1 (I1_I2066_G20_0 I1_I2066_G4_0n XI1_I2066_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I144_XG_MP2 (VDD I1_I2066_G19_16n I1_I2066_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I144_XG_MP0 (XI1_I2066_I144_XG_p1 I1_I2066_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I144_XG_MP1 (I1_I2066_G19_12 I1_I2066_G15_12n XI1_I2066_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I140_XG_MP2 (VDD I1_I2066_G15_12n I1_I2066_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I140_XG_MP0 (XI1_I2066_I140_XG_p1 I1_I2066_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I140_XG_MP1 (I1_I2066_G15_8 I1_I2066_G11_8n XI1_I2066_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I186_XG_MP2 (VDD I1_I2066_G19_4n I1_I2066_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I186_XG_MP0 (XI1_I2066_I186_XG_p1 I1_I2066_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I186_XG_MP1 (I1_I2066_G19_0 I1_I2066_G3_0n XI1_I2066_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I409_XG_MP2 (VDD I0_I1660_G46_31n I0_I1660_G46_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I409_XG_MP0 (XI0_I1660_I409_XG_p1 I0_I1660_P46_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I409_XG_MP1 (I0_I1660_G46_15 I0_I1660_G30_15n XI0_I1660_I409_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I299_XG_MP2 (VDD I0_I1660_G46_43n I0_I1660_G46_39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I299_XG_MP0 (XI0_I1660_I299_XG_p1 I0_I1660_P46_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I299_XG_MP1 (I0_I1660_G46_39 I0_I1660_G42_39n XI0_I1660_I299_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I303_XG_MP2 (VDD I0_I1660_G50_47n I0_I1660_G50_43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I303_XG_MP0 (XI0_I1660_I303_XG_p1 I0_I1660_P50_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I303_XG_MP1 (I0_I1660_G50_43 I0_I1660_G46_43n XI0_I1660_I303_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I305_XG_MP2 (VDD I0_I1660_G52_49n I0_I1660_G52_45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I305_XG_MP0 (XI0_I1660_I305_XG_p1 I0_I1660_P52_49n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I305_XG_MP1 (I0_I1660_G52_45 I0_I1660_G48_45n XI0_I1660_I305_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I310_XG_MP2 (VDD I0_I1660_G57_54n I0_I1660_G57_50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I310_XG_MP0 (XI0_I1660_I310_XG_p1 I0_I1660_P57_54n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I310_XG_MP1 (I0_I1660_G57_50 I0_I1660_G53_50n XI0_I1660_I310_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I316_XG_MP2 (VDD I0_I1660_G63_60n I0_I1660_G63_56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I316_XG_MP0 (XI0_I1660_I316_XG_p1 I0_I1660_P63_60n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I316_XG_MP1 (I0_I1660_G63_56 I0_I1660_G59_56n XI0_I1660_I316_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I312_XG_MP2 (VDD I0_I1660_G59_56n I0_I1660_G59_52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I312_XG_MP0 (XI0_I1660_I312_XG_p1 I0_I1660_P59_56n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I312_XG_MP1 (I0_I1660_G59_52 I0_I1660_G55_52n XI0_I1660_I312_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I308_XG_MP2 (VDD I0_I1660_G55_52n I0_I1660_G55_48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I308_XG_MP0 (XI0_I1660_I308_XG_p1 I0_I1660_P55_52n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I308_XG_MP1 (I0_I1660_G55_48 I0_I1660_G51_48n XI0_I1660_I308_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I179_XG_MP2 (VDD I0_I1660_gn49 I0_I1660_G49_48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I179_XG_MP0 (XI0_I1660_I179_XG_p1 I0_I1660_pn49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I179_XG_MP1 (I0_I1660_G49_48 I0_I1660_gn48 XI0_I1660_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I156_XG_MP2 (VDD I1_I1850_G31_28n I1_I1850_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I156_XG_MP0 (XI1_I1850_I156_XG_p1 I1_I1850_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I156_XG_MP1 (I1_I1850_G31_24 I1_I1850_G27_24n XI1_I1850_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I152_XG_MP2 (VDD I1_I1850_G27_24n I1_I1850_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I152_XG_MP0 (XI1_I1850_I152_XG_p1 I1_I1850_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I152_XG_MP1 (I1_I1850_G27_20 I1_I1850_G23_20n XI1_I1850_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I200_XG_MP2 (VDD I1_I1850_G29_14n I1_I1850_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I200_XG_MP0 (XI1_I1850_I200_XG_p1 I1_I1850_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I200_XG_MP1 (I1_I1850_G29_0 I1_I1850_G13_0n XI1_I1850_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I87_XG_MP2 (VDD I1_I1850_gn21 I1_I1850_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I87_XG_MP0 (XI1_I1850_I87_XG_p1 I1_I1850_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I87_XG_MP1 (I1_I1850_G21_20 I1_I1850_gn20 XI1_I1850_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I149_XG_MP2 (VDD I1_I1850_G24_21n I1_I1850_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I149_XG_MP0 (XI1_I1850_I149_XG_p1 I1_I1850_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I149_XG_MP1 (I1_I1850_G24_17 I1_I1850_G20_17n XI1_I1850_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I145_XG_MP2 (VDD I1_I1850_G20_17n I1_I1850_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I145_XG_MP0 (XI1_I1850_I145_XG_p1 I1_I1850_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I145_XG_MP1 (I1_I1850_G20_13 I1_I1850_G16_13n XI1_I1850_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I195_XG_MP2 (VDD I1_I1850_G24_9n I1_I1850_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I195_XG_MP0 (XI1_I1850_I195_XG_p1 I1_I1850_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I195_XG_MP1 (I1_I1850_G24_0 I1_I1850_G8_0n XI1_I1850_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I87_XG_MP2 (VDD I1_I1896_gn21 I1_I1896_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I87_XG_MP0 (XI1_I1896_I87_XG_p1 I1_I1896_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I87_XG_MP1 (I1_I1896_G21_20 I1_I1896_gn20 XI1_I1896_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I150_XG_MP2 (VDD I1_I1896_G25_22n I1_I1896_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I150_XG_MP0 (XI1_I1896_I150_XG_p1 I1_I1896_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I150_XG_MP1 (I1_I1896_G25_18 I1_I1896_G21_18n XI1_I1896_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I198_XG_MP2 (VDD I1_I1896_G27_12n I1_I1896_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I198_XG_MP0 (XI1_I1896_I198_XG_p1 I1_I1896_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I198_XG_MP1 (I1_I1896_G27_0 I1_I1896_G11_0n XI1_I1896_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I197_XG_MP2 (VDD I1_I1896_G26_11n I1_I1896_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I197_XG_MP0 (XI1_I1896_I197_XG_p1 I1_I1896_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I197_XG_MP1 (I1_I1896_G26_0 I1_I1896_G10_0n XI1_I1896_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I88_XG_MP2 (VDD I1_I1942_gn22 I1_I1942_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I88_XG_MP0 (XI1_I1942_I88_XG_p1 I1_I1942_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I88_XG_MP1 (I1_I1942_G22_21 I1_I1942_gn21 XI1_I1942_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I89_XG_MP2 (VDD I1_I1942_gn23 I1_I1942_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I89_XG_MP0 (XI1_I1942_I89_XG_p1 I1_I1942_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I89_XG_MP1 (I1_I1942_G23_22 I1_I1942_gn22 XI1_I1942_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I152_XG_MP2 (VDD I1_I1942_G27_24n I1_I1942_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I152_XG_MP0 (XI1_I1942_I152_XG_p1 I1_I1942_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I152_XG_MP1 (I1_I1942_G27_20 I1_I1942_G23_20n XI1_I1942_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I200_XG_MP2 (VDD I1_I1942_G29_14n I1_I1942_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I200_XG_MP0 (XI1_I1942_I200_XG_p1 I1_I1942_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I200_XG_MP1 (I1_I1942_G29_0 I1_I1942_G13_0n XI1_I1942_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I153_XG_MP2 (VDD I1_I1942_G28_25n I1_I1942_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I153_XG_MP0 (XI1_I1942_I153_XG_p1 I1_I1942_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I153_XG_MP1 (I1_I1942_G28_21 I1_I1942_G24_21n XI1_I1942_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I89_XG_MP2 (VDD I1_I1988_gn23 I1_I1988_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I89_XG_MP0 (XI1_I1988_I89_XG_p1 I1_I1988_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I89_XG_MP1 (I1_I1988_G23_22 I1_I1988_gn22 XI1_I1988_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I90_XG_MP2 (VDD I1_I1988_gn24 I1_I1988_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I90_XG_MP0 (XI1_I1988_I90_XG_p1 I1_I1988_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I90_XG_MP1 (I1_I1988_G24_23 I1_I1988_gn23 XI1_I1988_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I154_XG_MP2 (VDD I1_I1988_G29_26n I1_I1988_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I154_XG_MP0 (XI1_I1988_I154_XG_p1 I1_I1988_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I154_XG_MP1 (I1_I1988_G29_22 I1_I1988_G25_22n XI1_I1988_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I200_XG_MP2 (VDD I1_I1988_G29_14n I1_I1988_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I200_XG_MP0 (XI1_I1988_I200_XG_p1 I1_I1988_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I200_XG_MP1 (I1_I1988_G29_0 I1_I1988_G13_0n XI1_I1988_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1988_I153_XG_MP2 (VDD I1_I1988_G28_25n I1_I1988_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1988_I153_XG_MP0 (XI1_I1988_I153_XG_p1 I1_I1988_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1988_I153_XG_MP1 (I1_I1988_G28_21 I1_I1988_G24_21n XI1_I1988_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I86_XG_MP2 (VDD I1_I2066_gn20 I1_I2066_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I86_XG_MP0 (XI1_I2066_I86_XG_p1 I1_I2066_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I86_XG_MP1 (I1_I2066_G20_19 I1_I2066_gn19 XI1_I2066_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I87_XG_MP2 (VDD I1_I2066_gn21 I1_I2066_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I87_XG_MP0 (XI1_I2066_I87_XG_p1 I1_I2066_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I87_XG_MP1 (I1_I2066_G21_20 I1_I2066_gn20 XI1_I2066_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I197_XG_MP2 (VDD I1_I2066_G26_11n I1_I2066_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I197_XG_MP0 (XI1_I2066_I197_XG_p1 I1_I2066_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I197_XG_MP1 (I1_I2066_G26_0 I1_I2066_G10_0n XI1_I2066_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I150_XG_MP2 (VDD I1_I2066_G25_22n I1_I2066_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I150_XG_MP0 (XI1_I2066_I150_XG_p1 I1_I2066_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I150_XG_MP1 (I1_I2066_G25_18 I1_I2066_G21_18n XI1_I2066_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I146_XG_MP2 (VDD I1_I2066_G21_18n I1_I2066_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I146_XG_MP0 (XI1_I2066_I146_XG_p1 I1_I2066_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I146_XG_MP1 (I1_I2066_G21_14 I1_I2066_G17_14n XI1_I2066_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I2066_I190_XG_MP2 (VDD I1_I2066_G21_6n I1_I2066_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I2066_I190_XG_MP0 (XI1_I2066_I190_XG_p1 I1_I2066_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I2066_I190_XG_MP1 (I1_I2066_G21_0 I1_I2066_G5_0n XI1_I2066_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I417_XG_MP2 (VDD I0_I1660_G54_39n I0_I1660_G54_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I417_XG_MP0 (XI0_I1660_I417_XG_p1 I0_I1660_P54_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I417_XG_MP1 (I0_I1660_G54_23 I0_I1660_G38_23n XI0_I1660_I417_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I421_XG_MP2 (VDD I0_I1660_G58_43n I0_I1660_G58_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I421_XG_MP0 (XI0_I1660_I421_XG_p1 I0_I1660_P58_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I421_XG_MP1 (I0_I1660_G58_27 I0_I1660_G42_27n XI0_I1660_I421_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I309_XG_MP2 (VDD I0_I1660_G56_53n I0_I1660_G56_49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I309_XG_MP0 (XI0_I1660_I309_XG_p1 I0_I1660_P56_53n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I309_XG_MP1 (I0_I1660_G56_49 I0_I1660_G52_49n XI0_I1660_I309_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I314_XG_MP2 (VDD I0_I1660_G61_58n I0_I1660_G61_54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I314_XG_MP0 (XI0_I1660_I314_XG_p1 I0_I1660_P61_58n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I314_XG_MP1 (I0_I1660_G61_54 I0_I1660_G57_54n XI0_I1660_I314_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1660_I180_XG_MP2 (VDD I0_I1660_gn50 I0_I1660_G50_49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI0_I1660_I180_XG_MP0 (XI0_I1660_I180_XG_p1 I0_I1660_pn50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI0_I1660_I180_XG_MP1 (I0_I1660_G50_49 I0_I1660_gn49 XI0_I1660_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I154_XG_MP2 (VDD I1_I1850_G29_26n I1_I1850_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I154_XG_MP0 (XI1_I1850_I154_XG_p1 I1_I1850_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I154_XG_MP1 (I1_I1850_G29_22 I1_I1850_G25_22n XI1_I1850_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I89_XG_MP2 (VDD I1_I1850_gn23 I1_I1850_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I89_XG_MP0 (XI1_I1850_I89_XG_p1 I1_I1850_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I89_XG_MP1 (I1_I1850_G23_22 I1_I1850_gn22 XI1_I1850_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I91_XG_MP2 (VDD I1_I1850_gn25 I1_I1850_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I91_XG_MP0 (XI1_I1850_I91_XG_p1 I1_I1850_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I91_XG_MP1 (I1_I1850_G25_24 I1_I1850_gn24 XI1_I1850_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I90_XG_MP2 (VDD I1_I1850_gn24 I1_I1850_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I90_XG_MP0 (XI1_I1850_I90_XG_p1 I1_I1850_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I90_XG_MP1 (I1_I1850_G24_23 I1_I1850_gn23 XI1_I1850_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I88_XG_MP2 (VDD I1_I1850_gn22 I1_I1850_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I88_XG_MP0 (XI1_I1850_I88_XG_p1 I1_I1850_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I88_XG_MP1 (I1_I1850_G22_21 I1_I1850_gn21 XI1_I1850_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I147_XG_MP2 (VDD I1_I1850_G22_19n I1_I1850_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I147_XG_MP0 (XI1_I1850_I147_XG_p1 I1_I1850_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I147_XG_MP1 (I1_I1850_G22_15 I1_I1850_G18_15n XI1_I1850_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I197_XG_MP2 (VDD I1_I1850_G26_11n I1_I1850_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I197_XG_MP0 (XI1_I1850_I197_XG_p1 I1_I1850_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I197_XG_MP1 (I1_I1850_G26_0 I1_I1850_G10_0n XI1_I1850_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1850_I192_XG_MP2 (VDD I1_I1850_G22_7n I1_I1850_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1850_I192_XG_MP0 (XI1_I1850_I192_XG_p1 I1_I1850_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1850_I192_XG_MP1 (I1_I1850_G22_0 I1_I1850_G6_0n XI1_I1850_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I89_XG_MP2 (VDD I1_I1896_gn23 I1_I1896_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I89_XG_MP0 (XI1_I1896_I89_XG_p1 I1_I1896_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I89_XG_MP1 (I1_I1896_G23_22 I1_I1896_gn22 XI1_I1896_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I88_XG_MP2 (VDD I1_I1896_gn22 I1_I1896_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I88_XG_MP0 (XI1_I1896_I88_XG_p1 I1_I1896_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I88_XG_MP1 (I1_I1896_G22_21 I1_I1896_gn21 XI1_I1896_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I148_XG_MP2 (VDD I1_I1896_G23_20n I1_I1896_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I148_XG_MP0 (XI1_I1896_I148_XG_p1 I1_I1896_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I148_XG_MP1 (I1_I1896_G23_16 I1_I1896_G19_16n XI1_I1896_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I152_XG_MP2 (VDD I1_I1896_G27_24n I1_I1896_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I152_XG_MP0 (XI1_I1896_I152_XG_p1 I1_I1896_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I152_XG_MP1 (I1_I1896_G27_20 I1_I1896_G23_20n XI1_I1896_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I194_XG_MP2 (VDD I1_I1896_G23_8n I1_I1896_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I194_XG_MP0 (XI1_I1896_I194_XG_p1 I1_I1896_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I194_XG_MP1 (I1_I1896_G23_0 I1_I1896_G7_0n XI1_I1896_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1896_I192_XG_MP2 (VDD I1_I1896_G22_7n I1_I1896_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1896_I192_XG_MP0 (XI1_I1896_I192_XG_p1 I1_I1896_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1896_I192_XG_MP1 (I1_I1896_G22_0 I1_I1896_G6_0n XI1_I1896_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I91_XG_MP2 (VDD I1_I1942_gn25 I1_I1942_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I91_XG_MP0 (XI1_I1942_I91_XG_p1 I1_I1942_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I91_XG_MP1 (I1_I1942_G25_24 I1_I1942_gn24 XI1_I1942_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I90_XG_MP2 (VDD I1_I1942_gn24 I1_I1942_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I90_XG_MP0 (XI1_I1942_I90_XG_p1 I1_I1942_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I90_XG_MP1 (I1_I1942_G24_23 I1_I1942_gn23 XI1_I1942_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I154_XG_MP2 (VDD I1_I1942_G29_26n I1_I1942_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I154_XG_MP0 (XI1_I1942_I154_XG_p1 I1_I1942_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I154_XG_MP1 (I1_I1942_G29_22 I1_I1942_G25_22n XI1_I1942_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I202_XG_MP2 (VDD I1_I1942_G31_16n I1_c30_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I202_XG_MP0 (XI1_I1942_I202_XG_p1 I1_I1942_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I202_XG_MP1 (I1_c30_o I1_I1942_G15_0n XI1_I1942_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I155_XG_MP2 (VDD I1_I1942_G30_27n I1_I1942_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I155_XG_MP0 (XI1_I1942_I155_XG_p1 I1_I1942_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I155_XG_MP1 (I1_I1942_G30_23 I1_I1942_G26_23n XI1_I1942_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI1_I1942_I201_XG_MP2 (VDD I1_I1942_G30_15n I1_c30_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09356p as=0.08156p pd=0.91999u ps=1.15999u
    I_MXI1_I1942_I201_XG_MP0 (XI1_I1942_I201_XG_p1 I1_I1942_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.09356p pd=0.91999u ps=0.91999u
    I_MXI1_I1942_I201_XG_MP1 (I1_c30_m I1_I1942_G14_0n XI1_I1942_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
