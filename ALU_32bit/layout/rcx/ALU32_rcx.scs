    I_MXI1_I1436_I82_XP_MN0 (I1_I1436_P16_15 I1_I1436_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I82_XP_MN1 (VSS I1_I1436_pn15 I1_I1436_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I80_XP_MN0 (I1_I1436_P14_13 I1_I1436_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I80_XP_MN1 (VSS I1_I1436_pn13 I1_I1436_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I94_XP_MN0 (I1_I1114_P28_27 I1_I1114_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I94_XP_MN1 (VSS I1_I1114_pn27 I1_I1114_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I93_XP_MN0 (I1_I1114_P27_26 I1_I1114_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I93_XP_MN1 (VSS I1_I1114_pn26 I1_I1114_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I97_XP_MN0 (I1_I1114_P31_30 I1_I1114_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I97_XP_MN1 (VSS I1_I1114_pn30 I1_I1114_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I133_XP_MN0 (I1_I930_P8_1 I1_I930_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I133_XP_MN1 (VSS I1_I930_P4_1n I1_I930_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I68_XP_MN0 (I1_I930_P2_1 I1_I930_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I68_XP_MN1 (VSS I1_I930_pn1 I1_I930_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I68_XP_MN0 (I1_I654_P2_1 I1_I654_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I68_XP_MN1 (VSS I1_I654_pn1 I1_I654_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I73_XP_MN0 (I1_I654_P7_6 I1_I654_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I73_XP_MN1 (VSS I1_I654_pn6 I1_I654_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I75_XP_MN0 (I1_I654_P9_8 I1_I654_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I75_XP_MN1 (VSS I1_I654_pn8 I1_I654_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I77_XP_MN0 (I1_I654_P11_10 I1_I654_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I77_XP_MN1 (VSS I1_I654_pn10 I1_I654_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I79_XP_MN0 (I1_I654_P13_12 I1_I654_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I79_XP_MN1 (VSS I1_I654_pn12 I1_I654_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I81_XP_MN0 (I1_I654_P15_14 I1_I654_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I81_XP_MN1 (VSS I1_I654_pn14 I1_I654_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I83_XP_MN0 (I1_I654_P17_16 I1_I654_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I83_XP_MN1 (VSS I1_I654_pn16 I1_I654_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I85_XP_MN0 (I1_I654_P19_18 I1_I654_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I85_XP_MN1 (VSS I1_I654_pn18 I1_I654_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I152_XP_MN0 (I1_I654_P27_20 I1_I654_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I152_XP_MN1 (VSS I1_I654_P23_20n I1_I654_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I89_XP_MN0 (I1_I654_P23_22 I1_I654_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I89_XP_MN1 (VSS I1_I654_pn22 I1_I654_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I154_XP_MN0 (I1_I654_P29_22 I1_I654_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I154_XP_MN1 (VSS I1_I654_P25_22n I1_I654_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I93_XP_MN0 (I1_I654_P27_26 I1_I654_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I93_XP_MN1 (VSS I1_I654_pn26 I1_I654_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I95_XP_MN0 (I1_I654_P29_28 I1_I654_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I95_XP_MN1 (VSS I1_I654_pn28 I1_I654_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I94_XP_MN0 (I1_I1436_P28_27 I1_I1436_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I94_XP_MN1 (VSS I1_I1436_pn27 I1_I1436_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I92_XP_MN0 (I1_I1436_P26_25 I1_I1436_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I92_XP_MN1 (VSS I1_I1436_pn25 I1_I1436_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I90_XP_MN0 (I1_I1436_P24_23 I1_I1436_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I90_XP_MN1 (VSS I1_I1436_pn23 I1_I1436_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I153_XP_MN0 (I1_I1436_P28_21 I1_I1436_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I153_XP_MN1 (VSS I1_I1436_P24_21n I1_I1436_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I88_XP_MN0 (I1_I1436_P22_21 I1_I1436_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I88_XP_MN1 (VSS I1_I1436_pn21 I1_I1436_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I151_XP_MN0 (I1_I1436_P26_19 I1_I1436_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I151_XP_MN1 (VSS I1_I1436_P22_19n I1_I1436_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I147_XP_MN0 (I1_I1436_P22_15 I1_I1436_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I147_XP_MN1 (VSS I1_I1436_P18_15n I1_I1436_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I149_XP_MN0 (I1_I1436_P24_17 I1_I1436_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I149_XP_MN1 (VSS I1_I1436_P20_17n I1_I1436_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I143_XP_MN0 (I1_I1436_P18_11 I1_I1436_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I143_XP_MN1 (VSS I1_I1436_P14_11n I1_I1436_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I78_XP_MN0 (I1_I1436_P12_11 I1_I1436_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I78_XP_MN1 (VSS I1_I1436_pn11 I1_I1436_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I76_XP_MN0 (I1_I1436_P10_9 I1_I1436_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I76_XP_MN1 (VSS I1_I1436_pn9 I1_I1436_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I72_XP_MN0 (I1_I1436_P6_5 I1_I1436_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I72_XP_MN1 (VSS I1_I1436_pn5 I1_I1436_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I156_XP_MN0 (I1_I1114_P31_24 I1_I1114_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I156_XP_MN1 (VSS I1_I1114_P27_24n I1_I1114_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I92_XP_MN0 (I1_I1114_P26_25 I1_I1114_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I92_XP_MN1 (VSS I1_I1114_pn25 I1_I1114_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I155_XP_MN0 (I1_I1114_P30_23 I1_I1114_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I155_XP_MN1 (VSS I1_I1114_P26_23n I1_I1114_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I96_XP_MN0 (I1_I1068_P30_29 I1_I1068_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I96_XP_MN1 (VSS I1_I1068_pn29 I1_I1068_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I94_XP_MN0 (I1_I1068_P28_27 I1_I1068_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I94_XP_MN1 (VSS I1_I1068_pn27 I1_I1068_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I93_XP_MN0 (I1_I1068_P27_26 I1_I1068_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I93_XP_MN1 (VSS I1_I1068_pn26 I1_I1068_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I97_XP_MN0 (I1_I1068_P31_30 I1_I1068_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I97_XP_MN1 (VSS I1_I1068_pn30 I1_I1068_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I95_XP_MN0 (I1_I1068_P29_28 I1_I1068_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I95_XP_MN1 (VSS I1_I1068_pn28 I1_I1068_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I70_XP_MN0 (I1_I654_P4_3 I1_I654_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I70_XP_MN1 (VSS I1_I654_pn3 I1_I654_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I133_XP_MN0 (I1_I654_P8_1 I1_I654_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I133_XP_MN1 (VSS I1_I654_P4_1n I1_I654_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I135_XP_MN0 (I1_I654_P10_3 I1_I654_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I135_XP_MN1 (VSS I1_I654_P6_3n I1_I654_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I137_XP_MN0 (I1_I654_P12_5 I1_I654_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I137_XP_MN1 (VSS I1_I654_P8_5n I1_I654_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I139_XP_MN0 (I1_I654_P14_7 I1_I654_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I139_XP_MN1 (VSS I1_I654_P10_7n I1_I654_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I143_XP_MN0 (I1_I654_P18_11 I1_I654_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I143_XP_MN1 (VSS I1_I654_P14_11n I1_I654_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I87_XP_MN0 (I1_I654_P21_20 I1_I654_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I87_XP_MN1 (VSS I1_I654_pn20 I1_I654_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I155_XP_MN0 (I1_I654_P30_23 I1_I654_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I155_XP_MN1 (VSS I1_I654_P26_23n I1_I654_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I91_XP_MN0 (I1_I654_P25_24 I1_I654_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I91_XP_MN1 (VSS I1_I654_pn24 I1_I654_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I92_XP_MN0 (I1_I654_P26_25 I1_I654_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I92_XP_MN1 (VSS I1_I654_pn25 I1_I654_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I97_XP_MN0 (I1_I654_P31_30 I1_I654_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I97_XP_MN1 (VSS I1_I654_pn30 I1_I654_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I96_XP_MN0 (I1_I654_P30_29 I1_I654_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I96_XP_MN1 (VSS I1_I654_pn29 I1_I654_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I96_XP_MN0 (I1_I1436_P30_29 I1_I1436_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I96_XP_MN1 (VSS I1_I1436_pn29 I1_I1436_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I155_XP_MN0 (I1_I1436_P30_23 I1_I1436_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I155_XP_MN1 (VSS I1_I1436_P26_23n I1_I1436_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I145_XP_MN0 (I1_I1436_P20_13 I1_I1436_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I145_XP_MN1 (VSS I1_I1436_P16_13n I1_I1436_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I139_XP_MN0 (I1_I1436_P14_7 I1_I1436_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I139_XP_MN1 (VSS I1_I1436_P10_7n I1_I1436_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I141_XP_MN0 (I1_I1436_P16_9 I1_I1436_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I141_XP_MN1 (VSS I1_I1436_P12_9n I1_I1436_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I137_XP_MN0 (I1_I1436_P12_5 I1_I1436_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I137_XP_MN1 (VSS I1_I1436_P8_5n I1_I1436_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I135_XP_MN0 (I1_I1436_P10_3 I1_I1436_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I135_XP_MN1 (VSS I1_I1436_P6_3n I1_I1436_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I74_XP_MN0 (I1_I1436_P8_7 I1_I1436_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I74_XP_MN1 (VSS I1_I1436_pn7 I1_I1436_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I70_XP_MN0 (I1_I1436_P4_3 I1_I1436_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I70_XP_MN1 (VSS I1_I1436_pn3 I1_I1436_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I154_XP_MN0 (I1_I1114_P29_22 I1_I1114_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I154_XP_MN1 (VSS I1_I1114_P25_22n I1_I1114_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I91_XP_MN0 (I1_I1114_P25_24 I1_I1114_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I91_XP_MN1 (VSS I1_I1114_pn24 I1_I1114_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I89_XP_MN0 (I1_I1114_P23_22 I1_I1114_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I89_XP_MN1 (VSS I1_I1114_pn22 I1_I1114_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I90_XP_MN0 (I1_I1114_P24_23 I1_I1114_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I90_XP_MN1 (VSS I1_I1114_pn23 I1_I1114_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I155_XP_MN0 (I1_I1068_P30_23 I1_I1068_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I155_XP_MN1 (VSS I1_I1068_P26_23n I1_I1068_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I92_XP_MN0 (I1_I1068_P26_25 I1_I1068_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I92_XP_MN1 (VSS I1_I1068_pn25 I1_I1068_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I97_XP_MN0 (I1_I976_P31_30 I1_I976_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I97_XP_MN1 (VSS I1_I976_pn30 I1_I976_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I95_XP_MN0 (I1_I976_P29_28 I1_I976_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I95_XP_MN1 (VSS I1_I976_pn28 I1_I976_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I94_XP_MN0 (I1_I976_P28_27 I1_I976_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I94_XP_MN1 (VSS I1_I976_pn27 I1_I976_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I93_XP_MN0 (I1_I976_P27_26 I1_I976_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I93_XP_MN1 (VSS I1_I976_pn26 I1_I976_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I91_XP_MN0 (I1_I976_P25_24 I1_I976_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I91_XP_MN1 (VSS I1_I976_pn24 I1_I976_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I89_XP_MN0 (I1_I976_P23_22 I1_I976_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I89_XP_MN1 (VSS I1_I976_pn22 I1_I976_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I154_XP_MN0 (I1_I976_P29_22 I1_I976_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I154_XP_MN1 (VSS I1_I976_P25_22n I1_I976_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I87_XP_MN0 (I1_I976_P21_20 I1_I976_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I87_XP_MN1 (VSS I1_I976_pn20 I1_I976_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I150_XP_MN0 (I1_I976_P25_18 I1_I976_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I150_XP_MN1 (VSS I1_I976_P21_18n I1_I976_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I146_XP_MN0 (I1_I976_P21_14 I1_I976_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I146_XP_MN1 (VSS I1_I976_P17_14n I1_I976_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I72_XP_MN0 (I1_I654_P6_5 I1_I654_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I72_XP_MN1 (VSS I1_I654_pn5 I1_I654_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I74_XP_MN0 (I1_I654_P8_7 I1_I654_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I74_XP_MN1 (VSS I1_I654_pn7 I1_I654_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I141_XP_MN0 (I1_I654_P16_9 I1_I654_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I141_XP_MN1 (VSS I1_I654_P12_9n I1_I654_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I145_XP_MN0 (I1_I654_P20_13 I1_I654_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I145_XP_MN1 (VSS I1_I654_P16_13n I1_I654_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I149_XP_MN0 (I1_I654_P24_17 I1_I654_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I149_XP_MN1 (VSS I1_I654_P20_17n I1_I654_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I147_XP_MN0 (I1_I654_P22_15 I1_I654_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I147_XP_MN1 (VSS I1_I654_P18_15n I1_I654_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I151_XP_MN0 (I1_I654_P26_19 I1_I654_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I151_XP_MN1 (VSS I1_I654_P22_19n I1_I654_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I153_XP_MN0 (I1_I654_P28_21 I1_I654_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I153_XP_MN1 (VSS I1_I654_P24_21n I1_I654_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I90_XP_MN0 (I1_I654_P24_23 I1_I654_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I90_XP_MN1 (VSS I1_I654_pn23 I1_I654_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I94_XP_MN0 (I1_I654_P28_27 I1_I654_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I94_XP_MN1 (VSS I1_I654_pn27 I1_I654_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I95_XP_MN0 (I1_I1436_P29_28 I1_I1436_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I95_XP_MN1 (VSS I1_I1436_pn28 I1_I1436_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I93_XP_MN0 (I1_I1436_P27_26 I1_I1436_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I93_XP_MN1 (VSS I1_I1436_pn26 I1_I1436_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I91_XP_MN0 (I1_I1436_P25_24 I1_I1436_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I91_XP_MN1 (VSS I1_I1436_pn24 I1_I1436_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I89_XP_MN0 (I1_I1436_P23_22 I1_I1436_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I89_XP_MN1 (VSS I1_I1436_pn22 I1_I1436_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I87_XP_MN0 (I1_I1436_P21_20 I1_I1436_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I87_XP_MN1 (VSS I1_I1436_pn20 I1_I1436_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I85_XP_MN0 (I1_I1436_P19_18 I1_I1436_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I85_XP_MN1 (VSS I1_I1436_pn18 I1_I1436_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I83_XP_MN0 (I1_I1436_P17_16 I1_I1436_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I83_XP_MN1 (VSS I1_I1436_pn16 I1_I1436_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I81_XP_MN0 (I1_I1436_P15_14 I1_I1436_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I81_XP_MN1 (VSS I1_I1436_pn14 I1_I1436_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I79_XP_MN0 (I1_I1436_P13_12 I1_I1436_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I79_XP_MN1 (VSS I1_I1436_pn12 I1_I1436_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I77_XP_MN0 (I1_I1436_P11_10 I1_I1436_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I77_XP_MN1 (VSS I1_I1436_pn10 I1_I1436_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I75_XP_MN0 (I1_I1436_P9_8 I1_I1436_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I75_XP_MN1 (VSS I1_I1436_pn8 I1_I1436_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I73_XP_MN0 (I1_I1436_P7_6 I1_I1436_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I73_XP_MN1 (VSS I1_I1436_pn6 I1_I1436_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I133_XP_MN0 (I1_I1436_P8_1 I1_I1436_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I133_XP_MN1 (VSS I1_I1436_P4_1n I1_I1436_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I68_XP_MN0 (I1_I1436_P2_1 I1_I1436_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I68_XP_MN1 (VSS I1_I1436_pn1 I1_I1436_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I152_XP_MN0 (I1_I1114_P27_20 I1_I1114_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I152_XP_MN1 (VSS I1_I1114_P23_20n I1_I1114_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I153_XP_MN0 (I1_I1114_P28_21 I1_I1114_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I153_XP_MN1 (VSS I1_I1114_P24_21n I1_I1114_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I151_XP_MN0 (I1_I1114_P26_19 I1_I1114_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I151_XP_MN1 (VSS I1_I1114_P22_19n I1_I1114_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I147_XP_MN0 (I1_I1114_P22_15 I1_I1114_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I147_XP_MN1 (VSS I1_I1114_P18_15n I1_I1114_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I88_XP_MN0 (I1_I1114_P22_21 I1_I1114_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I88_XP_MN1 (VSS I1_I1114_pn21 I1_I1114_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I87_XP_MN0 (I1_I1114_P21_20 I1_I1114_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I87_XP_MN1 (VSS I1_I1114_pn20 I1_I1114_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I86_XP_MN0 (I1_I1114_P20_19 I1_I1114_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I86_XP_MN1 (VSS I1_I1114_pn19 I1_I1114_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I153_XP_MN0 (I1_I1068_P28_21 I1_I1068_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I153_XP_MN1 (VSS I1_I1068_P24_21n I1_I1068_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I90_XP_MN0 (I1_I1068_P24_23 I1_I1068_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I90_XP_MN1 (VSS I1_I1068_pn23 I1_I1068_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I154_XP_MN0 (I1_I1068_P29_22 I1_I1068_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I154_XP_MN1 (VSS I1_I1068_P25_22n I1_I1068_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I156_XP_MN0 (I1_I1068_P31_24 I1_I1068_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I156_XP_MN1 (VSS I1_I1068_P27_24n I1_I1068_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I91_XP_MN0 (I1_I1068_P25_24 I1_I1068_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I91_XP_MN1 (VSS I1_I1068_pn24 I1_I1068_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I96_XP_MN0 (I1_I1022_P30_29 I1_I1022_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I96_XP_MN1 (VSS I1_I1022_pn29 I1_I1022_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I97_XP_MN0 (I1_I1022_P31_30 I1_I1022_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I97_XP_MN1 (VSS I1_I1022_pn30 I1_I1022_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I96_XP_MN0 (I1_I976_P30_29 I1_I976_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I96_XP_MN1 (VSS I1_I976_pn29 I1_I976_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I92_XP_MN0 (I1_I976_P26_25 I1_I976_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I92_XP_MN1 (VSS I1_I976_pn25 I1_I976_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I156_XP_MN0 (I1_I976_P31_24 I1_I976_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I156_XP_MN1 (VSS I1_I976_P27_24n I1_I976_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I152_XP_MN0 (I1_I976_P27_20 I1_I976_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I152_XP_MN1 (VSS I1_I976_P23_20n I1_I976_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I85_XP_MN0 (I1_I976_P19_18 I1_I976_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I85_XP_MN1 (VSS I1_I976_pn18 I1_I976_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I83_XP_MN0 (I1_I976_P17_16 I1_I976_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I83_XP_MN1 (VSS I1_I976_pn16 I1_I976_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I144_XP_MN0 (I1_I976_P19_12 I1_I976_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I144_XP_MN1 (VSS I1_I976_P15_12n I1_I976_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I81_XP_MN0 (I1_I976_P15_14 I1_I976_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I81_XP_MN1 (VSS I1_I976_pn14 I1_I976_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I79_XP_MN0 (I1_I976_P13_12 I1_I976_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I79_XP_MN1 (VSS I1_I976_pn12 I1_I976_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I142_XP_MN0 (I1_I976_P17_10 I1_I976_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I142_XP_MN1 (VSS I1_I976_P13_10n I1_I976_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I76_XP_MN0 (I1_I654_P10_9 I1_I654_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I76_XP_MN1 (VSS I1_I654_pn9 I1_I654_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I78_XP_MN0 (I1_I654_P12_11 I1_I654_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I78_XP_MN1 (VSS I1_I654_pn11 I1_I654_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I80_XP_MN0 (I1_I654_P14_13 I1_I654_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I80_XP_MN1 (VSS I1_I654_pn13 I1_I654_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I82_XP_MN0 (I1_I654_P16_15 I1_I654_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I82_XP_MN1 (VSS I1_I654_pn15 I1_I654_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I84_XP_MN0 (I1_I654_P18_17 I1_I654_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I84_XP_MN1 (VSS I1_I654_pn17 I1_I654_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I86_XP_MN0 (I1_I654_P20_19 I1_I654_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I86_XP_MN1 (VSS I1_I654_pn19 I1_I654_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I88_XP_MN0 (I1_I654_P22_21 I1_I654_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I88_XP_MN1 (VSS I1_I654_pn21 I1_I654_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I97_XP_MN0 (I1_I1436_P31_30 I1_I1436_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I97_XP_MN1 (VSS I1_I1436_pn30 I1_I1436_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I156_XP_MN0 (I1_I1436_P31_24 I1_I1436_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I156_XP_MN1 (VSS I1_I1436_P27_24n I1_I1436_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I152_XP_MN0 (I1_I1436_P27_20 I1_I1436_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I152_XP_MN1 (VSS I1_I1436_P23_20n I1_I1436_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I154_XP_MN0 (I1_I1436_P29_22 I1_I1436_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I154_XP_MN1 (VSS I1_I1436_P25_22n I1_I1436_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I150_XP_MN0 (I1_I1436_P25_18 I1_I1436_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I150_XP_MN1 (VSS I1_I1436_P21_18n I1_I1436_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I146_XP_MN0 (I1_I1436_P21_14 I1_I1436_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I146_XP_MN1 (VSS I1_I1436_P17_14n I1_I1436_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I142_XP_MN0 (I1_I1436_P17_10 I1_I1436_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I142_XP_MN1 (VSS I1_I1436_P13_10n I1_I1436_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I138_XP_MN0 (I1_I1436_P13_6 I1_I1436_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I138_XP_MN1 (VSS I1_I1436_P9_6n I1_I1436_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I134_XP_MN0 (I1_I1436_P9_2 I1_I1436_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I134_XP_MN1 (VSS I1_I1436_P5_2n I1_I1436_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I71_XP_MN0 (I1_I1436_P5_4 I1_I1436_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I71_XP_MN1 (VSS I1_I1436_pn4 I1_I1436_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I69_XP_MN0 (I1_I1436_P3_2 I1_I1436_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I69_XP_MN1 (VSS I1_I1436_pn2 I1_I1436_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I148_XP_MN0 (I1_I1114_P23_16 I1_I1114_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I148_XP_MN1 (VSS I1_I1114_P19_16n I1_I1114_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I150_XP_MN0 (I1_I1114_P25_18 I1_I1114_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I150_XP_MN1 (VSS I1_I1114_P21_18n I1_I1114_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I146_XP_MN0 (I1_I1114_P21_14 I1_I1114_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I146_XP_MN1 (VSS I1_I1114_P17_14n I1_I1114_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I143_XP_MN0 (I1_I1114_P18_11 I1_I1114_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I143_XP_MN1 (VSS I1_I1114_P14_11n I1_I1114_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I85_XP_MN0 (I1_I1114_P19_18 I1_I1114_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I85_XP_MN1 (VSS I1_I1114_pn18 I1_I1114_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I84_XP_MN0 (I1_I1114_P18_17 I1_I1114_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I84_XP_MN1 (VSS I1_I1114_pn17 I1_I1114_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I147_XP_MN0 (I1_I1068_P22_15 I1_I1068_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I147_XP_MN1 (VSS I1_I1068_P18_15n I1_I1068_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I88_XP_MN0 (I1_I1068_P22_21 I1_I1068_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I88_XP_MN1 (VSS I1_I1068_pn21 I1_I1068_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I152_XP_MN0 (I1_I1068_P27_20 I1_I1068_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I152_XP_MN1 (VSS I1_I1068_P23_20n I1_I1068_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I89_XP_MN0 (I1_I1068_P23_22 I1_I1068_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I89_XP_MN1 (VSS I1_I1068_pn22 I1_I1068_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I95_XP_MN0 (I1_I1022_P29_28 I1_I1022_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I95_XP_MN1 (VSS I1_I1022_pn28 I1_I1022_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I93_XP_MN0 (I1_I1022_P27_26 I1_I1022_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I93_XP_MN1 (VSS I1_I1022_pn26 I1_I1022_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I90_XP_MN0 (I1_I976_P24_23 I1_I976_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I90_XP_MN1 (VSS I1_I976_pn23 I1_I976_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I88_XP_MN0 (I1_I976_P22_21 I1_I976_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I88_XP_MN1 (VSS I1_I976_pn21 I1_I976_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I148_XP_MN0 (I1_I976_P23_16 I1_I976_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I148_XP_MN1 (VSS I1_I976_P19_16n I1_I976_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I86_XP_MN0 (I1_I976_P20_19 I1_I976_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I86_XP_MN1 (VSS I1_I976_pn19 I1_I976_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I82_XP_MN0 (I1_I976_P16_15 I1_I976_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I82_XP_MN1 (VSS I1_I976_pn15 I1_I976_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I80_XP_MN0 (I1_I976_P14_13 I1_I976_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I80_XP_MN1 (VSS I1_I976_pn13 I1_I976_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I140_XP_MN0 (I1_I976_P15_8 I1_I976_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I140_XP_MN1 (VSS I1_I976_P11_8n I1_I976_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I136_XP_MN0 (I1_I976_P11_4 I1_I976_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I136_XP_MN1 (VSS I1_I976_P7_4n I1_I976_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I138_XP_MN0 (I1_I976_P13_6 I1_I976_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I138_XP_MN1 (VSS I1_I976_P9_6n I1_I976_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I77_XP_MN0 (I1_I976_P11_10 I1_I976_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I77_XP_MN1 (VSS I1_I976_pn10 I1_I976_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I75_XP_MN0 (I1_I976_P9_8 I1_I976_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I75_XP_MN1 (VSS I1_I976_pn8 I1_I976_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I73_XP_MN0 (I1_I976_P7_6 I1_I976_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I73_XP_MN1 (VSS I1_I976_pn6 I1_I976_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I148_XP_MN0 (I1_I1436_P23_16 I1_I1436_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I148_XP_MN1 (VSS I1_I1436_P19_16n I1_I1436_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I144_XP_MN0 (I1_I1436_P19_12 I1_I1436_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I144_XP_MN1 (VSS I1_I1436_P15_12n I1_I1436_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I140_XP_MN0 (I1_I1436_P15_8 I1_I1436_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I140_XP_MN1 (VSS I1_I1436_P11_8n I1_I1436_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I136_XP_MN0 (I1_I1436_P11_4 I1_I1436_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I136_XP_MN1 (VSS I1_I1436_P7_4n I1_I1436_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I144_XP_MN0 (I1_I1114_P19_12 I1_I1114_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I144_XP_MN1 (VSS I1_I1114_P15_12n I1_I1114_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I149_XP_MN0 (I1_I1114_P24_17 I1_I1114_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I149_XP_MN1 (VSS I1_I1114_P20_17n I1_I1114_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I145_XP_MN0 (I1_I1114_P20_13 I1_I1114_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I145_XP_MN1 (VSS I1_I1114_P16_13n I1_I1114_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I83_XP_MN0 (I1_I1114_P17_16 I1_I1114_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I83_XP_MN1 (VSS I1_I1114_pn16 I1_I1114_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I82_XP_MN0 (I1_I1114_P16_15 I1_I1114_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I82_XP_MN1 (VSS I1_I1114_pn15 I1_I1114_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I151_XP_MN0 (I1_I1068_P26_19 I1_I1068_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I151_XP_MN1 (VSS I1_I1068_P22_19n I1_I1068_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I86_XP_MN0 (I1_I1068_P20_19 I1_I1068_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I86_XP_MN1 (VSS I1_I1068_pn19 I1_I1068_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I150_XP_MN0 (I1_I1068_P25_18 I1_I1068_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I150_XP_MN1 (VSS I1_I1068_P21_18n I1_I1068_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I148_XP_MN0 (I1_I1068_P23_16 I1_I1068_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I148_XP_MN1 (VSS I1_I1068_P19_16n I1_I1068_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I87_XP_MN0 (I1_I1068_P21_20 I1_I1068_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I87_XP_MN1 (VSS I1_I1068_pn20 I1_I1068_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I94_XP_MN0 (I1_I1022_P28_27 I1_I1022_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I94_XP_MN1 (VSS I1_I1022_pn27 I1_I1022_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I92_XP_MN0 (I1_I1022_P26_25 I1_I1022_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I92_XP_MN1 (VSS I1_I1022_pn25 I1_I1022_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I91_XP_MN0 (I1_I1022_P25_24 I1_I1022_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I91_XP_MN1 (VSS I1_I1022_pn24 I1_I1022_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I155_XP_MN0 (I1_I976_P30_23 I1_I976_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I155_XP_MN1 (VSS I1_I976_P26_23n I1_I976_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I153_XP_MN0 (I1_I976_P28_21 I1_I976_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I153_XP_MN1 (VSS I1_I976_P24_21n I1_I976_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I84_XP_MN0 (I1_I976_P18_17 I1_I976_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I84_XP_MN1 (VSS I1_I976_pn17 I1_I976_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I78_XP_MN0 (I1_I976_P12_11 I1_I976_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I78_XP_MN1 (VSS I1_I976_pn11 I1_I976_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I134_XP_MN0 (I1_I976_P9_2 I1_I976_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I134_XP_MN1 (VSS I1_I976_P5_2n I1_I976_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I140_XP_MN0 (I1_I1114_P15_8 I1_I1114_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I140_XP_MN1 (VSS I1_I1114_P11_8n I1_I1114_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I142_XP_MN0 (I1_I1114_P17_10 I1_I1114_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I142_XP_MN1 (VSS I1_I1114_P13_10n I1_I1114_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I81_XP_MN0 (I1_I1114_P15_14 I1_I1114_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I81_XP_MN1 (VSS I1_I1114_pn14 I1_I1114_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I80_XP_MN0 (I1_I1114_P14_13 I1_I1114_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I80_XP_MN1 (VSS I1_I1114_pn13 I1_I1114_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I145_XP_MN0 (I1_I1068_P20_13 I1_I1068_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I145_XP_MN1 (VSS I1_I1068_P16_13n I1_I1068_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I149_XP_MN0 (I1_I1068_P24_17 I1_I1068_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I149_XP_MN1 (VSS I1_I1068_P20_17n I1_I1068_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I146_XP_MN0 (I1_I1068_P21_14 I1_I1068_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I146_XP_MN1 (VSS I1_I1068_P17_14n I1_I1068_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I144_XP_MN0 (I1_I1068_P19_12 I1_I1068_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I144_XP_MN1 (VSS I1_I1068_P15_12n I1_I1068_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I85_XP_MN0 (I1_I1068_P19_18 I1_I1068_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I85_XP_MN1 (VSS I1_I1068_pn18 I1_I1068_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I155_XP_MN0 (I1_I1022_P30_23 I1_I1022_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I155_XP_MN1 (VSS I1_I1022_P26_23n I1_I1022_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I90_XP_MN0 (I1_I1022_P24_23 I1_I1022_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I90_XP_MN1 (VSS I1_I1022_pn23 I1_I1022_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I89_XP_MN0 (I1_I1022_P23_22 I1_I1022_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I89_XP_MN1 (VSS I1_I1022_pn22 I1_I1022_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I151_XP_MN0 (I1_I976_P26_19 I1_I976_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I151_XP_MN1 (VSS I1_I976_P22_19n I1_I976_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I147_XP_MN0 (I1_I976_P22_15 I1_I976_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I147_XP_MN1 (VSS I1_I976_P18_15n I1_I976_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I149_XP_MN0 (I1_I976_P24_17 I1_I976_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I149_XP_MN1 (VSS I1_I976_P20_17n I1_I976_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I145_XP_MN0 (I1_I976_P20_13 I1_I976_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I145_XP_MN1 (VSS I1_I976_P16_13n I1_I976_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I143_XP_MN0 (I1_I976_P18_11 I1_I976_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I143_XP_MN1 (VSS I1_I976_P14_11n I1_I976_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I141_XP_MN0 (I1_I976_P16_9 I1_I976_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I141_XP_MN1 (VSS I1_I976_P12_9n I1_I976_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I76_XP_MN0 (I1_I976_P10_9 I1_I976_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I76_XP_MN1 (VSS I1_I976_pn9 I1_I976_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I74_XP_MN0 (I1_I976_P8_7 I1_I976_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I74_XP_MN1 (VSS I1_I976_pn7 I1_I976_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I71_XP_MN0 (I1_I976_P5_4 I1_I976_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I71_XP_MN1 (VSS I1_I976_pn4 I1_I976_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I68_XP_MN0 (I1_I608_P2_1 I1_I608_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I68_XP_MN1 (VSS I1_I608_pn1 I1_I608_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I133_XP_MN0 (I1_I608_P8_1 I1_I608_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I133_XP_MN1 (VSS I1_I608_P4_1n I1_I608_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I135_XP_MN0 (I1_I608_P10_3 I1_I608_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I135_XP_MN1 (VSS I1_I608_P6_3n I1_I608_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I137_XP_MN0 (I1_I608_P12_5 I1_I608_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I137_XP_MN1 (VSS I1_I608_P8_5n I1_I608_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I141_XP_MN0 (I1_I608_P16_9 I1_I608_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I141_XP_MN1 (VSS I1_I608_P12_9n I1_I608_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I139_XP_MN0 (I1_I608_P14_7 I1_I608_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I139_XP_MN1 (VSS I1_I608_P10_7n I1_I608_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I143_XP_MN0 (I1_I608_P18_11 I1_I608_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I143_XP_MN1 (VSS I1_I608_P14_11n I1_I608_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I145_XP_MN0 (I1_I608_P20_13 I1_I608_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I145_XP_MN1 (VSS I1_I608_P16_13n I1_I608_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I149_XP_MN0 (I1_I608_P24_17 I1_I608_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I149_XP_MN1 (VSS I1_I608_P20_17n I1_I608_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I147_XP_MN0 (I1_I608_P22_15 I1_I608_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I147_XP_MN1 (VSS I1_I608_P18_15n I1_I608_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I151_XP_MN0 (I1_I608_P26_19 I1_I608_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I151_XP_MN1 (VSS I1_I608_P22_19n I1_I608_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I155_XP_MN0 (I1_I608_P30_23 I1_I608_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I155_XP_MN1 (VSS I1_I608_P26_23n I1_I608_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I96_XP_MN0 (I1_I608_P30_29 I1_I608_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I96_XP_MN1 (VSS I1_I608_pn29 I1_I608_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I79_XP_MN0 (I1_I1482_P13_12 I1_I1482_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I79_XP_MN1 (VSS I1_I1482_pn12 I1_I1482_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I138_XP_MN0 (I1_I1114_P13_6 I1_I1114_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I138_XP_MN1 (VSS I1_I1114_P9_6n I1_I1114_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I137_XP_MN0 (I1_I1114_P12_5 I1_I1114_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I137_XP_MN1 (VSS I1_I1114_P8_5n I1_I1114_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I141_XP_MN0 (I1_I1114_P16_9 I1_I1114_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I141_XP_MN1 (VSS I1_I1114_P12_9n I1_I1114_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I135_XP_MN0 (I1_I1114_P10_3 I1_I1114_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I135_XP_MN1 (VSS I1_I1114_P6_3n I1_I1114_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I139_XP_MN0 (I1_I1114_P14_7 I1_I1114_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I139_XP_MN1 (VSS I1_I1114_P10_7n I1_I1114_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I79_XP_MN0 (I1_I1114_P13_12 I1_I1114_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I79_XP_MN1 (VSS I1_I1114_pn12 I1_I1114_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I84_XP_MN0 (I1_I1068_P18_17 I1_I1068_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I84_XP_MN1 (VSS I1_I1068_pn17 I1_I1068_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I140_XP_MN0 (I1_I1068_P15_8 I1_I1068_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I140_XP_MN1 (VSS I1_I1068_P11_8n I1_I1068_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I81_XP_MN0 (I1_I1068_P15_14 I1_I1068_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I81_XP_MN1 (VSS I1_I1068_pn14 I1_I1068_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I83_XP_MN0 (I1_I1068_P17_16 I1_I1068_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I83_XP_MN1 (VSS I1_I1068_pn16 I1_I1068_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I86_XP_MN0 (I1_I1022_P20_19 I1_I1022_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I86_XP_MN1 (VSS I1_I1022_pn19 I1_I1022_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I156_XP_MN0 (I1_I1022_P31_24 I1_I1022_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I156_XP_MN1 (VSS I1_I1022_P27_24n I1_I1022_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I88_XP_MN0 (I1_I1022_P22_21 I1_I1022_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I88_XP_MN1 (VSS I1_I1022_pn21 I1_I1022_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I87_XP_MN0 (I1_I1022_P21_20 I1_I1022_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I87_XP_MN1 (VSS I1_I1022_pn20 I1_I1022_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I139_XP_MN0 (I1_I976_P14_7 I1_I976_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I139_XP_MN1 (VSS I1_I976_P10_7n I1_I976_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I135_XP_MN0 (I1_I976_P10_3 I1_I976_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I135_XP_MN1 (VSS I1_I976_P6_3n I1_I976_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I137_XP_MN0 (I1_I976_P12_5 I1_I976_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I137_XP_MN1 (VSS I1_I976_P8_5n I1_I976_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I72_XP_MN0 (I1_I976_P6_5 I1_I976_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I72_XP_MN1 (VSS I1_I976_pn5 I1_I976_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I69_XP_MN0 (I1_I608_P3_2 I1_I608_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I69_XP_MN1 (VSS I1_I608_pn2 I1_I608_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I70_XP_MN0 (I1_I608_P4_3 I1_I608_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I70_XP_MN1 (VSS I1_I608_pn3 I1_I608_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I72_XP_MN0 (I1_I608_P6_5 I1_I608_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I72_XP_MN1 (VSS I1_I608_pn5 I1_I608_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I74_XP_MN0 (I1_I608_P8_7 I1_I608_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I74_XP_MN1 (VSS I1_I608_pn7 I1_I608_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I76_XP_MN0 (I1_I608_P10_9 I1_I608_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I76_XP_MN1 (VSS I1_I608_pn9 I1_I608_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I78_XP_MN0 (I1_I608_P12_11 I1_I608_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I78_XP_MN1 (VSS I1_I608_pn11 I1_I608_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I80_XP_MN0 (I1_I608_P14_13 I1_I608_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I80_XP_MN1 (VSS I1_I608_pn13 I1_I608_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I82_XP_MN0 (I1_I608_P16_15 I1_I608_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I82_XP_MN1 (VSS I1_I608_pn15 I1_I608_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I84_XP_MN0 (I1_I608_P18_17 I1_I608_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I84_XP_MN1 (VSS I1_I608_pn17 I1_I608_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I86_XP_MN0 (I1_I608_P20_19 I1_I608_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I86_XP_MN1 (VSS I1_I608_pn19 I1_I608_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I88_XP_MN0 (I1_I608_P22_21 I1_I608_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I88_XP_MN1 (VSS I1_I608_pn21 I1_I608_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I153_XP_MN0 (I1_I608_P28_21 I1_I608_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I153_XP_MN1 (VSS I1_I608_P24_21n I1_I608_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I90_XP_MN0 (I1_I608_P24_23 I1_I608_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I90_XP_MN1 (VSS I1_I608_pn23 I1_I608_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I92_XP_MN0 (I1_I608_P26_25 I1_I608_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I92_XP_MN1 (VSS I1_I608_pn25 I1_I608_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I94_XP_MN0 (I1_I608_P28_27 I1_I608_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I94_XP_MN1 (VSS I1_I608_pn27 I1_I608_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I97_XP_MN0 (I1_I608_P31_30 I1_I608_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I97_XP_MN1 (VSS I1_I608_pn30 I1_I608_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I89_XP_MN0 (I1_I1482_P23_22 I1_I1482_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I89_XP_MN1 (VSS I1_I1482_pn22 I1_I1482_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I148_XP_MN0 (I1_I1482_P23_16 I1_I1482_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I148_XP_MN1 (VSS I1_I1482_P19_16n I1_I1482_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I87_XP_MN0 (I1_I1482_P21_20 I1_I1482_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I87_XP_MN1 (VSS I1_I1482_pn20 I1_I1482_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I85_XP_MN0 (I1_I1482_P19_18 I1_I1482_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I85_XP_MN1 (VSS I1_I1482_pn18 I1_I1482_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I83_XP_MN0 (I1_I1482_P17_16 I1_I1482_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I83_XP_MN1 (VSS I1_I1482_pn16 I1_I1482_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I140_XP_MN0 (I1_I1482_P15_8 I1_I1482_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I140_XP_MN1 (VSS I1_I1482_P11_8n I1_I1482_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I81_XP_MN0 (I1_I1482_P15_14 I1_I1482_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I81_XP_MN1 (VSS I1_I1482_pn14 I1_I1482_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I138_XP_MN0 (I1_I1482_P13_6 I1_I1482_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I138_XP_MN1 (VSS I1_I1482_P9_6n I1_I1482_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I77_XP_MN0 (I1_I1482_P11_10 I1_I1482_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I77_XP_MN1 (VSS I1_I1482_pn10 I1_I1482_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I75_XP_MN0 (I1_I1482_P9_8 I1_I1482_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I75_XP_MN1 (VSS I1_I1482_pn8 I1_I1482_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I73_XP_MN0 (I1_I1482_P7_6 I1_I1482_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I73_XP_MN1 (VSS I1_I1482_pn6 I1_I1482_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I71_XP_MN0 (I1_I1482_P5_4 I1_I1482_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I71_XP_MN1 (VSS I1_I1482_pn4 I1_I1482_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I69_XP_MN0 (I1_I1482_P3_2 I1_I1482_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I69_XP_MN1 (VSS I1_I1482_pn2 I1_I1482_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I136_XP_MN0 (I1_I1114_P11_4 I1_I1114_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I136_XP_MN1 (VSS I1_I1114_P7_4n I1_I1114_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I134_XP_MN0 (I1_I1114_P9_2 I1_I1114_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I134_XP_MN1 (VSS I1_I1114_P5_2n I1_I1114_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I77_XP_MN0 (I1_I1114_P11_10 I1_I1114_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I77_XP_MN1 (VSS I1_I1114_pn10 I1_I1114_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I78_XP_MN0 (I1_I1114_P12_11 I1_I1114_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I78_XP_MN1 (VSS I1_I1114_pn11 I1_I1114_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I143_XP_MN0 (I1_I1068_P18_11 I1_I1068_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I143_XP_MN1 (VSS I1_I1068_P14_11n I1_I1068_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I82_XP_MN0 (I1_I1068_P16_15 I1_I1068_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I82_XP_MN1 (VSS I1_I1068_pn15 I1_I1068_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I80_XP_MN0 (I1_I1068_P14_13 I1_I1068_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I80_XP_MN1 (VSS I1_I1068_pn13 I1_I1068_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I138_XP_MN0 (I1_I1068_P13_6 I1_I1068_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I138_XP_MN1 (VSS I1_I1068_P9_6n I1_I1068_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I142_XP_MN0 (I1_I1068_P17_10 I1_I1068_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I142_XP_MN1 (VSS I1_I1068_P13_10n I1_I1068_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I79_XP_MN0 (I1_I1068_P13_12 I1_I1068_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I79_XP_MN1 (VSS I1_I1068_pn12 I1_I1068_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I151_XP_MN0 (I1_I1022_P26_19 I1_I1022_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I151_XP_MN1 (VSS I1_I1022_P22_19n I1_I1022_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I153_XP_MN0 (I1_I1022_P28_21 I1_I1022_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I153_XP_MN1 (VSS I1_I1022_P24_21n I1_I1022_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I152_XP_MN0 (I1_I1022_P27_20 I1_I1022_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I152_XP_MN1 (VSS I1_I1022_P23_20n I1_I1022_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I148_XP_MN0 (I1_I1022_P23_16 I1_I1022_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I148_XP_MN1 (VSS I1_I1022_P19_16n I1_I1022_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I85_XP_MN0 (I1_I1022_P19_18 I1_I1022_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I85_XP_MN1 (VSS I1_I1022_pn18 I1_I1022_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I133_XP_MN0 (I1_I976_P8_1 I1_I976_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I133_XP_MN1 (VSS I1_I976_P4_1n I1_I976_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I70_XP_MN0 (I1_I976_P4_3 I1_I976_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I70_XP_MN1 (VSS I1_I976_pn3 I1_I976_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I69_XP_MN0 (I1_I976_P3_2 I1_I976_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I69_XP_MN1 (VSS I1_I976_pn2 I1_I976_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I71_XP_MN0 (I1_I608_P5_4 I1_I608_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I71_XP_MN1 (VSS I1_I608_pn4 I1_I608_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I73_XP_MN0 (I1_I608_P7_6 I1_I608_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I73_XP_MN1 (VSS I1_I608_pn6 I1_I608_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I134_XP_MN0 (I1_I608_P9_2 I1_I608_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I134_XP_MN1 (VSS I1_I608_P5_2n I1_I608_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I136_XP_MN0 (I1_I608_P11_4 I1_I608_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I136_XP_MN1 (VSS I1_I608_P7_4n I1_I608_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I138_XP_MN0 (I1_I608_P13_6 I1_I608_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I138_XP_MN1 (VSS I1_I608_P9_6n I1_I608_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I140_XP_MN0 (I1_I608_P15_8 I1_I608_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I140_XP_MN1 (VSS I1_I608_P11_8n I1_I608_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I144_XP_MN0 (I1_I608_P19_12 I1_I608_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I144_XP_MN1 (VSS I1_I608_P15_12n I1_I608_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I156_XP_MN0 (I1_I608_P31_24 I1_I608_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I156_XP_MN1 (VSS I1_I608_P27_24n I1_I608_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I95_XP_MN0 (I1_I608_P29_28 I1_I608_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I95_XP_MN1 (VSS I1_I608_pn28 I1_I608_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I156_XP_MN0 (I1_I1482_P31_24 I1_I1482_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I156_XP_MN1 (VSS I1_I1482_P27_24n I1_I1482_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I91_XP_MN0 (I1_I1482_P25_24 I1_I1482_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I91_XP_MN1 (VSS I1_I1482_pn24 I1_I1482_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I152_XP_MN0 (I1_I1482_P27_20 I1_I1482_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I152_XP_MN1 (VSS I1_I1482_P23_20n I1_I1482_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I146_XP_MN0 (I1_I1482_P21_14 I1_I1482_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I146_XP_MN1 (VSS I1_I1482_P17_14n I1_I1482_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I144_XP_MN0 (I1_I1482_P19_12 I1_I1482_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I144_XP_MN1 (VSS I1_I1482_P15_12n I1_I1482_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I142_XP_MN0 (I1_I1482_P17_10 I1_I1482_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I142_XP_MN1 (VSS I1_I1482_P13_10n I1_I1482_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I136_XP_MN0 (I1_I1482_P11_4 I1_I1482_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I136_XP_MN1 (VSS I1_I1482_P7_4n I1_I1482_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I134_XP_MN0 (I1_I1482_P9_2 I1_I1482_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I134_XP_MN1 (VSS I1_I1482_P5_2n I1_I1482_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I74_XP_MN0 (I1_I1482_P8_7 I1_I1482_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I74_XP_MN1 (VSS I1_I1482_pn7 I1_I1482_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I72_XP_MN0 (I1_I1482_P6_5 I1_I1482_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I72_XP_MN1 (VSS I1_I1482_pn5 I1_I1482_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I70_XP_MN0 (I1_I1482_P4_3 I1_I1482_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I70_XP_MN1 (VSS I1_I1482_pn3 I1_I1482_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I68_XP_MN0 (I1_I1482_P2_1 I1_I1482_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I68_XP_MN1 (VSS I1_I1482_pn1 I1_I1482_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I75_XP_MN0 (I1_I1114_P9_8 I1_I1114_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I75_XP_MN1 (VSS I1_I1114_pn8 I1_I1114_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I76_XP_MN0 (I1_I1114_P10_9 I1_I1114_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I76_XP_MN1 (VSS I1_I1114_pn9 I1_I1114_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I73_XP_MN0 (I1_I1114_P7_6 I1_I1114_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I73_XP_MN1 (VSS I1_I1114_pn6 I1_I1114_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I72_XP_MN0 (I1_I1114_P6_5 I1_I1114_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I72_XP_MN1 (VSS I1_I1114_pn5 I1_I1114_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I133_XP_MN0 (I1_I1114_P8_1 I1_I1114_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I133_XP_MN1 (VSS I1_I1114_P4_1n I1_I1114_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I141_XP_MN0 (I1_I1068_P16_9 I1_I1068_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I141_XP_MN1 (VSS I1_I1068_P12_9n I1_I1068_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I139_XP_MN0 (I1_I1068_P14_7 I1_I1068_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I139_XP_MN1 (VSS I1_I1068_P10_7n I1_I1068_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I78_XP_MN0 (I1_I1068_P12_11 I1_I1068_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I78_XP_MN1 (VSS I1_I1068_pn11 I1_I1068_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I136_XP_MN0 (I1_I1068_P11_4 I1_I1068_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I136_XP_MN1 (VSS I1_I1068_P7_4n I1_I1068_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I147_XP_MN0 (I1_I1022_P22_15 I1_I1022_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I147_XP_MN1 (VSS I1_I1022_P18_15n I1_I1022_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I82_XP_MN0 (I1_I1022_P16_15 I1_I1022_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I82_XP_MN1 (VSS I1_I1022_pn15 I1_I1022_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I84_XP_MN0 (I1_I1022_P18_17 I1_I1022_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I84_XP_MN1 (VSS I1_I1022_pn17 I1_I1022_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I154_XP_MN0 (I1_I1022_P29_22 I1_I1022_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I154_XP_MN1 (VSS I1_I1022_P25_22n I1_I1022_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I144_XP_MN0 (I1_I1022_P19_12 I1_I1022_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I144_XP_MN1 (VSS I1_I1022_P15_12n I1_I1022_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I83_XP_MN0 (I1_I1022_P17_16 I1_I1022_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I83_XP_MN1 (VSS I1_I1022_pn16 I1_I1022_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I81_XP_MN0 (I1_I1022_P15_14 I1_I1022_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I81_XP_MN1 (VSS I1_I1022_pn14 I1_I1022_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I976_I68_XP_MN0 (I1_I976_P2_1 I1_I976_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I976_I68_XP_MN1 (VSS I1_I976_pn1 I1_I976_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I75_XP_MN0 (I1_I608_P9_8 I1_I608_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I75_XP_MN1 (VSS I1_I608_pn8 I1_I608_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I77_XP_MN0 (I1_I608_P11_10 I1_I608_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I77_XP_MN1 (VSS I1_I608_pn10 I1_I608_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I79_XP_MN0 (I1_I608_P13_12 I1_I608_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I79_XP_MN1 (VSS I1_I608_pn12 I1_I608_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I142_XP_MN0 (I1_I608_P17_10 I1_I608_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I142_XP_MN1 (VSS I1_I608_P13_10n I1_I608_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I83_XP_MN0 (I1_I608_P17_16 I1_I608_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I83_XP_MN1 (VSS I1_I608_pn16 I1_I608_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I146_XP_MN0 (I1_I608_P21_14 I1_I608_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I146_XP_MN1 (VSS I1_I608_P17_14n I1_I608_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I150_XP_MN0 (I1_I608_P25_18 I1_I608_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I150_XP_MN1 (VSS I1_I608_P21_18n I1_I608_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I148_XP_MN0 (I1_I608_P23_16 I1_I608_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I148_XP_MN1 (VSS I1_I608_P19_16n I1_I608_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I152_XP_MN0 (I1_I608_P27_20 I1_I608_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I152_XP_MN1 (VSS I1_I608_P23_20n I1_I608_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I154_XP_MN0 (I1_I608_P29_22 I1_I608_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I154_XP_MN1 (VSS I1_I608_P25_22n I1_I608_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I91_XP_MN0 (I1_I608_P25_24 I1_I608_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I91_XP_MN1 (VSS I1_I608_pn24 I1_I608_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I93_XP_MN0 (I1_I608_P27_26 I1_I608_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I93_XP_MN1 (VSS I1_I608_pn26 I1_I608_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I154_XP_MN0 (I1_I1482_P29_22 I1_I1482_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I154_XP_MN1 (VSS I1_I1482_P25_22n I1_I1482_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I150_XP_MN0 (I1_I1482_P25_18 I1_I1482_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I150_XP_MN1 (VSS I1_I1482_P21_18n I1_I1482_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I88_XP_MN0 (I1_I1482_P22_21 I1_I1482_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I88_XP_MN1 (VSS I1_I1482_pn21 I1_I1482_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I86_XP_MN0 (I1_I1482_P20_19 I1_I1482_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I86_XP_MN1 (VSS I1_I1482_pn19 I1_I1482_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I84_XP_MN0 (I1_I1482_P18_17 I1_I1482_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I84_XP_MN1 (VSS I1_I1482_pn17 I1_I1482_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I82_XP_MN0 (I1_I1482_P16_15 I1_I1482_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I82_XP_MN1 (VSS I1_I1482_pn15 I1_I1482_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I80_XP_MN0 (I1_I1482_P14_13 I1_I1482_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I80_XP_MN1 (VSS I1_I1482_pn13 I1_I1482_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I78_XP_MN0 (I1_I1482_P12_11 I1_I1482_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I78_XP_MN1 (VSS I1_I1482_pn11 I1_I1482_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I76_XP_MN0 (I1_I1482_P10_9 I1_I1482_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I76_XP_MN1 (VSS I1_I1482_pn9 I1_I1482_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I133_XP_MN0 (I1_I1482_P8_1 I1_I1482_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I133_XP_MN1 (VSS I1_I1482_P4_1n I1_I1482_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I74_XP_MN0 (I1_I1114_P8_7 I1_I1114_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I74_XP_MN1 (VSS I1_I1114_pn7 I1_I1114_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I71_XP_MN0 (I1_I1114_P5_4 I1_I1114_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I71_XP_MN1 (VSS I1_I1114_pn4 I1_I1114_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I69_XP_MN0 (I1_I1114_P3_2 I1_I1114_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I69_XP_MN1 (VSS I1_I1114_pn2 I1_I1114_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I68_XP_MN0 (I1_I1114_P2_1 I1_I1114_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I68_XP_MN1 (VSS I1_I1114_pn1 I1_I1114_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I137_XP_MN0 (I1_I1068_P12_5 I1_I1068_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I137_XP_MN1 (VSS I1_I1068_P8_5n I1_I1068_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I135_XP_MN0 (I1_I1068_P10_3 I1_I1068_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I135_XP_MN1 (VSS I1_I1068_P6_3n I1_I1068_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I76_XP_MN0 (I1_I1068_P10_9 I1_I1068_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I76_XP_MN1 (VSS I1_I1068_pn9 I1_I1068_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I134_XP_MN0 (I1_I1068_P9_2 I1_I1068_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I134_XP_MN1 (VSS I1_I1068_P5_2n I1_I1068_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I75_XP_MN0 (I1_I1068_P9_8 I1_I1068_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I75_XP_MN1 (VSS I1_I1068_pn8 I1_I1068_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I77_XP_MN0 (I1_I1068_P11_10 I1_I1068_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I77_XP_MN1 (VSS I1_I1068_pn10 I1_I1068_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I143_XP_MN0 (I1_I1022_P18_11 I1_I1022_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I143_XP_MN1 (VSS I1_I1022_P14_11n I1_I1022_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I149_XP_MN0 (I1_I1022_P24_17 I1_I1022_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I149_XP_MN1 (VSS I1_I1022_P20_17n I1_I1022_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I145_XP_MN0 (I1_I1022_P20_13 I1_I1022_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I145_XP_MN1 (VSS I1_I1022_P16_13n I1_I1022_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I80_XP_MN0 (I1_I1022_P14_13 I1_I1022_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I80_XP_MN1 (VSS I1_I1022_pn13 I1_I1022_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I78_XP_MN0 (I1_I1022_P12_11 I1_I1022_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I78_XP_MN1 (VSS I1_I1022_pn11 I1_I1022_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I150_XP_MN0 (I1_I1022_P25_18 I1_I1022_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I150_XP_MN1 (VSS I1_I1022_P21_18n I1_I1022_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I146_XP_MN0 (I1_I1022_P21_14 I1_I1022_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I146_XP_MN1 (VSS I1_I1022_P17_14n I1_I1022_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I140_XP_MN0 (I1_I1022_P15_8 I1_I1022_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I140_XP_MN1 (VSS I1_I1022_P11_8n I1_I1022_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I79_XP_MN0 (I1_I1022_P13_12 I1_I1022_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I79_XP_MN1 (VSS I1_I1022_pn12 I1_I1022_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I81_XP_MN0 (I1_I608_P15_14 I1_I608_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I81_XP_MN1 (VSS I1_I608_pn14 I1_I608_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I85_XP_MN0 (I1_I608_P19_18 I1_I608_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I85_XP_MN1 (VSS I1_I608_pn18 I1_I608_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I87_XP_MN0 (I1_I608_P21_20 I1_I608_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I87_XP_MN1 (VSS I1_I608_pn20 I1_I608_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I608_I89_XP_MN0 (I1_I608_P23_22 I1_I608_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I608_I89_XP_MN1 (VSS I1_I608_pn22 I1_I608_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I93_XP_MN0 (I1_I1482_P27_26 I1_I1482_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I93_XP_MN1 (VSS I1_I1482_pn26 I1_I1482_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I92_XP_MN0 (I1_I1482_P26_25 I1_I1482_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I92_XP_MN1 (VSS I1_I1482_pn25 I1_I1482_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I90_XP_MN0 (I1_I1482_P24_23 I1_I1482_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I90_XP_MN1 (VSS I1_I1482_pn23 I1_I1482_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I149_XP_MN0 (I1_I1482_P24_17 I1_I1482_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I149_XP_MN1 (VSS I1_I1482_P20_17n I1_I1482_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I145_XP_MN0 (I1_I1482_P20_13 I1_I1482_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I145_XP_MN1 (VSS I1_I1482_P16_13n I1_I1482_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I141_XP_MN0 (I1_I1482_P16_9 I1_I1482_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I141_XP_MN1 (VSS I1_I1482_P12_9n I1_I1482_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I137_XP_MN0 (I1_I1482_P12_5 I1_I1482_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I137_XP_MN1 (VSS I1_I1482_P8_5n I1_I1482_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I135_XP_MN0 (I1_I1482_P10_3 I1_I1482_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I135_XP_MN1 (VSS I1_I1482_P6_3n I1_I1482_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I70_XP_MN0 (I1_I1114_P4_3 I1_I1114_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I70_XP_MN1 (VSS I1_I1114_pn3 I1_I1114_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I133_XP_MN0 (I1_I1068_P8_1 I1_I1068_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I133_XP_MN1 (VSS I1_I1068_P4_1n I1_I1068_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I74_XP_MN0 (I1_I1068_P8_7 I1_I1068_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I74_XP_MN1 (VSS I1_I1068_pn7 I1_I1068_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I139_XP_MN0 (I1_I1022_P14_7 I1_I1022_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I139_XP_MN1 (VSS I1_I1022_P10_7n I1_I1022_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I76_XP_MN0 (I1_I1022_P10_9 I1_I1022_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I76_XP_MN1 (VSS I1_I1022_pn9 I1_I1022_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I142_XP_MN0 (I1_I1022_P17_10 I1_I1022_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I142_XP_MN1 (VSS I1_I1022_P13_10n I1_I1022_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I136_XP_MN0 (I1_I1022_P11_4 I1_I1022_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I136_XP_MN1 (VSS I1_I1022_P7_4n I1_I1022_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I75_XP_MN0 (I1_I1022_P9_8 I1_I1022_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I75_XP_MN1 (VSS I1_I1022_pn8 I1_I1022_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I77_XP_MN0 (I1_I1022_P11_10 I1_I1022_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I77_XP_MN1 (VSS I1_I1022_pn10 I1_I1022_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I153_XP_MN0 (I1_I1482_P28_21 I1_I1482_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I153_XP_MN1 (VSS I1_I1482_P24_21n I1_I1482_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I147_XP_MN0 (I1_I1482_P22_15 I1_I1482_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I147_XP_MN1 (VSS I1_I1482_P18_15n I1_I1482_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I76_XP_MN0 (I1_I1528_P10_9 I1_I1528_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I76_XP_MN1 (VSS I1_I1528_pn9 I1_I1528_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I74_XP_MN0 (I1_I1528_P8_7 I1_I1528_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I74_XP_MN1 (VSS I1_I1528_pn7 I1_I1528_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I72_XP_MN0 (I1_I1068_P6_5 I1_I1068_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I72_XP_MN1 (VSS I1_I1068_pn5 I1_I1068_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I71_XP_MN0 (I1_I1068_P5_4 I1_I1068_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I71_XP_MN1 (VSS I1_I1068_pn4 I1_I1068_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I73_XP_MN0 (I1_I1068_P7_6 I1_I1068_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I73_XP_MN1 (VSS I1_I1068_pn6 I1_I1068_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I135_XP_MN0 (I1_I1022_P10_3 I1_I1022_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I135_XP_MN1 (VSS I1_I1022_P6_3n I1_I1022_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I141_XP_MN0 (I1_I1022_P16_9 I1_I1022_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I141_XP_MN1 (VSS I1_I1022_P12_9n I1_I1022_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I137_XP_MN0 (I1_I1022_P12_5 I1_I1022_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I137_XP_MN1 (VSS I1_I1022_P8_5n I1_I1022_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I74_XP_MN0 (I1_I1022_P8_7 I1_I1022_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I74_XP_MN1 (VSS I1_I1022_pn7 I1_I1022_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I72_XP_MN0 (I1_I1022_P6_5 I1_I1022_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I72_XP_MN1 (VSS I1_I1022_pn5 I1_I1022_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I138_XP_MN0 (I1_I1022_P13_6 I1_I1022_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I138_XP_MN1 (VSS I1_I1022_P9_6n I1_I1022_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I134_XP_MN0 (I1_I1022_P9_2 I1_I1022_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I134_XP_MN1 (VSS I1_I1022_P5_2n I1_I1022_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I73_XP_MN0 (I1_I1022_P7_6 I1_I1022_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I73_XP_MN1 (VSS I1_I1022_pn6 I1_I1022_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I95_XP_MN0 (I1_I1482_P29_28 I1_I1482_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I95_XP_MN1 (VSS I1_I1482_pn28 I1_I1482_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I94_XP_MN0 (I1_I1482_P28_27 I1_I1482_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I94_XP_MN1 (VSS I1_I1482_pn27 I1_I1482_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I155_XP_MN0 (I1_I1482_P30_23 I1_I1482_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I155_XP_MN1 (VSS I1_I1482_P26_23n I1_I1482_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I151_XP_MN0 (I1_I1482_P26_19 I1_I1482_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I151_XP_MN1 (VSS I1_I1482_P22_19n I1_I1482_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I143_XP_MN0 (I1_I1482_P18_11 I1_I1482_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I143_XP_MN1 (VSS I1_I1482_P14_11n I1_I1482_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I139_XP_MN0 (I1_I1482_P14_7 I1_I1482_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I139_XP_MN1 (VSS I1_I1482_P10_7n I1_I1482_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I82_XP_MN0 (I1_I1528_P16_15 I1_I1528_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I82_XP_MN1 (VSS I1_I1528_pn15 I1_I1528_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I80_XP_MN0 (I1_I1528_P14_13 I1_I1528_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I80_XP_MN1 (VSS I1_I1528_pn13 I1_I1528_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I78_XP_MN0 (I1_I1528_P12_11 I1_I1528_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I78_XP_MN1 (VSS I1_I1528_pn11 I1_I1528_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I72_XP_MN0 (I1_I1528_P6_5 I1_I1528_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I72_XP_MN1 (VSS I1_I1528_pn5 I1_I1528_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I68_XP_MN0 (I1_I1068_P2_1 I1_I1068_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I68_XP_MN1 (VSS I1_I1068_pn1 I1_I1068_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I70_XP_MN0 (I1_I1068_P4_3 I1_I1068_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I70_XP_MN1 (VSS I1_I1068_pn3 I1_I1068_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1068_I69_XP_MN0 (I1_I1068_P3_2 I1_I1068_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1068_I69_XP_MN1 (VSS I1_I1068_pn2 I1_I1068_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I133_XP_MN0 (I1_I1022_P8_1 I1_I1022_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I133_XP_MN1 (VSS I1_I1022_P4_1n I1_I1022_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I70_XP_MN0 (I1_I1022_P4_3 I1_I1022_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I70_XP_MN1 (VSS I1_I1022_pn3 I1_I1022_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I68_XP_MN0 (I1_I1022_P2_1 I1_I1022_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I68_XP_MN1 (VSS I1_I1022_pn1 I1_I1022_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I69_XP_MN0 (I1_I1022_P3_2 I1_I1022_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I69_XP_MN1 (VSS I1_I1022_pn2 I1_I1022_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1022_I71_XP_MN0 (I1_I1022_P5_4 I1_I1022_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1022_I71_XP_MN1 (VSS I1_I1022_pn4 I1_I1022_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I68_XP_MN0 (I1_I562_P2_1 I1_I562_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I68_XP_MN1 (VSS I1_I562_pn1 I1_I562_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I69_XP_MN0 (I1_I562_P3_2 I1_I562_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I69_XP_MN1 (VSS I1_I562_pn2 I1_I562_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I97_XP_MN0 (I1_I1482_P31_30 I1_I1482_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I97_XP_MN1 (VSS I1_I1482_pn30 I1_I1482_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1482_I96_XP_MN0 (I1_I1482_P30_29 I1_I1482_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1482_I96_XP_MN1 (VSS I1_I1482_pn29 I1_I1482_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I86_XP_MN0 (I1_I1528_P20_19 I1_I1528_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I86_XP_MN1 (VSS I1_I1528_pn19 I1_I1528_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I84_XP_MN0 (I1_I1528_P18_17 I1_I1528_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I84_XP_MN1 (VSS I1_I1528_pn17 I1_I1528_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I149_XP_MN0 (I1_I1528_P24_17 I1_I1528_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I149_XP_MN1 (VSS I1_I1528_P20_17n I1_I1528_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I145_XP_MN0 (I1_I1528_P20_13 I1_I1528_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I145_XP_MN1 (VSS I1_I1528_P16_13n I1_I1528_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I143_XP_MN0 (I1_I1528_P18_11 I1_I1528_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I143_XP_MN1 (VSS I1_I1528_P14_11n I1_I1528_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I139_XP_MN0 (I1_I1528_P14_7 I1_I1528_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I139_XP_MN1 (VSS I1_I1528_P10_7n I1_I1528_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I141_XP_MN0 (I1_I1528_P16_9 I1_I1528_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I141_XP_MN1 (VSS I1_I1528_P12_9n I1_I1528_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I137_XP_MN0 (I1_I1528_P12_5 I1_I1528_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I137_XP_MN1 (VSS I1_I1528_P8_5n I1_I1528_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I135_XP_MN0 (I1_I1528_P10_3 I1_I1528_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I135_XP_MN1 (VSS I1_I1528_P6_3n I1_I1528_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I133_XP_MN0 (I1_I1528_P8_1 I1_I1528_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I133_XP_MN1 (VSS I1_I1528_P4_1n I1_I1528_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I70_XP_MN0 (I1_I1528_P4_3 I1_I1528_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I70_XP_MN1 (VSS I1_I1528_pn3 I1_I1528_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I68_XP_MN0 (I1_I1528_P2_1 I1_I1528_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I68_XP_MN1 (VSS I1_I1528_pn1 I1_I1528_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I70_XP_MN0 (I1_I562_P4_3 I1_I562_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I70_XP_MN1 (VSS I1_I562_pn3 I1_I562_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I72_XP_MN0 (I1_I562_P6_5 I1_I562_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I72_XP_MN1 (VSS I1_I562_pn5 I1_I562_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I133_XP_MN0 (I1_I562_P8_1 I1_I562_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I133_XP_MN1 (VSS I1_I562_P4_1n I1_I562_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I135_XP_MN0 (I1_I562_P10_3 I1_I562_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I135_XP_MN1 (VSS I1_I562_P6_3n I1_I562_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I137_XP_MN0 (I1_I562_P12_5 I1_I562_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I137_XP_MN1 (VSS I1_I562_P8_5n I1_I562_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I141_XP_MN0 (I1_I562_P16_9 I1_I562_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I141_XP_MN1 (VSS I1_I562_P12_9n I1_I562_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I90_XP_MN0 (I1_I1528_P24_23 I1_I1528_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I90_XP_MN1 (VSS I1_I1528_pn23 I1_I1528_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I88_XP_MN0 (I1_I1528_P22_21 I1_I1528_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I88_XP_MN1 (VSS I1_I1528_pn21 I1_I1528_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I151_XP_MN0 (I1_I1528_P26_19 I1_I1528_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I151_XP_MN1 (VSS I1_I1528_P22_19n I1_I1528_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I147_XP_MN0 (I1_I1528_P22_15 I1_I1528_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I147_XP_MN1 (VSS I1_I1528_P18_15n I1_I1528_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I69_XP_MN0 (I1_I1528_P3_2 I1_I1528_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I69_XP_MN1 (VSS I1_I1528_pn2 I1_I1528_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I116_MN0 (I2_I2_nor19 A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I116_MN1 (VSS B_19 I2_I2_nor19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I74_XP_MN0 (I1_I562_P8_7 I1_I562_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I74_XP_MN1 (VSS I1_I562_pn7 I1_I562_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I76_XP_MN0 (I1_I562_P10_9 I1_I562_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I76_XP_MN1 (VSS I1_I562_pn9 I1_I562_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I78_XP_MN0 (I1_I562_P12_11 I1_I562_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I78_XP_MN1 (VSS I1_I562_pn11 I1_I562_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I139_XP_MN0 (I1_I562_P14_7 I1_I562_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I139_XP_MN1 (VSS I1_I562_P10_7n I1_I562_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I143_XP_MN0 (I1_I562_P18_11 I1_I562_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I143_XP_MN1 (VSS I1_I562_P14_11n I1_I562_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I145_XP_MN0 (I1_I562_P20_13 I1_I562_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I145_XP_MN1 (VSS I1_I562_P16_13n I1_I562_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I149_XP_MN0 (I1_I562_P24_17 I1_I562_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I149_XP_MN1 (VSS I1_I562_P20_17n I1_I562_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I151_XP_MN0 (I1_I562_P26_19 I1_I562_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I151_XP_MN1 (VSS I1_I562_P22_19n I1_I562_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I147_XP_MN0 (I1_I562_P22_15 I1_I562_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I147_XP_MN1 (VSS I1_I562_P18_15n I1_I562_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I153_XP_MN0 (I1_I562_P28_21 I1_I562_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I153_XP_MN1 (VSS I1_I562_P24_21n I1_I562_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I155_XP_MN0 (I1_I562_P30_23 I1_I562_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I155_XP_MN1 (VSS I1_I562_P26_23n I1_I562_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I96_XP_MN0 (I1_I562_P30_29 I1_I562_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I96_XP_MN1 (VSS I1_I562_pn29 I1_I562_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I92_XP_MN0 (I1_I1528_P26_25 I1_I1528_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I92_XP_MN1 (VSS I1_I1528_pn25 I1_I1528_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I89_XP_MN0 (I1_I1528_P23_22 I1_I1528_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I89_XP_MN1 (VSS I1_I1528_pn22 I1_I1528_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I155_XP_MN0 (I1_I1528_P30_23 I1_I1528_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I155_XP_MN1 (VSS I1_I1528_P26_23n I1_I1528_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I87_XP_MN0 (I1_I1528_P21_20 I1_I1528_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I87_XP_MN1 (VSS I1_I1528_pn20 I1_I1528_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I153_XP_MN0 (I1_I1528_P28_21 I1_I1528_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I153_XP_MN1 (VSS I1_I1528_P24_21n I1_I1528_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I85_XP_MN0 (I1_I1528_P19_18 I1_I1528_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I85_XP_MN1 (VSS I1_I1528_pn18 I1_I1528_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I83_XP_MN0 (I1_I1528_P17_16 I1_I1528_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I83_XP_MN1 (VSS I1_I1528_pn16 I1_I1528_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I79_XP_MN0 (I1_I1528_P13_12 I1_I1528_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I79_XP_MN1 (VSS I1_I1528_pn12 I1_I1528_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I77_XP_MN0 (I1_I1528_P11_10 I1_I1528_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I77_XP_MN1 (VSS I1_I1528_pn10 I1_I1528_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I75_XP_MN0 (I1_I1528_P9_8 I1_I1528_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I75_XP_MN1 (VSS I1_I1528_pn8 I1_I1528_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I73_XP_MN0 (I1_I1528_P7_6 I1_I1528_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I73_XP_MN1 (VSS I1_I1528_pn6 I1_I1528_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I71_XP_MN0 (I1_I1528_P5_4 I1_I1528_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I71_XP_MN1 (VSS I1_I1528_pn4 I1_I1528_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I77_XP_MN0 (I1_I1574_P11_10 I1_I1574_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I77_XP_MN1 (VSS I1_I1574_pn10 I1_I1574_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I319_MN0 (I2_I3_q19_1 I2_I3_o19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I319_MN1 (VSS I2_I3_o19_1 I2_I3_q19_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I331_MN0 (I2_I3_q20_1 I2_I3_o20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I331_MN1 (VSS I2_I3_o20_1 I2_I3_q20_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I10_MN0 (I2_I4_z0_10 Y_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I10_MN1 (VSS Y_21 I2_I4_z0_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I11_MN0 (I2_I4_z0_11 Y_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I11_MN1 (VSS Y_23 I2_I4_z0_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I71_XP_MN0 (I1_I562_P5_4 I1_I562_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I71_XP_MN1 (VSS I1_I562_pn4 I1_I562_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I73_XP_MN0 (I1_I562_P7_6 I1_I562_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I73_XP_MN1 (VSS I1_I562_pn6 I1_I562_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I75_XP_MN0 (I1_I562_P9_8 I1_I562_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I75_XP_MN1 (VSS I1_I562_pn8 I1_I562_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I77_XP_MN0 (I1_I562_P11_10 I1_I562_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I77_XP_MN1 (VSS I1_I562_pn10 I1_I562_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I80_XP_MN0 (I1_I562_P14_13 I1_I562_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I80_XP_MN1 (VSS I1_I562_pn13 I1_I562_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I82_XP_MN0 (I1_I562_P16_15 I1_I562_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I82_XP_MN1 (VSS I1_I562_pn15 I1_I562_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I84_XP_MN0 (I1_I562_P18_17 I1_I562_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I84_XP_MN1 (VSS I1_I562_pn17 I1_I562_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I86_XP_MN0 (I1_I562_P20_19 I1_I562_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I86_XP_MN1 (VSS I1_I562_pn19 I1_I562_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I88_XP_MN0 (I1_I562_P22_21 I1_I562_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I88_XP_MN1 (VSS I1_I562_pn21 I1_I562_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I94_XP_MN0 (I1_I562_P28_27 I1_I562_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I94_XP_MN1 (VSS I1_I562_pn27 I1_I562_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I97_XP_MN0 (I1_I562_P31_30 I1_I562_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I97_XP_MN1 (VSS I1_I562_pn30 I1_I562_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I97_XP_MN0 (I1_I1528_P31_30 I1_I1528_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I97_XP_MN1 (VSS I1_I1528_pn30 I1_I1528_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I95_XP_MN0 (I1_I1528_P29_28 I1_I1528_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I95_XP_MN1 (VSS I1_I1528_pn28 I1_I1528_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I93_XP_MN0 (I1_I1528_P27_26 I1_I1528_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I93_XP_MN1 (VSS I1_I1528_pn26 I1_I1528_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I91_XP_MN0 (I1_I1528_P25_24 I1_I1528_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I91_XP_MN1 (VSS I1_I1528_pn24 I1_I1528_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I96_XP_MN0 (I1_I1528_P30_29 I1_I1528_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I96_XP_MN1 (VSS I1_I1528_pn29 I1_I1528_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I94_XP_MN0 (I1_I1528_P28_27 I1_I1528_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I94_XP_MN1 (VSS I1_I1528_pn27 I1_I1528_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I150_XP_MN0 (I1_I1528_P25_18 I1_I1528_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I150_XP_MN1 (VSS I1_I1528_P21_18n I1_I1528_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I81_XP_MN0 (I1_I1528_P15_14 I1_I1528_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I81_XP_MN1 (VSS I1_I1528_pn14 I1_I1528_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I138_XP_MN0 (I1_I1528_P13_6 I1_I1528_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I138_XP_MN1 (VSS I1_I1528_P9_6n I1_I1528_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I134_XP_MN0 (I1_I1528_P9_2 I1_I1528_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I134_XP_MN1 (VSS I1_I1528_P5_2n I1_I1528_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I144_XP_MN0 (I1_I1574_P19_12 I1_I1574_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I144_XP_MN1 (VSS I1_I1574_P15_12n I1_I1574_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I140_XP_MN0 (I1_I1574_P15_8 I1_I1574_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I140_XP_MN1 (VSS I1_I1574_P11_8n I1_I1574_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I79_XP_MN0 (I1_I1574_P13_12 I1_I1574_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I79_XP_MN1 (VSS I1_I1574_pn12 I1_I1574_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2277_MN0 (I1_z0_15 B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2277_MN1 (VSS I1_B_31_b3_5 I1_z0_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2276_MN0 (I1_z0_14 B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2276_MN1 (VSS B_29 I1_z0_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I128_MN0 (I2_I2_nor21 A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I128_MN1 (VSS B_21 I2_I2_nor21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I343_MN0 (I2_I3_q21_1 I2_I3_o21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I343_MN1 (VSS I2_I3_o21_1 I2_I3_q21_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I307_MN0 (I2_I3_q18_1 I2_I3_o18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I307_MN1 (VSS I2_I3_o18_1 I2_I3_q18_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I122_MN0 (I2_I2_nor20 A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I122_MN1 (VSS B_20 I2_I2_nor20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I9_MN0 (I2_I4_z0_9 Y_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I9_MN1 (VSS Y_19 I2_I4_z0_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I79_XP_MN0 (I1_I562_P13_12 I1_I562_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I79_XP_MN1 (VSS I1_I562_pn12 I1_I562_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I81_XP_MN0 (I1_I562_P15_14 I1_I562_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I81_XP_MN1 (VSS I1_I562_pn14 I1_I562_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I83_XP_MN0 (I1_I562_P17_16 I1_I562_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I83_XP_MN1 (VSS I1_I562_pn16 I1_I562_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I90_XP_MN0 (I1_I562_P24_23 I1_I562_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I90_XP_MN1 (VSS I1_I562_pn23 I1_I562_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I92_XP_MN0 (I1_I562_P26_25 I1_I562_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I92_XP_MN1 (VSS I1_I562_pn25 I1_I562_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I95_XP_MN0 (I1_I562_P29_28 I1_I562_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I95_XP_MN1 (VSS I1_I562_pn28 I1_I562_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I156_XP_MN0 (I1_I1712_P31_24 I1_I1712_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I156_XP_MN1 (VSS I1_I1712_P27_24n I1_I1712_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I152_XP_MN0 (I1_I1712_P27_20 I1_I1712_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I152_XP_MN1 (VSS I1_I1712_P23_20n I1_I1712_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I148_XP_MN0 (I1_I1712_P23_16 I1_I1712_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I148_XP_MN1 (VSS I1_I1712_P19_16n I1_I1712_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I144_XP_MN0 (I1_I1712_P19_12 I1_I1712_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I144_XP_MN1 (VSS I1_I1712_P15_12n I1_I1712_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I140_XP_MN0 (I1_I1712_P15_8 I1_I1712_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I140_XP_MN1 (VSS I1_I1712_P11_8n I1_I1712_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I156_XP_MN0 (I1_I1528_P31_24 I1_I1528_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I156_XP_MN1 (VSS I1_I1528_P27_24n I1_I1528_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I136_XP_MN0 (I1_I1712_P11_4 I1_I1712_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I136_XP_MN1 (VSS I1_I1712_P7_4n I1_I1712_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I154_XP_MN0 (I1_I1528_P29_22 I1_I1528_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I154_XP_MN1 (VSS I1_I1528_P25_22n I1_I1528_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I152_XP_MN0 (I1_I1528_P27_20 I1_I1528_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I152_XP_MN1 (VSS I1_I1528_P23_20n I1_I1528_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I148_XP_MN0 (I1_I1528_P23_16 I1_I1528_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I148_XP_MN1 (VSS I1_I1528_P19_16n I1_I1528_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I144_XP_MN0 (I1_I1528_P19_12 I1_I1528_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I144_XP_MN1 (VSS I1_I1528_P15_12n I1_I1528_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I146_XP_MN0 (I1_I1528_P21_14 I1_I1528_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I146_XP_MN1 (VSS I1_I1528_P17_14n I1_I1528_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I140_XP_MN0 (I1_I1528_P15_8 I1_I1528_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I140_XP_MN1 (VSS I1_I1528_P11_8n I1_I1528_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I142_XP_MN0 (I1_I1528_P17_10 I1_I1528_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I142_XP_MN1 (VSS I1_I1528_P13_10n I1_I1528_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1528_I136_XP_MN0 (I1_I1528_P11_4 I1_I1528_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1528_I136_XP_MN1 (VSS I1_I1528_P7_4n I1_I1528_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I152_XP_MN0 (I1_I1574_P27_20 I1_I1574_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I152_XP_MN1 (VSS I1_I1574_P23_20n I1_I1574_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I148_XP_MN0 (I1_I1574_P23_16 I1_I1574_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I148_XP_MN1 (VSS I1_I1574_P19_16n I1_I1574_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I81_XP_MN0 (I1_I1574_P15_14 I1_I1574_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I81_XP_MN1 (VSS I1_I1574_pn14 I1_I1574_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I78_XP_MN0 (I1_I1574_P12_11 I1_I1574_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I78_XP_MN1 (VSS I1_I1574_pn11 I1_I1574_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I136_XP_MN0 (I1_I1574_P11_4 I1_I1574_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I136_XP_MN1 (VSS I1_I1574_P7_4n I1_I1574_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I75_XP_MN0 (I1_I1574_P9_8 I1_I1574_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I75_XP_MN1 (VSS I1_I1574_pn8 I1_I1574_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I73_XP_MN0 (I1_I1574_P7_6 I1_I1574_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I73_XP_MN1 (VSS I1_I1574_pn6 I1_I1574_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2275_MN0 (I1_z0_13 B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2275_MN1 (VSS B_27 I1_z0_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2274_MN0 (I1_z0_12 B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2274_MN1 (VSS B_25 I1_z0_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2289_MN0 (I1_z2_3 I1_z1_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2289_MN1 (VSS I1_z1_7 I1_z2_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I295_MN0 (I2_I3_q17_1 I2_I3_o17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I295_MN1 (VSS I2_I3_o17_1 I2_I3_q17_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I110_MN0 (I2_I2_nor18 A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I110_MN1 (VSS B_18 I2_I2_nor18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I283_MN0 (I2_I3_q16_1 I2_I3_o16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I283_MN1 (VSS I2_I3_o16_1 I2_I3_q16_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I140_MN0 (I2_I2_nor23 A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I140_MN1 (VSS B_23 I2_I2_nor23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I367_MN0 (I2_I3_q23_1 I2_I3_o23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I367_MN1 (VSS I2_I3_o23_1 I2_I3_q23_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I355_MN0 (I2_I3_q22_1 I2_I3_o22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I355_MN1 (VSS I2_I3_o22_1 I2_I3_q22_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I50_MN0 (I2_I4_z2_2 I2_I4_z1_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I50_MN1 (VSS I2_I4_z1_5 I2_I4_z2_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I134_MN0 (I2_I2_nor22 A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I134_MN1 (VSS B_22 I2_I2_nor22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I8_MN0 (I2_I4_z0_8 Y_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I8_MN1 (VSS Y_17 I2_I4_z0_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I164_MN0 (I2_I2_nor27 A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I164_MN1 (VSS B_27 I2_I2_nor27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I176_MN0 (I2_I2_nor29 A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I176_MN1 (VSS B_29 I2_I2_nor29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I134_XP_MN0 (I1_I562_P9_2 I1_I562_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I134_XP_MN1 (VSS I1_I562_P5_2n I1_I562_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I85_XP_MN0 (I1_I562_P19_18 I1_I562_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I85_XP_MN1 (VSS I1_I562_pn18 I1_I562_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I87_XP_MN0 (I1_I562_P21_20 I1_I562_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I87_XP_MN1 (VSS I1_I562_pn20 I1_I562_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I89_XP_MN0 (I1_I562_P23_22 I1_I562_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I89_XP_MN1 (VSS I1_I562_pn22 I1_I562_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I93_XP_MN0 (I1_I562_P27_26 I1_I562_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I93_XP_MN1 (VSS I1_I562_pn26 I1_I562_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I97_XP_MN0 (I1_I1712_P31_30 I1_I1712_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I97_XP_MN1 (VSS I1_I1712_pn30 I1_I1712_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I154_XP_MN0 (I1_I1712_P29_22 I1_I1712_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I154_XP_MN1 (VSS I1_I1712_P25_22n I1_I1712_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I150_XP_MN0 (I1_I1712_P25_18 I1_I1712_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I150_XP_MN1 (VSS I1_I1712_P21_18n I1_I1712_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I146_XP_MN0 (I1_I1712_P21_14 I1_I1712_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I146_XP_MN1 (VSS I1_I1712_P17_14n I1_I1712_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I134_XP_MN0 (I1_I1712_P9_2 I1_I1712_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I134_XP_MN1 (VSS I1_I1712_P5_2n I1_I1712_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I156_XP_MN0 (I1_I1574_P31_24 I1_I1574_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I156_XP_MN1 (VSS I1_I1574_P27_24n I1_I1574_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I146_XP_MN0 (I1_I1574_P21_14 I1_I1574_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I146_XP_MN1 (VSS I1_I1574_P17_14n I1_I1574_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I142_XP_MN0 (I1_I1574_P17_10 I1_I1574_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I142_XP_MN1 (VSS I1_I1574_P13_10n I1_I1574_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I138_XP_MN0 (I1_I1574_P13_6 I1_I1574_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I138_XP_MN1 (VSS I1_I1574_P9_6n I1_I1574_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I134_XP_MN0 (I1_I1574_P9_2 I1_I1574_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I134_XP_MN1 (VSS I1_I1574_P5_2n I1_I1574_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I71_XP_MN0 (I1_I1574_P5_4 I1_I1574_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I71_XP_MN1 (VSS I1_I1574_pn4 I1_I1574_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2266_MN0 (I1_z0_4 B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2266_MN1 (VSS B_9 I1_z0_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2287_MN0 (I1_z2_1 I1_z1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2287_MN1 (VSS I1_z1_3 I1_z2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2268_MN0 (I1_z0_6 B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2268_MN1 (VSS B_13 I1_z0_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2269_MN0 (I1_z0_7 B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2269_MN1 (VSS B_15 I1_z0_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I82_XP_MN0 (I2_I1_I42_P16_15 I2_I1_I42_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I82_XP_MN1 (VSS I2_I1_I42_pn15 I2_I1_I42_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I83_XP_MN0 (I2_I1_I42_P17_16 I2_I1_I42_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I83_XP_MN1 (VSS I2_I1_I42_pn16 I2_I1_I42_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I84_XP_MN0 (I2_I1_I42_P18_17 I2_I1_I42_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I84_XP_MN1 (VSS I2_I1_I42_pn17 I2_I1_I42_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I104_MN0 (I2_I2_nor17 A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I104_MN1 (VSS B_17 I2_I2_nor17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I98_MN0 (I2_I2_nor16 A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I98_MN1 (VSS B_16 I2_I2_nor16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2288_MN0 (I1_z2_2 I1_z1_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2288_MN1 (VSS I1_z1_5 I1_z2_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2273_MN0 (I1_z0_11 B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2273_MN1 (VSS B_23 I1_z0_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2272_MN0 (I1_z0_10 B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2272_MN1 (VSS B_21 I1_z0_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I152_MN0 (I2_I2_nor25 A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I152_MN1 (VSS B_25 I2_I2_nor25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I391_MN0 (I2_I3_q25_1 I2_I3_o25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I391_MN1 (VSS I2_I3_o25_1 I2_I3_q25_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I136_XP_MN0 (I1_I562_P11_4 I1_I562_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I136_XP_MN1 (VSS I1_I562_P7_4n I1_I562_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I138_XP_MN0 (I1_I562_P13_6 I1_I562_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I138_XP_MN1 (VSS I1_I562_P9_6n I1_I562_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I142_XP_MN0 (I1_I562_P17_10 I1_I562_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I142_XP_MN1 (VSS I1_I562_P13_10n I1_I562_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I146_XP_MN0 (I1_I562_P21_14 I1_I562_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I146_XP_MN1 (VSS I1_I562_P17_14n I1_I562_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I150_XP_MN0 (I1_I562_P25_18 I1_I562_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I150_XP_MN1 (VSS I1_I562_P21_18n I1_I562_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I148_XP_MN0 (I1_I562_P23_16 I1_I562_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I148_XP_MN1 (VSS I1_I562_P19_16n I1_I562_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I154_XP_MN0 (I1_I562_P29_22 I1_I562_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I154_XP_MN1 (VSS I1_I562_P25_22n I1_I562_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I91_XP_MN0 (I1_I562_P25_24 I1_I562_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I91_XP_MN1 (VSS I1_I562_pn24 I1_I562_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I95_XP_MN0 (I1_I1712_P29_28 I1_I1712_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I95_XP_MN1 (VSS I1_I1712_pn28 I1_I1712_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I93_XP_MN0 (I1_I1712_P27_26 I1_I1712_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I93_XP_MN1 (VSS I1_I1712_pn26 I1_I1712_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I142_XP_MN0 (I1_I1712_P17_10 I1_I1712_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I142_XP_MN1 (VSS I1_I1712_P13_10n I1_I1712_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I138_XP_MN0 (I1_I1712_P13_6 I1_I1712_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I138_XP_MN1 (VSS I1_I1712_P9_6n I1_I1712_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I97_XP_MN0 (I1_I1574_P31_30 I1_I1574_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I97_XP_MN1 (VSS I1_I1574_pn30 I1_I1574_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I154_XP_MN0 (I1_I1574_P29_22 I1_I1574_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I154_XP_MN1 (VSS I1_I1574_P25_22n I1_I1574_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I150_XP_MN0 (I1_I1574_P25_18 I1_I1574_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I150_XP_MN1 (VSS I1_I1574_P21_18n I1_I1574_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I83_XP_MN0 (I1_I1574_P17_16 I1_I1574_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I83_XP_MN1 (VSS I1_I1574_pn16 I1_I1574_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I80_XP_MN0 (I1_I1574_P14_13 I1_I1574_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I80_XP_MN1 (VSS I1_I1574_pn13 I1_I1574_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I76_XP_MN0 (I1_I1574_P10_9 I1_I1574_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I76_XP_MN1 (VSS I1_I1574_pn9 I1_I1574_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I74_XP_MN0 (I1_I1574_P8_7 I1_I1574_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I74_XP_MN1 (VSS I1_I1574_pn7 I1_I1574_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I72_XP_MN0 (I1_I1574_P6_5 I1_I1574_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I72_XP_MN1 (VSS I1_I1574_pn5 I1_I1574_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I69_XP_MN0 (I1_I1574_P3_2 I1_I1574_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I69_XP_MN1 (VSS I1_I1574_pn2 I1_I1574_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I80_MN0 (I2_I2_nor13 A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I80_MN1 (VSS B_13 I2_I2_nor13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I247_MN0 (I2_I3_q13_1 I2_I3_o13_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I247_MN1 (VSS I2_I3_o13_1 I2_I3_q13_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I271_MN0 (I2_I3_q15_1 I2_I3_o15_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I271_MN1 (VSS I2_I3_o15_1 I2_I3_q15_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I92_MN0 (I2_I2_nor15 A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I92_MN1 (VSS B_15 I2_I2_nor15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2267_MN0 (I1_z0_5 B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2267_MN1 (VSS B_11 I1_z0_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I80_XP_MN0 (I2_I1_I42_P14_13 I2_I1_I42_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I80_XP_MN1 (VSS I2_I1_I42_pn13 I2_I1_I42_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I145_XP_MN0 (I2_I1_I42_P20_13 I2_I1_I42_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I145_XP_MN1 (VSS I2_I1_I42_P16_13n I2_I1_I42_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I149_XP_MN0 (I2_I1_I42_P24_17 I2_I1_I42_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I149_XP_MN1 (VSS I2_I1_I42_P20_17n I2_I1_I42_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I147_XP_MN0 (I2_I1_I42_P22_15 I2_I1_I42_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I147_XP_MN1 (VSS I2_I1_I42_P18_15n I2_I1_I42_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I153_XP_MN0 (I2_I1_I42_P28_21 I2_I1_I42_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I153_XP_MN1 (VSS I2_I1_I42_P24_21n I2_I1_I42_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I89_XP_MN0 (I2_I1_I42_P23_22 I2_I1_I42_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I89_XP_MN1 (VSS I2_I1_I42_pn22 I2_I1_I42_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I90_XP_MN0 (I2_I1_I42_P24_23 I2_I1_I42_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I90_XP_MN1 (VSS I2_I1_I42_pn23 I2_I1_I42_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I92_XP_MN0 (I2_I1_I42_P26_25 I2_I1_I42_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I92_XP_MN1 (VSS I2_I1_I42_pn25 I2_I1_I42_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2292_MN0 (DIVDZ I1_z3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2292_MN1 (VSS I1_z3_1 DIVDZ VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2295_MN0 (DIVV I1_vn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2295_MN1 (VSS DIVDZ DIVV VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2271_MN0 (I1_z0_9 B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2271_MN1 (VSS B_19 I1_z0_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2270_MN0 (I1_z0_8 B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2270_MN1 (VSS B_17 I1_z0_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I379_MN0 (I2_I3_q24_1 I2_I3_o24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I379_MN1 (VSS I2_I3_o24_1 I2_I3_q24_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I415_MN0 (I2_I3_q27_1 I2_I3_o27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I415_MN1 (VSS I2_I3_o27_1 I2_I3_q27_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I439_MN0 (I2_I3_q29_1 I2_I3_o29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I439_MN1 (VSS I2_I3_o29_1 I2_I3_q29_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I427_MN0 (I2_I3_q28_1 I2_I3_o28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I427_MN1 (VSS I2_I3_o28_1 I2_I3_q28_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I140_XP_MN0 (I1_I562_P15_8 I1_I562_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I140_XP_MN1 (VSS I1_I562_P11_8n I1_I562_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I144_XP_MN0 (I1_I562_P19_12 I1_I562_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I144_XP_MN1 (VSS I1_I562_P15_12n I1_I562_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I152_XP_MN0 (I1_I562_P27_20 I1_I562_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I152_XP_MN1 (VSS I1_I562_P23_20n I1_I562_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I562_I156_XP_MN0 (I1_I562_P31_24 I1_I562_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I562_I156_XP_MN1 (VSS I1_I562_P27_24n I1_I562_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I94_XP_MN0 (I1_I1712_P28_27 I1_I1712_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I94_XP_MN1 (VSS I1_I1712_pn27 I1_I1712_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I92_XP_MN0 (I1_I1712_P26_25 I1_I1712_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I92_XP_MN1 (VSS I1_I1712_pn25 I1_I1712_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I91_XP_MN0 (I1_I1712_P25_24 I1_I1712_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I91_XP_MN1 (VSS I1_I1712_pn24 I1_I1712_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I153_XP_MN0 (I1_I1712_P28_21 I1_I1712_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I153_XP_MN1 (VSS I1_I1712_P24_21n I1_I1712_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I137_XP_MN0 (I1_I1712_P12_5 I1_I1712_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I137_XP_MN1 (VSS I1_I1712_P8_5n I1_I1712_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I77_XP_MN0 (I1_I1712_P11_10 I1_I1712_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I77_XP_MN1 (VSS I1_I1712_pn10 I1_I1712_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I75_XP_MN0 (I1_I1712_P9_8 I1_I1712_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I75_XP_MN1 (VSS I1_I1712_pn8 I1_I1712_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I73_XP_MN0 (I1_I1712_P7_6 I1_I1712_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I73_XP_MN1 (VSS I1_I1712_pn6 I1_I1712_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I133_XP_MN0 (I1_I1712_P8_1 I1_I1712_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I133_XP_MN1 (VSS I1_I1712_P4_1n I1_I1712_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I71_XP_MN0 (I1_I1712_P5_4 I1_I1712_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I71_XP_MN1 (VSS I1_I1712_pn4 I1_I1712_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I72_XP_MN0 (I1_I1712_P6_5 I1_I1712_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I72_XP_MN1 (VSS I1_I1712_pn5 I1_I1712_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I70_XP_MN0 (I1_I1712_P4_3 I1_I1712_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I70_XP_MN1 (VSS I1_I1712_pn3 I1_I1712_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I69_XP_MN0 (I1_I1712_P3_2 I1_I1712_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I69_XP_MN1 (VSS I1_I1712_pn2 I1_I1712_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I95_XP_MN0 (I1_I1574_P29_28 I1_I1574_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I95_XP_MN1 (VSS I1_I1574_pn28 I1_I1574_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I93_XP_MN0 (I1_I1574_P27_26 I1_I1574_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I93_XP_MN1 (VSS I1_I1574_pn26 I1_I1574_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I96_XP_MN0 (I1_I1574_P30_29 I1_I1574_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I96_XP_MN1 (VSS I1_I1574_pn29 I1_I1574_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I94_XP_MN0 (I1_I1574_P28_27 I1_I1574_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I94_XP_MN1 (VSS I1_I1574_pn27 I1_I1574_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I85_XP_MN0 (I1_I1574_P19_18 I1_I1574_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I85_XP_MN1 (VSS I1_I1574_pn18 I1_I1574_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I82_XP_MN0 (I1_I1574_P16_15 I1_I1574_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I82_XP_MN1 (VSS I1_I1574_pn15 I1_I1574_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I70_XP_MN0 (I1_I1574_P4_3 I1_I1574_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I70_XP_MN1 (VSS I1_I1574_pn3 I1_I1574_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I259_MN0 (I2_I3_q14_1 I2_I3_o14_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I259_MN1 (VSS I2_I3_o14_1 I2_I3_q14_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I79_XP_MN0 (I2_I1_I42_P13_12 I2_I1_I42_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I79_XP_MN1 (VSS I2_I1_I42_pn12 I2_I1_I42_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I139_XP_MN0 (I2_I1_I42_P14_7 I2_I1_I42_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I139_XP_MN1 (VSS I2_I1_I42_P10_7n I2_I1_I42_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I81_XP_MN0 (I2_I1_I42_P15_14 I2_I1_I42_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I81_XP_MN1 (VSS I2_I1_I42_pn14 I2_I1_I42_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I143_XP_MN0 (I2_I1_I42_P18_11 I2_I1_I42_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I143_XP_MN1 (VSS I2_I1_I42_P14_11n I2_I1_I42_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I151_XP_MN0 (I2_I1_I42_P26_19 I2_I1_I42_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I151_XP_MN1 (VSS I2_I1_I42_P22_19n I2_I1_I42_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I155_XP_MN0 (I2_I1_I42_P30_23 I2_I1_I42_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I155_XP_MN1 (VSS I2_I1_I42_P26_23n I2_I1_I42_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I91_XP_MN0 (I2_I1_I42_P25_24 I2_I1_I42_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I91_XP_MN1 (VSS I2_I1_I42_pn24 I2_I1_I42_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I93_XP_MN0 (I2_I1_I42_P27_26 I2_I1_I42_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I93_XP_MN1 (VSS I2_I1_I42_pn26 I2_I1_I42_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I94_XP_MN0 (I2_I1_I42_P28_27 I2_I1_I42_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I94_XP_MN1 (VSS I2_I1_I42_pn27 I2_I1_I42_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I96_XP_MN0 (I2_I1_I42_P30_29 I2_I1_I42_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I96_XP_MN1 (VSS I2_I1_I42_pn29 I2_I1_I42_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I13_MN0 (I2_SEL_OR I2_I0_h00 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I13_MN1 (VSS I2_I0_l11 I2_SEL_OR VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I14_MN0 (I2_SEL_XOR I2_I0_h01 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I14_MN1 (VSS I2_I0_l00 I2_SEL_XOR VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I12_MN0 (I2_SEL_AND I2_I0_h00 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I12_MN1 (VSS I2_I0_l10 I2_SEL_AND VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I146_MN0 (I2_I2_nor24 A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I146_MN1 (VSS B_24 I2_I2_nor24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I403_MN0 (I2_I3_q26_1 I2_I3_o26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I403_MN1 (VSS I2_I3_o26_1 I2_I3_q26_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I158_MN0 (I2_I2_nor26 A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I158_MN1 (VSS B_26 I2_I2_nor26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I170_MN0 (I2_I2_nor28 A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I170_MN1 (VSS B_28 I2_I2_nor28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I463_MN0 (I2_I3_q31_1 I2_I3_o31_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I463_MN1 (VSS I2_I3_o31_1 I2_I3_q31_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I51_MN0 (I2_I4_z2_3 I2_I4_z1_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I51_MN1 (VSS I2_I4_z1_7 I2_I4_z2_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I13_MN0 (I2_I4_z0_13 Y_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I13_MN1 (VSS Y_27 I2_I4_z0_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I15_MN0 (I2_I4_z0_15 Y_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I15_MN1 (VSS Y_31 I2_I4_z0_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I96_XP_MN0 (I1_I1712_P30_29 I1_I1712_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I96_XP_MN1 (VSS I1_I1712_pn29 I1_I1712_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I151_XP_MN0 (I1_I1712_P26_19 I1_I1712_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I151_XP_MN1 (VSS I1_I1712_P22_19n I1_I1712_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I149_XP_MN0 (I1_I1712_P24_17 I1_I1712_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I149_XP_MN1 (VSS I1_I1712_P20_17n I1_I1712_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I145_XP_MN0 (I1_I1712_P20_13 I1_I1712_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I145_XP_MN1 (VSS I1_I1712_P16_13n I1_I1712_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I141_XP_MN0 (I1_I1712_P16_9 I1_I1712_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I141_XP_MN1 (VSS I1_I1712_P12_9n I1_I1712_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I68_XP_MN0 (I1_I1712_P2_1 I1_I1712_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I68_XP_MN1 (VSS I1_I1712_pn1 I1_I1712_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I91_XP_MN0 (I1_I1574_P25_24 I1_I1574_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I91_XP_MN1 (VSS I1_I1574_pn24 I1_I1574_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I92_XP_MN0 (I1_I1574_P26_25 I1_I1574_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I92_XP_MN1 (VSS I1_I1574_pn25 I1_I1574_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I84_XP_MN0 (I1_I1574_P18_17 I1_I1574_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I84_XP_MN1 (VSS I1_I1574_pn17 I1_I1574_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I153_XP_MN0 (I1_I1574_P28_21 I1_I1574_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I153_XP_MN1 (VSS I1_I1574_P24_21n I1_I1574_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I145_XP_MN0 (I1_I1574_P20_13 I1_I1574_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I145_XP_MN1 (VSS I1_I1574_P16_13n I1_I1574_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I141_XP_MN0 (I1_I1574_P16_9 I1_I1574_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I141_XP_MN1 (VSS I1_I1574_P12_9n I1_I1574_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I137_XP_MN0 (I1_I1574_P12_5 I1_I1574_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I137_XP_MN1 (VSS I1_I1574_P8_5n I1_I1574_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I133_XP_MN0 (I1_I1574_P8_1 I1_I1574_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I133_XP_MN1 (VSS I1_I1574_P4_1n I1_I1574_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I7_MN0 (I2_I4_z0_7 Y_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I7_MN1 (VSS Y_15 I2_I4_z0_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I6_MN0 (I2_I4_z0_6 Y_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I6_MN1 (VSS Y_13 I2_I4_z0_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I235_MN0 (I2_I3_q12_1 I2_I3_o12_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I235_MN1 (VSS I2_I3_o12_1 I2_I3_q12_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I86_MN0 (I2_I2_nor14 A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I86_MN1 (VSS B_14 I2_I2_nor14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I78_XP_MN0 (I2_I1_I42_P12_11 I2_I1_I42_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I78_XP_MN1 (VSS I2_I1_I42_pn11 I2_I1_I42_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I141_XP_MN0 (I2_I1_I42_P16_9 I2_I1_I42_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I141_XP_MN1 (VSS I2_I1_I42_P12_9n I2_I1_I42_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I144_XP_MN0 (I2_I1_I42_P19_12 I2_I1_I42_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I144_XP_MN1 (VSS I2_I1_I42_P15_12n I2_I1_I42_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I148_XP_MN0 (I2_I1_I42_P23_16 I2_I1_I42_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I148_XP_MN1 (VSS I2_I1_I42_P19_16n I2_I1_I42_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I152_XP_MN0 (I2_I1_I42_P27_20 I2_I1_I42_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I152_XP_MN1 (VSS I2_I1_I42_P23_20n I2_I1_I42_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I154_XP_MN0 (I2_I1_I42_P29_22 I2_I1_I42_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I154_XP_MN1 (VSS I2_I1_I42_P25_22n I2_I1_I42_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I95_XP_MN0 (I2_I1_I42_P29_28 I2_I1_I42_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I95_XP_MN1 (VSS I2_I1_I42_pn28 I2_I1_I42_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I97_XP_MN0 (I2_I1_I42_P31_30 I2_I1_I42_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I97_XP_MN1 (VSS I2_I1_I42_pn30 I2_I1_I42_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I11_MN0 (I2_SEL_AS I2_I0_h00 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I11_MN1 (VSS OP_1 I2_SEL_AS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I17_MN0 (I2_SEL_DIV I2_I0_h10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I17_MN1 (VSS I2_I0_l11 I2_SEL_DIV VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I16_MN0 (I2_SEL_MUL I2_I0_h10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I16_MN1 (VSS I2_I0_l01 I2_SEL_MUL VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I0_I15_MN0 (I2_SEL_NOT I2_I0_h01 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I0_I15_MN1 (VSS I2_I0_l01 I2_SEL_NOT VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I182_MN0 (I2_I2_nor30 A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I182_MN1 (VSS B_30 I2_I2_nor30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I451_MN0 (I2_I3_q30_1 I2_I3_o30_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I451_MN1 (VSS I2_I3_o30_1 I2_I3_q30_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I188_MN0 (I2_I2_nor31 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I188_MN1 (VSS B_31 I2_I2_nor31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I90_XP_MN0 (I1_I1712_P24_23 I1_I1712_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I90_XP_MN1 (VSS I1_I1712_pn23 I1_I1712_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I155_XP_MN0 (I1_I1712_P30_23 I1_I1712_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I155_XP_MN1 (VSS I1_I1712_P26_23n I1_I1712_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I147_XP_MN0 (I1_I1712_P22_15 I1_I1712_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I147_XP_MN1 (VSS I1_I1712_P18_15n I1_I1712_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I143_XP_MN0 (I1_I1712_P18_11 I1_I1712_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I143_XP_MN1 (VSS I1_I1712_P14_11n I1_I1712_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I139_XP_MN0 (I1_I1712_P14_7 I1_I1712_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I139_XP_MN1 (VSS I1_I1712_P10_7n I1_I1712_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I135_XP_MN0 (I1_I1712_P10_3 I1_I1712_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I135_XP_MN1 (VSS I1_I1712_P6_3n I1_I1712_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I74_XP_MN0 (I1_I1712_P8_7 I1_I1712_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I74_XP_MN1 (VSS I1_I1712_pn7 I1_I1712_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I89_XP_MN0 (I1_I1574_P23_22 I1_I1574_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I89_XP_MN1 (VSS I1_I1574_pn22 I1_I1574_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I90_XP_MN0 (I1_I1574_P24_23 I1_I1574_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I90_XP_MN1 (VSS I1_I1574_pn23 I1_I1574_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I149_XP_MN0 (I1_I1574_P24_17 I1_I1574_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I149_XP_MN1 (VSS I1_I1574_P20_17n I1_I1574_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I68_XP_MN0 (I1_I1574_P2_1 I1_I1574_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I68_XP_MN1 (VSS I1_I1574_pn1 I1_I1574_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I74_MN0 (I2_I2_nor12 A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I74_MN1 (VSS B_12 I2_I2_nor12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I68_MN0 (I2_I2_nor11 A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I68_MN1 (VSS B_11 I2_I2_nor11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I223_MN0 (I2_I3_q11_1 I2_I3_o11_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I223_MN1 (VSS I2_I3_o11_1 I2_I3_q11_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2265_MN0 (I1_z0_3 B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2265_MN1 (VSS B_7 I1_z0_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I77_XP_MN0 (I2_I1_I42_P11_10 I2_I1_I42_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I77_XP_MN1 (VSS I2_I1_I42_pn10 I2_I1_I42_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I137_XP_MN0 (I2_I1_I42_P12_5 I2_I1_I42_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I137_XP_MN1 (VSS I2_I1_I42_P8_5n I2_I1_I42_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I140_XP_MN0 (I2_I1_I42_P15_8 I2_I1_I42_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I140_XP_MN1 (VSS I2_I1_I42_P11_8n I2_I1_I42_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I146_XP_MN0 (I2_I1_I42_P21_14 I2_I1_I42_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I146_XP_MN1 (VSS I2_I1_I42_P17_14n I2_I1_I42_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I150_XP_MN0 (I2_I1_I42_P25_18 I2_I1_I42_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I150_XP_MN1 (VSS I2_I1_I42_P21_18n I2_I1_I42_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I156_XP_MN0 (I2_I1_I42_P31_24 I2_I1_I42_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I156_XP_MN1 (VSS I2_I1_I42_P27_24n I2_I1_I42_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I89_XP_MN0 (I1_I1712_P23_22 I1_I1712_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I89_XP_MN1 (VSS I1_I1712_pn22 I1_I1712_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I88_XP_MN0 (I1_I1712_P22_21 I1_I1712_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I88_XP_MN1 (VSS I1_I1712_pn21 I1_I1712_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I86_XP_MN0 (I1_I1712_P20_19 I1_I1712_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I86_XP_MN1 (VSS I1_I1712_pn19 I1_I1712_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I85_XP_MN0 (I1_I1712_P19_18 I1_I1712_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I85_XP_MN1 (VSS I1_I1712_pn18 I1_I1712_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I78_XP_MN0 (I1_I1712_P12_11 I1_I1712_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I78_XP_MN1 (VSS I1_I1712_pn11 I1_I1712_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I76_XP_MN0 (I1_I1712_P10_9 I1_I1712_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I76_XP_MN1 (VSS I1_I1712_pn9 I1_I1712_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I87_XP_MN0 (I1_I1574_P21_20 I1_I1574_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I87_XP_MN1 (VSS I1_I1574_pn20 I1_I1574_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I86_XP_MN0 (I1_I1574_P20_19 I1_I1574_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I86_XP_MN1 (VSS I1_I1574_pn19 I1_I1574_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I155_XP_MN0 (I1_I1574_P30_23 I1_I1574_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I155_XP_MN1 (VSS I1_I1574_P26_23n I1_I1574_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I88_XP_MN0 (I1_I1574_P22_21 I1_I1574_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I88_XP_MN1 (VSS I1_I1574_pn21 I1_I1574_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I151_XP_MN0 (I1_I1574_P26_19 I1_I1574_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I151_XP_MN1 (VSS I1_I1574_P22_19n I1_I1574_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I147_XP_MN0 (I1_I1574_P22_15 I1_I1574_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I147_XP_MN1 (VSS I1_I1574_P18_15n I1_I1574_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I143_XP_MN0 (I1_I1574_P18_11 I1_I1574_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I143_XP_MN1 (VSS I1_I1574_P14_11n I1_I1574_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I139_XP_MN0 (I1_I1574_P14_7 I1_I1574_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I139_XP_MN1 (VSS I1_I1574_P10_7n I1_I1574_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1574_I135_XP_MN0 (I1_I1574_P10_3 I1_I1574_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1574_I135_XP_MN1 (VSS I1_I1574_P6_3n I1_I1574_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2286_MN0 (I1_z2_0 I1_z1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2286_MN1 (VSS I1_z1_1 I1_z2_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2263_MN0 (I1_z0_1 B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2263_MN1 (VSS B_3 I1_z0_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2264_MN0 (I1_z0_2 B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2264_MN1 (VSS B_5 I1_z0_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I76_XP_MN0 (I2_I1_I42_P10_9 I2_I1_I42_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I76_XP_MN1 (VSS I2_I1_I42_pn9 I2_I1_I42_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I135_XP_MN0 (I2_I1_I42_P10_3 I2_I1_I42_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I135_XP_MN1 (VSS I2_I1_I42_P6_3n I2_I1_I42_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I138_XP_MN0 (I2_I1_I42_P13_6 I2_I1_I42_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I138_XP_MN1 (VSS I2_I1_I42_P9_6n I2_I1_I42_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I136_XP_MN0 (I2_I1_I42_P11_4 I2_I1_I42_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I136_XP_MN1 (VSS I2_I1_I42_P7_4n I2_I1_I42_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I142_XP_MN0 (I2_I1_I42_P17_10 I2_I1_I42_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I142_XP_MN1 (VSS I2_I1_I42_P13_10n I2_I1_I42_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I87_XP_MN0 (I1_I1712_P21_20 I1_I1712_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I87_XP_MN1 (VSS I1_I1712_pn20 I1_I1712_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I84_XP_MN0 (I1_I1712_P18_17 I1_I1712_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I84_XP_MN1 (VSS I1_I1712_pn17 I1_I1712_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I81_XP_MN0 (I1_I1712_P15_14 I1_I1712_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I81_XP_MN1 (VSS I1_I1712_pn14 I1_I1712_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I83_XP_MN0 (I1_I1712_P17_16 I1_I1712_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I83_XP_MN1 (VSS I1_I1712_pn16 I1_I1712_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I82_XP_MN0 (I1_I1712_P16_15 I1_I1712_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I82_XP_MN1 (VSS I1_I1712_pn15 I1_I1712_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I79_XP_MN0 (I1_I1712_P13_12 I1_I1712_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I79_XP_MN1 (VSS I1_I1712_pn12 I1_I1712_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1712_I80_XP_MN0 (I1_I1712_P14_13 I1_I1712_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1712_I80_XP_MN1 (VSS I1_I1712_pn13 I1_I1712_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I68_XP_MN0 (I1_I1666_P2_1 I1_I1666_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I68_XP_MN1 (VSS I1_I1666_pn1 I1_I1666_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I70_XP_MN0 (I1_I1666_P4_3 I1_I1666_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I70_XP_MN1 (VSS I1_I1666_pn3 I1_I1666_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I69_XP_MN0 (I1_I1666_P3_2 I1_I1666_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I69_XP_MN1 (VSS I1_I1666_pn2 I1_I1666_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2262_MN0 (I1_z0_0 I1_B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2262_MN1 (VSS B_1 I1_z0_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I75_XP_MN0 (I2_I1_I42_P9_8 I2_I1_I42_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I75_XP_MN1 (VSS I2_I1_I42_pn8 I2_I1_I42_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I74_XP_MN0 (I2_I1_I42_P8_7 I2_I1_I42_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I74_XP_MN1 (VSS I2_I1_I42_pn7 I2_I1_I42_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I133_XP_MN0 (I2_I1_I42_P8_1 I2_I1_I42_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I133_XP_MN1 (VSS I2_I1_I42_P4_1n I2_I1_I42_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I134_XP_MN0 (I2_I1_I42_P9_2 I2_I1_I42_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I134_XP_MN1 (VSS I2_I1_I42_P5_2n I2_I1_I42_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I72_XP_MN0 (I1_I1666_P6_5 I1_I1666_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I72_XP_MN1 (VSS I1_I1666_pn5 I1_I1666_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I71_XP_MN0 (I1_I1666_P5_4 I1_I1666_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I71_XP_MN1 (VSS I1_I1666_pn4 I1_I1666_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I73_XP_MN0 (I2_I1_I42_P7_6 I2_I1_I42_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I73_XP_MN1 (VSS I2_I1_I42_pn6 I2_I1_I42_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I72_XP_MN0 (I2_I1_I42_P6_5 I2_I1_I42_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I72_XP_MN1 (VSS I2_I1_I42_pn5 I2_I1_I42_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I135_XP_MN0 (I1_I1666_P10_3 I1_I1666_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I135_XP_MN1 (VSS I1_I1666_P6_3n I1_I1666_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I133_XP_MN0 (I1_I1666_P8_1 I1_I1666_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I133_XP_MN1 (VSS I1_I1666_P4_1n I1_I1666_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I74_XP_MN0 (I1_I1666_P8_7 I1_I1666_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I74_XP_MN1 (VSS I1_I1666_pn7 I1_I1666_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I73_XP_MN0 (I1_I1666_P7_6 I1_I1666_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I73_XP_MN1 (VSS I1_I1666_pn6 I1_I1666_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I75_XP_MN0 (I1_I1666_P9_8 I1_I1666_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I75_XP_MN1 (VSS I1_I1666_pn8 I1_I1666_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I71_XP_MN0 (I2_I1_I42_P5_4 I2_I1_I42_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I71_XP_MN1 (VSS I2_I1_I42_pn4 I2_I1_I42_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I137_XP_MN0 (I1_I1666_P12_5 I1_I1666_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I137_XP_MN1 (VSS I1_I1666_P8_5n I1_I1666_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I76_XP_MN0 (I1_I1666_P10_9 I1_I1666_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I76_XP_MN1 (VSS I1_I1666_pn9 I1_I1666_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I134_XP_MN0 (I1_I1666_P9_2 I1_I1666_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I134_XP_MN1 (VSS I1_I1666_P5_2n I1_I1666_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I77_XP_MN0 (I1_I1666_P11_10 I1_I1666_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I77_XP_MN1 (VSS I1_I1666_pn10 I1_I1666_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I56_MN0 (I2_I2_nor9 A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I56_MN1 (VSS B_9 I2_I2_nor9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I50_MN0 (I2_I2_nor8 A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I50_MN1 (VSS B_8 I2_I2_nor8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I70_XP_MN0 (I2_I1_I42_P4_3 I2_I1_I42_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I70_XP_MN1 (VSS I2_I1_I42_pn3 I2_I1_I42_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I69_XP_MN0 (I2_I1_I42_P3_2 I2_I1_I42_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I69_XP_MN1 (VSS I2_I1_I42_pn2 I2_I1_I42_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I141_XP_MN0 (I1_I1666_P16_9 I1_I1666_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I141_XP_MN1 (VSS I1_I1666_P12_9n I1_I1666_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I78_XP_MN0 (I1_I1666_P12_11 I1_I1666_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I78_XP_MN1 (VSS I1_I1666_pn11 I1_I1666_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I136_XP_MN0 (I1_I1666_P11_4 I1_I1666_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I136_XP_MN1 (VSS I1_I1666_P7_4n I1_I1666_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I138_XP_MN0 (I1_I1666_P13_6 I1_I1666_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I138_XP_MN1 (VSS I1_I1666_P9_6n I1_I1666_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I79_XP_MN0 (I1_I1666_P13_12 I1_I1666_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I79_XP_MN1 (VSS I1_I1666_pn12 I1_I1666_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I74_XP_MN0 (I1_I1620_P8_7 I1_I1620_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I74_XP_MN1 (VSS I1_I1620_pn7 I1_I1620_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I73_XP_MN0 (I1_I1620_P7_6 I1_I1620_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I73_XP_MN1 (VSS I1_I1620_pn6 I1_I1620_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I72_XP_MN0 (I1_I1620_P6_5 I1_I1620_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I72_XP_MN1 (VSS I1_I1620_pn5 I1_I1620_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I69_XP_MN0 (I1_I1620_P3_2 I1_I1620_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I69_XP_MN1 (VSS I1_I1620_pn2 I1_I1620_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I68_XP_MN0 (I1_I1620_P2_1 I1_I1620_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I68_XP_MN1 (VSS I1_I1620_pn1 I1_I1620_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I1_I42_I68_XP_MN0 (I2_I1_I42_P2_1 I2_I1_I42_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I1_I42_I68_XP_MN1 (VSS I2_I1_I42_pn1 I2_I1_I42_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I91_XP_MN0 (I1_I1758_P25_24 I1_I1758_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I91_XP_MN1 (VSS I1_I1758_pn24 I1_I1758_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I143_XP_MN0 (I1_I1666_P18_11 I1_I1666_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I143_XP_MN1 (VSS I1_I1666_P14_11n I1_I1666_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I139_XP_MN0 (I1_I1666_P14_7 I1_I1666_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I139_XP_MN1 (VSS I1_I1666_P10_7n I1_I1666_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I145_XP_MN0 (I1_I1666_P20_13 I1_I1666_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I145_XP_MN1 (VSS I1_I1666_P16_13n I1_I1666_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I80_XP_MN0 (I1_I1666_P14_13 I1_I1666_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I80_XP_MN1 (VSS I1_I1666_pn13 I1_I1666_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I142_XP_MN0 (I1_I1666_P17_10 I1_I1666_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I142_XP_MN1 (VSS I1_I1666_P13_10n I1_I1666_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I81_XP_MN0 (I1_I1666_P15_14 I1_I1666_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I81_XP_MN1 (VSS I1_I1666_pn14 I1_I1666_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I80_XP_MN0 (I1_I1620_P14_13 I1_I1620_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I80_XP_MN1 (VSS I1_I1620_pn13 I1_I1620_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I79_XP_MN0 (I1_I1620_P13_12 I1_I1620_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I79_XP_MN1 (VSS I1_I1620_pn12 I1_I1620_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I78_XP_MN0 (I1_I1620_P12_11 I1_I1620_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I78_XP_MN1 (VSS I1_I1620_pn11 I1_I1620_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I77_XP_MN0 (I1_I1620_P11_10 I1_I1620_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I77_XP_MN1 (VSS I1_I1620_pn10 I1_I1620_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I76_XP_MN0 (I1_I1620_P10_9 I1_I1620_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I76_XP_MN1 (VSS I1_I1620_pn9 I1_I1620_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I75_XP_MN0 (I1_I1620_P9_8 I1_I1620_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I75_XP_MN1 (VSS I1_I1620_pn8 I1_I1620_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I71_XP_MN0 (I1_I1620_P5_4 I1_I1620_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I71_XP_MN1 (VSS I1_I1620_pn4 I1_I1620_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I70_XP_MN0 (I1_I1620_P4_3 I1_I1620_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I70_XP_MN1 (VSS I1_I1620_pn3 I1_I1620_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I62_MN0 (I2_I2_nor10 A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I62_MN1 (VSS B_10 I2_I2_nor10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I93_XP_MN0 (I1_I1758_P27_26 I1_I1758_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I93_XP_MN1 (VSS I1_I1758_pn26 I1_I1758_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I89_XP_MN0 (I1_I1758_P23_22 I1_I1758_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I89_XP_MN1 (VSS I1_I1758_pn22 I1_I1758_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I87_XP_MN0 (I1_I1758_P21_20 I1_I1758_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I87_XP_MN1 (VSS I1_I1758_pn20 I1_I1758_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I85_XP_MN0 (I1_I1758_P19_18 I1_I1758_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I85_XP_MN1 (VSS I1_I1758_pn18 I1_I1758_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I83_XP_MN0 (I1_I1758_P17_16 I1_I1758_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I83_XP_MN1 (VSS I1_I1758_pn16 I1_I1758_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I81_XP_MN0 (I1_I1758_P15_14 I1_I1758_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I81_XP_MN1 (VSS I1_I1758_pn14 I1_I1758_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I149_XP_MN0 (I1_I1666_P24_17 I1_I1666_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I149_XP_MN1 (VSS I1_I1666_P20_17n I1_I1666_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I82_XP_MN0 (I1_I1666_P16_15 I1_I1666_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I82_XP_MN1 (VSS I1_I1666_pn15 I1_I1666_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I140_XP_MN0 (I1_I1666_P15_8 I1_I1666_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I140_XP_MN1 (VSS I1_I1666_P11_8n I1_I1666_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I83_XP_MN0 (I1_I1666_P17_16 I1_I1666_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I83_XP_MN1 (VSS I1_I1666_pn16 I1_I1666_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I139_XP_MN0 (I1_I1620_P14_7 I1_I1620_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I139_XP_MN1 (VSS I1_I1620_P10_7n I1_I1620_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I135_XP_MN0 (I1_I1620_P10_3 I1_I1620_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I135_XP_MN1 (VSS I1_I1620_P6_3n I1_I1620_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I82_XP_MN0 (I1_I1620_P16_15 I1_I1620_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I82_XP_MN1 (VSS I1_I1620_pn15 I1_I1620_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I137_XP_MN0 (I1_I1620_P12_5 I1_I1620_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I137_XP_MN1 (VSS I1_I1620_P8_5n I1_I1620_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I133_XP_MN0 (I1_I1620_P8_1 I1_I1620_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I133_XP_MN1 (VSS I1_I1620_P4_1n I1_I1620_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I211_MN0 (I2_I3_q10_1 I2_I3_o10_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I211_MN1 (VSS I2_I3_o10_1 I2_I3_q10_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I175_MN0 (I2_I3_q7_1 I2_I3_o7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I175_MN1 (VSS I2_I3_o7_1 I2_I3_q7_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I44_MN0 (I2_I2_nor7 A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I44_MN1 (VSS B_7 I2_I2_nor7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I163_MN0 (I2_I3_q6_1 I2_I3_o6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I163_MN1 (VSS I2_I3_o6_1 I2_I3_q6_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I38_MN0 (I2_I2_nor6 A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I38_MN1 (VSS B_6 I2_I2_nor6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I97_XP_MN0 (I1_I1758_P31_30 I1_I1758_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I97_XP_MN1 (VSS I1_I1758_pn30 I1_I1758_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I95_XP_MN0 (I1_I1758_P29_28 I1_I1758_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I95_XP_MN1 (VSS I1_I1758_pn28 I1_I1758_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I156_XP_MN0 (I1_I1758_P31_24 I1_I1758_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I156_XP_MN1 (VSS I1_I1758_P27_24n I1_I1758_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I154_XP_MN0 (I1_I1758_P29_22 I1_I1758_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I154_XP_MN1 (VSS I1_I1758_P25_22n I1_I1758_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I148_XP_MN0 (I1_I1758_P23_16 I1_I1758_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I148_XP_MN1 (VSS I1_I1758_P19_16n I1_I1758_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I152_XP_MN0 (I1_I1758_P27_20 I1_I1758_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I152_XP_MN1 (VSS I1_I1758_P23_20n I1_I1758_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I150_XP_MN0 (I1_I1758_P25_18 I1_I1758_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I150_XP_MN1 (VSS I1_I1758_P21_18n I1_I1758_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I144_XP_MN0 (I1_I1758_P19_12 I1_I1758_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I144_XP_MN1 (VSS I1_I1758_P15_12n I1_I1758_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I79_XP_MN0 (I1_I1758_P13_12 I1_I1758_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I79_XP_MN1 (VSS I1_I1758_pn12 I1_I1758_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I77_XP_MN0 (I1_I1758_P11_10 I1_I1758_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I77_XP_MN1 (VSS I1_I1758_pn10 I1_I1758_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I147_XP_MN0 (I1_I1666_P22_15 I1_I1666_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I147_XP_MN1 (VSS I1_I1666_P18_15n I1_I1666_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I84_XP_MN0 (I1_I1666_P18_17 I1_I1666_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I84_XP_MN1 (VSS I1_I1666_pn17 I1_I1666_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I86_XP_MN0 (I1_I1666_P20_19 I1_I1666_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I86_XP_MN1 (VSS I1_I1666_pn19 I1_I1666_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I150_XP_MN0 (I1_I1666_P25_18 I1_I1666_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I150_XP_MN1 (VSS I1_I1666_P21_18n I1_I1666_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I85_XP_MN0 (I1_I1666_P19_18 I1_I1666_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I85_XP_MN1 (VSS I1_I1666_pn18 I1_I1666_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I143_XP_MN0 (I1_I1620_P18_11 I1_I1620_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I143_XP_MN1 (VSS I1_I1620_P14_11n I1_I1620_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I81_XP_MN0 (I1_I1620_P15_14 I1_I1620_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I81_XP_MN1 (VSS I1_I1620_pn14 I1_I1620_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I141_XP_MN0 (I1_I1620_P16_9 I1_I1620_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I141_XP_MN1 (VSS I1_I1620_P12_9n I1_I1620_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I134_XP_MN0 (I1_I1620_P9_2 I1_I1620_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I134_XP_MN1 (VSS I1_I1620_P5_2n I1_I1620_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I146_XP_MN0 (I1_I1758_P21_14 I1_I1758_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I146_XP_MN1 (VSS I1_I1758_P17_14n I1_I1758_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I140_XP_MN0 (I1_I1758_P15_8 I1_I1758_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I140_XP_MN1 (VSS I1_I1758_P11_8n I1_I1758_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I142_XP_MN0 (I1_I1758_P17_10 I1_I1758_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I142_XP_MN1 (VSS I1_I1758_P13_10n I1_I1758_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I136_XP_MN0 (I1_I1758_P11_4 I1_I1758_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I136_XP_MN1 (VSS I1_I1758_P7_4n I1_I1758_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I75_XP_MN0 (I1_I1758_P9_8 I1_I1758_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I75_XP_MN1 (VSS I1_I1758_pn8 I1_I1758_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I73_XP_MN0 (I1_I1758_P7_6 I1_I1758_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I73_XP_MN1 (VSS I1_I1758_pn6 I1_I1758_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I151_XP_MN0 (I1_I1666_P26_19 I1_I1666_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I151_XP_MN1 (VSS I1_I1666_P22_19n I1_I1666_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I152_XP_MN0 (I1_I1666_P27_20 I1_I1666_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I152_XP_MN1 (VSS I1_I1666_P23_20n I1_I1666_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I148_XP_MN0 (I1_I1666_P23_16 I1_I1666_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I148_XP_MN1 (VSS I1_I1666_P19_16n I1_I1666_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I87_XP_MN0 (I1_I1666_P21_20 I1_I1666_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I87_XP_MN1 (VSS I1_I1666_pn20 I1_I1666_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I147_XP_MN0 (I1_I1620_P22_15 I1_I1620_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I147_XP_MN1 (VSS I1_I1620_P18_15n I1_I1620_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I84_XP_MN0 (I1_I1620_P18_17 I1_I1620_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I84_XP_MN1 (VSS I1_I1620_pn17 I1_I1620_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I83_XP_MN0 (I1_I1620_P17_16 I1_I1620_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I83_XP_MN1 (VSS I1_I1620_pn16 I1_I1620_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I145_XP_MN0 (I1_I1620_P20_13 I1_I1620_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I145_XP_MN1 (VSS I1_I1620_P16_13n I1_I1620_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I136_XP_MN0 (I1_I1620_P11_4 I1_I1620_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I136_XP_MN1 (VSS I1_I1620_P7_4n I1_I1620_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I199_MN0 (I2_I3_q9_1 I2_I3_o9_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I199_MN1 (VSS I2_I3_o9_1 I2_I3_q9_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I187_MN0 (I2_I3_q8_1 I2_I3_o8_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I187_MN1 (VSS I2_I3_o8_1 I2_I3_q8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I96_XP_MN0 (I1_I1758_P30_29 I1_I1758_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I96_XP_MN1 (VSS I1_I1758_pn29 I1_I1758_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I92_XP_MN0 (I1_I1758_P26_25 I1_I1758_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I92_XP_MN1 (VSS I1_I1758_pn25 I1_I1758_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I90_XP_MN0 (I1_I1758_P24_23 I1_I1758_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I90_XP_MN1 (VSS I1_I1758_pn23 I1_I1758_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I86_XP_MN0 (I1_I1758_P20_19 I1_I1758_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I86_XP_MN1 (VSS I1_I1758_pn19 I1_I1758_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I82_XP_MN0 (I1_I1758_P16_15 I1_I1758_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I82_XP_MN1 (VSS I1_I1758_pn15 I1_I1758_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I138_XP_MN0 (I1_I1758_P13_6 I1_I1758_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I138_XP_MN1 (VSS I1_I1758_P9_6n I1_I1758_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I80_XP_MN0 (I1_I1758_P14_13 I1_I1758_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I80_XP_MN1 (VSS I1_I1758_pn13 I1_I1758_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I134_XP_MN0 (I1_I1758_P9_2 I1_I1758_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I134_XP_MN1 (VSS I1_I1758_P5_2n I1_I1758_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I155_XP_MN0 (I1_I1666_P30_23 I1_I1666_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I155_XP_MN1 (VSS I1_I1666_P26_23n I1_I1666_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I153_XP_MN0 (I1_I1666_P28_21 I1_I1666_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I153_XP_MN1 (VSS I1_I1666_P24_21n I1_I1666_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I90_XP_MN0 (I1_I1666_P24_23 I1_I1666_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I90_XP_MN1 (VSS I1_I1666_pn23 I1_I1666_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I88_XP_MN0 (I1_I1666_P22_21 I1_I1666_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I88_XP_MN1 (VSS I1_I1666_pn21 I1_I1666_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I154_XP_MN0 (I1_I1666_P29_22 I1_I1666_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I154_XP_MN1 (VSS I1_I1666_P25_22n I1_I1666_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I89_XP_MN0 (I1_I1666_P23_22 I1_I1666_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I89_XP_MN1 (VSS I1_I1666_pn22 I1_I1666_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I151_XP_MN0 (I1_I1620_P26_19 I1_I1620_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I151_XP_MN1 (VSS I1_I1620_P22_19n I1_I1620_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I86_XP_MN0 (I1_I1620_P20_19 I1_I1620_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I86_XP_MN1 (VSS I1_I1620_pn19 I1_I1620_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I85_XP_MN0 (I1_I1620_P19_18 I1_I1620_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I85_XP_MN1 (VSS I1_I1620_pn18 I1_I1620_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I149_XP_MN0 (I1_I1620_P24_17 I1_I1620_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I149_XP_MN1 (VSS I1_I1620_P20_17n I1_I1620_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I140_XP_MN0 (I1_I1620_P15_8 I1_I1620_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I140_XP_MN1 (VSS I1_I1620_P11_8n I1_I1620_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I142_XP_MN0 (I1_I1620_P17_10 I1_I1620_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I142_XP_MN1 (VSS I1_I1620_P13_10n I1_I1620_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I138_XP_MN0 (I1_I1620_P13_6 I1_I1620_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I138_XP_MN1 (VSS I1_I1620_P9_6n I1_I1620_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I32_MN0 (I2_I2_nor5 A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I32_MN1 (VSS B_5 I2_I2_nor5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I49_MN0 (I2_I4_z2_1 I2_I4_z1_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I49_MN1 (VSS I2_I4_z1_3 I2_I4_z2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I5_MN0 (I2_I4_z0_5 Y_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I5_MN1 (VSS Y_11 I2_I4_z0_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I155_XP_MN0 (I1_I1758_P30_23 I1_I1758_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I155_XP_MN1 (VSS I1_I1758_P26_23n I1_I1758_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I94_XP_MN0 (I1_I1758_P28_27 I1_I1758_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I94_XP_MN1 (VSS I1_I1758_pn27 I1_I1758_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I151_XP_MN0 (I1_I1758_P26_19 I1_I1758_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I151_XP_MN1 (VSS I1_I1758_P22_19n I1_I1758_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I88_XP_MN0 (I1_I1758_P22_21 I1_I1758_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I88_XP_MN1 (VSS I1_I1758_pn21 I1_I1758_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I84_XP_MN0 (I1_I1758_P18_17 I1_I1758_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I84_XP_MN1 (VSS I1_I1758_pn17 I1_I1758_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I76_XP_MN0 (I1_I1758_P10_9 I1_I1758_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I76_XP_MN1 (VSS I1_I1758_pn9 I1_I1758_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I74_XP_MN0 (I1_I1758_P8_7 I1_I1758_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I74_XP_MN1 (VSS I1_I1758_pn7 I1_I1758_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I72_XP_MN0 (I1_I1758_P6_5 I1_I1758_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I72_XP_MN1 (VSS I1_I1758_pn5 I1_I1758_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I71_XP_MN0 (I1_I1758_P5_4 I1_I1758_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I71_XP_MN1 (VSS I1_I1758_pn4 I1_I1758_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I92_XP_MN0 (I1_I1666_P26_25 I1_I1666_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I92_XP_MN1 (VSS I1_I1666_pn25 I1_I1666_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I95_XP_MN0 (I1_I1666_P29_28 I1_I1666_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I95_XP_MN1 (VSS I1_I1666_pn28 I1_I1666_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I156_XP_MN0 (I1_I1666_P31_24 I1_I1666_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I156_XP_MN1 (VSS I1_I1666_P27_24n I1_I1666_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I91_XP_MN0 (I1_I1666_P25_24 I1_I1666_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I91_XP_MN1 (VSS I1_I1666_pn24 I1_I1666_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I88_XP_MN0 (I1_I1620_P22_21 I1_I1620_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I88_XP_MN1 (VSS I1_I1620_pn21 I1_I1620_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I87_XP_MN0 (I1_I1620_P21_20 I1_I1620_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I87_XP_MN1 (VSS I1_I1620_pn20 I1_I1620_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I144_XP_MN0 (I1_I1620_P19_12 I1_I1620_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I144_XP_MN1 (VSS I1_I1620_P15_12n I1_I1620_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I146_XP_MN0 (I1_I1620_P21_14 I1_I1620_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I146_XP_MN1 (VSS I1_I1620_P17_14n I1_I1620_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I4_MN0 (I2_I4_z0_4 Y_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I4_MN1 (VSS Y_9 I2_I4_z0_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I2_MN0 (I2_I2_nor0 A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I2_MN1 (VSS B_0 I2_I2_nor0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I153_XP_MN0 (I1_I1758_P28_21 I1_I1758_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I153_XP_MN1 (VSS I1_I1758_P24_21n I1_I1758_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I147_XP_MN0 (I1_I1758_P22_15 I1_I1758_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I147_XP_MN1 (VSS I1_I1758_P18_15n I1_I1758_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I149_XP_MN0 (I1_I1758_P24_17 I1_I1758_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I149_XP_MN1 (VSS I1_I1758_P20_17n I1_I1758_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I145_XP_MN0 (I1_I1758_P20_13 I1_I1758_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I145_XP_MN1 (VSS I1_I1758_P16_13n I1_I1758_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I143_XP_MN0 (I1_I1758_P18_11 I1_I1758_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I143_XP_MN1 (VSS I1_I1758_P14_11n I1_I1758_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I139_XP_MN0 (I1_I1758_P14_7 I1_I1758_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I139_XP_MN1 (VSS I1_I1758_P10_7n I1_I1758_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I141_XP_MN0 (I1_I1758_P16_9 I1_I1758_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I141_XP_MN1 (VSS I1_I1758_P12_9n I1_I1758_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I78_XP_MN0 (I1_I1758_P12_11 I1_I1758_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I78_XP_MN1 (VSS I1_I1758_pn11 I1_I1758_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I69_XP_MN0 (I1_I1758_P3_2 I1_I1758_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I69_XP_MN1 (VSS I1_I1758_pn2 I1_I1758_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I97_XP_MN0 (I1_I1666_P31_30 I1_I1666_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I97_XP_MN1 (VSS I1_I1666_pn30 I1_I1666_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I94_XP_MN0 (I1_I1666_P28_27 I1_I1666_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I94_XP_MN1 (VSS I1_I1666_pn27 I1_I1666_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I93_XP_MN0 (I1_I1666_P27_26 I1_I1666_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I93_XP_MN1 (VSS I1_I1666_pn26 I1_I1666_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I89_XP_MN0 (I1_I1620_P23_22 I1_I1620_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I89_XP_MN1 (VSS I1_I1620_pn22 I1_I1620_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I153_XP_MN0 (I1_I1620_P28_21 I1_I1620_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I153_XP_MN1 (VSS I1_I1620_P24_21n I1_I1620_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I148_XP_MN0 (I1_I1620_P23_16 I1_I1620_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I148_XP_MN1 (VSS I1_I1620_P19_16n I1_I1620_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I150_XP_MN0 (I1_I1620_P25_18 I1_I1620_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I150_XP_MN1 (VSS I1_I1620_P21_18n I1_I1620_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I151_MN0 (I2_I3_q5_1 I2_I3_o5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I151_MN1 (VSS I2_I3_o5_1 I2_I3_q5_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I91_MN0 (I2_I3_q0_1 I2_I3_o0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I91_MN1 (VSS I2_I3_o0_1 I2_I3_q0_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I137_XP_MN0 (I1_I1758_P12_5 I1_I1758_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I137_XP_MN1 (VSS I1_I1758_P8_5n I1_I1758_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I135_XP_MN0 (I1_I1758_P10_3 I1_I1758_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I135_XP_MN1 (VSS I1_I1758_P6_3n I1_I1758_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I133_XP_MN0 (I1_I1758_P8_1 I1_I1758_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I133_XP_MN1 (VSS I1_I1758_P4_1n I1_I1758_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I70_XP_MN0 (I1_I1758_P4_3 I1_I1758_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I70_XP_MN1 (VSS I1_I1758_pn3 I1_I1758_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1666_I96_XP_MN0 (I1_I1666_P30_29 I1_I1666_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1666_I96_XP_MN1 (VSS I1_I1666_pn29 I1_I1666_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I155_XP_MN0 (I1_I1620_P30_23 I1_I1620_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I155_XP_MN1 (VSS I1_I1620_P26_23n I1_I1620_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I90_XP_MN0 (I1_I1620_P24_23 I1_I1620_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I90_XP_MN1 (VSS I1_I1620_pn23 I1_I1620_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I8_MN0 (I2_I2_nor1 A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I8_MN1 (VSS B_1 I2_I2_nor1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I14_MN0 (I2_I2_nor2 A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I14_MN1 (VSS B_2 I2_I2_nor2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I26_MN0 (I2_I2_nor4 A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I26_MN1 (VSS B_4 I2_I2_nor4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1758_I68_XP_MN0 (I1_I1758_P2_1 I1_I1758_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1758_I68_XP_MN1 (VSS I1_I1758_pn1 I1_I1758_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I92_XP_MN0 (I1_I1620_P26_25 I1_I1620_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I92_XP_MN1 (VSS I1_I1620_pn25 I1_I1620_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I91_XP_MN0 (I1_I1620_P25_24 I1_I1620_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I91_XP_MN1 (VSS I1_I1620_pn24 I1_I1620_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I156_XP_MN0 (I1_I1620_P31_24 I1_I1620_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I156_XP_MN1 (VSS I1_I1620_P27_24n I1_I1620_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I152_XP_MN0 (I1_I1620_P27_20 I1_I1620_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I152_XP_MN1 (VSS I1_I1620_P23_20n I1_I1620_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I154_XP_MN0 (I1_I1620_P29_22 I1_I1620_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I154_XP_MN1 (VSS I1_I1620_P25_22n I1_I1620_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I2_I20_MN0 (I2_I2_nor3 A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I2_I20_MN1 (VSS B_3 I2_I2_nor3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I139_MN0 (I2_I3_q4_1 I2_I3_o4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I139_MN1 (VSS I2_I3_o4_1 I2_I3_q4_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I97_XP_MN0 (I1_I1620_P31_30 I1_I1620_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I97_XP_MN1 (VSS I1_I1620_pn30 I1_I1620_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I96_XP_MN0 (I1_I1620_P30_29 I1_I1620_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I96_XP_MN1 (VSS I1_I1620_pn29 I1_I1620_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I95_XP_MN0 (I1_I1620_P29_28 I1_I1620_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I95_XP_MN1 (VSS I1_I1620_pn28 I1_I1620_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I94_XP_MN0 (I1_I1620_P28_27 I1_I1620_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I94_XP_MN1 (VSS I1_I1620_pn27 I1_I1620_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1620_I93_XP_MN0 (I1_I1620_P27_26 I1_I1620_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1620_I93_XP_MN1 (VSS I1_I1620_pn26 I1_I1620_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I103_MN0 (I2_I3_q1_1 I2_I3_o1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I103_MN1 (VSS I2_I3_o1_1 I2_I3_q1_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I127_MN0 (I2_I3_q3_1 I2_I3_o3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I127_MN1 (VSS I2_I3_o3_1 I2_I3_q3_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I115_MN0 (I2_I3_q2_1 I2_I3_o2_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I115_MN1 (VSS I2_I3_o2_1 I2_I3_q2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I84_XP_MN0 (I1_I1804_P18_17 I1_I1804_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I84_XP_MN1 (VSS I1_I1804_pn17 I1_I1804_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I80_XP_MN0 (I1_I1804_P14_13 I1_I1804_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I80_XP_MN1 (VSS I1_I1804_pn13 I1_I1804_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I78_XP_MN0 (I1_I1804_P12_11 I1_I1804_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I78_XP_MN1 (VSS I1_I1804_pn11 I1_I1804_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I48_MN0 (I2_I4_z2_0 I2_I4_z1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I48_MN1 (VSS I2_I4_z1_1 I2_I4_z2_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I3_MN0 (I2_I4_z0_3 Y_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I3_MN1 (VSS Y_7 I2_I4_z0_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I2_MN0 (I2_I4_z0_2 Y_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I2_MN1 (VSS Y_5 I2_I4_z0_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I60_MN0 (I2_I4_z4_0 I2_I4_z3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I60_MN1 (VSS I2_I4_z3_1 I2_I4_z4_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I90_XP_MN0 (I1_I1804_P24_23 I1_I1804_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I90_XP_MN1 (VSS I1_I1804_pn23 I1_I1804_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I88_XP_MN0 (I1_I1804_P22_21 I1_I1804_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I88_XP_MN1 (VSS I1_I1804_pn21 I1_I1804_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I86_XP_MN0 (I1_I1804_P20_19 I1_I1804_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I86_XP_MN1 (VSS I1_I1804_pn19 I1_I1804_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I82_XP_MN0 (I1_I1804_P16_15 I1_I1804_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I82_XP_MN1 (VSS I1_I1804_pn15 I1_I1804_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I76_XP_MN0 (I1_I1804_P10_9 I1_I1804_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I76_XP_MN1 (VSS I1_I1804_pn9 I1_I1804_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I74_XP_MN0 (I1_I1804_P8_7 I1_I1804_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I74_XP_MN1 (VSS I1_I1804_pn7 I1_I1804_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I72_XP_MN0 (I1_I1804_P6_5 I1_I1804_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I72_XP_MN1 (VSS I1_I1804_pn5 I1_I1804_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I70_XP_MN0 (I1_I1804_P4_3 I1_I1804_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I70_XP_MN1 (VSS I1_I1804_pn3 I1_I1804_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I68_XP_MN0 (I1_I1804_P2_1 I1_I1804_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I68_XP_MN1 (VSS I1_I1804_pn1 I1_I1804_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I1_MN0 (I2_I4_z0_1 Y_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I1_MN1 (VSS Y_3 I2_I4_z0_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I94_XP_MN0 (I1_I1804_P28_27 I1_I1804_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I94_XP_MN1 (VSS I1_I1804_pn27 I1_I1804_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I92_XP_MN0 (I1_I1804_P26_25 I1_I1804_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I92_XP_MN1 (VSS I1_I1804_pn25 I1_I1804_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I153_XP_MN0 (I1_I1804_P28_21 I1_I1804_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I153_XP_MN1 (VSS I1_I1804_P24_21n I1_I1804_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I151_XP_MN0 (I1_I1804_P26_19 I1_I1804_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I151_XP_MN1 (VSS I1_I1804_P22_19n I1_I1804_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I147_XP_MN0 (I1_I1804_P22_15 I1_I1804_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I147_XP_MN1 (VSS I1_I1804_P18_15n I1_I1804_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I149_XP_MN0 (I1_I1804_P24_17 I1_I1804_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I149_XP_MN1 (VSS I1_I1804_P20_17n I1_I1804_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I145_XP_MN0 (I1_I1804_P20_13 I1_I1804_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I145_XP_MN1 (VSS I1_I1804_P16_13n I1_I1804_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I141_XP_MN0 (I1_I1804_P16_9 I1_I1804_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I141_XP_MN1 (VSS I1_I1804_P12_9n I1_I1804_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I137_XP_MN0 (I1_I1804_P12_5 I1_I1804_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I137_XP_MN1 (VSS I1_I1804_P8_5n I1_I1804_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I133_XP_MN0 (I1_I1804_P8_1 I1_I1804_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I133_XP_MN1 (VSS I1_I1804_P4_1n I1_I1804_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I69_XP_MN0 (I1_I1804_P3_2 I1_I1804_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I69_XP_MN1 (VSS I1_I1804_pn2 I1_I1804_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I68_XP_MN0 (I1_I1896_P2_1 I1_I1896_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I68_XP_MN1 (VSS I1_I1896_pn1 I1_I1896_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I70_XP_MN0 (I1_I1942_P4_3 I1_I1942_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I70_XP_MN1 (VSS I1_I1942_pn3 I1_I1942_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I69_XP_MN0 (I1_I1942_P3_2 I1_I1942_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I69_XP_MN1 (VSS I1_I1942_pn2 I1_I1942_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I68_XP_MN0 (I1_I1942_P2_1 I1_I1942_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I68_XP_MN1 (VSS I1_I1942_pn1 I1_I1942_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I0_MN0 (I2_I4_z0_0 Y_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I0_MN1 (VSS Y_1 I2_I4_z0_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I96_XP_MN0 (I1_I1804_P30_29 I1_I1804_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I96_XP_MN1 (VSS I1_I1804_pn29 I1_I1804_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I155_XP_MN0 (I1_I1804_P30_23 I1_I1804_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I155_XP_MN1 (VSS I1_I1804_P26_23n I1_I1804_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I143_XP_MN0 (I1_I1804_P18_11 I1_I1804_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I143_XP_MN1 (VSS I1_I1804_P14_11n I1_I1804_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I139_XP_MN0 (I1_I1804_P14_7 I1_I1804_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I139_XP_MN1 (VSS I1_I1804_P10_7n I1_I1804_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I135_XP_MN0 (I1_I1804_P10_3 I1_I1804_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I135_XP_MN1 (VSS I1_I1804_P6_3n I1_I1804_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I73_XP_MN0 (I1_I1804_P7_6 I1_I1804_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I73_XP_MN1 (VSS I1_I1804_pn6 I1_I1804_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I71_XP_MN0 (I1_I1804_P5_4 I1_I1804_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I71_XP_MN1 (VSS I1_I1804_pn4 I1_I1804_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I69_XP_MN0 (I1_I1896_P3_2 I1_I1896_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I69_XP_MN1 (VSS I1_I1896_pn2 I1_I1896_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I71_XP_MN0 (I1_I1942_P5_4 I1_I1942_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I71_XP_MN1 (VSS I1_I1942_pn4 I1_I1942_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I72_XP_MN0 (I1_I1942_P6_5 I1_I1942_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I72_XP_MN1 (VSS I1_I1942_pn5 I1_I1942_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I71_XP_MN0 (I1_I1988_P5_4 I1_I1988_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I71_XP_MN1 (VSS I1_I1988_pn4 I1_I1988_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I69_XP_MN0 (I1_I1988_P3_2 I1_I1988_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I69_XP_MN1 (VSS I1_I1988_pn2 I1_I1988_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I70_XP_MN0 (I1_I1988_P4_3 I1_I1988_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I70_XP_MN1 (VSS I1_I1988_pn3 I1_I1988_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I68_XP_MN0 (I1_I1988_P2_1 I1_I1988_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I68_XP_MN1 (VSS I1_I1988_pn1 I1_I1988_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I137_XP_MN0 (I0_I1660_P7_6 I0_I1660_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I137_XP_MN1 (VSS I0_I1660_pn6 I0_I1660_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I138_XP_MN0 (I0_I1660_P8_7 I0_I1660_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I138_XP_MN1 (VSS I0_I1660_pn7 I0_I1660_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I139_XP_MN0 (I0_I1660_P9_8 I0_I1660_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I139_XP_MN1 (VSS I0_I1660_pn8 I0_I1660_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I140_XP_MN0 (I0_I1660_P10_9 I0_I1660_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I140_XP_MN1 (VSS I0_I1660_pn9 I0_I1660_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I141_XP_MN0 (I0_I1660_P11_10 I0_I1660_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I141_XP_MN1 (VSS I0_I1660_pn10 I0_I1660_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I142_XP_MN0 (I0_I1660_P12_11 I0_I1660_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I142_XP_MN1 (VSS I0_I1660_pn11 I0_I1660_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I143_XP_MN0 (I0_I1660_P13_12 I0_I1660_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I143_XP_MN1 (VSS I0_I1660_pn12 I0_I1660_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I144_XP_MN0 (I0_I1660_P14_13 I0_I1660_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I144_XP_MN1 (VSS I0_I1660_pn13 I0_I1660_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I145_XP_MN0 (I0_I1660_P15_14 I0_I1660_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I145_XP_MN1 (VSS I0_I1660_pn14 I0_I1660_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I146_XP_MN0 (I0_I1660_P16_15 I0_I1660_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I146_XP_MN1 (VSS I0_I1660_pn15 I0_I1660_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I147_XP_MN0 (I0_I1660_P17_16 I0_I1660_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I147_XP_MN1 (VSS I0_I1660_pn16 I0_I1660_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I148_XP_MN0 (I0_I1660_P18_17 I0_I1660_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I148_XP_MN1 (VSS I0_I1660_pn17 I0_I1660_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I149_XP_MN0 (I0_I1660_P19_18 I0_I1660_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I149_XP_MN1 (VSS I0_I1660_pn18 I0_I1660_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I150_XP_MN0 (I0_I1660_P20_19 I0_I1660_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I150_XP_MN1 (VSS I0_I1660_pn19 I0_I1660_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I151_XP_MN0 (I0_I1660_P21_20 I0_I1660_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I151_XP_MN1 (VSS I0_I1660_pn20 I0_I1660_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I152_XP_MN0 (I0_I1660_P22_21 I0_I1660_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I152_XP_MN1 (VSS I0_I1660_pn21 I0_I1660_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I153_XP_MN0 (I0_I1660_P23_22 I0_I1660_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I153_XP_MN1 (VSS I0_I1660_pn22 I0_I1660_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I154_XP_MN0 (I0_I1660_P24_23 I0_I1660_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I154_XP_MN1 (VSS I0_I1660_pn23 I0_I1660_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I155_XP_MN0 (I0_I1660_P25_24 I0_I1660_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I155_XP_MN1 (VSS I0_I1660_pn24 I0_I1660_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I156_XP_MN0 (I0_I1660_P26_25 I0_I1660_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I156_XP_MN1 (VSS I0_I1660_pn25 I0_I1660_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I157_XP_MN0 (I0_I1660_P27_26 I0_I1660_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I157_XP_MN1 (VSS I0_I1660_pn26 I0_I1660_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I158_XP_MN0 (I0_I1660_P28_27 I0_I1660_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I158_XP_MN1 (VSS I0_I1660_pn27 I0_I1660_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I159_XP_MN0 (I0_I1660_P29_28 I0_I1660_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I159_XP_MN1 (VSS I0_I1660_pn28 I0_I1660_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I97_XP_MN0 (I1_I1804_P31_30 I1_I1804_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I97_XP_MN1 (VSS I1_I1804_pn30 I1_I1804_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I95_XP_MN0 (I1_I1804_P29_28 I1_I1804_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I95_XP_MN1 (VSS I1_I1804_pn28 I1_I1804_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I93_XP_MN0 (I1_I1804_P27_26 I1_I1804_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I93_XP_MN1 (VSS I1_I1804_pn26 I1_I1804_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I91_XP_MN0 (I1_I1804_P25_24 I1_I1804_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I91_XP_MN1 (VSS I1_I1804_pn24 I1_I1804_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I89_XP_MN0 (I1_I1804_P23_22 I1_I1804_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I89_XP_MN1 (VSS I1_I1804_pn22 I1_I1804_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I87_XP_MN0 (I1_I1804_P21_20 I1_I1804_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I87_XP_MN1 (VSS I1_I1804_pn20 I1_I1804_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I83_XP_MN0 (I1_I1804_P17_16 I1_I1804_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I83_XP_MN1 (VSS I1_I1804_pn16 I1_I1804_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I81_XP_MN0 (I1_I1804_P15_14 I1_I1804_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I81_XP_MN1 (VSS I1_I1804_pn14 I1_I1804_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I79_XP_MN0 (I1_I1804_P13_12 I1_I1804_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I79_XP_MN1 (VSS I1_I1804_pn12 I1_I1804_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I77_XP_MN0 (I1_I1804_P11_10 I1_I1804_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I77_XP_MN1 (VSS I1_I1804_pn10 I1_I1804_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I75_XP_MN0 (I1_I1804_P9_8 I1_I1804_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I75_XP_MN1 (VSS I1_I1804_pn8 I1_I1804_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I69_XP_MN0 (I1_I1850_P3_2 I1_I1850_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I69_XP_MN1 (VSS I1_I1850_pn2 I1_I1850_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I68_XP_MN0 (I1_I1850_P2_1 I1_I1850_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I68_XP_MN1 (VSS I1_I1850_pn1 I1_I1850_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I71_XP_MN0 (I1_I1896_P5_4 I1_I1896_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I71_XP_MN1 (VSS I1_I1896_pn4 I1_I1896_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I72_XP_MN0 (I1_I1896_P6_5 I1_I1896_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I72_XP_MN1 (VSS I1_I1896_pn5 I1_I1896_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I70_XP_MN0 (I1_I1896_P4_3 I1_I1896_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I70_XP_MN1 (VSS I1_I1896_pn3 I1_I1896_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I73_XP_MN0 (I1_I1942_P7_6 I1_I1942_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I73_XP_MN1 (VSS I1_I1942_pn6 I1_I1942_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I74_XP_MN0 (I1_I1942_P8_7 I1_I1942_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I74_XP_MN1 (VSS I1_I1942_pn7 I1_I1942_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I133_XP_MN0 (I1_I1942_P8_1 I1_I1942_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I133_XP_MN1 (VSS I1_I1942_P4_1n I1_I1942_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I73_XP_MN0 (I1_I1988_P7_6 I1_I1988_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I73_XP_MN1 (VSS I1_I1988_pn6 I1_I1988_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I134_XP_MN0 (I1_I1988_P9_2 I1_I1988_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I134_XP_MN1 (VSS I1_I1988_P5_2n I1_I1988_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I72_XP_MN0 (I1_I1988_P6_5 I1_I1988_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I72_XP_MN1 (VSS I1_I1988_pn5 I1_I1988_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I133_XP_MN0 (I1_I1988_P8_1 I1_I1988_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I133_XP_MN1 (VSS I1_I1988_P4_1n I1_I1988_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I135_XP_MN0 (I0_I1660_P5_4 I0_I1660_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I135_XP_MN1 (VSS I0_I1660_pn4 I0_I1660_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I136_XP_MN0 (I0_I1660_P6_5 I0_I1660_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I136_XP_MN1 (VSS I0_I1660_pn5 I0_I1660_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I264_XP_MN0 (I0_I1660_P11_4 I0_I1660_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I264_XP_MN1 (VSS I0_I1660_P7_4n I0_I1660_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I262_XP_MN0 (I0_I1660_P9_2 I0_I1660_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I262_XP_MN1 (VSS I0_I1660_P5_2n I0_I1660_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I266_XP_MN0 (I0_I1660_P13_6 I0_I1660_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I266_XP_MN1 (VSS I0_I1660_P9_6n I0_I1660_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I270_XP_MN0 (I0_I1660_P17_10 I0_I1660_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I270_XP_MN1 (VSS I0_I1660_P13_10n I0_I1660_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I268_XP_MN0 (I0_I1660_P15_8 I0_I1660_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I268_XP_MN1 (VSS I0_I1660_P11_8n I0_I1660_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I272_XP_MN0 (I0_I1660_P19_12 I0_I1660_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I272_XP_MN1 (VSS I0_I1660_P15_12n I0_I1660_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I274_XP_MN0 (I0_I1660_P21_14 I0_I1660_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I274_XP_MN1 (VSS I0_I1660_P17_14n I0_I1660_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I276_XP_MN0 (I0_I1660_P23_16 I0_I1660_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I276_XP_MN1 (VSS I0_I1660_P19_16n I0_I1660_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I278_XP_MN0 (I0_I1660_P25_18 I0_I1660_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I278_XP_MN1 (VSS I0_I1660_P21_18n I0_I1660_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I280_XP_MN0 (I0_I1660_P27_20 I0_I1660_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I280_XP_MN1 (VSS I0_I1660_P23_20n I0_I1660_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I282_XP_MN0 (I0_I1660_P29_22 I0_I1660_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I282_XP_MN1 (VSS I0_I1660_P25_22n I0_I1660_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I160_XP_MN0 (I0_I1660_P30_29 I0_I1660_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I160_XP_MN1 (VSS I0_I1660_pn29 I0_I1660_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I284_XP_MN0 (I0_I1660_P31_24 I0_I1660_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I284_XP_MN1 (VSS I0_I1660_P27_24n I0_I1660_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I154_XP_MN0 (I1_I1804_P29_22 I1_I1804_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I154_XP_MN1 (VSS I1_I1804_P25_22n I1_I1804_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I150_XP_MN0 (I1_I1804_P25_18 I1_I1804_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I150_XP_MN1 (VSS I1_I1804_P21_18n I1_I1804_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I146_XP_MN0 (I1_I1804_P21_14 I1_I1804_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I146_XP_MN1 (VSS I1_I1804_P17_14n I1_I1804_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I85_XP_MN0 (I1_I1804_P19_18 I1_I1804_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I85_XP_MN1 (VSS I1_I1804_pn18 I1_I1804_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I134_XP_MN0 (I1_I1804_P9_2 I1_I1804_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I134_XP_MN1 (VSS I1_I1804_P5_2n I1_I1804_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I71_XP_MN0 (I1_I1850_P5_4 I1_I1850_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I71_XP_MN1 (VSS I1_I1850_pn4 I1_I1850_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I70_XP_MN0 (I1_I1850_P4_3 I1_I1850_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I70_XP_MN1 (VSS I1_I1850_pn3 I1_I1850_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I73_XP_MN0 (I1_I1896_P7_6 I1_I1896_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I73_XP_MN1 (VSS I1_I1896_pn6 I1_I1896_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I74_XP_MN0 (I1_I1896_P8_7 I1_I1896_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I74_XP_MN1 (VSS I1_I1896_pn7 I1_I1896_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I75_XP_MN0 (I1_I1942_P9_8 I1_I1942_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I75_XP_MN1 (VSS I1_I1942_pn8 I1_I1942_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I134_XP_MN0 (I1_I1942_P9_2 I1_I1942_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I134_XP_MN1 (VSS I1_I1942_P5_2n I1_I1942_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I76_XP_MN0 (I1_I1942_P10_9 I1_I1942_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I76_XP_MN1 (VSS I1_I1942_pn9 I1_I1942_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I135_XP_MN0 (I1_I1942_P10_3 I1_I1942_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I135_XP_MN1 (VSS I1_I1942_P6_3n I1_I1942_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I75_XP_MN0 (I1_I1988_P9_8 I1_I1988_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I75_XP_MN1 (VSS I1_I1988_pn8 I1_I1988_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I74_XP_MN0 (I1_I1988_P8_7 I1_I1988_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I74_XP_MN1 (VSS I1_I1988_pn7 I1_I1988_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I132_XP_MN0 (I0_I1660_P2_1 I0_I1660_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I132_XP_MN1 (VSS I0_I1660_pn1 I0_I1660_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I133_XP_MN0 (I0_I1660_P3_2 I0_I1660_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I133_XP_MN1 (VSS I0_I1660_pn2 I0_I1660_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I134_XP_MN0 (I0_I1660_P4_3 I0_I1660_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I134_XP_MN1 (VSS I0_I1660_pn3 I0_I1660_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I398_XP_MN0 (I0_I1660_P35_4 I0_I1660_P35_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I398_XP_MN1 (VSS I0_I1660_P19_4n I0_I1660_P35_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I402_XP_MN0 (I0_I1660_P39_8 I0_I1660_P39_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I402_XP_MN1 (VSS I0_I1660_P23_8n I0_I1660_P39_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I161_XP_MN0 (I0_I1660_P31_30 I0_I1660_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I161_XP_MN1 (VSS I0_I1660_pn30 I0_I1660_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I156_XP_MN0 (I1_I1804_P31_24 I1_I1804_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I156_XP_MN1 (VSS I1_I1804_P27_24n I1_I1804_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I144_XP_MN0 (I1_I1804_P19_12 I1_I1804_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I144_XP_MN1 (VSS I1_I1804_P15_12n I1_I1804_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I142_XP_MN0 (I1_I1804_P17_10 I1_I1804_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I142_XP_MN1 (VSS I1_I1804_P13_10n I1_I1804_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I138_XP_MN0 (I1_I1804_P13_6 I1_I1804_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I138_XP_MN1 (VSS I1_I1804_P9_6n I1_I1804_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I72_XP_MN0 (I1_I1850_P6_5 I1_I1850_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I72_XP_MN1 (VSS I1_I1850_pn5 I1_I1850_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I133_XP_MN0 (I1_I1896_P8_1 I1_I1896_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I133_XP_MN1 (VSS I1_I1896_P4_1n I1_I1896_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I77_XP_MN0 (I1_I1942_P11_10 I1_I1942_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I77_XP_MN1 (VSS I1_I1942_pn10 I1_I1942_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I136_XP_MN0 (I1_I1942_P11_4 I1_I1942_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I136_XP_MN1 (VSS I1_I1942_P7_4n I1_I1942_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I77_XP_MN0 (I1_I1988_P11_10 I1_I1988_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I77_XP_MN1 (VSS I1_I1988_pn10 I1_I1988_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I76_XP_MN0 (I1_I1988_P10_9 I1_I1988_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I76_XP_MN1 (VSS I1_I1988_pn9 I1_I1988_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I141_XP_MN0 (I1_I1988_P16_9 I1_I1988_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I141_XP_MN1 (VSS I1_I1988_P12_9n I1_I1988_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I135_XP_MN0 (I1_I1988_P10_3 I1_I1988_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I135_XP_MN1 (VSS I1_I1988_P6_3n I1_I1988_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I70_XP_MN0 (I1_I2066_P4_3 I1_I2066_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I70_XP_MN1 (VSS I1_I2066_pn3 I1_I2066_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I68_XP_MN0 (I1_I2066_P2_1 I1_I2066_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I68_XP_MN1 (VSS I1_I2066_pn1 I1_I2066_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I69_XP_MN0 (I1_I2066_P3_2 I1_I2066_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I69_XP_MN1 (VSS I1_I2066_pn2 I1_I2066_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I261_XP_MN0 (I0_I1660_P8_1 I0_I1660_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I261_XP_MN1 (VSS I0_I1660_P4_1n I0_I1660_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I265_XP_MN0 (I0_I1660_P12_5 I0_I1660_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I265_XP_MN1 (VSS I0_I1660_P8_5n I0_I1660_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I269_XP_MN0 (I0_I1660_P16_9 I0_I1660_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I269_XP_MN1 (VSS I0_I1660_P12_9n I0_I1660_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I396_XP_MN0 (I0_I1660_P33_2 I0_I1660_P33_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I396_XP_MN1 (VSS I0_I1660_P17_2n I0_I1660_P33_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I273_XP_MN0 (I0_I1660_P20_13 I0_I1660_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I273_XP_MN1 (VSS I0_I1660_P16_13n I0_I1660_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I277_XP_MN0 (I0_I1660_P24_17 I0_I1660_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I277_XP_MN1 (VSS I0_I1660_P20_17n I0_I1660_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I281_XP_MN0 (I0_I1660_P28_21 I0_I1660_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I281_XP_MN1 (VSS I0_I1660_P24_21n I0_I1660_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I400_XP_MN0 (I0_I1660_P37_6 I0_I1660_P37_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I400_XP_MN1 (VSS I0_I1660_P21_6n I0_I1660_P37_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I164_XP_MN0 (I0_I1660_P34_33 I0_I1660_pn34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I164_XP_MN1 (VSS I0_I1660_pn33 I0_I1660_P34_33 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I412_XP_MN0 (I0_I1660_P49_18 I0_I1660_P49_34n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I412_XP_MN1 (VSS I0_I1660_P33_18n I0_I1660_P49_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I286_XP_MN0 (I0_I1660_P33_26 I0_I1660_P33_30n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I286_XP_MN1 (VSS I0_I1660_P29_26n I0_I1660_P33_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I162_XP_MN0 (I0_I1660_P32_31 I0_I1660_pn32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I162_XP_MN1 (VSS I0_I1660_pn31 I0_I1660_P32_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I288_XP_MN0 (I0_I1660_P35_28 I0_I1660_P35_32n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I288_XP_MN1 (VSS I0_I1660_P31_28n I0_I1660_P35_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I163_XP_MN0 (I0_I1660_P33_32 I0_I1660_pn33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I163_XP_MN1 (VSS I0_I1660_pn32 I0_I1660_P33_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I152_XP_MN0 (I1_I1804_P27_20 I1_I1804_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I152_XP_MN1 (VSS I1_I1804_P23_20n I1_I1804_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I148_XP_MN0 (I1_I1804_P23_16 I1_I1804_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I148_XP_MN1 (VSS I1_I1804_P19_16n I1_I1804_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I140_XP_MN0 (I1_I1804_P15_8 I1_I1804_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I140_XP_MN1 (VSS I1_I1804_P11_8n I1_I1804_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I136_XP_MN0 (I1_I1804_P11_4 I1_I1804_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I136_XP_MN1 (VSS I1_I1804_P7_4n I1_I1804_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I73_XP_MN0 (I1_I1850_P7_6 I1_I1850_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I73_XP_MN1 (VSS I1_I1850_pn6 I1_I1850_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I77_XP_MN0 (I1_I1896_P11_10 I1_I1896_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I77_XP_MN1 (VSS I1_I1896_pn10 I1_I1896_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I75_XP_MN0 (I1_I1896_P9_8 I1_I1896_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I75_XP_MN1 (VSS I1_I1896_pn8 I1_I1896_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I134_XP_MN0 (I1_I1896_P9_2 I1_I1896_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I134_XP_MN1 (VSS I1_I1896_P5_2n I1_I1896_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I76_XP_MN0 (I1_I1896_P10_9 I1_I1896_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I76_XP_MN1 (VSS I1_I1896_pn9 I1_I1896_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I135_XP_MN0 (I1_I1896_P10_3 I1_I1896_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I135_XP_MN1 (VSS I1_I1896_P6_3n I1_I1896_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I79_XP_MN0 (I1_I1942_P13_12 I1_I1942_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I79_XP_MN1 (VSS I1_I1942_pn12 I1_I1942_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I78_XP_MN0 (I1_I1942_P12_11 I1_I1942_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I78_XP_MN1 (VSS I1_I1942_pn11 I1_I1942_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I141_XP_MN0 (I1_I1942_P16_9 I1_I1942_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I141_XP_MN1 (VSS I1_I1942_P12_9n I1_I1942_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I137_XP_MN0 (I1_I1942_P12_5 I1_I1942_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I137_XP_MN1 (VSS I1_I1942_P8_5n I1_I1942_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I138_XP_MN0 (I1_I1988_P13_6 I1_I1988_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I138_XP_MN1 (VSS I1_I1988_P9_6n I1_I1988_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I136_XP_MN0 (I1_I1988_P11_4 I1_I1988_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I136_XP_MN1 (VSS I1_I1988_P7_4n I1_I1988_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I78_XP_MN0 (I1_I1988_P12_11 I1_I1988_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I78_XP_MN1 (VSS I1_I1988_pn11 I1_I1988_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I137_XP_MN0 (I1_I1988_P12_5 I1_I1988_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I137_XP_MN1 (VSS I1_I1988_P8_5n I1_I1988_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I74_XP_MN0 (I1_I2066_P8_7 I1_I2066_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I74_XP_MN1 (VSS I1_I2066_pn7 I1_I2066_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I72_XP_MN0 (I1_I2066_P6_5 I1_I2066_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I72_XP_MN1 (VSS I1_I2066_pn5 I1_I2066_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I133_XP_MN0 (I1_I2066_P8_1 I1_I2066_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I133_XP_MN1 (VSS I1_I2066_P4_1n I1_I2066_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I71_XP_MN0 (I1_I2066_P5_4 I1_I2066_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I71_XP_MN1 (VSS I1_I2066_pn4 I1_I2066_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I263_XP_MN0 (I0_I1660_P10_3 I0_I1660_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I263_XP_MN1 (VSS I0_I1660_P6_3n I0_I1660_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I395_XP_MN0 (I0_I1660_P32_1 I0_I1660_P32_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I395_XP_MN1 (VSS I0_I1660_P16_1n I0_I1660_P32_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I285_XP_MN0 (I0_I1660_P32_25 I0_I1660_P32_29n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I285_XP_MN1 (VSS I0_I1660_P28_25n I0_I1660_P32_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I166_XP_MN0 (I0_I1660_P36_35 I0_I1660_pn36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I166_XP_MN1 (VSS I0_I1660_pn35 I0_I1660_P36_35 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I404_XP_MN0 (I0_I1660_P41_10 I0_I1660_P41_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I404_XP_MN1 (VSS I0_I1660_P25_10n I0_I1660_P41_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I414_XP_MN0 (I0_I1660_P51_20 I0_I1660_P51_36n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I414_XP_MN1 (VSS I0_I1660_P35_20n I0_I1660_P51_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I406_XP_MN0 (I0_I1660_P43_12 I0_I1660_P43_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I406_XP_MN1 (VSS I0_I1660_P27_12n I0_I1660_P43_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I410_XP_MN0 (I0_I1660_P47_16 I0_I1660_P47_32n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I410_XP_MN1 (VSS I0_I1660_P31_16n I0_I1660_P47_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I296_XP_MN0 (I0_I1660_P43_36 I0_I1660_P43_40n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I296_XP_MN1 (VSS I0_I1660_P39_36n I0_I1660_P43_36 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I165_XP_MN0 (I0_I1660_P35_34 I0_I1660_pn35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I165_XP_MN1 (VSS I0_I1660_pn34 I0_I1660_P35_34 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I167_XP_MN0 (I0_I1660_P37_36 I0_I1660_pn37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I167_XP_MN1 (VSS I0_I1660_pn36 I0_I1660_P37_36 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I136_XP_MN0 (I1_I1850_P11_4 I1_I1850_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I136_XP_MN1 (VSS I1_I1850_P7_4n I1_I1850_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I77_XP_MN0 (I1_I1850_P11_10 I1_I1850_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I77_XP_MN1 (VSS I1_I1850_pn10 I1_I1850_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I76_XP_MN0 (I1_I1850_P10_9 I1_I1850_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I76_XP_MN1 (VSS I1_I1850_pn9 I1_I1850_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I75_XP_MN0 (I1_I1850_P9_8 I1_I1850_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I75_XP_MN1 (VSS I1_I1850_pn8 I1_I1850_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I74_XP_MN0 (I1_I1850_P8_7 I1_I1850_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I74_XP_MN1 (VSS I1_I1850_pn7 I1_I1850_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I136_XP_MN0 (I1_I1896_P11_4 I1_I1896_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I136_XP_MN1 (VSS I1_I1896_P7_4n I1_I1896_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I78_XP_MN0 (I1_I1896_P12_11 I1_I1896_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I78_XP_MN1 (VSS I1_I1896_pn11 I1_I1896_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I142_XP_MN0 (I1_I1942_P17_10 I1_I1942_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I142_XP_MN1 (VSS I1_I1942_P13_10n I1_I1942_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I138_XP_MN0 (I1_I1942_P13_6 I1_I1942_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I138_XP_MN1 (VSS I1_I1942_P9_6n I1_I1942_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I80_XP_MN0 (I1_I1942_P14_13 I1_I1942_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I80_XP_MN1 (VSS I1_I1942_pn13 I1_I1942_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I139_XP_MN0 (I1_I1942_P14_7 I1_I1942_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I139_XP_MN1 (VSS I1_I1942_P10_7n I1_I1942_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I79_XP_MN0 (I1_I1988_P13_12 I1_I1988_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I79_XP_MN1 (VSS I1_I1988_pn12 I1_I1988_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I142_XP_MN0 (I1_I1988_P17_10 I1_I1988_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I142_XP_MN1 (VSS I1_I1988_P13_10n I1_I1988_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I80_XP_MN0 (I1_I1988_P14_13 I1_I1988_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I80_XP_MN1 (VSS I1_I1988_pn13 I1_I1988_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I143_XP_MN0 (I1_I1988_P18_11 I1_I1988_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I143_XP_MN1 (VSS I1_I1988_P14_11n I1_I1988_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I139_XP_MN0 (I1_I1988_P14_7 I1_I1988_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I139_XP_MN1 (VSS I1_I1988_P10_7n I1_I1988_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I76_XP_MN0 (I1_I2066_P10_9 I1_I2066_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I76_XP_MN1 (VSS I1_I2066_pn9 I1_I2066_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I137_XP_MN0 (I1_I2066_P12_5 I1_I2066_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I137_XP_MN1 (VSS I1_I2066_P8_5n I1_I2066_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I75_XP_MN0 (I1_I2066_P9_8 I1_I2066_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I75_XP_MN1 (VSS I1_I2066_pn8 I1_I2066_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I73_XP_MN0 (I1_I2066_P7_6 I1_I2066_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I73_XP_MN1 (VSS I1_I2066_pn6 I1_I2066_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I267_XP_MN0 (I0_I1660_P14_7 I0_I1660_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I267_XP_MN1 (VSS I0_I1660_P10_7n I0_I1660_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I271_XP_MN0 (I0_I1660_P18_11 I0_I1660_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I271_XP_MN1 (VSS I0_I1660_P14_11n I0_I1660_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I399_XP_MN0 (I0_I1660_P36_5 I0_I1660_P36_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I399_XP_MN1 (VSS I0_I1660_P20_5n I0_I1660_P36_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I411_XP_MN0 (I0_I1660_P48_17 I0_I1660_P48_33n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I411_XP_MN1 (VSS I0_I1660_P32_17n I0_I1660_P48_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I403_XP_MN0 (I0_I1660_P40_9 I0_I1660_P40_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I403_XP_MN1 (VSS I0_I1660_P24_9n I0_I1660_P40_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I289_XP_MN0 (I0_I1660_P36_29 I0_I1660_P36_33n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I289_XP_MN1 (VSS I0_I1660_P32_29n I0_I1660_P36_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I293_XP_MN0 (I0_I1660_P40_33 I0_I1660_P40_37n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I293_XP_MN1 (VSS I0_I1660_P36_33n I0_I1660_P40_33 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I168_XP_MN0 (I0_I1660_P38_37 I0_I1660_pn38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I168_XP_MN1 (VSS I0_I1660_pn37 I0_I1660_P38_37 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I294_XP_MN0 (I0_I1660_P41_34 I0_I1660_P41_38n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I294_XP_MN1 (VSS I0_I1660_P37_34n I0_I1660_P41_34 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I171_XP_MN0 (I0_I1660_P41_40 I0_I1660_pn41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I171_XP_MN1 (VSS I0_I1660_pn40 I0_I1660_P41_40 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I169_XP_MN0 (I0_I1660_P39_38 I0_I1660_pn39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I169_XP_MN1 (VSS I0_I1660_pn38 I0_I1660_P39_38 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I138_XP_MN0 (I1_I1850_P13_6 I1_I1850_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I138_XP_MN1 (VSS I1_I1850_P9_6n I1_I1850_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I134_XP_MN0 (I1_I1850_P9_2 I1_I1850_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I134_XP_MN1 (VSS I1_I1850_P5_2n I1_I1850_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I79_XP_MN0 (I1_I1850_P13_12 I1_I1850_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I79_XP_MN1 (VSS I1_I1850_pn12 I1_I1850_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I78_XP_MN0 (I1_I1850_P12_11 I1_I1850_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I78_XP_MN1 (VSS I1_I1850_pn11 I1_I1850_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I133_XP_MN0 (I1_I1850_P8_1 I1_I1850_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I133_XP_MN1 (VSS I1_I1850_P4_1n I1_I1850_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I79_XP_MN0 (I1_I1896_P13_12 I1_I1896_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I79_XP_MN1 (VSS I1_I1896_pn12 I1_I1896_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I138_XP_MN0 (I1_I1896_P13_6 I1_I1896_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I138_XP_MN1 (VSS I1_I1896_P9_6n I1_I1896_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I137_XP_MN0 (I1_I1896_P12_5 I1_I1896_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I137_XP_MN1 (VSS I1_I1896_P8_5n I1_I1896_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I81_XP_MN0 (I1_I1942_P15_14 I1_I1942_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I81_XP_MN1 (VSS I1_I1942_pn14 I1_I1942_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I140_XP_MN0 (I1_I1942_P15_8 I1_I1942_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I140_XP_MN1 (VSS I1_I1942_P11_8n I1_I1942_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I143_XP_MN0 (I1_I1942_P18_11 I1_I1942_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I143_XP_MN1 (VSS I1_I1942_P14_11n I1_I1942_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I81_XP_MN0 (I1_I1988_P15_14 I1_I1988_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I81_XP_MN1 (VSS I1_I1988_pn14 I1_I1988_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I140_XP_MN0 (I1_I1988_P15_8 I1_I1988_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I140_XP_MN1 (VSS I1_I1988_P11_8n I1_I1988_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I82_XP_MN0 (I1_I1988_P16_15 I1_I1988_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I82_XP_MN1 (VSS I1_I1988_pn15 I1_I1988_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I145_XP_MN0 (I1_I1988_P20_13 I1_I1988_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I145_XP_MN1 (VSS I1_I1988_P16_13n I1_I1988_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I78_XP_MN0 (I1_I2066_P12_11 I1_I2066_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I78_XP_MN1 (VSS I1_I2066_pn11 I1_I2066_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I141_XP_MN0 (I1_I2066_P16_9 I1_I2066_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I141_XP_MN1 (VSS I1_I2066_P12_9n I1_I2066_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I134_XP_MN0 (I1_I2066_P9_2 I1_I2066_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I134_XP_MN1 (VSS I1_I2066_P5_2n I1_I2066_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I397_XP_MN0 (I0_I1660_P34_3 I0_I1660_P34_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I397_XP_MN1 (VSS I0_I1660_P18_3n I0_I1660_P34_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I275_XP_MN0 (I0_I1660_P22_15 I0_I1660_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I275_XP_MN1 (VSS I0_I1660_P18_15n I0_I1660_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I279_XP_MN0 (I0_I1660_P26_19 I0_I1660_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I279_XP_MN1 (VSS I0_I1660_P22_19n I0_I1660_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I297_XP_MN0 (I0_I1660_P44_37 I0_I1660_P44_41n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I297_XP_MN1 (VSS I0_I1660_P40_37n I0_I1660_P44_37 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I170_XP_MN0 (I0_I1660_P40_39 I0_I1660_pn40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I170_XP_MN1 (VSS I0_I1660_pn39 I0_I1660_P40_39 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I416_XP_MN0 (I0_I1660_P53_22 I0_I1660_P53_38n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I416_XP_MN1 (VSS I0_I1660_P37_22n I0_I1660_P53_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I418_XP_MN0 (I0_I1660_P55_24 I0_I1660_P55_40n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I418_XP_MN1 (VSS I0_I1660_P39_24n I0_I1660_P55_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I426_XP_MN0 (I0_I1660_P63_32 I0_I1660_P63_48n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I426_XP_MN1 (VSS I0_I1660_P47_32n I0_I1660_P63_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I300_XP_MN0 (I0_I1660_P47_40 I0_I1660_P47_44n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I300_XP_MN1 (VSS I0_I1660_P43_40n I0_I1660_P47_40 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I298_XP_MN0 (I0_I1660_P45_38 I0_I1660_P45_42n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I298_XP_MN1 (VSS I0_I1660_P41_38n I0_I1660_P45_38 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I173_XP_MN0 (I0_I1660_P43_42 I0_I1660_pn43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I173_XP_MN1 (VSS I0_I1660_pn42 I0_I1660_P43_42 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I144_XP_MN0 (I1_I1850_P19_12 I1_I1850_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I144_XP_MN1 (VSS I1_I1850_P15_12n I1_I1850_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I140_XP_MN0 (I1_I1850_P15_8 I1_I1850_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I140_XP_MN1 (VSS I1_I1850_P11_8n I1_I1850_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I142_XP_MN0 (I1_I1850_P17_10 I1_I1850_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I142_XP_MN1 (VSS I1_I1850_P13_10n I1_I1850_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I81_XP_MN0 (I1_I1850_P15_14 I1_I1850_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I81_XP_MN1 (VSS I1_I1850_pn14 I1_I1850_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I80_XP_MN0 (I1_I1850_P14_13 I1_I1850_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I80_XP_MN1 (VSS I1_I1850_pn13 I1_I1850_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I137_XP_MN0 (I1_I1850_P12_5 I1_I1850_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I137_XP_MN1 (VSS I1_I1850_P8_5n I1_I1850_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I135_XP_MN0 (I1_I1850_P10_3 I1_I1850_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I135_XP_MN1 (VSS I1_I1850_P6_3n I1_I1850_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I81_XP_MN0 (I1_I1896_P15_14 I1_I1896_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I81_XP_MN1 (VSS I1_I1896_pn14 I1_I1896_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I142_XP_MN0 (I1_I1896_P17_10 I1_I1896_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I142_XP_MN1 (VSS I1_I1896_P13_10n I1_I1896_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I80_XP_MN0 (I1_I1896_P14_13 I1_I1896_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I80_XP_MN1 (VSS I1_I1896_pn13 I1_I1896_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I141_XP_MN0 (I1_I1896_P16_9 I1_I1896_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I141_XP_MN1 (VSS I1_I1896_P12_9n I1_I1896_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I139_XP_MN0 (I1_I1896_P14_7 I1_I1896_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I139_XP_MN1 (VSS I1_I1896_P10_7n I1_I1896_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I83_XP_MN0 (I1_I1942_P17_16 I1_I1942_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I83_XP_MN1 (VSS I1_I1942_pn16 I1_I1942_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I144_XP_MN0 (I1_I1942_P19_12 I1_I1942_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I144_XP_MN1 (VSS I1_I1942_P15_12n I1_I1942_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I82_XP_MN0 (I1_I1942_P16_15 I1_I1942_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I82_XP_MN1 (VSS I1_I1942_pn15 I1_I1942_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I145_XP_MN0 (I1_I1942_P20_13 I1_I1942_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I145_XP_MN1 (VSS I1_I1942_P16_13n I1_I1942_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I149_XP_MN0 (I1_I1942_P24_17 I1_I1942_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I149_XP_MN1 (VSS I1_I1942_P20_17n I1_I1942_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I83_XP_MN0 (I1_I1988_P17_16 I1_I1988_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I83_XP_MN1 (VSS I1_I1988_pn16 I1_I1988_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I146_XP_MN0 (I1_I1988_P21_14 I1_I1988_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I146_XP_MN1 (VSS I1_I1988_P17_14n I1_I1988_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I144_XP_MN0 (I1_I1988_P19_12 I1_I1988_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I144_XP_MN1 (VSS I1_I1988_P15_12n I1_I1988_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I84_XP_MN0 (I1_I1988_P18_17 I1_I1988_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I84_XP_MN1 (VSS I1_I1988_pn17 I1_I1988_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I149_XP_MN0 (I1_I1988_P24_17 I1_I1988_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I149_XP_MN1 (VSS I1_I1988_P20_17n I1_I1988_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I80_XP_MN0 (I1_I2066_P14_13 I1_I2066_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I80_XP_MN1 (VSS I1_I2066_pn13 I1_I2066_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I135_XP_MN0 (I1_I2066_P10_3 I1_I2066_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I135_XP_MN1 (VSS I1_I2066_P6_3n I1_I2066_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I77_XP_MN0 (I1_I2066_P11_10 I1_I2066_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I77_XP_MN1 (VSS I1_I2066_pn10 I1_I2066_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I79_XP_MN0 (I1_I2066_P13_12 I1_I2066_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I79_XP_MN1 (VSS I1_I2066_pn12 I1_I2066_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I138_XP_MN0 (I1_I2066_P13_6 I1_I2066_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I138_XP_MN1 (VSS I1_I2066_P9_6n I1_I2066_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I415_XP_MN0 (I0_I1660_P52_21 I0_I1660_P52_37n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I415_XP_MN1 (VSS I0_I1660_P36_21n I0_I1660_P52_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I287_XP_MN0 (I0_I1660_P34_27 I0_I1660_P34_31n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I287_XP_MN1 (VSS I0_I1660_P30_27n I0_I1660_P34_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I419_XP_MN0 (I0_I1660_P56_25 I0_I1660_P56_41n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I419_XP_MN1 (VSS I0_I1660_P40_25n I0_I1660_P56_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I172_XP_MN0 (I0_I1660_P42_41 I0_I1660_pn42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I172_XP_MN1 (VSS I0_I1660_pn41 I0_I1660_P42_41 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I408_XP_MN0 (I0_I1660_P45_14 I0_I1660_P45_30n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I408_XP_MN1 (VSS I0_I1660_P29_14n I0_I1660_P45_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I422_XP_MN0 (I0_I1660_P59_28 I0_I1660_P59_44n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I422_XP_MN1 (VSS I0_I1660_P43_28n I0_I1660_P59_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I302_XP_MN0 (I0_I1660_P49_42 I0_I1660_P49_46n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I302_XP_MN1 (VSS I0_I1660_P45_42n I0_I1660_P49_42 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I304_XP_MN0 (I0_I1660_P51_44 I0_I1660_P51_48n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I304_XP_MN1 (VSS I0_I1660_P47_44n I0_I1660_P51_44 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I175_XP_MN0 (I0_I1660_P45_44 I0_I1660_pn45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I175_XP_MN1 (VSS I0_I1660_pn44 I0_I1660_P45_44 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I148_XP_MN0 (I1_I1850_P23_16 I1_I1850_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I148_XP_MN1 (VSS I1_I1850_P19_16n I1_I1850_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I146_XP_MN0 (I1_I1850_P21_14 I1_I1850_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I146_XP_MN1 (VSS I1_I1850_P17_14n I1_I1850_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I83_XP_MN0 (I1_I1850_P17_16 I1_I1850_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I83_XP_MN1 (VSS I1_I1850_pn16 I1_I1850_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I84_XP_MN0 (I1_I1850_P18_17 I1_I1850_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I84_XP_MN1 (VSS I1_I1850_pn17 I1_I1850_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I82_XP_MN0 (I1_I1850_P16_15 I1_I1850_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I82_XP_MN1 (VSS I1_I1850_pn15 I1_I1850_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I141_XP_MN0 (I1_I1850_P16_9 I1_I1850_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I141_XP_MN1 (VSS I1_I1850_P12_9n I1_I1850_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I83_XP_MN0 (I1_I1896_P17_16 I1_I1896_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I83_XP_MN1 (VSS I1_I1896_pn16 I1_I1896_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I140_XP_MN0 (I1_I1896_P15_8 I1_I1896_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I140_XP_MN1 (VSS I1_I1896_P11_8n I1_I1896_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I82_XP_MN0 (I1_I1896_P16_15 I1_I1896_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I82_XP_MN1 (VSS I1_I1896_pn15 I1_I1896_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I84_XP_MN0 (I1_I1896_P18_17 I1_I1896_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I84_XP_MN1 (VSS I1_I1896_pn17 I1_I1896_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I143_XP_MN0 (I1_I1896_P18_11 I1_I1896_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I143_XP_MN1 (VSS I1_I1896_P14_11n I1_I1896_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I85_XP_MN0 (I1_I1942_P19_18 I1_I1942_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I85_XP_MN1 (VSS I1_I1942_pn18 I1_I1942_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I146_XP_MN0 (I1_I1942_P21_14 I1_I1942_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I146_XP_MN1 (VSS I1_I1942_P17_14n I1_I1942_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I84_XP_MN0 (I1_I1942_P18_17 I1_I1942_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I84_XP_MN1 (VSS I1_I1942_pn17 I1_I1942_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I85_XP_MN0 (I1_I1988_P19_18 I1_I1988_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I85_XP_MN1 (VSS I1_I1988_pn18 I1_I1988_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I150_XP_MN0 (I1_I1988_P25_18 I1_I1988_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I150_XP_MN1 (VSS I1_I1988_P21_18n I1_I1988_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I86_XP_MN0 (I1_I1988_P20_19 I1_I1988_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I86_XP_MN1 (VSS I1_I1988_pn19 I1_I1988_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I82_XP_MN0 (I1_I2066_P16_15 I1_I2066_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I82_XP_MN1 (VSS I1_I2066_pn15 I1_I2066_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I143_XP_MN0 (I1_I2066_P18_11 I1_I2066_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I143_XP_MN1 (VSS I1_I2066_P14_11n I1_I2066_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I139_XP_MN0 (I1_I2066_P14_7 I1_I2066_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I139_XP_MN1 (VSS I1_I2066_P10_7n I1_I2066_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I81_XP_MN0 (I1_I2066_P15_14 I1_I2066_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I81_XP_MN1 (VSS I1_I2066_pn14 I1_I2066_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I142_XP_MN0 (I1_I2066_P17_10 I1_I2066_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I142_XP_MN1 (VSS I1_I2066_P13_10n I1_I2066_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I140_XP_MN0 (I1_I2066_P15_8 I1_I2066_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I140_XP_MN1 (VSS I1_I2066_P11_8n I1_I2066_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I136_XP_MN0 (I1_I2066_P11_4 I1_I2066_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I136_XP_MN1 (VSS I1_I2066_P7_4n I1_I2066_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I401_XP_MN0 (I0_I1660_P38_7 I0_I1660_P38_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I401_XP_MN1 (VSS I0_I1660_P22_7n I0_I1660_P38_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I405_XP_MN0 (I0_I1660_P42_11 I0_I1660_P42_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I405_XP_MN1 (VSS I0_I1660_P26_11n I0_I1660_P42_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I291_XP_MN0 (I0_I1660_P38_31 I0_I1660_P38_35n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I291_XP_MN1 (VSS I0_I1660_P34_31n I0_I1660_P38_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I295_XP_MN0 (I0_I1660_P42_35 I0_I1660_P42_39n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I295_XP_MN1 (VSS I0_I1660_P38_35n I0_I1660_P42_35 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I301_XP_MN0 (I0_I1660_P48_41 I0_I1660_P48_45n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I301_XP_MN1 (VSS I0_I1660_P44_41n I0_I1660_P48_41 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I174_XP_MN0 (I0_I1660_P44_43 I0_I1660_pn44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I174_XP_MN1 (VSS I0_I1660_pn43 I0_I1660_P44_43 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I420_XP_MN0 (I0_I1660_P57_26 I0_I1660_P57_42n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I420_XP_MN1 (VSS I0_I1660_P41_26n I0_I1660_P57_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I308_XP_MN0 (I0_I1660_P55_48 I0_I1660_P55_52n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I308_XP_MN1 (VSS I0_I1660_P51_48n I0_I1660_P55_48 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I177_XP_MN0 (I0_I1660_P47_46 I0_I1660_pn47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I177_XP_MN1 (VSS I0_I1660_pn46 I0_I1660_P47_46 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I150_XP_MN0 (I1_I1850_P25_18 I1_I1850_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I150_XP_MN1 (VSS I1_I1850_P21_18n I1_I1850_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I85_XP_MN0 (I1_I1850_P19_18 I1_I1850_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I85_XP_MN1 (VSS I1_I1850_pn18 I1_I1850_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I139_XP_MN0 (I1_I1850_P14_7 I1_I1850_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I139_XP_MN1 (VSS I1_I1850_P10_7n I1_I1850_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I85_XP_MN0 (I1_I1896_P19_18 I1_I1896_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I85_XP_MN1 (VSS I1_I1896_pn18 I1_I1896_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I146_XP_MN0 (I1_I1896_P21_14 I1_I1896_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I146_XP_MN1 (VSS I1_I1896_P17_14n I1_I1896_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I144_XP_MN0 (I1_I1896_P19_12 I1_I1896_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I144_XP_MN1 (VSS I1_I1896_P15_12n I1_I1896_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I145_XP_MN0 (I1_I1896_P20_13 I1_I1896_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I145_XP_MN1 (VSS I1_I1896_P16_13n I1_I1896_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I150_XP_MN0 (I1_I1942_P25_18 I1_I1942_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I150_XP_MN1 (VSS I1_I1942_P21_18n I1_I1942_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I86_XP_MN0 (I1_I1942_P20_19 I1_I1942_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I86_XP_MN1 (VSS I1_I1942_pn19 I1_I1942_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I151_XP_MN0 (I1_I1942_P26_19 I1_I1942_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I151_XP_MN1 (VSS I1_I1942_P22_19n I1_I1942_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I147_XP_MN0 (I1_I1942_P22_15 I1_I1942_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I147_XP_MN1 (VSS I1_I1942_P18_15n I1_I1942_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I87_XP_MN0 (I1_I1988_P21_20 I1_I1988_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I87_XP_MN1 (VSS I1_I1988_pn20 I1_I1988_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I148_XP_MN0 (I1_I1988_P23_16 I1_I1988_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I148_XP_MN1 (VSS I1_I1988_P19_16n I1_I1988_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I152_XP_MN0 (I1_I1988_P27_20 I1_I1988_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I152_XP_MN1 (VSS I1_I1988_P23_20n I1_I1988_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I151_XP_MN0 (I1_I1988_P26_19 I1_I1988_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I151_XP_MN1 (VSS I1_I1988_P22_19n I1_I1988_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I147_XP_MN0 (I1_I1988_P22_15 I1_I1988_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I147_XP_MN1 (VSS I1_I1988_P18_15n I1_I1988_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I84_XP_MN0 (I1_I2066_P18_17 I1_I2066_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I84_XP_MN1 (VSS I1_I2066_pn17 I1_I2066_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I149_XP_MN0 (I1_I2066_P24_17 I1_I2066_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I149_XP_MN1 (VSS I1_I2066_P20_17n I1_I2066_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I145_XP_MN0 (I1_I2066_P20_13 I1_I2066_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I145_XP_MN1 (VSS I1_I2066_P16_13n I1_I2066_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I83_XP_MN0 (I1_I2066_P17_16 I1_I2066_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I83_XP_MN1 (VSS I1_I2066_pn16 I1_I2066_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I413_XP_MN0 (I0_I1660_P50_19 I0_I1660_P50_35n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I413_XP_MN1 (VSS I0_I1660_P34_19n I0_I1660_P50_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I423_XP_MN0 (I0_I1660_P60_29 I0_I1660_P60_45n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I423_XP_MN1 (VSS I0_I1660_P44_29n I0_I1660_P60_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I305_XP_MN0 (I0_I1660_P52_45 I0_I1660_P52_49n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I305_XP_MN1 (VSS I0_I1660_P48_45n I0_I1660_P52_45 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I176_XP_MN0 (I0_I1660_P46_45 I0_I1660_pn46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I176_XP_MN1 (VSS I0_I1660_pn45 I0_I1660_P46_45 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I424_XP_MN0 (I0_I1660_P61_30 I0_I1660_P61_46n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I424_XP_MN1 (VSS I0_I1660_P45_30n I0_I1660_P61_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I310_XP_MN0 (I0_I1660_P57_50 I0_I1660_P57_54n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I310_XP_MN1 (VSS I0_I1660_P53_50n I0_I1660_P57_50 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I306_XP_MN0 (I0_I1660_P53_46 I0_I1660_P53_50n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I306_XP_MN1 (VSS I0_I1660_P49_46n I0_I1660_P53_46 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I312_XP_MN0 (I0_I1660_P59_52 I0_I1660_P59_56n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I312_XP_MN1 (VSS I0_I1660_P55_52n I0_I1660_P59_52 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I179_XP_MN0 (I0_I1660_P49_48 I0_I1660_pn49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I179_XP_MN1 (VSS I0_I1660_pn48 I0_I1660_P49_48 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I152_XP_MN0 (I1_I1850_P27_20 I1_I1850_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I152_XP_MN1 (VSS I1_I1850_P23_20n I1_I1850_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I87_XP_MN0 (I1_I1850_P21_20 I1_I1850_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I87_XP_MN1 (VSS I1_I1850_pn20 I1_I1850_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I86_XP_MN0 (I1_I1850_P20_19 I1_I1850_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I86_XP_MN1 (VSS I1_I1850_pn19 I1_I1850_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I145_XP_MN0 (I1_I1850_P20_13 I1_I1850_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I145_XP_MN1 (VSS I1_I1850_P16_13n I1_I1850_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I143_XP_MN0 (I1_I1850_P18_11 I1_I1850_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I143_XP_MN1 (VSS I1_I1850_P14_11n I1_I1850_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I150_XP_MN0 (I1_I1896_P25_18 I1_I1896_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I150_XP_MN1 (VSS I1_I1896_P21_18n I1_I1896_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I86_XP_MN0 (I1_I1896_P20_19 I1_I1896_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I86_XP_MN1 (VSS I1_I1896_pn19 I1_I1896_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I149_XP_MN0 (I1_I1896_P24_17 I1_I1896_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I149_XP_MN1 (VSS I1_I1896_P20_17n I1_I1896_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I87_XP_MN0 (I1_I1942_P21_20 I1_I1942_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I87_XP_MN1 (VSS I1_I1942_pn20 I1_I1942_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I148_XP_MN0 (I1_I1942_P23_16 I1_I1942_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I148_XP_MN1 (VSS I1_I1942_P19_16n I1_I1942_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I152_XP_MN0 (I1_I1942_P27_20 I1_I1942_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I152_XP_MN1 (VSS I1_I1942_P23_20n I1_I1942_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I88_XP_MN0 (I1_I1942_P22_21 I1_I1942_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I88_XP_MN1 (VSS I1_I1942_pn21 I1_I1942_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I89_XP_MN0 (I1_I1988_P23_22 I1_I1988_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I89_XP_MN1 (VSS I1_I1988_pn22 I1_I1988_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I88_XP_MN0 (I1_I1988_P22_21 I1_I1988_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I88_XP_MN1 (VSS I1_I1988_pn21 I1_I1988_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I85_XP_MN0 (I1_I2066_P19_18 I1_I2066_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I85_XP_MN1 (VSS I1_I2066_pn18 I1_I2066_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I150_XP_MN0 (I1_I2066_P25_18 I1_I2066_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I150_XP_MN1 (VSS I1_I2066_P21_18n I1_I2066_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I146_XP_MN0 (I1_I2066_P21_14 I1_I2066_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I146_XP_MN1 (VSS I1_I2066_P17_14n I1_I2066_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I144_XP_MN0 (I1_I2066_P19_12 I1_I2066_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I144_XP_MN1 (VSS I1_I2066_P15_12n I1_I2066_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I409_XP_MN0 (I0_I1660_P46_15 I0_I1660_P46_31n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I409_XP_MN1 (VSS I0_I1660_P30_15n I0_I1660_P46_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I421_XP_MN0 (I0_I1660_P58_27 I0_I1660_P58_43n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I421_XP_MN1 (VSS I0_I1660_P42_27n I0_I1660_P58_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I299_XP_MN0 (I0_I1660_P46_39 I0_I1660_P46_43n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I299_XP_MN1 (VSS I0_I1660_P42_39n I0_I1660_P46_39 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I303_XP_MN0 (I0_I1660_P50_43 I0_I1660_P50_47n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I303_XP_MN1 (VSS I0_I1660_P46_43n I0_I1660_P50_43 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I309_XP_MN0 (I0_I1660_P56_49 I0_I1660_P56_53n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I309_XP_MN1 (VSS I0_I1660_P52_49n I0_I1660_P56_49 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I178_XP_MN0 (I0_I1660_P48_47 I0_I1660_pn48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I178_XP_MN1 (VSS I0_I1660_pn47 I0_I1660_P48_47 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I180_XP_MN0 (I0_I1660_P50_49 I0_I1660_pn50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I180_XP_MN1 (VSS I0_I1660_pn49 I0_I1660_P50_49 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I314_XP_MN0 (I0_I1660_P61_54 I0_I1660_P61_58n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I314_XP_MN1 (VSS I0_I1660_P57_54n I0_I1660_P61_54 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I316_XP_MN0 (I0_I1660_P63_56 I0_I1660_P63_60n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I316_XP_MN1 (VSS I0_I1660_P59_56n I0_I1660_P63_56 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I181_XP_MN0 (I0_I1660_P51_50 I0_I1660_pn51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I181_XP_MN1 (VSS I0_I1660_pn50 I0_I1660_P51_50 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I156_XP_MN0 (I1_I1850_P31_24 I1_I1850_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I156_XP_MN1 (VSS I1_I1850_P27_24n I1_I1850_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I154_XP_MN0 (I1_I1850_P29_22 I1_I1850_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I154_XP_MN1 (VSS I1_I1850_P25_22n I1_I1850_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I89_XP_MN0 (I1_I1850_P23_22 I1_I1850_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I89_XP_MN1 (VSS I1_I1850_pn22 I1_I1850_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I88_XP_MN0 (I1_I1850_P22_21 I1_I1850_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I88_XP_MN1 (VSS I1_I1850_pn21 I1_I1850_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I147_XP_MN0 (I1_I1850_P22_15 I1_I1850_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I147_XP_MN1 (VSS I1_I1850_P18_15n I1_I1850_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I149_XP_MN0 (I1_I1850_P24_17 I1_I1850_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I149_XP_MN1 (VSS I1_I1850_P20_17n I1_I1850_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I87_XP_MN0 (I1_I1896_P21_20 I1_I1896_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I87_XP_MN1 (VSS I1_I1896_pn20 I1_I1896_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I152_XP_MN0 (I1_I1896_P27_20 I1_I1896_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I152_XP_MN1 (VSS I1_I1896_P23_20n I1_I1896_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I148_XP_MN0 (I1_I1896_P23_16 I1_I1896_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I148_XP_MN1 (VSS I1_I1896_P19_16n I1_I1896_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I88_XP_MN0 (I1_I1896_P22_21 I1_I1896_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I88_XP_MN1 (VSS I1_I1896_pn21 I1_I1896_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I151_XP_MN0 (I1_I1896_P26_19 I1_I1896_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I151_XP_MN1 (VSS I1_I1896_P22_19n I1_I1896_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I147_XP_MN0 (I1_I1896_P22_15 I1_I1896_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I147_XP_MN1 (VSS I1_I1896_P18_15n I1_I1896_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I89_XP_MN0 (I1_I1942_P23_22 I1_I1942_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I89_XP_MN1 (VSS I1_I1942_pn22 I1_I1942_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I154_XP_MN0 (I1_I1942_P29_22 I1_I1942_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I154_XP_MN1 (VSS I1_I1942_P25_22n I1_I1942_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I153_XP_MN0 (I1_I1942_P28_21 I1_I1942_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I153_XP_MN1 (VSS I1_I1942_P24_21n I1_I1942_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I154_XP_MN0 (I1_I1988_P29_22 I1_I1988_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I154_XP_MN1 (VSS I1_I1988_P25_22n I1_I1988_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I90_XP_MN0 (I1_I1988_P24_23 I1_I1988_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I90_XP_MN1 (VSS I1_I1988_pn23 I1_I1988_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I153_XP_MN0 (I1_I1988_P28_21 I1_I1988_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I153_XP_MN1 (VSS I1_I1988_P24_21n I1_I1988_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I88_XP_MN0 (I1_I2066_P22_21 I1_I2066_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I88_XP_MN1 (VSS I1_I2066_pn21 I1_I2066_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I86_XP_MN0 (I1_I2066_P20_19 I1_I2066_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I86_XP_MN1 (VSS I1_I2066_pn19 I1_I2066_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I153_XP_MN0 (I1_I2066_P28_21 I1_I2066_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I153_XP_MN1 (VSS I1_I2066_P24_21n I1_I2066_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I147_XP_MN0 (I1_I2066_P22_15 I1_I2066_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I147_XP_MN1 (VSS I1_I2066_P18_15n I1_I2066_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I87_XP_MN0 (I1_I2066_P21_20 I1_I2066_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I87_XP_MN1 (VSS I1_I2066_pn20 I1_I2066_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I20_MN0 (I2_I4_z0_20 Y_40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I20_MN1 (VSS Y_41 I2_I4_z0_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I21_MN0 (I2_I4_z0_21 Y_42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I21_MN1 (VSS Y_43 I2_I4_z0_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I417_XP_MN0 (I0_I1660_P54_23 I0_I1660_P54_39n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I417_XP_MN1 (VSS I0_I1660_P38_23n I0_I1660_P54_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I307_XP_MN0 (I0_I1660_P54_47 I0_I1660_P54_51n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I307_XP_MN1 (VSS I0_I1660_P50_47n I0_I1660_P54_47 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I313_XP_MN0 (I0_I1660_P60_53 I0_I1660_P60_57n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I313_XP_MN1 (VSS I0_I1660_P56_53n I0_I1660_P60_53 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I91_XP_MN0 (I1_I1850_P25_24 I1_I1850_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I91_XP_MN1 (VSS I1_I1850_pn24 I1_I1850_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I90_XP_MN0 (I1_I1850_P24_23 I1_I1850_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I90_XP_MN1 (VSS I1_I1850_pn23 I1_I1850_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I151_XP_MN0 (I1_I1850_P26_19 I1_I1850_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I151_XP_MN1 (VSS I1_I1850_P22_19n I1_I1850_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I89_XP_MN0 (I1_I1896_P23_22 I1_I1896_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I89_XP_MN1 (VSS I1_I1896_pn22 I1_I1896_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I154_XP_MN0 (I1_I1896_P29_22 I1_I1896_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I154_XP_MN1 (VSS I1_I1896_P25_22n I1_I1896_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I90_XP_MN0 (I1_I1896_P24_23 I1_I1896_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I90_XP_MN1 (VSS I1_I1896_pn23 I1_I1896_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I153_XP_MN0 (I1_I1896_P28_21 I1_I1896_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I153_XP_MN1 (VSS I1_I1896_P24_21n I1_I1896_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I91_XP_MN0 (I1_I1942_P25_24 I1_I1942_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I91_XP_MN1 (VSS I1_I1942_pn24 I1_I1942_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I156_XP_MN0 (I1_I1942_P31_24 I1_I1942_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I156_XP_MN1 (VSS I1_I1942_P27_24n I1_I1942_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I90_XP_MN0 (I1_I1942_P24_23 I1_I1942_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I90_XP_MN1 (VSS I1_I1942_pn23 I1_I1942_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I155_XP_MN0 (I1_I1942_P30_23 I1_I1942_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I155_XP_MN1 (VSS I1_I1942_P26_23n I1_I1942_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I91_XP_MN0 (I1_I1988_P25_24 I1_I1988_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I91_XP_MN1 (VSS I1_I1988_pn24 I1_I1988_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I156_XP_MN0 (I1_I1988_P31_24 I1_I1988_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I156_XP_MN1 (VSS I1_I1988_P27_24n I1_I1988_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I155_XP_MN0 (I1_I1988_P30_23 I1_I1988_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I155_XP_MN1 (VSS I1_I1988_P26_23n I1_I1988_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I151_XP_MN0 (I1_I2066_P26_19 I1_I2066_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I151_XP_MN1 (VSS I1_I2066_P22_19n I1_I2066_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I89_XP_MN0 (I1_I2066_P23_22 I1_I2066_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I89_XP_MN1 (VSS I1_I2066_pn22 I1_I2066_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I148_XP_MN0 (I1_I2066_P23_16 I1_I2066_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I148_XP_MN1 (VSS I1_I2066_P19_16n I1_I2066_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I22_MN0 (I2_I4_z0_22 Y_44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I22_MN1 (VSS Y_45 I2_I4_z0_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I425_XP_MN0 (I0_I1660_P62_31 I0_I1660_P62_47n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I425_XP_MN1 (VSS I0_I1660_P46_31n I0_I1660_P62_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I311_XP_MN0 (I0_I1660_P58_51 I0_I1660_P58_55n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I311_XP_MN1 (VSS I0_I1660_P54_51n I0_I1660_P58_51 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I182_XP_MN0 (I0_I1660_P52_51 I0_I1660_pn52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I182_XP_MN1 (VSS I0_I1660_pn51 I0_I1660_P52_51 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I189_XP_MN0 (I0_I1660_P59_58 I0_I1660_pn59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I189_XP_MN1 (VSS I0_I1660_pn58 I0_I1660_P59_58 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I187_XP_MN0 (I0_I1660_P57_56 I0_I1660_pn57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
