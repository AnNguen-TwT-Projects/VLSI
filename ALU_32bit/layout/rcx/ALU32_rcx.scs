    I_MXI0_I274_MN1_1 (VSS I0_A_26_b2_0 I0_A_26_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I264_MN1 (I0_A_25_b3_0 I0_A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I264_MN1_1 (VSS I0_A_25_b2_0 I0_A_25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I271_MN1 (I0_A_26_b1_0 I0_A_26_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I271_MN1_1 (VSS I0_A_26_b0 I0_A_26_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I262_MN1 (I0_A_25_b2_0 I0_A_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I262_MN1_1 (VSS I0_A_25_b1_0 I0_A_25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I667_MN1 (I0_two3_b3_5 I0_two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I667_MN1_1 (VSS I0_two3_b2_1 I0_two3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I282_MN1 (I0_A_27_b2_0 I0_A_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I282_MN1_1 (VSS I0_A_27_b1_0 I0_A_27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I305_MN1 (I0_A_29_b3_1 I0_A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I305_MN1_1 (VSS I0_A_29_b2_0 I0_A_29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I306_MN1 (I0_A_29_b3_2 I0_A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I306_MN1_1 (VSS I0_A_29_b2_0 I0_A_29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I315_MN1 (I0_A_30_b3_1 I0_A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I315_MN1_1 (VSS I0_A_30_b2_0 I0_A_30_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I316_MN1 (I0_A_30_b3_2 I0_A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I316_MN1_1 (VSS I0_A_30_b2_0 I0_A_30_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I321_MN1 (I0_A_31_b1_0 I0_A_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I321_MN1_1 (VSS I0_A_31_b0 I0_A_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I322_MN1 (I0_A_31_b2_0 I0_A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I322_MN1_1 (VSS I0_A_31_b1_0 I0_A_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1577_MN1 (I1_qu9 I1_p22_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1577_MN1_1 (VSS I1_p22_32 I1_qu9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1537_MN1 (I1_qu10_b3_1 I1_qu10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1537_MN1_1 (VSS I1_qu10_b2_0 I1_qu10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I177_MN1 (I1_dd4_b3_4 I1_dd4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I177_MN1_1 (VSS I1_dd4_b2_1 I1_dd4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I190_MN1 (I1_dd5_b3_4 I1_dd5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I190_MN1_1 (VSS I1_dd5_b2_1 I1_dd5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I164_MN1 (I1_dd3_b3_4 I1_dd3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I164_MN1_1 (VSS I1_dd3_b2_1 I1_dd3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I138_MN1 (I1_dd1_b3_4 I1_dd1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I138_MN1_1 (VSS I1_dd1_b2_1 I1_dd1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I5_MN1 (I1_A_31_b3_0 I1_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I5_MN1_1 (VSS I1_A_31_b2_0 I1_A_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I121_MN1 (I0_A_11_b1_0 I0_A_11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I121_MN1_1 (VSS I0_A_11_b0 I0_A_11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I353_MN1 (I0_B_7_b1_0 I0_B_7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I353_MN1_1 (VSS I0_B_7_b0 I0_B_7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2_MN1 (I1_A_31_b2_0 I1_A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2_MN1_1 (VSS I1_A_31_b1_0 I1_A_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I594_MN1 (I0_one2_b1_0 I0_one2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I594_MN1_1 (VSS I0_one2_b0 I0_one2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I604_MN1 (I0_two2_b1_0 I0_two2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I604_MN1_1 (VSS I0_two2_b0 I0_two2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1_MN1 (I1_A_31_b1_0 I1_A_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1_MN1_1 (VSS I1_A_31_b0 I1_A_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I486_MN1 (I0_one0_b2_1 I0_one0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I486_MN1_1 (VSS I0_one0_b1_0 I0_one0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I605_MN1 (I0_two2_b2_0 I0_two2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I605_MN1_1 (VSS I0_two2_b1_0 I0_two2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I496_MN1 (I0_two0_b2_1 I0_two0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I496_MN1_1 (VSS I0_two0_b1_0 I0_two0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I345_MN1 (I0_B_5_b2_1 I0_B_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I345_MN1_1 (VSS I0_B_5_b1_0 I0_B_5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I356_MN1 (I0_B_7_b3_0 I0_B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I356_MN1_1 (VSS I0_B_7_b2_0 I0_B_7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I659_MN1 (I0_two3_b1_0 I0_two3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I659_MN1_1 (VSS I0_two3_b0 I0_two3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I354_MN1 (I0_B_7_b2_0 I0_B_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I354_MN1_1 (VSS I0_B_7_b1_0 I0_B_7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I355_MN1 (I0_B_7_b2_1 I0_B_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I355_MN1_1 (VSS I0_B_7_b1_0 I0_B_7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I649_MN1 (I0_one3_b1_0 I0_one3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I649_MN1_1 (VSS I0_one3_b0 I0_one3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I661_MN1 (I0_two3_b2_1 I0_two3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I661_MN1_1 (VSS I0_two3_b1_0 I0_two3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I660_MN1 (I0_two3_b2_0 I0_two3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I660_MN1_1 (VSS I0_two3_b1_0 I0_two3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I651_MN1 (I0_one3_b2_1 I0_one3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I651_MN1_1 (VSS I0_one3_b1_0 I0_one3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I824_MN1 (I0_two6_b1_0 I0_two6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I824_MN1_1 (VSS I0_two6_b0 I0_two6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I204_MN1 (I0_A_19_b3_0 I0_A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I204_MN1_1 (VSS I0_A_19_b2_0 I0_A_19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I214_MN1 (I0_A_20_b3_0 I0_A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I214_MN1_1 (VSS I0_A_20_b2_0 I0_A_20_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I184_MN1 (I0_A_17_b3_0 I0_A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I184_MN1_1 (VSS I0_A_17_b2_0 I0_A_17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I234_MN1 (I0_A_22_b3_0 I0_A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I234_MN1_1 (VSS I0_A_22_b2_0 I0_A_22_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I360_MN1 (I0_B_7_b3_4 I0_B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I360_MN1_1 (VSS I0_B_7_b2_1 I0_B_7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I244_MN1 (I0_A_23_b3_0 I0_A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I244_MN1_1 (VSS I0_A_23_b2_0 I0_A_23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I254_MN1 (I0_A_24_b3_0 I0_A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I254_MN1_1 (VSS I0_A_24_b2_0 I0_A_24_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I666_MN1 (I0_two3_b3_4 I0_two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I666_MN1_1 (VSS I0_two3_b2_1 I0_two3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I255_MN1 (I0_A_24_b3_1 I0_A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I255_MN1_1 (VSS I0_A_24_b2_0 I0_A_24_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I232_MN1 (I0_A_22_b2_0 I0_A_22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I232_MN1_1 (VSS I0_A_22_b1_0 I0_A_22_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I272_MN1 (I0_A_26_b2_0 I0_A_26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I272_MN1_1 (VSS I0_A_26_b1_0 I0_A_26_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I275_MN1 (I0_A_26_b3_1 I0_A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I275_MN1_1 (VSS I0_A_26_b2_0 I0_A_26_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I285_MN1 (I0_A_27_b3_1 I0_A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I285_MN1_1 (VSS I0_A_27_b2_0 I0_A_27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I657_MN1 (I0_one3_b3_5 I0_one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I657_MN1_1 (VSS I0_one3_b2_1 I0_one3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I242_MN1 (I0_A_23_b2_0 I0_A_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I242_MN1_1 (VSS I0_A_23_b1_0 I0_A_23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I252_MN1 (I0_A_24_b2_0 I0_A_24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I252_MN1_1 (VSS I0_A_24_b1_0 I0_A_24_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I256_MN1 (I0_A_24_b3_2 I0_A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I256_MN1_1 (VSS I0_A_24_b2_0 I0_A_24_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1678_MN1 (I1_qu7_b3_4 I1_qu7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1678_MN1_1 (VSS I1_qu7_b2_1 I1_qu7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1677_MN1 (I1_qu7_b3_3 I1_qu7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1677_MN1_1 (VSS I1_qu7_b2_1 I1_qu7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1679_MN1 (I1_qu7_b3_5 I1_qu7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1679_MN1_1 (VSS I1_qu7_b2_1 I1_qu7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1673_MN1 (I1_qu7_b2_1 I1_qu7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1673_MN1_1 (VSS I1_qu7_b1_0 I1_qu7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1676_MN1 (I1_qu7_b3_2 I1_qu7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1676_MN1_1 (VSS I1_qu7_b2_0 I1_qu7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1675_MN1 (I1_qu7_b3_1 I1_qu7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1675_MN1_1 (VSS I1_qu7_b2_0 I1_qu7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1628_MN1 (I1_qu8_b3_0 I1_qu8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1628_MN1_1 (VSS I1_qu8_b2_0 I1_qu8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1579_MN1 (I1_qu9_b1_0 I1_qu9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1579_MN1_1 (VSS I1_qu9_b0 I1_qu9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1538_MN1 (I1_qu10_b3_2 I1_qu10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1538_MN1_1 (VSS I1_qu10_b2_0 I1_qu10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I203_MN1 (I1_dd6_b3_4 I1_dd6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I203_MN1_1 (VSS I1_dd6_b2_1 I1_dd6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I216_MN1 (I1_dd7_b3_4 I1_dd7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I216_MN1_1 (VSS I1_dd7_b2_1 I1_dd7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1_MN1 (I0_B_1_b1_0 I0_B_1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1_MN1_1 (VSS I0_B_1_b0 I0_B_1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I333_MN1 (I0_B_3_b1_0 I0_B_3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I333_MN1_1 (VSS I0_B_3_b0 I0_B_3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I343_MN1 (I0_B_5_b1_0 I0_B_5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I343_MN1_1 (VSS I0_B_5_b0 I0_B_5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I539_MN1 (I0_one1_b1_0 I0_one1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I539_MN1_1 (VSS I0_one1_b0 I0_one1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I549_MN1 (I0_two1_b1_0 I0_two1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I549_MN1_1 (VSS I0_two1_b0 I0_two1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I544_MN1 (I0_one1_b3_2 I0_one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I544_MN1_1 (VSS I0_one1_b2_0 I0_one1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I550_MN1 (I0_two1_b2_0 I0_two1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I550_MN1_1 (VSS I0_two1_b1_0 I0_two1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I346_MN1 (I0_B_5_b3_0 I0_B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I346_MN1_1 (VSS I0_B_5_b2_0 I0_B_5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I347_MN1 (I0_B_5_b3_1 I0_B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I347_MN1_1 (VSS I0_B_5_b2_0 I0_B_5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I344_MN1 (I0_B_5_b2_0 I0_B_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I344_MN1_1 (VSS I0_B_5_b1_0 I0_B_5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I348_MN1 (I0_B_5_b3_2 I0_B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I348_MN1_1 (VSS I0_B_5_b2_0 I0_B_5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I599_MN1 (I0_one2_b3_2 I0_one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I599_MN1_1 (VSS I0_one2_b2_0 I0_one2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I595_MN1 (I0_one2_b2_0 I0_one2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I595_MN1_1 (VSS I0_one2_b1_0 I0_one2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I609_MN1 (I0_two2_b3_2 I0_two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I609_MN1_1 (VSS I0_two2_b2_0 I0_two2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I769_MN1 (I0_two5_b1_0 I0_two5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I769_MN1_1 (VSS I0_two5_b0 I0_two5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I759_MN1 (I0_one5_b1_0 I0_one5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I759_MN1_1 (VSS I0_one5_b0 I0_one5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I814_MN1 (I0_one6_b1_0 I0_one6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I814_MN1_1 (VSS I0_one6_b0 I0_one6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I174_MN1 (I0_A_16_b3_0 I0_A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I174_MN1_1 (VSS I0_A_16_b2_0 I0_A_16_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I365_MN1 (I0_B_9_b2_1 I0_B_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I365_MN1_1 (VSS I0_B_9_b1_0 I0_B_9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I175_MN1 (I0_A_16_b3_1 I0_A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I175_MN1_1 (VSS I0_A_16_b2_0 I0_A_16_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I194_MN1 (I0_A_18_b3_0 I0_A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I194_MN1_1 (VSS I0_A_18_b2_0 I0_A_18_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I371_MN1 (I0_B_9_b3_5 I0_B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I371_MN1_1 (VSS I0_B_9_b2_1 I0_B_9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I172_MN1 (I0_A_16_b2_0 I0_A_16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I172_MN1_1 (VSS I0_A_16_b1_0 I0_A_16_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I215_MN1 (I0_A_20_b3_1 I0_A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I215_MN1_1 (VSS I0_A_20_b2_0 I0_A_20_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I361_MN1 (I0_B_7_b3_5 I0_B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I361_MN1_1 (VSS I0_B_7_b2_1 I0_B_7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I182_MN1 (I0_A_17_b2_0 I0_A_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I182_MN1_1 (VSS I0_A_17_b1_0 I0_A_17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I224_MN1 (I0_A_21_b3_0 I0_A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I224_MN1_1 (VSS I0_A_21_b2_0 I0_A_21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I225_MN1 (I0_A_21_b3_1 I0_A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I225_MN1_1 (VSS I0_A_21_b2_0 I0_A_21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I370_MN1 (I0_B_9_b3_4 I0_B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I370_MN1_1 (VSS I0_B_9_b2_1 I0_B_9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I359_MN1 (I0_B_7_b3_3 I0_B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I359_MN1_1 (VSS I0_B_7_b2_1 I0_B_7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I192_MN1 (I0_A_18_b2_0 I0_A_18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I192_MN1_1 (VSS I0_A_18_b1_0 I0_A_18_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I216_MN1 (I0_A_20_b3_2 I0_A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I216_MN1_1 (VSS I0_A_20_b2_0 I0_A_20_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I235_MN1 (I0_A_22_b3_1 I0_A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I235_MN1_1 (VSS I0_A_22_b2_0 I0_A_22_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I226_MN1 (I0_A_21_b3_2 I0_A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I226_MN1_1 (VSS I0_A_21_b2_0 I0_A_21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I656_MN1 (I0_one3_b3_4 I0_one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I656_MN1_1 (VSS I0_one3_b2_1 I0_one3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I245_MN1 (I0_A_23_b3_1 I0_A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I245_MN1_1 (VSS I0_A_23_b2_0 I0_A_23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I212_MN1 (I0_A_20_b2_0 I0_A_20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I212_MN1_1 (VSS I0_A_20_b1_0 I0_A_20_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I222_MN1 (I0_A_21_b2_0 I0_A_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I222_MN1_1 (VSS I0_A_21_b1_0 I0_A_21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I722_MN1 (I0_two4_b3_5 I0_two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I722_MN1_1 (VSS I0_two4_b2_1 I0_two4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I266_MN1 (I0_A_25_b3_2 I0_A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I266_MN1_1 (VSS I0_A_25_b2_0 I0_A_25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I276_MN1 (I0_A_26_b3_2 I0_A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I276_MN1_1 (VSS I0_A_26_b2_0 I0_A_26_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I246_MN1 (I0_A_23_b3_2 I0_A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I246_MN1_1 (VSS I0_A_23_b2_0 I0_A_23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I712_MN1 (I0_one4_b3_5 I0_one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I712_MN1_1 (VSS I0_one4_b2_1 I0_one4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I286_MN1 (I0_A_27_b3_2 I0_A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I286_MN1_1 (VSS I0_A_27_b2_0 I0_A_27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I295_MN1 (I0_A_28_b3_1 I0_A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I295_MN1_1 (VSS I0_A_28_b2_0 I0_A_28_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I296_MN1 (I0_A_28_b3_2 I0_A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I296_MN1_1 (VSS I0_A_28_b2_0 I0_A_28_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1672_MN1 (I1_qu7_b2_0 I1_qu7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1672_MN1_1 (VSS I1_qu7_b1_0 I1_qu7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1629_MN1 (I1_qu8_b3_1 I1_qu8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1629_MN1_1 (VSS I1_qu8_b2_0 I1_qu8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1580_MN1 (I1_qu9_b2_0 I1_qu9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1580_MN1_1 (VSS I1_qu9_b1_0 I1_qu9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1584_MN1 (I1_qu9_b3_2 I1_qu9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1584_MN1_1 (VSS I1_qu9_b2_0 I1_qu9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I268_MN1 (I1_dd11_b3_4 I1_dd11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I268_MN1_1 (VSS I1_dd11_b2_1 I1_dd11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I255_MN1 (I1_dd10_b3_4 I1_dd10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I255_MN1_1 (VSS I1_dd10_b2_1 I1_dd10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1583_MN1 (I1_qu9_b3_1 I1_qu9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1583_MN1_1 (VSS I1_qu9_b2_0 I1_qu9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1582_MN1 (I1_qu9_b3_0 I1_qu9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1582_MN1_1 (VSS I1_qu9_b2_0 I1_qu9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I62_MN1 (I2_I3_SEL_DIV_b3_1 I2_I3_SEL_DIV_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I62_MN1_1 (VSS I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I61_MN1 (I2_I3_SEL_DIV_b3_0 I2_I3_SEL_DIV_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I61_MN1_1 (VSS I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I484_MN1 (I0_one0_b1_0 I0_one0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I484_MN1_1 (VSS I0_one0_b0 I0_one0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I2_MN1 (I0_B_1_b2_0 I0_B_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I2_MN1_1 (VSS I0_B_1_b1_0 I0_B_1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I6_MN1 (I0_B_1_b3_2 I0_B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I6_MN1_1 (VSS I0_B_1_b2_0 I0_B_1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I336_MN1 (I0_B_3_b3_0 I0_B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I336_MN1_1 (VSS I0_B_3_b2_0 I0_B_3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I334_MN1 (I0_B_3_b2_0 I0_B_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I334_MN1_1 (VSS I0_B_3_b1_0 I0_B_3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I338_MN1 (I0_B_3_b3_2 I0_B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I338_MN1_1 (VSS I0_B_3_b2_0 I0_B_3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I540_MN1 (I0_one1_b2_0 I0_one1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I540_MN1_1 (VSS I0_one1_b1_0 I0_one1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I704_MN1 (I0_one4_b1_0 I0_one4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I704_MN1_1 (VSS I0_one4_b0 I0_one4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I554_MN1 (I0_two1_b3_2 I0_two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I554_MN1_1 (VSS I0_two1_b2_0 I0_two1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I357_MN1 (I0_B_7_b3_1 I0_B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I357_MN1_1 (VSS I0_B_7_b2_0 I0_B_7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I124_MN1 (I0_A_11_b3_0 I0_A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I124_MN1_1 (VSS I0_A_11_b2_0 I0_A_11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I358_MN1 (I0_B_7_b3_2 I0_B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I358_MN1_1 (VSS I0_B_7_b2_0 I0_B_7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I664_MN1 (I0_two3_b3_2 I0_two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I664_MN1_1 (VSS I0_two3_b2_0 I0_two3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I650_MN1 (I0_one3_b2_0 I0_one3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I650_MN1_1 (VSS I0_one3_b1_0 I0_one3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I716_MN1 (I0_two4_b2_1 I0_two4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I716_MN1_1 (VSS I0_two4_b1_0 I0_two4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I710_MN1 (I0_one4_b3_3 I0_one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I710_MN1_1 (VSS I0_one4_b2_1 I0_one4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I720_MN1 (I0_two4_b3_3 I0_two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I720_MN1_1 (VSS I0_two4_b2_1 I0_two4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I185_MN1 (I0_A_17_b3_1 I0_A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I185_MN1_1 (VSS I0_A_17_b2_0 I0_A_17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I195_MN1 (I0_A_18_b3_1 I0_A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I195_MN1_1 (VSS I0_A_18_b2_0 I0_A_18_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I176_MN1 (I0_A_16_b3_2 I0_A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I176_MN1_1 (VSS I0_A_16_b2_0 I0_A_16_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I761_MN1 (I0_one5_b2_1 I0_one5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I761_MN1_1 (VSS I0_one5_b1_0 I0_one5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I205_MN1 (I0_A_19_b3_1 I0_A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I205_MN1_1 (VSS I0_A_19_b2_0 I0_A_19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I765_MN1 (I0_one5_b3_3 I0_one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I765_MN1_1 (VSS I0_one5_b2_1 I0_one5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I375_MN1 (I0_B_11_b2_1 I0_B_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I375_MN1_1 (VSS I0_B_11_b1_0 I0_B_11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I369_MN1 (I0_B_9_b3_3 I0_B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I369_MN1_1 (VSS I0_B_9_b2_1 I0_B_9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I775_MN1 (I0_two5_b3_3 I0_two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I775_MN1_1 (VSS I0_two5_b2_1 I0_two5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I186_MN1 (I0_A_17_b3_2 I0_A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I186_MN1_1 (VSS I0_A_17_b2_0 I0_A_17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I379_MN1 (I0_B_11_b3_3 I0_B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I379_MN1_1 (VSS I0_B_11_b2_1 I0_B_11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I381_MN1 (I0_B_11_b3_5 I0_B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I381_MN1_1 (VSS I0_B_11_b2_1 I0_B_11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I196_MN1 (I0_A_18_b3_2 I0_A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I196_MN1_1 (VSS I0_A_18_b2_0 I0_A_18_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I380_MN1 (I0_B_11_b3_4 I0_B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I380_MN1_1 (VSS I0_B_11_b2_1 I0_B_11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I206_MN1 (I0_A_19_b3_2 I0_A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I206_MN1_1 (VSS I0_A_19_b2_0 I0_A_19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I820_MN1 (I0_one6_b3_3 I0_one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I820_MN1_1 (VSS I0_one6_b2_1 I0_one6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I711_MN1 (I0_one4_b3_4 I0_one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I711_MN1_1 (VSS I0_one4_b2_1 I0_one4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I173_MN1 (I0_A_16_b2_1 I0_A_16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I173_MN1_1 (VSS I0_A_16_b1_0 I0_A_16_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I766_MN1 (I0_one5_b3_4 I0_one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I766_MN1_1 (VSS I0_one5_b2_1 I0_one5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I776_MN1 (I0_two5_b3_4 I0_two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I776_MN1_1 (VSS I0_two5_b2_1 I0_two5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I777_MN1 (I0_two5_b3_5 I0_two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I777_MN1_1 (VSS I0_two5_b2_1 I0_two5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I767_MN1 (I0_one5_b3_5 I0_one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I767_MN1_1 (VSS I0_one5_b2_1 I0_one5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I326_MN1 (I0_A_31_b3_2 I0_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I326_MN1_1 (VSS I0_A_31_b2_0 I0_A_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1724_MN1 (I1_qu6_b3_4 I1_qu6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1724_MN1_1 (VSS I1_qu6_b2_1 I1_qu6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1725_MN1 (I1_qu6_b3_5 I1_qu6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1725_MN1_1 (VSS I1_qu6_b2_1 I1_qu6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1723_MN1 (I1_qu6_b3_3 I1_qu6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1723_MN1_1 (VSS I1_qu6_b2_1 I1_qu6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1719_MN1 (I1_qu6_b2_1 I1_qu6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1719_MN1_1 (VSS I1_qu6_b1_0 I1_qu6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1715_MN1 (I1_qu6 I1_p25_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1715_MN1_1 (VSS I1_p25_32 I1_qu6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1717_MN1 (I1_qu6_b1_0 I1_qu6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1717_MN1_1 (VSS I1_qu6_b0 I1_qu6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1722_MN1 (I1_qu6_b3_2 I1_qu6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1722_MN1_1 (VSS I1_qu6_b2_0 I1_qu6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1718_MN1 (I1_qu6_b2_0 I1_qu6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1718_MN1_1 (VSS I1_qu6_b1_0 I1_qu6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I307_MN1 (I1_dd14_b3_4 I1_dd14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I307_MN1_1 (VSS I1_dd14_b2_1 I1_dd14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I294_MN1 (I1_dd13_b3_4 I1_dd13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I294_MN1_1 (VSS I1_dd13_b2_1 I1_dd13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I27_MN1 (I1_B_0_b1_0 I1_B_0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I27_MN1_1 (VSS I1_B_0_b0 I1_B_0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I4_MN1 (I2_I1_SUB_b3_0 I2_I1_SUB_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I4_MN1_1 (VSS I2_I1_SUB_b2_0 I2_I1_SUB_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I494_MN1 (I0_two0_b1_0 I0_two0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I494_MN1_1 (VSS I0_two0_b0 I0_two0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I363_MN1 (I0_B_9_b1_0 I0_B_9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I363_MN1_1 (VSS I0_B_9_b0 I0_B_9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I495_MN1 (I0_two0_b2_0 I0_two0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I495_MN1_1 (VSS I0_two0_b1_0 I0_two0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I499_MN1 (I0_two0_b3_2 I0_two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I499_MN1_1 (VSS I0_two0_b2_0 I0_two0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I485_MN1 (I0_one0_b2_0 I0_one0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I485_MN1_1 (VSS I0_one0_b1_0 I0_one0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I489_MN1 (I0_one0_b3_2 I0_one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I489_MN1_1 (VSS I0_one0_b2_0 I0_one0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I337_MN1 (I0_B_3_b3_1 I0_B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I337_MN1_1 (VSS I0_B_3_b2_0 I0_B_3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I714_MN1 (I0_two4_b1_0 I0_two4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I714_MN1_1 (VSS I0_two4_b0 I0_two4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I364_MN1 (I0_B_9_b2_0 I0_B_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I364_MN1_1 (VSS I0_B_9_b1_0 I0_B_9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I144_MN1 (I0_A_13_b3_0 I0_A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I144_MN1_1 (VSS I0_A_13_b2_0 I0_A_13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I654_MN1 (I0_one3_b3_2 I0_one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I654_MN1_1 (VSS I0_one3_b2_0 I0_one3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I374_MN1 (I0_B_11_b2_0 I0_B_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I374_MN1_1 (VSS I0_B_11_b1_0 I0_B_11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I134_MN1 (I0_A_12_b3_0 I0_A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I134_MN1_1 (VSS I0_A_12_b2_0 I0_A_12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I760_MN1 (I0_one5_b2_0 I0_one5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I760_MN1_1 (VSS I0_one5_b1_0 I0_one5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I164_MN1 (I0_A_15_b3_0 I0_A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I164_MN1_1 (VSS I0_A_15_b2_0 I0_A_15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I122_MN1 (I0_A_11_b2_0 I0_A_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I122_MN1_1 (VSS I0_A_11_b1_0 I0_A_11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I154_MN1 (I0_A_14_b3_0 I0_A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I154_MN1_1 (VSS I0_A_14_b2_0 I0_A_14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I126_MN1 (I0_A_11_b3_2 I0_A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I126_MN1_1 (VSS I0_A_11_b2_0 I0_A_11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I125_MN1 (I0_A_11_b3_1 I0_A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I125_MN1_1 (VSS I0_A_11_b2_0 I0_A_11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I162_MN1 (I0_A_15_b2_0 I0_A_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I162_MN1_1 (VSS I0_A_15_b1_0 I0_A_15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I136_MN1 (I0_A_12_b3_2 I0_A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I136_MN1_1 (VSS I0_A_12_b2_0 I0_A_12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I152_MN1 (I0_A_14_b2_0 I0_A_14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I152_MN1_1 (VSS I0_A_14_b1_0 I0_A_14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I146_MN1 (I0_A_13_b3_2 I0_A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I146_MN1_1 (VSS I0_A_13_b2_0 I0_A_13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I145_MN1 (I0_A_13_b3_1 I0_A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I145_MN1_1 (VSS I0_A_13_b2_0 I0_A_13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I155_MN1 (I0_A_14_b3_1 I0_A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I155_MN1_1 (VSS I0_A_14_b2_0 I0_A_14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I825_MN1 (I0_two6_b2_0 I0_two6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I825_MN1_1 (VSS I0_two6_b1_0 I0_two6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I166_MN1 (I0_A_15_b3_2 I0_A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I166_MN1_1 (VSS I0_A_15_b2_0 I0_A_15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I165_MN1 (I0_A_15_b3_1 I0_A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I165_MN1_1 (VSS I0_A_15_b2_0 I0_A_15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I156_MN1 (I0_A_14_b3_2 I0_A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I156_MN1_1 (VSS I0_A_14_b2_0 I0_A_14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I706_MN1 (I0_one4_b2_1 I0_one4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I706_MN1_1 (VSS I0_one4_b1_0 I0_one4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I879_MN1 (I0_two7_b1_0 I0_two7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I879_MN1_1 (VSS I0_two7_b0 I0_two7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I771_MN1 (I0_two5_b2_1 I0_two5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I771_MN1_1 (VSS I0_two5_b1_0 I0_two5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I826_MN1 (I0_two6_b2_1 I0_two6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I826_MN1_1 (VSS I0_two6_b1_0 I0_two6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I385_MN1 (I0_B_13_b2_1 I0_B_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I385_MN1_1 (VSS I0_B_13_b1_0 I0_B_13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I143_MN1 (I0_A_13_b2_1 I0_A_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I143_MN1_1 (VSS I0_A_13_b1_0 I0_A_13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I816_MN1 (I0_one6_b2_1 I0_one6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I816_MN1_1 (VSS I0_one6_b1_0 I0_one6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I830_MN1 (I0_two6_b3_3 I0_two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I830_MN1_1 (VSS I0_two6_b2_1 I0_two6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I885_MN1 (I0_two7_b3_3 I0_two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I885_MN1_1 (VSS I0_two7_b2_1 I0_two7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I390_MN1 (I0_B_13_b3_4 I0_B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I390_MN1_1 (VSS I0_B_13_b2_1 I0_B_13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I831_MN1 (I0_two6_b3_4 I0_two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I831_MN1_1 (VSS I0_two6_b2_1 I0_two6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I832_MN1 (I0_two6_b3_5 I0_two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I832_MN1_1 (VSS I0_two6_b2_1 I0_two6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I821_MN1 (I0_one6_b3_4 I0_one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I821_MN1_1 (VSS I0_one6_b2_1 I0_one6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I822_MN1 (I0_one6_b3_5 I0_one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I822_MN1_1 (VSS I0_one6_b2_1 I0_one6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I327_MN1 (I0_A_31_b3_3 I0_A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I327_MN1_1 (VSS I0_A_31_b2_0 I0_A_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1671_MN1 (I1_qu7_b1_0 I1_qu7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1671_MN1_1 (VSS I1_qu7_b0 I1_qu7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I320_MN1 (I1_dd15_b3_4 I1_dd15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I320_MN1_1 (VSS I1_dd15_b2_1 I1_dd15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I346_MN1 (I1_dd17_b3_4 I1_dd17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I346_MN1_1 (VSS I1_dd17_b2_1 I1_dd17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I333_MN1 (I1_dd16_b3_4 I1_dd16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I333_MN1_1 (VSS I1_dd16_b2_1 I1_dd16_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I281_MN1 (I1_dd12_b3_4 I1_dd12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I281_MN1_1 (VSS I1_dd12_b2_1 I1_dd12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I5_MN1 (I2_I3_SEL_AND_b3_1 I2_I3_SEL_AND_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I5_MN1_1 (VSS I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I15_MN1 (I2_I3_SEL_OR_b3_1 I2_I3_SEL_OR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I15_MN1_1 (VSS I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I4_MN1 (I0_B_1_b3_0 I0_B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I4_MN1_1 (VSS I0_B_1_b2_0 I0_B_1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I552_MN1 (I0_two1_b3_0 I0_two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I552_MN1_1 (VSS I0_two1_b2_0 I0_two1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I553_MN1 (I0_two1_b3_1 I0_two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I553_MN1_1 (VSS I0_two1_b2_0 I0_two1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I543_MN1 (I0_one1_b3_1 I0_one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I543_MN1_1 (VSS I0_one1_b2_0 I0_one1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I607_MN1 (I0_two2_b3_0 I0_two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I607_MN1_1 (VSS I0_two2_b2_0 I0_two2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I597_MN1 (I0_one2_b3_0 I0_one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I597_MN1_1 (VSS I0_one2_b2_0 I0_one2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I608_MN1 (I0_two2_b3_1 I0_two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I608_MN1_1 (VSS I0_two2_b2_0 I0_two2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I598_MN1 (I0_one2_b3_1 I0_one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I598_MN1_1 (VSS I0_one2_b2_0 I0_one2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I705_MN1 (I0_one4_b2_0 I0_one4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I705_MN1_1 (VSS I0_one4_b1_0 I0_one4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I376_MN1 (I0_B_11_b3_0 I0_B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I376_MN1_1 (VSS I0_B_11_b2_0 I0_B_11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I715_MN1 (I0_two4_b2_0 I0_two4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I715_MN1_1 (VSS I0_two4_b1_0 I0_two4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I719_MN1 (I0_two4_b3_2 I0_two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I719_MN1_1 (VSS I0_two4_b2_0 I0_two4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I764_MN1 (I0_one5_b3_2 I0_one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I764_MN1_1 (VSS I0_one5_b2_0 I0_one5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I774_MN1 (I0_two5_b3_2 I0_two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I774_MN1_1 (VSS I0_two5_b2_0 I0_two5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I819_MN1 (I0_one6_b3_2 I0_one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I819_MN1_1 (VSS I0_one6_b2_0 I0_one6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I388_MN1 (I0_B_13_b3_2 I0_B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I388_MN1_1 (VSS I0_B_13_b2_0 I0_B_13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I123_MN1 (I0_A_11_b2_1 I0_A_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I123_MN1_1 (VSS I0_A_11_b1_0 I0_A_11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I829_MN1 (I0_two6_b3_2 I0_two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I829_MN1_1 (VSS I0_two6_b2_0 I0_two6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I869_MN1 (I0_one7_b1_0 I0_one7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I869_MN1_1 (VSS I0_one7_b0 I0_one7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1721_MN1 (I1_qu6_b3_1 I1_qu6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1721_MN1_1 (VSS I1_qu6_b2_0 I1_qu6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1626_MN1 (I1_qu8_b2_0 I1_qu8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1626_MN1_1 (VSS I1_qu8_b1_0 I1_qu8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1630_MN1 (I1_qu8_b3_2 I1_qu8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1630_MN1_1 (VSS I1_qu8_b2_0 I1_qu8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1625_MN1 (I1_qu8_b1_0 I1_qu8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1625_MN1_1 (VSS I1_qu8_b0 I1_qu8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1623_MN1 (I1_qu8 I1_p23_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1623_MN1_1 (VSS I1_p23_32 I1_qu8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I497_MN1 (I0_two0_b3_0 I0_two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I497_MN1_1 (VSS I0_two0_b2_0 I0_two0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I366_MN1 (I0_B_9_b3_0 I0_B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I366_MN1_1 (VSS I0_B_9_b2_0 I0_B_9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I104_MN1 (I0_A_9_b3_0 I0_A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I104_MN1_1 (VSS I0_A_9_b2_0 I0_A_9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I111_MN1 (I0_A_10_b1_0 I0_A_10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I111_MN1_1 (VSS I0_A_10_b0 I0_A_10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I652_MN1 (I0_one3_b3_0 I0_one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I652_MN1_1 (VSS I0_one3_b2_0 I0_one3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I114_MN1 (I0_A_10_b3_0 I0_A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I114_MN1_1 (VSS I0_A_10_b2_0 I0_A_10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I653_MN1 (I0_one3_b3_1 I0_one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I653_MN1_1 (VSS I0_one3_b2_0 I0_one3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I663_MN1 (I0_two3_b3_1 I0_two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I663_MN1_1 (VSS I0_two3_b2_0 I0_two3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I115_MN1 (I0_A_10_b3_1 I0_A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I115_MN1_1 (VSS I0_A_10_b2_0 I0_A_10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I709_MN1 (I0_one4_b3_2 I0_one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I709_MN1_1 (VSS I0_one4_b2_0 I0_one4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I105_MN1 (I0_A_9_b3_1 I0_A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I105_MN1_1 (VSS I0_A_9_b2_0 I0_A_9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I106_MN1 (I0_A_9_b3_2 I0_A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I106_MN1_1 (VSS I0_A_9_b2_0 I0_A_9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I368_MN1 (I0_B_9_b3_2 I0_B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I368_MN1_1 (VSS I0_B_9_b2_0 I0_B_9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I378_MN1 (I0_B_11_b3_2 I0_B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I378_MN1_1 (VSS I0_B_11_b2_0 I0_B_11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I377_MN1 (I0_B_11_b3_1 I0_B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I377_MN1_1 (VSS I0_B_11_b2_0 I0_B_11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I116_MN1 (I0_A_10_b3_2 I0_A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I116_MN1_1 (VSS I0_A_10_b2_0 I0_A_10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I112_MN1 (I0_A_10_b2_0 I0_A_10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I112_MN1_1 (VSS I0_A_10_b1_0 I0_A_10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I828_MN1 (I0_two6_b3_1 I0_two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I828_MN1_1 (VSS I0_two6_b2_0 I0_two6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I387_MN1 (I0_B_13_b3_1 I0_B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I387_MN1_1 (VSS I0_B_13_b2_0 I0_B_13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I394_MN1 (I0_B_15_b2_0 I0_B_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I394_MN1_1 (VSS I0_B_15_b1_0 I0_B_15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I398_MN1 (I0_B_15_b3_2 I0_B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I398_MN1_1 (VSS I0_B_15_b2_0 I0_B_15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I870_MN1 (I0_one7_b2_0 I0_one7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I870_MN1_1 (VSS I0_one7_b1_0 I0_one7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I874_MN1 (I0_one7_b3_2 I0_one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I874_MN1_1 (VSS I0_one7_b2_0 I0_one7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I153_MN1 (I0_A_14_b2_1 I0_A_14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I153_MN1_1 (VSS I0_A_14_b1_0 I0_A_14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I133_MN1 (I0_A_12_b2_1 I0_A_12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I133_MN1_1 (VSS I0_A_12_b1_0 I0_A_12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I163_MN1 (I0_A_15_b2_1 I0_A_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I163_MN1_1 (VSS I0_A_15_b1_0 I0_A_15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I881_MN1 (I0_two7_b2_1 I0_two7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I881_MN1_1 (VSS I0_two7_b1_0 I0_two7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I875_MN1 (I0_one7_b3_3 I0_one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I875_MN1_1 (VSS I0_one7_b2_1 I0_one7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I871_MN1 (I0_one7_b2_1 I0_one7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I871_MN1_1 (VSS I0_one7_b1_0 I0_one7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I395_MN1 (I0_B_15_b2_1 I0_B_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I395_MN1_1 (VSS I0_B_15_b1_0 I0_B_15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I399_MN1 (I0_B_15_b3_3 I0_B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I399_MN1_1 (VSS I0_B_15_b2_1 I0_B_15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I401_MN1 (I0_B_15_b3_5 I0_B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I401_MN1_1 (VSS I0_B_15_b2_1 I0_B_15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I400_MN1 (I0_B_15_b3_4 I0_B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I400_MN1_1 (VSS I0_B_15_b2_1 I0_B_15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I886_MN1 (I0_two7_b3_4 I0_two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I886_MN1_1 (VSS I0_two7_b2_1 I0_two7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I876_MN1 (I0_one7_b3_4 I0_one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I876_MN1_1 (VSS I0_one7_b2_1 I0_one7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I94_MN1 (I0_A_8_b3_0 I0_A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I94_MN1_1 (VSS I0_A_8_b2_0 I0_A_8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I84_MN1 (I0_A_7_b3_0 I0_A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I84_MN1_1 (VSS I0_A_7_b2_0 I0_A_7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I74_MN1 (I0_A_6_b3_0 I0_A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I74_MN1_1 (VSS I0_A_6_b2_0 I0_A_6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I92_MN1 (I0_A_8_b2_0 I0_A_8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I92_MN1_1 (VSS I0_A_8_b1_0 I0_A_8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I102_MN1 (I0_A_9_b2_0 I0_A_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I102_MN1_1 (VSS I0_A_9_b1_0 I0_A_9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I662_MN1 (I0_two3_b3_0 I0_two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I662_MN1_1 (VSS I0_two3_b2_0 I0_two3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I367_MN1 (I0_B_9_b3_1 I0_B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I367_MN1_1 (VSS I0_B_9_b2_0 I0_B_9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I96_MN1 (I0_A_8_b3_2 I0_A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I96_MN1_1 (VSS I0_A_8_b2_0 I0_A_8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I95_MN1 (I0_A_8_b3_1 I0_A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I95_MN1_1 (VSS I0_A_8_b2_0 I0_A_8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I763_MN1 (I0_one5_b3_1 I0_one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I763_MN1_1 (VSS I0_one5_b2_0 I0_one5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I827_MN1 (I0_two6_b3_0 I0_two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I827_MN1_1 (VSS I0_two6_b2_0 I0_two6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I817_MN1 (I0_one6_b3_0 I0_one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I817_MN1_1 (VSS I0_one6_b2_0 I0_one6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I818_MN1 (I0_one6_b3_1 I0_one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I818_MN1_1 (VSS I0_one6_b2_0 I0_one6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I397_MN1 (I0_B_15_b3_1 I0_B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I397_MN1_1 (VSS I0_B_15_b2_0 I0_B_15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I396_MN1 (I0_B_15_b3_0 I0_B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I396_MN1_1 (VSS I0_B_15_b2_0 I0_B_15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I877_MN1 (I0_one7_b3_5 I0_one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I877_MN1_1 (VSS I0_one7_b2_1 I0_one7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I887_MN1 (I0_two7_b3_5 I0_two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I887_MN1_1 (VSS I0_two7_b2_1 I0_two7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I77_MN1 (I2_I3_SEL_AS_b3_1 I2_I3_SEL_AS_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I77_MN1_1 (VSS I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I487_MN1 (I0_one0_b3_0 I0_one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I487_MN1_1 (VSS I0_one0_b2_0 I0_one0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I64_MN1 (I0_A_5_b3_0 I0_A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I64_MN1_1 (VSS I0_A_5_b2_0 I0_A_5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I82_MN1 (I0_A_7_b2_0 I0_A_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I82_MN1_1 (VSS I0_A_7_b1_0 I0_A_7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I717_MN1 (I0_two4_b3_0 I0_two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I717_MN1_1 (VSS I0_two4_b2_0 I0_two4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I75_MN1 (I0_A_6_b3_1 I0_A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I75_MN1_1 (VSS I0_A_6_b2_0 I0_A_6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I707_MN1 (I0_one4_b3_0 I0_one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I707_MN1_1 (VSS I0_one4_b2_0 I0_one4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I86_MN1 (I0_A_7_b3_2 I0_A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I86_MN1_1 (VSS I0_A_7_b2_0 I0_A_7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I718_MN1 (I0_two4_b3_1 I0_two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I718_MN1_1 (VSS I0_two4_b2_0 I0_two4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I773_MN1 (I0_two5_b3_1 I0_two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I773_MN1_1 (VSS I0_two5_b2_0 I0_two5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I882_MN1 (I0_two7_b3_0 I0_two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I882_MN1_1 (VSS I0_two7_b2_0 I0_two7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I873_MN1 (I0_one7_b3_1 I0_one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I873_MN1_1 (VSS I0_one7_b2_0 I0_one7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I113_MN1 (I0_A_10_b2_1 I0_A_10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I113_MN1_1 (VSS I0_A_10_b1_0 I0_A_10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I359_MN1 (I1_dd18_b3_4 I1_dd18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I359_MN1_1 (VSS I1_dd18_b2_1 I1_dd18_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I372_MN1 (I1_dd19_b3_4 I1_dd19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I372_MN1_1 (VSS I1_dd19_b2_1 I1_dd19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2073_MN1 (I1_sq_b3_1 I1_sq_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2073_MN1_1 (VSS I1_sq_b2_0 I1_sq_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I65_MN1 (I0_A_5_b3_1 I0_A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I65_MN1_1 (VSS I0_A_5_b2_0 I0_A_5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I72_MN1 (I0_A_6_b2_0 I0_A_6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I72_MN1_1 (VSS I0_A_6_b1_0 I0_A_6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I83_MN1 (I0_A_7_b2_1 I0_A_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I83_MN1_1 (VSS I0_A_7_b1_0 I0_A_7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I76_MN1 (I0_A_6_b3_2 I0_A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I76_MN1_1 (VSS I0_A_6_b2_0 I0_A_6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I66_MN1 (I0_A_5_b3_2 I0_A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I66_MN1_1 (VSS I0_A_5_b2_0 I0_A_5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I772_MN1 (I0_two5_b3_0 I0_two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I772_MN1_1 (VSS I0_two5_b2_0 I0_two5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I883_MN1 (I0_two7_b3_1 I0_two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I883_MN1_1 (VSS I0_two7_b2_0 I0_two7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I872_MN1 (I0_one7_b3_0 I0_one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I872_MN1_1 (VSS I0_one7_b2_0 I0_one7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I203_MN1 (I0_A_19_b2_1 I0_A_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I203_MN1_1 (VSS I0_A_19_b1_0 I0_A_19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I213_MN1 (I0_A_20_b2_1 I0_A_20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I213_MN1_1 (VSS I0_A_20_b1_0 I0_A_20_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1768_MN1 (I1_qu5_b3_2 I1_qu5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1768_MN1_1 (VSS I1_qu5_b2_0 I1_qu5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1767_MN1 (I1_qu5_b3_1 I1_qu5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1767_MN1_1 (VSS I1_qu5_b2_0 I1_qu5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1720_MN1 (I1_qu6_b3_0 I1_qu6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1720_MN1_1 (VSS I1_qu6_b2_0 I1_qu6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1669_MN1 (I1_qu7 I1_p24_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1669_MN1_1 (VSS I1_p24_32 I1_qu7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I385_MN1 (I1_dd20_b3_4 I1_dd20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I385_MN1_1 (VSS I1_dd20_b2_1 I1_dd20_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I34_MN1 (I2_I3_SEL_NOT_b3_0 I2_I3_SEL_NOT_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I34_MN1_1 (VSS I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I4_MN1 (I2_I3_SEL_AND_b3_0 I2_I3_SEL_AND_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I4_MN1_1 (VSS I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I101_MN1 (I0_A_9_b1_0 I0_A_9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I101_MN1_1 (VSS I0_A_9_b0 I0_A_9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I71_MN1 (I0_A_6_b1_0 I0_A_6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I71_MN1_1 (VSS I0_A_6_b0 I0_A_6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I81_MN1 (I0_A_7_b1_0 I0_A_7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I81_MN1_1 (VSS I0_A_7_b0 I0_A_7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I91_MN1 (I0_A_8_b1_0 I0_A_8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I91_MN1_1 (VSS I0_A_8_b0 I0_A_8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I55_MN1 (I0_A_4_b3_1 I0_A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I55_MN1_1 (VSS I0_A_4_b2_0 I0_A_4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I762_MN1 (I0_one5_b3_0 I0_one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I762_MN1_1 (VSS I0_one5_b2_0 I0_one5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1761_MN1 (I1_qu5 I1_p26_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1761_MN1_1 (VSS I1_p26_32 I1_qu5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1581_MN1 (I1_qu9_b2_1 I1_qu9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1581_MN1_1 (VSS I1_qu9_b1_0 I1_qu9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1585_MN1 (I1_qu9_b3_3 I1_qu9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1585_MN1_1 (VSS I1_qu9_b2_1 I1_qu9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I14_MN1 (I2_I3_SEL_OR_b3_0 I2_I3_SEL_OR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I14_MN1_1 (VSS I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I24_MN1 (I2_I3_SEL_XOR_b3_0 I2_I3_SEL_XOR_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I24_MN1_1 (VSS I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I54_MN1 (I0_A_4_b3_0 I0_A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I54_MN1_1 (VSS I0_A_4_b2_0 I0_A_4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I46_MN1 (I0_A_3_b3_2 I0_A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I46_MN1_1 (VSS I0_A_3_b2_0 I0_A_3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I45_MN1 (I0_A_3_b3_1 I0_A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I45_MN1_1 (VSS I0_A_3_b2_0 I0_A_3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I56_MN1 (I0_A_4_b3_2 I0_A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I56_MN1_1 (VSS I0_A_4_b2_0 I0_A_4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I103_MN1 (I0_A_9_b2_1 I0_A_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I103_MN1_1 (VSS I0_A_9_b1_0 I0_A_9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I73_MN1 (I0_A_6_b2_1 I0_A_6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I73_MN1_1 (VSS I0_A_6_b1_0 I0_A_6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I167_MN1 (I0_A_15_b3_3 I0_A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I167_MN1_1 (VSS I0_A_15_b2_1 I0_A_15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I193_MN1 (I0_A_18_b2_1 I0_A_18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I193_MN1_1 (VSS I0_A_18_b1_0 I0_A_18_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I183_MN1 (I0_A_17_b2_1 I0_A_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I183_MN1_1 (VSS I0_A_17_b1_0 I0_A_17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1631_MN1 (I1_qu8_b3_3 I1_qu8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1631_MN1_1 (VSS I1_qu8_b2_1 I1_qu8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I398_MN1 (I1_dd21_b3_4 I1_dd21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I398_MN1_1 (VSS I1_dd21_b2_1 I1_dd21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1627_MN1 (I1_qu8_b2_1 I1_qu8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1627_MN1_1 (VSS I1_qu8_b1_0 I1_qu8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I76_MN1 (I2_I3_SEL_AS_b3_0 I2_I3_SEL_AS_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I76_MN1_1 (VSS I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I34_MN1 (I0_A_2_b3_0 I0_A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I34_MN1_1 (VSS I0_A_2_b2_0 I0_A_2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I32_MN1 (I0_A_2_b2_0 I0_A_2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I32_MN1_1 (VSS I0_A_2_b1_0 I0_A_2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I44_MN1 (I0_A_3_b3_0 I0_A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I44_MN1_1 (VSS I0_A_3_b2_0 I0_A_3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I52_MN1 (I0_A_4_b2_0 I0_A_4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I52_MN1_1 (VSS I0_A_4_b1_0 I0_A_4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I16_MN1 (I0_A_0_b3_2 I0_A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I16_MN1_1 (VSS I0_A_0_b2_0 I0_A_0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I15_MN1 (I0_A_0_b3_1 I0_A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I15_MN1_1 (VSS I0_A_0_b2_0 I0_A_0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I25_MN1 (I0_A_1_b3_1 I0_A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I25_MN1_1 (VSS I0_A_1_b2_0 I0_A_1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I26_MN1 (I0_A_1_b3_2 I0_A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I26_MN1_1 (VSS I0_A_1_b2_0 I0_A_1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I62_MN1 (I0_A_5_b2_0 I0_A_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I62_MN1_1 (VSS I0_A_5_b1_0 I0_A_5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I36_MN1 (I0_A_2_b3_2 I0_A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I36_MN1_1 (VSS I0_A_2_b2_0 I0_A_2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I35_MN1 (I0_A_2_b3_1 I0_A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I35_MN1_1 (VSS I0_A_2_b2_0 I0_A_2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I117_MN1 (I0_A_10_b3_3 I0_A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I117_MN1_1 (VSS I0_A_10_b2_1 I0_A_10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I147_MN1 (I0_A_13_b3_3 I0_A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I147_MN1_1 (VSS I0_A_13_b2_1 I0_A_13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I197_MN1 (I0_A_18_b3_3 I0_A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I197_MN1_1 (VSS I0_A_18_b2_1 I0_A_18_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I157_MN1 (I0_A_14_b3_3 I0_A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I157_MN1_1 (VSS I0_A_14_b2_1 I0_A_14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I187_MN1 (I0_A_17_b3_3 I0_A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I187_MN1_1 (VSS I0_A_17_b2_1 I0_A_17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I207_MN1 (I0_A_19_b3_3 I0_A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I207_MN1_1 (VSS I0_A_19_b2_1 I0_A_19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1763_MN1 (I1_qu5_b1_0 I1_qu5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1763_MN1_1 (VSS I1_qu5_b0 I1_qu5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1765_MN1 (I1_qu5_b2_1 I1_qu5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1765_MN1_1 (VSS I1_qu5_b1_0 I1_qu5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1764_MN1 (I1_qu5_b2_0 I1_qu5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1764_MN1_1 (VSS I1_qu5_b1_0 I1_qu5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1632_MN1 (I1_qu8_b3_4 I1_qu8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1632_MN1_1 (VSS I1_qu8_b2_1 I1_qu8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1633_MN1 (I1_qu8_b3_5 I1_qu8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1633_MN1_1 (VSS I1_qu8_b2_1 I1_qu8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I424_MN1 (I1_dd23_b3_4 I1_dd23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I424_MN1_1 (VSS I1_dd23_b2_1 I1_dd23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I515_MN1 (I1_dd30_b3_4 I1_dd30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I515_MN1_1 (VSS I1_dd30_b2_1 I1_dd30_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1587_MN1 (I1_qu9_b3_5 I1_qu9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1587_MN1_1 (VSS I1_qu9_b2_1 I1_qu9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2072_MN1 (I1_sq_b3_0 I1_sq_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2072_MN1_1 (VSS I1_sq_b2_0 I1_sq_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I61_MN1 (I0_A_5_b1_0 I0_A_5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I61_MN1_1 (VSS I0_A_5_b0 I0_A_5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I24_MN1 (I0_A_1_b3_0 I0_A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I24_MN1_1 (VSS I0_A_1_b2_0 I0_A_1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I14_MN1 (I0_A_0_b3_0 I0_A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I14_MN1_1 (VSS I0_A_0_b2_0 I0_A_0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I22_MN1 (I0_A_1_b2_0 I0_A_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I22_MN1_1 (VSS I0_A_1_b1_0 I0_A_1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I93_MN1 (I0_A_8_b2_1 I0_A_8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I93_MN1_1 (VSS I0_A_8_b1_0 I0_A_8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I927_MN1 (I0_one8_b3_0 I0_one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I927_MN1_1 (VSS I0_one8_b2_0 I0_one8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I97_MN1 (I0_A_8_b3_3 I0_A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I97_MN1_1 (VSS I0_A_8_b2_1 I0_A_8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I928_MN1 (I0_one8_b3_1 I0_one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I928_MN1_1 (VSS I0_one8_b2_0 I0_one8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I938_MN1 (I0_two8_b3_1 I0_two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I938_MN1_1 (VSS I0_two8_b2_0 I0_two8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I107_MN1 (I0_A_9_b3_3 I0_A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I107_MN1_1 (VSS I0_A_9_b2_1 I0_A_9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I939_MN1 (I0_two8_b3_2 I0_two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I939_MN1_1 (VSS I0_two8_b2_0 I0_two8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I929_MN1 (I0_one8_b3_2 I0_one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I929_MN1_1 (VSS I0_one8_b2_0 I0_one8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I925_MN1 (I0_one8_b2_0 I0_one8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I925_MN1_1 (VSS I0_one8_b1_0 I0_one8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I408_MN1 (I0_B_17_b3_2 I0_B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I408_MN1_1 (VSS I0_B_17_b2_0 I0_B_17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I127_MN1 (I0_A_11_b3_3 I0_A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I127_MN1_1 (VSS I0_A_11_b2_1 I0_A_11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I137_MN1 (I0_A_12_b3_3 I0_A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I137_MN1_1 (VSS I0_A_12_b2_1 I0_A_12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I418_MN1 (I0_B_19_b3_2 I0_B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I418_MN1_1 (VSS I0_B_19_b2_0 I0_B_19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I404_MN1 (I0_B_17_b2_0 I0_B_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I404_MN1_1 (VSS I0_B_17_b1_0 I0_B_17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I217_MN1 (I0_A_20_b3_3 I0_A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I217_MN1_1 (VSS I0_A_20_b2_1 I0_A_20_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1770_MN1 (I1_qu5_b3_4 I1_qu5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1770_MN1_1 (VSS I1_qu5_b2_1 I1_qu5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1771_MN1 (I1_qu5_b3_5 I1_qu5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1771_MN1_1 (VSS I1_qu5_b2_1 I1_qu5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1769_MN1 (I1_qu5_b3_3 I1_qu5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1769_MN1_1 (VSS I1_qu5_b2_1 I1_qu5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1766_MN1 (I1_qu5_b3_0 I1_qu5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1766_MN1_1 (VSS I1_qu5_b2_0 I1_qu5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I450_MN1 (I1_dd25_b3_4 I1_dd25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I450_MN1_1 (VSS I1_dd25_b2_1 I1_dd25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I437_MN1 (I1_dd24_b3_4 I1_dd24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I437_MN1_1 (VSS I1_dd24_b2_1 I1_dd24_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1586_MN1 (I1_qu9_b3_4 I1_qu9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1586_MN1_1 (VSS I1_qu9_b2_1 I1_qu9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I12_MN1 (I0_A_0_b2_0 I0_A_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I12_MN1_1 (VSS I0_A_0_b1_0 I0_A_0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I51_MN1 (I0_A_4_b1_0 I0_A_4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I51_MN1_1 (VSS I0_A_4_b0 I0_A_4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I21_MN1 (I0_A_1_b1_0 I0_A_1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I21_MN1_1 (VSS I0_A_1_b0 I0_A_1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I937_MN1 (I0_two8_b3_0 I0_two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I937_MN1_1 (VSS I0_two8_b2_0 I0_two8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I87_MN1 (I0_A_7_b3_3 I0_A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I87_MN1_1 (VSS I0_A_7_b2_1 I0_A_7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1037_MN1 (I0_one10_b3_0 I0_one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1037_MN1_1 (VSS I0_one10_b2_0 I0_one10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1048_MN1 (I0_two10_b3_1 I0_two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1048_MN1_1 (VSS I0_two10_b2_0 I0_two10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1038_MN1 (I0_one10_b3_1 I0_one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1038_MN1_1 (VSS I0_one10_b2_0 I0_one10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I994_MN1 (I0_two9_b3_2 I0_two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I994_MN1_1 (VSS I0_two9_b2_0 I0_two9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I426_MN1 (I0_B_21_b3_0 I0_B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I426_MN1_1 (VSS I0_B_21_b2_0 I0_B_21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I427_MN1 (I0_B_21_b3_1 I0_B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I427_MN1_1 (VSS I0_B_21_b2_0 I0_B_21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I984_MN1 (I0_one9_b3_2 I0_one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I984_MN1_1 (VSS I0_one9_b2_0 I0_one9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1034_MN1 (I0_one10_b1_0 I0_one10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1034_MN1_1 (VSS I0_one10_b0 I0_one10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I935_MN1 (I0_two8_b2_0 I0_two8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I935_MN1_1 (VSS I0_two8_b1_0 I0_two8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1035_MN1 (I0_one10_b2_0 I0_one10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1035_MN1_1 (VSS I0_one10_b1_0 I0_one10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1049_MN1 (I0_two10_b3_2 I0_two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1049_MN1_1 (VSS I0_two10_b2_0 I0_two10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I934_MN1 (I0_two8_b1_0 I0_two8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I934_MN1_1 (VSS I0_two8_b0 I0_two8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1039_MN1 (I0_one10_b3_2 I0_one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1039_MN1_1 (VSS I0_one10_b2_0 I0_one10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I924_MN1 (I0_one8_b1_0 I0_one8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I924_MN1_1 (VSS I0_one8_b0 I0_one8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I98_MN1 (I0_A_8_b3_4 I0_A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I98_MN1_1 (VSS I0_A_8_b2_1 I0_A_8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I108_MN1 (I0_A_9_b3_4 I0_A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I108_MN1_1 (VSS I0_A_9_b2_1 I0_A_9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I99_MN1 (I0_A_8_b3_5 I0_A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I99_MN1_1 (VSS I0_A_8_b2_1 I0_A_8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I118_MN1 (I0_A_10_b3_4 I0_A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I118_MN1_1 (VSS I0_A_10_b2_1 I0_A_10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I438_MN1 (I0_B_23_b3_2 I0_B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I438_MN1_1 (VSS I0_B_23_b2_0 I0_B_23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I128_MN1 (I0_A_11_b3_4 I0_A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I128_MN1_1 (VSS I0_A_11_b2_1 I0_A_11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I138_MN1 (I0_A_12_b3_4 I0_A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I138_MN1_1 (VSS I0_A_12_b2_1 I0_A_12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I926_MN1 (I0_one8_b2_1 I0_one8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I926_MN1_1 (VSS I0_one8_b1_0 I0_one8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I936_MN1 (I0_two8_b2_1 I0_two8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I936_MN1_1 (VSS I0_two8_b1_0 I0_two8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I930_MN1 (I0_one8_b3_3 I0_one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I930_MN1_1 (VSS I0_one8_b2_1 I0_one8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I940_MN1 (I0_two8_b3_3 I0_two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I940_MN1_1 (VSS I0_two8_b2_1 I0_two8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I405_MN1 (I0_B_17_b2_1 I0_B_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I405_MN1_1 (VSS I0_B_17_b1_0 I0_B_17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I409_MN1 (I0_B_17_b3_3 I0_B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I409_MN1_1 (VSS I0_B_17_b2_1 I0_B_17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I415_MN1 (I0_B_19_b2_1 I0_B_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I415_MN1_1 (VSS I0_B_19_b1_0 I0_B_19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I414_MN1 (I0_B_19_b2_0 I0_B_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I414_MN1_1 (VSS I0_B_19_b1_0 I0_B_19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I419_MN1 (I0_B_19_b3_3 I0_B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I419_MN1_1 (VSS I0_B_19_b2_1 I0_B_19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I451_MN1 (I1_dd25_b3_5 I1_dd25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I451_MN1_1 (VSS I1_dd25_b2_1 I1_dd25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I502_MN1 (I1_dd29_b3_4 I1_dd29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I502_MN1_1 (VSS I1_dd29_b2_1 I1_dd29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I476_MN1 (I1_dd27_b3_4 I1_dd27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I476_MN1_1 (VSS I1_dd27_b2_1 I1_dd27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I463_MN1 (I1_dd26_b3_4 I1_dd26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I463_MN1_1 (VSS I1_dd26_b2_1 I1_dd26_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I489_MN1 (I1_dd28_b3_4 I1_dd28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I489_MN1_1 (VSS I1_dd28_b2_1 I1_dd28_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I204_MN1 (I1_dd6_b3_5 I1_dd6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I204_MN1_1 (VSS I1_dd6_b2_1 I1_dd6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I191_MN1 (I1_dd5_b3_5 I1_dd5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I191_MN1_1 (VSS I1_dd5_b2_1 I1_dd5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I139_MN1 (I1_dd1_b3_5 I1_dd1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I139_MN1_1 (VSS I1_dd1_b2_1 I1_dd1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I165_MN1 (I1_dd3_b3_5 I1_dd3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I165_MN1_1 (VSS I1_dd3_b2_1 I1_dd3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I41_MN1 (I0_A_3_b1_0 I0_A_3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I41_MN1_1 (VSS I0_A_3_b0 I0_A_3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I23_MN1 (I0_A_1_b2_1 I0_A_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I23_MN1_1 (VSS I0_A_1_b1_0 I0_A_1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I42_MN1 (I0_A_3_b2_0 I0_A_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I42_MN1_1 (VSS I0_A_3_b1_0 I0_A_3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I63_MN1 (I0_A_5_b2_1 I0_A_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I63_MN1_1 (VSS I0_A_5_b1_0 I0_A_5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I10_MN1 (I1_A_31_b3_5 I1_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I10_MN1_1 (VSS I1_A_31_b2_1 I1_A_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1047_MN1 (I0_two10_b3_0 I0_two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1047_MN1_1 (VSS I0_two10_b2_0 I0_two10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I983_MN1 (I0_one9_b3_1 I0_one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I983_MN1_1 (VSS I0_one9_b2_0 I0_one9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I416_MN1 (I0_B_19_b3_0 I0_B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I416_MN1_1 (VSS I0_B_19_b2_0 I0_B_19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I417_MN1 (I0_B_19_b3_1 I0_B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I417_MN1_1 (VSS I0_B_19_b2_0 I0_B_19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I989_MN1 (I0_two9_b1_0 I0_two9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I989_MN1_1 (VSS I0_two9_b0 I0_two9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I990_MN1 (I0_two9_b2_0 I0_two9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I990_MN1_1 (VSS I0_two9_b1_0 I0_two9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I980_MN1 (I0_one9_b2_0 I0_one9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I980_MN1_1 (VSS I0_one9_b1_0 I0_one9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1044_MN1 (I0_two10_b1_0 I0_two10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1044_MN1_1 (VSS I0_two10_b0 I0_two10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1045_MN1 (I0_two10_b2_0 I0_two10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1045_MN1_1 (VSS I0_two10_b1_0 I0_two10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I78_MN1 (I0_A_6_b3_4 I0_A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I78_MN1_1 (VSS I0_A_6_b2_1 I0_A_6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I79_MN1 (I0_A_6_b3_5 I0_A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I79_MN1_1 (VSS I0_A_6_b2_1 I0_A_6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1093_MN1 (I0_one11_b3_1 I0_one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1093_MN1_1 (VSS I0_one11_b2_0 I0_one11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1103_MN1 (I0_two11_b3_1 I0_two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1103_MN1_1 (VSS I0_two11_b2_0 I0_two11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I88_MN1 (I0_A_7_b3_4 I0_A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I88_MN1_1 (VSS I0_A_7_b2_1 I0_A_7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I89_MN1 (I0_A_7_b3_5 I0_A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I89_MN1_1 (VSS I0_A_7_b2_1 I0_A_7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I109_MN1 (I0_A_9_b3_5 I0_A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I109_MN1_1 (VSS I0_A_9_b2_1 I0_A_9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I437_MN1 (I0_B_23_b3_1 I0_B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I437_MN1_1 (VSS I0_B_23_b2_0 I0_B_23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1104_MN1 (I0_two11_b3_2 I0_two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1104_MN1_1 (VSS I0_two11_b2_0 I0_two11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I434_MN1 (I0_B_23_b2_0 I0_B_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I434_MN1_1 (VSS I0_B_23_b1_0 I0_B_23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I119_MN1 (I0_A_10_b3_5 I0_A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I119_MN1_1 (VSS I0_A_10_b2_1 I0_A_10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I129_MN1 (I0_A_11_b3_5 I0_A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I129_MN1_1 (VSS I0_A_11_b2_1 I0_A_11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1046_MN1 (I0_two10_b2_1 I0_two10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1046_MN1_1 (VSS I0_two10_b1_0 I0_two10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1036_MN1 (I0_one10_b2_1 I0_one10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1036_MN1_1 (VSS I0_one10_b1_0 I0_one10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1050_MN1 (I0_two10_b3_3 I0_two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1050_MN1_1 (VSS I0_two10_b2_1 I0_two10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1040_MN1 (I0_one10_b3_3 I0_one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1040_MN1_1 (VSS I0_one10_b2_1 I0_one10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I411_MN1 (I0_B_17_b3_5 I0_B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I411_MN1_1 (VSS I0_B_17_b2_1 I0_B_17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I991_MN1 (I0_two9_b2_1 I0_two9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I991_MN1_1 (VSS I0_two9_b1_0 I0_two9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I995_MN1 (I0_two9_b3_3 I0_two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I995_MN1_1 (VSS I0_two9_b2_1 I0_two9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I985_MN1 (I0_one9_b3_3 I0_one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I985_MN1_1 (VSS I0_one9_b2_1 I0_one9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I981_MN1 (I0_one9_b2_1 I0_one9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I981_MN1_1 (VSS I0_one9_b1_0 I0_one9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I412_MN1 (I1_dd22_b3_5 I1_dd22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I412_MN1_1 (VSS I1_dd22_b2_1 I1_dd22_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I464_MN1 (I1_dd26_b3_5 I1_dd26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I464_MN1_1 (VSS I1_dd26_b2_1 I1_dd26_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I373_MN1 (I1_dd19_b3_5 I1_dd19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I373_MN1_1 (VSS I1_dd19_b2_1 I1_dd19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I308_MN1 (I1_dd14_b3_5 I1_dd14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I308_MN1_1 (VSS I1_dd14_b2_1 I1_dd14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I321_MN1 (I1_dd15_b3_5 I1_dd15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I321_MN1_1 (VSS I1_dd15_b2_1 I1_dd15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I295_MN1 (I1_dd13_b3_5 I1_dd13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I295_MN1_1 (VSS I1_dd13_b2_1 I1_dd13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I243_MN1 (I1_dd9_b3_5 I1_dd9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I243_MN1_1 (VSS I1_dd9_b2_1 I1_dd9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I282_MN1 (I1_dd12_b3_5 I1_dd12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I282_MN1_1 (VSS I1_dd12_b2_1 I1_dd12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I152_MN1 (I1_dd2_b3_5 I1_dd2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I152_MN1_1 (VSS I1_dd2_b2_1 I1_dd2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I178_MN1 (I1_dd4_b3_5 I1_dd4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I178_MN1_1 (VSS I1_dd4_b2_1 I1_dd4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I45_MN1 (I2_I3_SEL_MUL_b3_0 I2_I3_SEL_MUL_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I45_MN1_1 (VSS I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I11_MN1 (I0_A_0_b1_0 I0_A_0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I11_MN1_1 (VSS I0_A_0_b0 I0_A_0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I46_MN1 (I2_I3_SEL_MUL_b3_1 I2_I3_SEL_MUL_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I46_MN1_1 (VSS I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I31_MN1 (I0_A_2_b1_0 I0_A_2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I31_MN1_1 (VSS I0_A_2_b0 I0_A_2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I13_MN1 (I0_A_0_b2_1 I0_A_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I13_MN1_1 (VSS I0_A_0_b1_0 I0_A_0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I33_MN1 (I0_A_2_b2_1 I0_A_2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I33_MN1_1 (VSS I0_A_2_b1_0 I0_A_2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I47_MN1 (I2_I3_SEL_MUL_b3_2 I2_I3_SEL_MUL_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I47_MN1_1 (VSS I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I43_MN1 (I0_A_3_b2_1 I0_A_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I43_MN1_1 (VSS I0_A_3_b1_0 I0_A_3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I66_MN1 (I2_I3_SEL_DIV_b3_5 I2_I3_SEL_DIV_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I66_MN1_1 (VSS I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I65_MN1 (I2_I3_SEL_DIV_b3_4 I2_I3_SEL_DIV_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I65_MN1_1 (VSS I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I53_MN1 (I0_A_4_b2_1 I0_A_4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I53_MN1_1 (VSS I0_A_4_b1_0 I0_A_4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I48_MN1 (I2_I3_SEL_MUL_b3_3 I2_I3_SEL_MUL_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I48_MN1_1 (VSS I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I42_MN1 (I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I42_MN1_1 (VSS I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I41_MN1 (I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I41_MN1_1 (VSS I2_I3_SEL_MUL_b0 I2_I3_SEL_MUL_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I17_MN1 (I0_A_0_b3_3 I0_A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I17_MN1_1 (VSS I0_A_0_b2_1 I0_A_0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I27_MN1 (I0_A_1_b3_3 I0_A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I27_MN1_1 (VSS I0_A_1_b2_1 I0_A_1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I37_MN1 (I0_A_2_b3_3 I0_A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I37_MN1_1 (VSS I0_A_2_b2_1 I0_A_2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I47_MN1 (I0_A_3_b3_3 I0_A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I47_MN1_1 (VSS I0_A_3_b2_1 I0_A_3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I57_MN1 (I0_A_4_b3_3 I0_A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I57_MN1_1 (VSS I0_A_4_b2_1 I0_A_4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I992_MN1 (I0_two9_b3_0 I0_two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I992_MN1_1 (VSS I0_two9_b2_0 I0_two9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I77_MN1 (I0_A_6_b3_3 I0_A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I77_MN1_1 (VSS I0_A_6_b2_1 I0_A_6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I982_MN1 (I0_one9_b3_0 I0_one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I982_MN1_1 (VSS I0_one9_b2_0 I0_one9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I67_MN1 (I0_A_5_b3_3 I0_A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I67_MN1_1 (VSS I0_A_5_b2_1 I0_A_5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I993_MN1 (I0_two9_b3_1 I0_two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I993_MN1_1 (VSS I0_two9_b2_0 I0_two9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I979_MN1 (I0_one9_b1_0 I0_one9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I979_MN1_1 (VSS I0_one9_b0 I0_one9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I68_MN1 (I0_A_5_b3_4 I0_A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I68_MN1_1 (VSS I0_A_5_b2_1 I0_A_5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I69_MN1 (I0_A_5_b3_5 I0_A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I69_MN1_1 (VSS I0_A_5_b2_1 I0_A_5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1092_MN1 (I0_one11_b3_0 I0_one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1092_MN1_1 (VSS I0_one11_b2_0 I0_one11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1102_MN1 (I0_two11_b3_0 I0_two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1102_MN1_1 (VSS I0_two11_b2_0 I0_two11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I436_MN1 (I0_B_23_b3_0 I0_B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I436_MN1_1 (VSS I0_B_23_b2_0 I0_B_23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1094_MN1 (I0_one11_b3_2 I0_one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1094_MN1_1 (VSS I0_one11_b2_0 I0_one11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I148_MN1 (I0_A_13_b3_4 I0_A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I148_MN1_1 (VSS I0_A_13_b2_1 I0_A_13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I410_MN1 (I0_B_17_b3_4 I0_B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I410_MN1_1 (VSS I0_B_17_b2_1 I0_B_17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I421_MN1 (I0_B_19_b3_5 I0_B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I421_MN1_1 (VSS I0_B_19_b2_1 I0_B_19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I420_MN1 (I0_B_19_b3_4 I0_B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I420_MN1_1 (VSS I0_B_19_b2_1 I0_B_19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I503_MN1 (I1_dd29_b3_5 I1_dd29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I503_MN1_1 (VSS I1_dd29_b2_1 I1_dd29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I438_MN1 (I1_dd24_b3_5 I1_dd24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I438_MN1_1 (VSS I1_dd24_b2_1 I1_dd24_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I399_MN1 (I1_dd21_b3_5 I1_dd21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I399_MN1_1 (VSS I1_dd21_b2_1 I1_dd21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I386_MN1 (I1_dd20_b3_5 I1_dd20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I386_MN1_1 (VSS I1_dd20_b2_1 I1_dd20_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I516_MN1 (I1_dd30_b3_5 I1_dd30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I516_MN1_1 (VSS I1_dd30_b2_1 I1_dd30_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I347_MN1 (I1_dd17_b3_5 I1_dd17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I347_MN1_1 (VSS I1_dd17_b2_1 I1_dd17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I360_MN1 (I1_dd18_b3_5 I1_dd18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I360_MN1_1 (VSS I1_dd18_b2_1 I1_dd18_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I425_MN1 (I1_dd23_b3_5 I1_dd23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I425_MN1_1 (VSS I1_dd23_b2_1 I1_dd23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I217_MN1 (I1_dd7_b3_5 I1_dd7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I217_MN1_1 (VSS I1_dd7_b2_1 I1_dd7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I3_MN1 (I1_A_31_b2_1 I1_A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I3_MN1_1 (VSS I1_A_31_b1_0 I1_A_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I48_MN1 (I0_A_3_b3_4 I0_A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I48_MN1_1 (VSS I0_A_3_b2_1 I0_A_3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I38_MN1 (I0_A_2_b3_4 I0_A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I38_MN1_1 (VSS I0_A_2_b2_1 I0_A_2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I39_MN1 (I0_A_2_b3_5 I0_A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I39_MN1_1 (VSS I0_A_2_b2_1 I0_A_2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I49_MN1 (I0_A_3_b3_5 I0_A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I49_MN1_1 (VSS I0_A_3_b2_1 I0_A_3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I447_MN1 (I0_B_25_b3_1 I0_B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I447_MN1_1 (VSS I0_B_25_b2_0 I0_B_25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1148_MN1 (I0_one12_b3_1 I0_one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1148_MN1_1 (VSS I0_one12_b2_0 I0_one12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1213_MN1 (I0_two13_b3_1 I0_two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1213_MN1_1 (VSS I0_two13_b2_0 I0_two13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1149_MN1 (I0_one12_b3_2 I0_one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1149_MN1_1 (VSS I0_one12_b2_0 I0_one12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I444_MN1 (I0_B_25_b2_0 I0_B_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I444_MN1_1 (VSS I0_B_25_b1_0 I0_B_25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I448_MN1 (I0_B_25_b3_2 I0_B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I448_MN1_1 (VSS I0_B_25_b2_0 I0_B_25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1159_MN1 (I0_two12_b3_2 I0_two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1159_MN1_1 (VSS I0_two12_b2_0 I0_two12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I139_MN1 (I0_A_12_b3_5 I0_A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I139_MN1_1 (VSS I0_A_12_b2_1 I0_A_12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I158_MN1 (I0_A_14_b3_4 I0_A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I158_MN1_1 (VSS I0_A_14_b2_1 I0_A_14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1950_MN1 (I1_qu1_b3_0 I1_qu1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1950_MN1_1 (VSS I1_qu1_b2_0 I1_qu1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I28_MN1 (I0_A_1_b3_4 I0_A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I28_MN1_1 (VSS I0_A_1_b2_1 I0_A_1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I59_MN1 (I0_A_4_b3_5 I0_A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I59_MN1_1 (VSS I0_A_4_b2_1 I0_A_4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I58_MN1 (I0_A_4_b3_4 I0_A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I58_MN1_1 (VSS I0_A_4_b2_1 I0_A_4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1157_MN1 (I0_two12_b3_0 I0_two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1157_MN1_1 (VSS I0_two12_b2_0 I0_two12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1147_MN1 (I0_one12_b3_0 I0_one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1147_MN1_1 (VSS I0_one12_b2_0 I0_one12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1203_MN1 (I0_one13_b3_1 I0_one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1203_MN1_1 (VSS I0_one13_b2_0 I0_one13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I454_MN1 (I0_B_27_b2_0 I0_B_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I454_MN1_1 (VSS I0_B_27_b1_0 I0_B_27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I457_MN1 (I0_B_27_b3_1 I0_B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I457_MN1_1 (VSS I0_B_27_b2_0 I0_B_27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1090_MN1 (I0_one11_b2_0 I0_one11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1090_MN1_1 (VSS I0_one11_b1_0 I0_one11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1214_MN1 (I0_two13_b3_2 I0_two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1214_MN1_1 (VSS I0_two13_b2_0 I0_two13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I169_MN1 (I0_A_15_b3_5 I0_A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I169_MN1_1 (VSS I0_A_15_b2_1 I0_A_15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I168_MN1 (I0_A_15_b3_4 I0_A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I168_MN1_1 (VSS I0_A_15_b2_1 I0_A_15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I159_MN1 (I0_A_14_b3_5 I0_A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I159_MN1_1 (VSS I0_A_14_b2_1 I0_A_14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I178_MN1 (I0_A_16_b3_4 I0_A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I178_MN1_1 (VSS I0_A_16_b2_1 I0_A_16_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1905_MN1 (I1_qu2_b3_1 I1_qu2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1905_MN1_1 (VSS I1_qu2_b2_0 I1_qu2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1904_MN1 (I1_qu2_b3_0 I1_qu2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1904_MN1_1 (VSS I1_qu2_b2_0 I1_qu2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1995_MN1 (I1_p31_32_b3_0 I1_p31_32_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1995_MN1_1 (VSS I1_p31_32_b2_0 I1_p31_32_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I49_MN1 (I2_I3_SEL_MUL_b3_4 I2_I3_SEL_MUL_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I49_MN1_1 (VSS I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I29_MN1 (I0_A_1_b3_5 I0_A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I29_MN1_1 (VSS I0_A_1_b2_1 I0_A_1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I18_MN1 (I0_A_0_b3_4 I0_A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I18_MN1_1 (VSS I0_A_0_b2_1 I0_A_0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I19_MN1 (I0_A_0_b3_5 I0_A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I19_MN1_1 (VSS I0_A_0_b2_1 I0_A_0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1202_MN1 (I0_one13_b3_0 I0_one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1202_MN1_1 (VSS I0_one13_b2_0 I0_one13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I456_MN1 (I0_B_27_b3_0 I0_B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I456_MN1_1 (VSS I0_B_27_b2_0 I0_B_27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1212_MN1 (I0_two13_b3_0 I0_two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1212_MN1_1 (VSS I0_two13_b2_0 I0_two13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1323_MN1 (I0_two15_b3_1 I0_two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1323_MN1_1 (VSS I0_two15_b2_0 I0_two15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I467_MN1 (I0_B_29_b3_1 I0_B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I467_MN1_1 (VSS I0_B_29_b2_0 I0_B_29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1258_MN1 (I0_one14_b3_1 I0_one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1258_MN1_1 (VSS I0_one14_b2_0 I0_one14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I179_MN1 (I0_A_16_b3_5 I0_A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I179_MN1_1 (VSS I0_A_16_b2_1 I0_A_16_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I223_MN1 (I0_A_21_b2_1 I0_A_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I223_MN1_1 (VSS I0_A_21_b1_0 I0_A_21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1204_MN1 (I0_one13_b3_2 I0_one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1204_MN1_1 (VSS I0_one13_b2_0 I0_one13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I458_MN1 (I0_B_27_b3_2 I0_B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I458_MN1_1 (VSS I0_B_27_b2_0 I0_B_27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I149_MN1 (I0_A_13_b3_5 I0_A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I149_MN1_1 (VSS I0_A_13_b2_1 I0_A_13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I425_MN1 (I0_B_21_b2_1 I0_B_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I425_MN1_1 (VSS I0_B_21_b1_0 I0_B_21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1812_MN1 (I1_qu4_b3_0 I1_qu4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1812_MN1_1 (VSS I1_qu4_b2_0 I1_qu4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1858_MN1 (I1_qu3_b3_0 I1_qu3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1858_MN1_1 (VSS I1_qu3_b2_0 I1_qu3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I256_MN1 (I1_dd10_b3_5 I1_dd10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I256_MN1_1 (VSS I1_dd10_b2_1 I1_dd10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1951_MN1 (I1_qu1_b3_1 I1_qu1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1951_MN1_1 (VSS I1_qu1_b2_0 I1_qu1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1996_MN1 (I1_p31_32_b3_1 I1_p31_32_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1996_MN1_1 (VSS I1_p31_32_b2_0 I1_p31_32_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1257_MN1 (I0_one14_b3_0 I0_one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1257_MN1_1 (VSS I0_one14_b2_0 I0_one14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1155_MN1 (I0_two12_b2_0 I0_two12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1155_MN1_1 (VSS I0_two12_b1_0 I0_two12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1267_MN1 (I0_two14_b3_0 I0_two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1267_MN1_1 (VSS I0_two14_b2_0 I0_two14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1312_MN1 (I0_one15_b3_0 I0_one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1312_MN1_1 (VSS I0_one15_b2_0 I0_one15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1322_MN1 (I0_two15_b3_0 I0_two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1322_MN1_1 (VSS I0_two15_b2_0 I0_two15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I477_MN1 (I0_B_31_b3_1 I0_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I477_MN1_1 (VSS I0_B_31_b2_0 I0_B_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1100_MN1 (I0_two11_b2_0 I0_two11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1100_MN1_1 (VSS I0_two11_b1_0 I0_two11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I464_MN1 (I0_B_29_b2_0 I0_B_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I464_MN1_1 (VSS I0_B_29_b1_0 I0_B_29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I466_MN1 (I0_B_29_b3_0 I0_B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I466_MN1_1 (VSS I0_B_29_b2_0 I0_B_29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1313_MN1 (I0_one15_b3_1 I0_one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1313_MN1_1 (VSS I0_one15_b2_0 I0_one15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I468_MN1 (I0_B_29_b3_2 I0_B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I468_MN1_1 (VSS I0_B_29_b2_0 I0_B_29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1269_MN1 (I0_two14_b3_2 I0_two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1269_MN1_1 (VSS I0_two14_b2_0 I0_two14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1268_MN1 (I0_two14_b3_1 I0_two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1268_MN1_1 (VSS I0_two14_b2_0 I0_two14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I227_MN1 (I0_A_21_b3_3 I0_A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I227_MN1_1 (VSS I0_A_21_b2_1 I0_A_21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I931_MN1 (I0_one8_b3_4 I0_one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I931_MN1_1 (VSS I0_one8_b2_1 I0_one8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I941_MN1 (I0_two8_b3_4 I0_two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I941_MN1_1 (VSS I0_two8_b2_1 I0_two8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1859_MN1 (I1_qu3_b3_1 I1_qu3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1859_MN1_1 (VSS I1_qu3_b2_0 I1_qu3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1145_MN1 (I0_one12_b2_0 I0_one12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1145_MN1_1 (VSS I0_one12_b1_0 I0_one12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I473_MN1 (I0_B_31_b1_0 I0_B_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I473_MN1_1 (VSS I0_B_31_b0 I0_B_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1310_MN1 (I0_one15_b2_0 I0_one15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1310_MN1_1 (VSS I0_one15_b1_0 I0_one15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1089_MN1 (I0_one11_b1_0 I0_one11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1089_MN1_1 (VSS I0_one11_b0 I0_one11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I478_MN1 (I0_B_31_b3_2 I0_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I478_MN1_1 (VSS I0_B_31_b2_0 I0_B_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1314_MN1 (I0_one15_b3_2 I0_one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1314_MN1_1 (VSS I0_one15_b2_0 I0_one15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1259_MN1 (I0_one14_b3_2 I0_one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1259_MN1_1 (VSS I0_one14_b2_0 I0_one14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I431_MN1 (I0_B_21_b3_5 I0_B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I431_MN1_1 (VSS I0_B_21_b2_1 I0_B_21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I429_MN1 (I0_B_21_b3_3 I0_B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I429_MN1_1 (VSS I0_B_21_b2_1 I0_B_21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1051_MN1 (I0_two10_b3_4 I0_two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1051_MN1_1 (VSS I0_two10_b2_1 I0_two10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1813_MN1 (I1_qu4_b3_1 I1_qu4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1813_MN1_1 (VSS I1_qu4_b2_0 I1_qu4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1997_MN1 (I1_p31_32_b3_2 I1_p31_32_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1997_MN1_1 (VSS I1_p31_32_b2_0 I1_p31_32_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1993_MN1 (I1_p31_32_b2_0 I1_p31_32_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1993_MN1_1 (VSS I1_p31_32_b1_0 I1_p31_32_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I4_MN1 (I1_A_31_b2_2 I1_A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I4_MN1_1 (VSS I1_A_31_b1_0 I1_A_31_b2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1209_MN1 (I0_two13_b1_0 I0_two13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1209_MN1_1 (VSS I0_two13_b0 I0_two13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1199_MN1 (I0_one13_b1_0 I0_one13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1199_MN1_1 (VSS I0_one13_b0 I0_one13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1200_MN1 (I0_one13_b2_0 I0_one13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1200_MN1_1 (VSS I0_one13_b1_0 I0_one13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1210_MN1 (I0_two13_b2_0 I0_two13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1210_MN1_1 (VSS I0_two13_b1_0 I0_two13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1154_MN1 (I0_two12_b1_0 I0_two12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1154_MN1_1 (VSS I0_two12_b0 I0_two12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1144_MN1 (I0_one12_b1_0 I0_one12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1144_MN1_1 (VSS I0_one12_b0 I0_one12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I474_MN1 (I0_B_31_b2_0 I0_B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I474_MN1_1 (VSS I0_B_31_b1_0 I0_B_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I476_MN1 (I0_B_31_b3_0 I0_B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I476_MN1_1 (VSS I0_B_31_b2_0 I0_B_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1099_MN1 (I0_two11_b1_0 I0_two11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1099_MN1_1 (VSS I0_two11_b0 I0_two11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1320_MN1 (I0_two15_b2_0 I0_two15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1320_MN1_1 (VSS I0_two15_b1_0 I0_two15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1324_MN1 (I0_two15_b3_2 I0_two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1324_MN1_1 (VSS I0_two15_b2_0 I0_two15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I233_MN1 (I0_A_22_b2_1 I0_A_22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I233_MN1_1 (VSS I0_A_22_b1_0 I0_A_22_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I243_MN1 (I0_A_23_b2_1 I0_A_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I243_MN1_1 (VSS I0_A_23_b1_0 I0_A_23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I253_MN1 (I0_A_24_b2_1 I0_A_24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I253_MN1_1 (VSS I0_A_24_b1_0 I0_A_24_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I247_MN1 (I0_A_23_b3_3 I0_A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I247_MN1_1 (VSS I0_A_23_b2_1 I0_A_23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I257_MN1 (I0_A_24_b3_3 I0_A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I257_MN1_1 (VSS I0_A_24_b2_1 I0_A_24_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I237_MN1 (I0_A_22_b3_3 I0_A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I237_MN1_1 (VSS I0_A_22_b2_1 I0_A_22_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I430_MN1 (I0_B_21_b3_4 I0_B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I430_MN1_1 (VSS I0_B_21_b2_1 I0_B_21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1041_MN1 (I0_one10_b3_4 I0_one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1041_MN1_1 (VSS I0_one10_b2_1 I0_one10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I996_MN1 (I0_two9_b3_4 I0_two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I996_MN1_1 (VSS I0_two9_b2_1 I0_two9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I986_MN1 (I0_one9_b3_4 I0_one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I986_MN1_1 (VSS I0_one9_b2_1 I0_one9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1906_MN1 (I1_qu2_b3_2 I1_qu2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1906_MN1_1 (VSS I1_qu2_b2_0 I1_qu2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1952_MN1 (I1_qu1_b3_2 I1_qu1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1952_MN1_1 (VSS I1_qu1_b2_0 I1_qu1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1264_MN1 (I0_two14_b1_0 I0_two14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1264_MN1_1 (VSS I0_two14_b0 I0_two14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1265_MN1 (I0_two14_b2_0 I0_two14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1265_MN1_1 (VSS I0_two14_b1_0 I0_two14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1255_MN1 (I0_one14_b2_0 I0_one14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1255_MN1_1 (VSS I0_one14_b1_0 I0_one14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1146_MN1 (I0_one12_b2_1 I0_one12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1146_MN1_1 (VSS I0_one12_b1_0 I0_one12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1309_MN1 (I0_one15_b1_0 I0_one15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1309_MN1_1 (VSS I0_one15_b0 I0_one15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I455_MN1 (I0_B_27_b2_1 I0_B_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I455_MN1_1 (VSS I0_B_27_b1_0 I0_B_27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1319_MN1 (I0_two15_b1_0 I0_two15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1319_MN1_1 (VSS I0_two15_b0 I0_two15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I441_MN1 (I0_B_23_b3_5 I0_B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I441_MN1_1 (VSS I0_B_23_b2_1 I0_B_23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I445_MN1 (I0_B_25_b2_1 I0_B_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I445_MN1_1 (VSS I0_B_25_b1_0 I0_B_25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I440_MN1 (I0_B_23_b3_4 I0_B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I440_MN1_1 (VSS I0_B_23_b2_1 I0_B_23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I439_MN1 (I0_B_23_b3_3 I0_B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I439_MN1_1 (VSS I0_B_23_b2_1 I0_B_23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I435_MN1 (I0_B_23_b2_1 I0_B_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I435_MN1_1 (VSS I0_B_23_b1_0 I0_B_23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I449_MN1 (I0_B_25_b3_3 I0_B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I449_MN1_1 (VSS I0_B_25_b2_1 I0_B_25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I198_MN1 (I0_A_18_b3_4 I0_A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I198_MN1_1 (VSS I0_A_18_b2_1 I0_A_18_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I189_MN1 (I0_A_17_b3_5 I0_A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I189_MN1_1 (VSS I0_A_17_b2_1 I0_A_17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I188_MN1 (I0_A_17_b3_4 I0_A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I188_MN1_1 (VSS I0_A_17_b2_1 I0_A_17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I273_MN1 (I0_A_26_b2_1 I0_A_26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I273_MN1_1 (VSS I0_A_26_b1_0 I0_A_26_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I263_MN1 (I0_A_25_b2_1 I0_A_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I263_MN1_1 (VSS I0_A_25_b1_0 I0_A_25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I277_MN1 (I0_A_26_b3_3 I0_A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I277_MN1_1 (VSS I0_A_26_b2_1 I0_A_26_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I267_MN1 (I0_A_25_b3_3 I0_A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I267_MN1_1 (VSS I0_A_25_b2_1 I0_A_25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1807_MN1 (I1_qu4 I1_p27_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1807_MN1_1 (VSS I1_p27_32 I1_qu4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1809_MN1 (I1_qu4_b1_0 I1_qu4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1809_MN1_1 (VSS I1_qu4_b0 I1_qu4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1860_MN1 (I1_qu3_b3_2 I1_qu3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1860_MN1_1 (VSS I1_qu3_b2_0 I1_qu3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I11_MN1 (I1_A_31_b3_6 I1_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I11_MN1_1 (VSS I1_A_31_b2_1 I1_A_31_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1254_MN1 (I0_one14_b1_0 I0_one14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1254_MN1_1 (VSS I0_one14_b0 I0_one14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I461_MN1 (I0_B_27_b3_5 I0_B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I461_MN1_1 (VSS I0_B_27_b2_1 I0_B_27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I459_MN1 (I0_B_27_b3_3 I0_B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I459_MN1_1 (VSS I0_B_27_b2_1 I0_B_27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I465_MN1 (I0_B_29_b2_1 I0_B_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I465_MN1_1 (VSS I0_B_29_b1_0 I0_B_29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1091_MN1 (I0_one11_b2_1 I0_one11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1091_MN1_1 (VSS I0_one11_b1_0 I0_one11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I208_MN1 (I0_A_19_b3_4 I0_A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I208_MN1_1 (VSS I0_A_19_b2_1 I0_A_19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I283_MN1 (I0_A_27_b2_1 I0_A_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I283_MN1_1 (VSS I0_A_27_b1_0 I0_A_27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I313_MN1 (I0_A_30_b2_1 I0_A_30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I313_MN1_1 (VSS I0_A_30_b1_0 I0_A_30_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I293_MN1 (I0_A_28_b2_1 I0_A_28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I293_MN1_1 (VSS I0_A_28_b1_0 I0_A_28_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I287_MN1 (I0_A_27_b3_3 I0_A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I287_MN1_1 (VSS I0_A_27_b2_1 I0_A_27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I932_MN1 (I0_one8_b3_5 I0_one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I932_MN1_1 (VSS I0_one8_b2_1 I0_one8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1810_MN1 (I1_qu4_b2_0 I1_qu4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1810_MN1_1 (VSS I1_qu4_b1_0 I1_qu4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1814_MN1 (I1_qu4_b3_2 I1_qu4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1814_MN1_1 (VSS I1_qu4_b2_0 I1_qu4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1856_MN1 (I1_qu3_b2_0 I1_qu3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1856_MN1_1 (VSS I1_qu3_b1_0 I1_qu3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I318_MN1 (I0_A_30_b3_4 I0_A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I318_MN1_1 (VSS I0_A_30_b2_1 I0_A_30_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1201_MN1 (I0_one13_b2_1 I0_one13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1201_MN1_1 (VSS I0_one13_b1_0 I0_one13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1211_MN1 (I0_two13_b2_1 I0_two13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1211_MN1_1 (VSS I0_two13_b1_0 I0_two13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1256_MN1 (I0_one14_b2_1 I0_one14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1256_MN1_1 (VSS I0_one14_b1_0 I0_one14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1266_MN1 (I0_two14_b2_1 I0_two14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1266_MN1_1 (VSS I0_two14_b1_0 I0_two14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1162_MN1 (I0_two12_b3_5 I0_two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1162_MN1_1 (VSS I0_two12_b2_1 I0_two12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I475_MN1 (I0_B_31_b2_1 I0_B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I475_MN1_1 (VSS I0_B_31_b1_0 I0_B_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1152_MN1 (I0_one12_b3_5 I0_one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1152_MN1_1 (VSS I0_one12_b2_1 I0_one12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1311_MN1 (I0_one15_b2_1 I0_one15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1311_MN1_1 (VSS I0_one15_b1_0 I0_one15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1321_MN1 (I0_two15_b2_1 I0_two15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1321_MN1_1 (VSS I0_two15_b1_0 I0_two15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1101_MN1 (I0_two11_b2_1 I0_two11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1101_MN1_1 (VSS I0_two11_b1_0 I0_two11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I450_MN1 (I0_B_25_b3_4 I0_B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I450_MN1_1 (VSS I0_B_25_b2_1 I0_B_25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1215_MN1 (I0_two13_b3_3 I0_two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1215_MN1_1 (VSS I0_two13_b2_1 I0_two13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1205_MN1 (I0_one13_b3_3 I0_one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1205_MN1_1 (VSS I0_one13_b2_1 I0_one13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I199_MN1 (I0_A_18_b3_5 I0_A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I199_MN1_1 (VSS I0_A_18_b2_1 I0_A_18_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I228_MN1 (I0_A_21_b3_4 I0_A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I228_MN1_1 (VSS I0_A_21_b2_1 I0_A_21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I219_MN1 (I0_A_20_b3_5 I0_A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I219_MN1_1 (VSS I0_A_20_b2_1 I0_A_20_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I209_MN1 (I0_A_19_b3_5 I0_A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I209_MN1_1 (VSS I0_A_19_b2_1 I0_A_19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I218_MN1 (I0_A_20_b3_4 I0_A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I218_MN1_1 (VSS I0_A_20_b2_1 I0_A_20_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1150_MN1 (I0_one12_b3_3 I0_one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1150_MN1_1 (VSS I0_one12_b2_1 I0_one12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1160_MN1 (I0_two12_b3_3 I0_two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1160_MN1_1 (VSS I0_two12_b2_1 I0_two12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1052_MN1 (I0_two10_b3_5 I0_two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1052_MN1_1 (VSS I0_two10_b2_1 I0_two10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I942_MN1 (I0_two8_b3_5 I0_two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I942_MN1_1 (VSS I0_two8_b2_1 I0_two8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I997_MN1 (I0_two9_b3_5 I0_two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I997_MN1_1 (VSS I0_two9_b2_1 I0_two9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1853_MN1 (I1_qu3 I1_p28_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1853_MN1_1 (VSS I1_p28_32 I1_qu3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1855_MN1 (I1_qu3_b1_0 I1_qu3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1855_MN1_1 (VSS I1_qu3_b0 I1_qu3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I12_MN1 (I1_A_31_b3_7 I1_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I12_MN1_1 (VSS I1_A_31_b2_1 I1_A_31_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I67_MN1 (I2_I3_SEL_DIV_b3_6 I2_I3_SEL_DIV_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I67_MN1_1 (VSS I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I51_MN1 (I2_I3_SEL_MUL_b3_6 I2_I3_SEL_MUL_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I51_MN1_1 (VSS I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I319_MN1 (I0_A_30_b3_5 I0_A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I319_MN1_1 (VSS I0_A_30_b2_1 I0_A_30_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I330_MN1 (I0_A_31_b3_6 I0_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I330_MN1_1 (VSS I0_A_31_b2_1 I0_A_31_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I299_MN1 (I0_A_28_b3_5 I0_A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I299_MN1_1 (VSS I0_A_28_b2_1 I0_A_28_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I308_MN1 (I0_A_29_b3_4 I0_A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I308_MN1_1 (VSS I0_A_29_b2_1 I0_A_29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1207_MN1 (I0_one13_b3_5 I0_one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1207_MN1_1 (VSS I0_one13_b2_1 I0_one13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1217_MN1 (I0_two13_b3_5 I0_two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1217_MN1_1 (VSS I0_two13_b2_1 I0_two13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I298_MN1 (I0_A_28_b3_4 I0_A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I298_MN1_1 (VSS I0_A_28_b2_1 I0_A_28_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I289_MN1 (I0_A_27_b3_5 I0_A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I289_MN1_1 (VSS I0_A_27_b2_1 I0_A_27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1107_MN1 (I0_two11_b3_5 I0_two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1107_MN1_1 (VSS I0_two11_b2_1 I0_two11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1097_MN1 (I0_one11_b3_5 I0_one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1097_MN1_1 (VSS I0_one11_b2_1 I0_one11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1216_MN1 (I0_two13_b3_4 I0_two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1216_MN1_1 (VSS I0_two13_b2_1 I0_two13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1206_MN1 (I0_one13_b3_4 I0_one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1206_MN1_1 (VSS I0_one13_b2_1 I0_one13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I288_MN1 (I0_A_27_b3_4 I0_A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I288_MN1_1 (VSS I0_A_27_b2_1 I0_A_27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1161_MN1 (I0_two12_b3_4 I0_two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1161_MN1_1 (VSS I0_two12_b2_1 I0_two12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1151_MN1 (I0_one12_b3_4 I0_one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1151_MN1_1 (VSS I0_one12_b2_1 I0_one12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1096_MN1 (I0_one11_b3_4 I0_one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1096_MN1_1 (VSS I0_one11_b2_1 I0_one11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1106_MN1 (I0_two11_b3_4 I0_two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1106_MN1_1 (VSS I0_two11_b2_1 I0_two11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1042_MN1 (I0_one10_b3_5 I0_one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1042_MN1_1 (VSS I0_one10_b2_1 I0_one10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I297_MN1 (I0_A_28_b3_3 I0_A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I297_MN1_1 (VSS I0_A_28_b2_1 I0_A_28_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I303_MN1 (I0_A_29_b2_1 I0_A_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I303_MN1_1 (VSS I0_A_29_b1_0 I0_A_29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I59_MN1 (I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I59_MN1_1 (VSS I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I68_MN1 (I2_I3_SEL_DIV_b3_7 I2_I3_SEL_DIV_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I68_MN1_1 (VSS I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I52_MN1 (I2_I3_SEL_MUL_b3_7 I2_I3_SEL_MUL_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I52_MN1_1 (VSS I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I329_MN1 (I0_A_31_b3_5 I0_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I329_MN1_1 (VSS I0_A_31_b2_1 I0_A_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I229_MN1 (I0_A_21_b3_5 I0_A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I229_MN1_1 (VSS I0_A_21_b2_1 I0_A_21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I238_MN1 (I0_A_22_b3_4 I0_A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I238_MN1_1 (VSS I0_A_22_b2_1 I0_A_22_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I317_MN1 (I0_A_30_b3_3 I0_A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I317_MN1_1 (VSS I0_A_30_b2_1 I0_A_30_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I307_MN1 (I0_A_29_b3_3 I0_A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I307_MN1_1 (VSS I0_A_29_b2_1 I0_A_29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I323_MN1 (I0_A_31_b2_1 I0_A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I323_MN1_1 (VSS I0_A_31_b1_0 I0_A_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I987_MN1 (I0_one9_b3_5 I0_one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I987_MN1_1 (VSS I0_one9_b2_1 I0_one9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I44_MN1 (I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I44_MN1_1 (VSS I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I309_MN1 (I0_A_29_b3_5 I0_A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I309_MN1_1 (VSS I0_A_29_b2_1 I0_A_29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I469_MN1 (I0_B_29_b3_3 I0_B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I469_MN1_1 (VSS I0_B_29_b2_1 I0_B_29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I470_MN1 (I0_B_29_b3_4 I0_B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I470_MN1_1 (VSS I0_B_29_b2_1 I0_B_29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1260_MN1 (I0_one14_b3_3 I0_one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1260_MN1_1 (VSS I0_one14_b2_1 I0_one14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1270_MN1 (I0_two14_b3_3 I0_two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1270_MN1_1 (VSS I0_two14_b2_1 I0_two14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I249_MN1 (I0_A_23_b3_5 I0_A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I249_MN1_1 (VSS I0_A_23_b2_1 I0_A_23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I248_MN1 (I0_A_23_b3_4 I0_A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I248_MN1_1 (VSS I0_A_23_b2_1 I0_A_23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I258_MN1 (I0_A_24_b3_4 I0_A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I258_MN1_1 (VSS I0_A_24_b2_1 I0_A_24_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1902_MN1 (I1_qu2_b2_0 I1_qu2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1902_MN1_1 (VSS I1_qu2_b1_0 I1_qu2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1948_MN1 (I1_qu1_b2_0 I1_qu1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1948_MN1_1 (VSS I1_qu1_b1_0 I1_qu1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1994_MN1 (I1_p31_32_b2_1 I1_p31_32_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1994_MN1_1 (VSS I1_p31_32_b1_0 I1_p31_32_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I60_MN1 (I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I60_MN1_1 (VSS I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1272_MN1 (I0_two14_b3_5 I0_two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1272_MN1_1 (VSS I0_two14_b2_1 I0_two14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1262_MN1 (I0_one14_b3_5 I0_one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1262_MN1_1 (VSS I0_one14_b2_1 I0_one14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1261_MN1 (I0_one14_b3_4 I0_one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1261_MN1_1 (VSS I0_one14_b2_1 I0_one14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1325_MN1 (I0_two15_b3_3 I0_two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1325_MN1_1 (VSS I0_two15_b2_1 I0_two15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I239_MN1 (I0_A_22_b3_5 I0_A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I239_MN1_1 (VSS I0_A_22_b2_1 I0_A_22_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I259_MN1 (I0_A_24_b3_5 I0_A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I259_MN1_1 (VSS I0_A_24_b2_1 I0_A_24_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I328_MN1 (I0_A_31_b3_4 I0_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I328_MN1_1 (VSS I0_A_31_b2_1 I0_A_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1949_MN1 (I1_qu1_b2_1 I1_qu1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1949_MN1_1 (VSS I1_qu1_b1_0 I1_qu1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1953_MN1 (I1_qu1_b3_3 I1_qu1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1953_MN1_1 (VSS I1_qu1_b2_1 I1_qu1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1998_MN1 (I1_p31_32_b3_3 I1_p31_32_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1998_MN1_1 (VSS I1_p31_32_b2_1 I1_p31_32_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1992_MN1 (I1_p31_32_b1_0 I1_p31_32_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1992_MN1_1 (VSS I1_p31_32_b0 I1_p31_32_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I13_MN1 (I1_A_31_b3_8 I1_A_31_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I13_MN1_1 (VSS I1_A_31_b2_2 I1_A_31_b3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I480_MN1 (I0_B_31_b3_4 I0_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I480_MN1_1 (VSS I0_B_31_b2_1 I0_B_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1316_MN1 (I0_one15_b3_4 I0_one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1316_MN1_1 (VSS I0_one15_b2_1 I0_one15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I479_MN1 (I0_B_31_b3_3 I0_B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I479_MN1_1 (VSS I0_B_31_b2_1 I0_B_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1271_MN1 (I0_two14_b3_4 I0_two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1271_MN1_1 (VSS I0_two14_b2_1 I0_two14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1326_MN1 (I0_two15_b3_4 I0_two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1326_MN1_1 (VSS I0_two15_b2_1 I0_two15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1315_MN1 (I0_one15_b3_3 I0_one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1315_MN1_1 (VSS I0_one15_b2_1 I0_one15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I268_MN1 (I0_A_25_b3_4 I0_A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I268_MN1_1 (VSS I0_A_25_b2_1 I0_A_25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1816_MN1 (I1_qu4_b3_4 I1_qu4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1816_MN1_1 (VSS I1_qu4_b2_1 I1_qu4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1817_MN1 (I1_qu4_b3_5 I1_qu4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1817_MN1_1 (VSS I1_qu4_b2_1 I1_qu4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1815_MN1 (I1_qu4_b3_3 I1_qu4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1815_MN1_1 (VSS I1_qu4_b2_1 I1_qu4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1811_MN1 (I1_qu4_b2_1 I1_qu4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1811_MN1_1 (VSS I1_qu4_b1_0 I1_qu4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1862_MN1 (I1_qu3_b3_4 I1_qu3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1862_MN1_1 (VSS I1_qu3_b2_1 I1_qu3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1863_MN1 (I1_qu3_b3_5 I1_qu3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1863_MN1_1 (VSS I1_qu3_b2_1 I1_qu3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1861_MN1 (I1_qu3_b3_3 I1_qu3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1861_MN1_1 (VSS I1_qu3_b2_1 I1_qu3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1857_MN1 (I1_qu3_b2_1 I1_qu3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1857_MN1_1 (VSS I1_qu3_b1_0 I1_qu3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1907_MN1 (I1_qu2_b3_3 I1_qu2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1907_MN1_1 (VSS I1_qu2_b2_1 I1_qu2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1903_MN1 (I1_qu2_b2_1 I1_qu2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1903_MN1_1 (VSS I1_qu2_b1_0 I1_qu2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1909_MN1 (I1_qu2_b3_5 I1_qu2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1909_MN1_1 (VSS I1_qu2_b2_1 I1_qu2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1954_MN1 (I1_qu1_b3_4 I1_qu1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1954_MN1_1 (VSS I1_qu1_b2_1 I1_qu1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1955_MN1 (I1_qu1_b3_5 I1_qu1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1955_MN1_1 (VSS I1_qu1_b2_1 I1_qu1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I69_MN1 (I2_I3_SEL_DIV_b3_8 I2_I3_SEL_DIV_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I69_MN1_1 (VSS I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I53_MN1 (I2_I3_SEL_MUL_b3_8 I2_I3_SEL_MUL_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I53_MN1_1 (VSS I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I331_MN1 (I0_A_31_b3_7 I0_A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I331_MN1_1 (VSS I0_A_31_b2_1 I0_A_31_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I279_MN1 (I0_A_26_b3_5 I0_A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I279_MN1_1 (VSS I0_A_26_b2_1 I0_A_26_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I269_MN1 (I0_A_25_b3_5 I0_A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I269_MN1_1 (VSS I0_A_25_b2_1 I0_A_25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I278_MN1 (I0_A_26_b3_4 I0_A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I278_MN1_1 (VSS I0_A_26_b2_1 I0_A_26_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1908_MN1 (I1_qu2_b3_4 I1_qu2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1908_MN1_1 (VSS I1_qu2_b2_1 I1_qu2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1947_MN1 (I1_qu1_b1_0 I1_qu1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1947_MN1_1 (VSS I1_qu1_b0 I1_qu1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1999_MN1 (I1_p31_32_b3_4 I1_p31_32_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1999_MN1_1 (VSS I1_p31_32_b2_1 I1_p31_32_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I14_MN1 (I1_A_31_b3_9 I1_A_31_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I14_MN1_1 (VSS I1_A_31_b2_2 I1_A_31_b3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I70_MN1 (I2_I3_SEL_DIV_b3_9 I2_I3_SEL_DIV_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I70_MN1_1 (VSS I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I54_MN1 (I2_I3_SEL_MUL_b3_9 I2_I3_SEL_MUL_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I54_MN1_1 (VSS I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1899_MN1 (I1_qu2 I1_p29_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1899_MN1_1 (VSS I1_p29_32 I1_qu2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1901_MN1 (I1_qu2_b1_0 I1_qu2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1901_MN1_1 (VSS I1_qu2_b0 I1_qu2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1945_MN1 (I1_qu1 I1_p30_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1945_MN1_1 (VSS I1_p30_32 I1_qu1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2000_MN1 (I1_p31_32_b3_5 I1_p31_32_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2000_MN1_1 (VSS I1_p31_32_b2_1 I1_p31_32_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I15_MN1 (I1_A_31_b3_10 I1_A_31_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I15_MN1_1 (VSS I1_A_31_b2_2 I1_A_31_b3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I71_MN1 (I2_I3_SEL_DIV_b3_10 I2_I3_SEL_DIV_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I71_MN1_1 (VSS I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I55_MN1 (I2_I3_SEL_MUL_b3_10 I2_I3_SEL_MUL_b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I55_MN1_1 (VSS I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1613_MN5 (I0_ha252_0 I0_fa138_0 XI0_I1613_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1613_MN7 (XI0_I1613_xn2 XI0_I1613_xan I0_ha252_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1613_MN8 (VSS XI0_I1613_xbn XI0_I1613_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1613_MN6 (XI0_I1613_xn1 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1613_MN1 (VSS I0_fa138_0 XI0_I1613_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1613_MN14 (XI0_I1613_an I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1613_MN13 (XI0_I1613_con I0_fa138_0 XI0_I1613_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1613_MN17 (I0_ha252_1 XI0_I1613_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1613_MN3 (VSS I0_B_9_b3_5 XI0_I1613_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1615_MN5 (I0_ha254_0 I0_fa139_1 XI0_I1615_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1615_MN7 (XI0_I1615_xn2 XI0_I1615_xan I0_ha254_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1615_MN8 (VSS XI0_I1615_xbn XI0_I1615_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1615_MN6 (XI0_I1615_xn1 I0_fa140_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1615_MN1 (VSS I0_fa139_1 XI0_I1615_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1615_MN14 (XI0_I1615_an I0_fa140_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1615_MN13 (XI0_I1615_con I0_fa139_1 XI0_I1615_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1615_MN17 (I0_ha254_1 XI0_I1615_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1615_MN3 (VSS I0_fa140_0 XI0_I1615_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1617_MN5 (I0_ha256_0 I0_cm141_1 XI0_I1617_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1617_MN7 (XI0_I1617_xn2 XI0_I1617_xan I0_ha256_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1617_MN8 (VSS XI0_I1617_xbn XI0_I1617_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1617_MN6 (XI0_I1617_xn1 I0_cm142_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1617_MN1 (VSS I0_cm141_1 XI0_I1617_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1617_MN14 (XI0_I1617_an I0_cm142_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1617_MN13 (XI0_I1617_con I0_cm141_1 XI0_I1617_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1617_MN17 (I0_ha256_1 XI0_I1617_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1617_MN3 (VSS I0_cm142_0 XI0_I1617_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1620_MN5 (I0_ha259_0 I0_cm144_1 XI0_I1620_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1620_MN7 (XI0_I1620_xn2 XI0_I1620_xan I0_ha259_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1620_MN8 (VSS XI0_I1620_xbn XI0_I1620_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1620_MN6 (XI0_I1620_xn1 I0_cm145_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1620_MN1 (VSS I0_cm144_1 XI0_I1620_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1620_MN14 (XI0_I1620_an I0_cm145_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1620_MN13 (XI0_I1620_con I0_cm144_1 XI0_I1620_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1620_MN17 (I0_ha259_1 XI0_I1620_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1620_MN3 (VSS I0_cm145_0 XI0_I1620_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1619_MN5 (I0_ha258_0 I0_cm143_1 XI0_I1619_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1619_MN7 (XI0_I1619_xn2 XI0_I1619_xan I0_ha258_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1619_MN8 (VSS XI0_I1619_xbn XI0_I1619_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1619_MN6 (XI0_I1619_xn1 I0_cm144_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1619_MN1 (VSS I0_cm143_1 XI0_I1619_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1619_MN14 (XI0_I1619_an I0_cm144_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1619_MN13 (XI0_I1619_con I0_cm143_1 XI0_I1619_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1619_MN17 (I0_ha258_1 XI0_I1619_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1619_MN3 (VSS I0_cm144_0 XI0_I1619_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1612_MN5 (I0_ha251_0 I0_cm4_1 XI0_I1612_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1612_MN7 (XI0_I1612_xn2 XI0_I1612_xan I0_ha251_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1612_MN8 (VSS XI0_I1612_xbn XI0_I1612_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1612_MN6 (XI0_I1612_xn1 I0_cm5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1612_MN1 (VSS I0_cm4_1 XI0_I1612_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1612_MN14 (XI0_I1612_an I0_cm5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1612_MN13 (XI0_I1612_con I0_cm4_1 XI0_I1612_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1612_MN17 (I0_ha251_1 XI0_I1612_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1612_MN3 (VSS I0_cm5_0 XI0_I1612_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1614_MN5 (I0_ha253_0 I0_fa138_1 XI0_I1614_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1614_MN7 (XI0_I1614_xn2 XI0_I1614_xan I0_ha253_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1614_MN8 (VSS XI0_I1614_xbn XI0_I1614_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1614_MN6 (XI0_I1614_xn1 I0_fa139_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1614_MN1 (VSS I0_fa138_1 XI0_I1614_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1614_MN14 (XI0_I1614_an I0_fa139_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1614_MN13 (XI0_I1614_con I0_fa138_1 XI0_I1614_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1614_MN17 (I0_ha253_1 XI0_I1614_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1614_MN3 (VSS I0_fa139_0 XI0_I1614_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1616_MN5 (I0_ha255_0 I0_fa140_1 XI0_I1616_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1616_MN7 (XI0_I1616_xn2 XI0_I1616_xan I0_ha255_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1616_MN8 (VSS XI0_I1616_xbn XI0_I1616_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1616_MN6 (XI0_I1616_xn1 I0_cm141_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1616_MN1 (VSS I0_fa140_1 XI0_I1616_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1616_MN14 (XI0_I1616_an I0_cm141_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1616_MN13 (XI0_I1616_con I0_fa140_1 XI0_I1616_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1616_MN17 (I0_ha255_1 XI0_I1616_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1616_MN3 (VSS I0_cm141_0 XI0_I1616_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1618_MN5 (I0_ha257_0 I0_cm142_1 XI0_I1618_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1618_MN7 (XI0_I1618_xn2 XI0_I1618_xan I0_ha257_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1618_MN8 (VSS XI0_I1618_xbn XI0_I1618_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1618_MN6 (XI0_I1618_xn1 I0_cm143_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1618_MN1 (VSS I0_cm142_1 XI0_I1618_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1618_MN14 (XI0_I1618_an I0_cm143_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1618_MN13 (XI0_I1618_con I0_cm142_1 XI0_I1618_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1618_MN17 (I0_ha257_1 XI0_I1618_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1618_MN3 (VSS I0_cm143_0 XI0_I1618_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1622_MN5 (I0_ha261_0 I0_fa210_1 XI0_I1622_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1622_MN7 (XI0_I1622_xn2 XI0_I1622_xan I0_ha261_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1622_MN8 (VSS XI0_I1622_xbn XI0_I1622_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1622_MN6 (XI0_I1622_xn1 I0_fa211_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1622_MN1 (VSS I0_fa210_1 XI0_I1622_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1622_MN14 (XI0_I1622_an I0_fa211_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1622_MN13 (XI0_I1622_con I0_fa210_1 XI0_I1622_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1622_MN17 (I0_ha261_1 XI0_I1622_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1622_MN3 (VSS I0_fa211_0 XI0_I1622_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1623_MN5 (I0_ha262_0 I0_fa211_1 XI0_I1623_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1623_MN7 (XI0_I1623_xn2 XI0_I1623_xan I0_ha262_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1623_MN8 (VSS XI0_I1623_xbn XI0_I1623_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1623_MN6 (XI0_I1623_xn1 I0_fa212_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1623_MN1 (VSS I0_fa211_1 XI0_I1623_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1623_MN14 (XI0_I1623_an I0_fa212_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1623_MN13 (XI0_I1623_con I0_fa211_1 XI0_I1623_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1623_MN17 (I0_ha262_1 XI0_I1623_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1623_MN3 (VSS I0_fa212_0 XI0_I1623_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1627_MN5 (I0_ha266_0 I0_cm215_1 XI0_I1627_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1627_MN7 (XI0_I1627_xn2 XI0_I1627_xan I0_ha266_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1627_MN8 (VSS XI0_I1627_xbn XI0_I1627_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1627_MN6 (XI0_I1627_xn1 I0_cm216_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1627_MN1 (VSS I0_cm215_1 XI0_I1627_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1627_MN14 (XI0_I1627_an I0_cm216_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1627_MN13 (XI0_I1627_con I0_cm215_1 XI0_I1627_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1627_MN17 (I0_ha266_1 XI0_I1627_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1627_MN3 (VSS I0_cm216_0 XI0_I1627_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1611_MN5 (I0_ha250_0 I0_fa3_1 XI0_I1611_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1611_MN7 (XI0_I1611_xn2 XI0_I1611_xan I0_ha250_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1611_MN8 (VSS XI0_I1611_xbn XI0_I1611_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1611_MN6 (XI0_I1611_xn1 I0_cm4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1611_MN1 (VSS I0_fa3_1 XI0_I1611_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1611_MN14 (XI0_I1611_an I0_cm4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1611_MN13 (XI0_I1611_con I0_fa3_1 XI0_I1611_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1611_MN17 (I0_ha250_1 XI0_I1611_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1611_MN3 (VSS I0_cm4_0 XI0_I1611_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1621_MN5 (I0_ha260_0 I0_fa210_0 XI0_I1621_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1621_MN7 (XI0_I1621_xn2 XI0_I1621_xan I0_ha260_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1621_MN8 (VSS XI0_I1621_xbn XI0_I1621_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1621_MN6 (XI0_I1621_xn1 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1621_MN1 (VSS I0_fa210_0 XI0_I1621_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1621_MN14 (XI0_I1621_an I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1621_MN13 (XI0_I1621_con I0_fa210_0 XI0_I1621_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1621_MN17 (I0_ha260_1 XI0_I1621_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1621_MN3 (VSS I0_B_17_b3_5 XI0_I1621_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1626_MN5 (I0_ha265_0 I0_cm214_1 XI0_I1626_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1626_MN7 (XI0_I1626_xn2 XI0_I1626_xan I0_ha265_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1626_MN8 (VSS XI0_I1626_xbn XI0_I1626_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1626_MN6 (XI0_I1626_xn1 I0_cm215_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1626_MN1 (VSS I0_cm214_1 XI0_I1626_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1626_MN14 (XI0_I1626_an I0_cm215_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1626_MN13 (XI0_I1626_con I0_cm214_1 XI0_I1626_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1626_MN17 (I0_ha265_1 XI0_I1626_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1626_MN3 (VSS I0_cm215_0 XI0_I1626_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1624_MN5 (I0_ha263_0 I0_fa212_1 XI0_I1624_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1624_MN7 (XI0_I1624_xn2 XI0_I1624_xan I0_ha263_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1624_MN8 (VSS XI0_I1624_xbn XI0_I1624_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1624_MN6 (XI0_I1624_xn1 I0_fa213_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1624_MN1 (VSS I0_fa212_1 XI0_I1624_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1624_MN14 (XI0_I1624_an I0_fa213_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1624_MN13 (XI0_I1624_con I0_fa212_1 XI0_I1624_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1624_MN17 (I0_ha263_1 XI0_I1624_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1624_MN3 (VSS I0_fa213_0 XI0_I1624_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1625_MN5 (I0_ha264_0 I0_fa213_1 XI0_I1625_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1625_MN7 (XI0_I1625_xn2 XI0_I1625_xan I0_ha264_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1625_MN8 (VSS XI0_I1625_xbn XI0_I1625_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1625_MN6 (XI0_I1625_xn1 I0_cm214_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1625_MN1 (VSS I0_fa213_1 XI0_I1625_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1625_MN14 (XI0_I1625_an I0_cm214_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1625_MN13 (XI0_I1625_con I0_fa213_1 XI0_I1625_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1625_MN17 (I0_ha264_1 XI0_I1625_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1625_MN3 (VSS I0_cm214_0 XI0_I1625_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1628_MN5 (I0_ha267_0 I0_cm216_1 XI0_I1628_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1628_MN7 (XI0_I1628_xn2 XI0_I1628_xan I0_ha267_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1628_MN8 (VSS XI0_I1628_xbn XI0_I1628_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1628_MN6 (XI0_I1628_xn1 I0_cm217_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1628_MN1 (VSS I0_cm216_1 XI0_I1628_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1628_MN14 (XI0_I1628_an I0_cm217_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1628_MN13 (XI0_I1628_con I0_cm216_1 XI0_I1628_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1628_MN17 (I0_ha267_1 XI0_I1628_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1628_MN3 (VSS I0_cm217_0 XI0_I1628_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1629_MN5 (I0_ha268_0 I0_cm217_1 XI0_I1629_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1629_MN7 (XI0_I1629_xn2 XI0_I1629_xan I0_ha268_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1629_MN8 (VSS XI0_I1629_xbn XI0_I1629_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1629_MN6 (XI0_I1629_xn1 I0_cm218_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1629_MN1 (VSS I0_cm217_1 XI0_I1629_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1629_MN14 (XI0_I1629_an I0_cm218_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1629_MN13 (XI0_I1629_con I0_cm217_1 XI0_I1629_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1629_MN17 (I0_ha268_1 XI0_I1629_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1629_MN3 (VSS I0_cm218_0 XI0_I1629_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1630_MN5 (I0_ha269_0 I0_cm218_1 XI0_I1630_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1630_MN7 (XI0_I1630_xn2 XI0_I1630_xan I0_ha269_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1630_MN8 (VSS XI0_I1630_xbn XI0_I1630_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1630_MN6 (XI0_I1630_xn1 I0_cm219_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1630_MN1 (VSS I0_cm218_1 XI0_I1630_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1630_MN14 (XI0_I1630_an I0_cm219_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1630_MN13 (XI0_I1630_con I0_cm218_1 XI0_I1630_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1630_MN17 (I0_ha269_1 XI0_I1630_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1630_MN3 (VSS I0_cm219_0 XI0_I1630_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1631_MN5 (I0_ha270_0 I0_cm219_1 XI0_I1631_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1631_MN7 (XI0_I1631_xn2 XI0_I1631_xan I0_ha270_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1631_MN8 (VSS XI0_I1631_xbn XI0_I1631_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1631_MN6 (XI0_I1631_xn1 I0_cm220_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1631_MN1 (VSS I0_cm219_1 XI0_I1631_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1631_MN14 (XI0_I1631_an I0_cm220_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1631_MN13 (XI0_I1631_con I0_cm219_1 XI0_I1631_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1631_MN17 (I0_ha270_1 XI0_I1631_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1631_MN3 (VSS I0_cm220_0 XI0_I1631_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1633_MN5 (I0_ha272_0 I0_cm221_1 XI0_I1633_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1633_MN7 (XI0_I1633_xn2 XI0_I1633_xan I0_ha272_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1633_MN8 (VSS XI0_I1633_xbn XI0_I1633_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1633_MN6 (XI0_I1633_xn1 I0_cm222_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1633_MN1 (VSS I0_cm221_1 XI0_I1633_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1633_MN14 (XI0_I1633_an I0_cm222_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1633_MN13 (XI0_I1633_con I0_cm221_1 XI0_I1633_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1633_MN17 (I0_ha272_1 XI0_I1633_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1633_MN3 (VSS I0_cm222_0 XI0_I1633_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1632_MN5 (I0_ha271_0 I0_cm220_1 XI0_I1632_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1632_MN7 (XI0_I1632_xn2 XI0_I1632_xan I0_ha271_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1632_MN8 (VSS XI0_I1632_xbn XI0_I1632_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1632_MN6 (XI0_I1632_xn1 I0_cm221_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1632_MN1 (VSS I0_cm220_1 XI0_I1632_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1632_MN14 (XI0_I1632_an I0_cm221_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1632_MN13 (XI0_I1632_con I0_cm220_1 XI0_I1632_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1632_MN17 (I0_ha271_1 XI0_I1632_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1632_MN3 (VSS I0_cm221_0 XI0_I1632_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1634_MN5 (I0_ha273_0 I0_cm222_1 XI0_I1634_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1634_MN7 (XI0_I1634_xn2 XI0_I1634_xan I0_ha273_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1634_MN8 (VSS XI0_I1634_xbn XI0_I1634_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1634_MN6 (XI0_I1634_xn1 I0_cm223_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1634_MN1 (VSS I0_cm222_1 XI0_I1634_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1634_MN14 (XI0_I1634_an I0_cm223_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1634_MN13 (XI0_I1634_con I0_cm222_1 XI0_I1634_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1634_MN17 (I0_ha273_1 XI0_I1634_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1634_MN3 (VSS I0_cm223_0 XI0_I1634_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1635_MN5 (I0_ha274_0 I0_cm223_1 XI0_I1635_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1635_MN7 (XI0_I1635_xn2 XI0_I1635_xan I0_ha274_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1635_MN8 (VSS XI0_I1635_xbn XI0_I1635_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1635_MN6 (XI0_I1635_xn1 I0_cm224_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1635_MN1 (VSS I0_cm223_1 XI0_I1635_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1635_MN14 (XI0_I1635_an I0_cm224_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1635_MN13 (XI0_I1635_con I0_cm223_1 XI0_I1635_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1635_MN17 (I0_ha274_1 XI0_I1635_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1635_MN3 (VSS I0_cm224_0 XI0_I1635_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1637_MN5 (I0_ha276_0 I0_cm225_1 XI0_I1637_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1637_MN7 (XI0_I1637_xn2 XI0_I1637_xan I0_ha276_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1637_MN8 (VSS XI0_I1637_xbn XI0_I1637_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1637_MN6 (XI0_I1637_xn1 I0_cm226_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1637_MN1 (VSS I0_cm225_1 XI0_I1637_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1637_MN14 (XI0_I1637_an I0_cm226_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1637_MN13 (XI0_I1637_con I0_cm225_1 XI0_I1637_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1637_MN17 (I0_ha276_1 XI0_I1637_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1637_MN3 (VSS I0_cm226_0 XI0_I1637_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1636_MN5 (I0_ha275_0 I0_cm224_1 XI0_I1636_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1636_MN7 (XI0_I1636_xn2 XI0_I1636_xan I0_ha275_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1636_MN8 (VSS XI0_I1636_xbn XI0_I1636_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1636_MN6 (XI0_I1636_xn1 I0_cm225_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1636_MN1 (VSS I0_cm224_1 XI0_I1636_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1636_MN14 (XI0_I1636_an I0_cm225_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1636_MN13 (XI0_I1636_con I0_cm224_1 XI0_I1636_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1636_MN17 (I0_ha275_1 XI0_I1636_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1636_MN3 (VSS I0_cm225_0 XI0_I1636_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1638_MN5 (I0_ha277_0 I0_cm226_1 XI0_I1638_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1638_MN7 (XI0_I1638_xn2 XI0_I1638_xan I0_ha277_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1638_MN8 (VSS XI0_I1638_xbn XI0_I1638_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1638_MN6 (XI0_I1638_xn1 I0_cm227_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1638_MN1 (VSS I0_cm226_1 XI0_I1638_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1638_MN14 (XI0_I1638_an I0_cm227_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1638_MN13 (XI0_I1638_con I0_cm226_1 XI0_I1638_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1638_MN17 (I0_ha277_1 XI0_I1638_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1638_MN3 (VSS I0_cm227_0 XI0_I1638_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1639_MN5 (I0_ha278_0 I0_cm227_1 XI0_I1639_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1639_MN7 (XI0_I1639_xn2 XI0_I1639_xan I0_ha278_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1639_MN8 (VSS XI0_I1639_xbn XI0_I1639_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1639_MN6 (XI0_I1639_xn1 I0_cm228_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1639_MN1 (VSS I0_cm227_1 XI0_I1639_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1639_MN14 (XI0_I1639_an I0_cm228_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1639_MN13 (XI0_I1639_con I0_cm227_1 XI0_I1639_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1639_MN17 (I0_ha278_1 XI0_I1639_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1639_MN3 (VSS I0_cm228_0 XI0_I1639_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1640_MN5 (I0_ha279_0 I0_cm228_1 XI0_I1640_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1640_MN7 (XI0_I1640_xn2 XI0_I1640_xan I0_ha279_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1640_MN8 (VSS XI0_I1640_xbn XI0_I1640_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1640_MN6 (XI0_I1640_xn1 I0_cm229_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1640_MN1 (VSS I0_cm228_1 XI0_I1640_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1640_MN14 (XI0_I1640_an I0_cm229_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1640_MN13 (XI0_I1640_con I0_cm228_1 XI0_I1640_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1640_MN17 (I0_ha279_1 XI0_I1640_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1640_MN3 (VSS I0_cm229_0 XI0_I1640_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1643_MN5 (I0_ha282_0 I0_cm231_1 XI0_I1643_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1643_MN7 (XI0_I1643_xn2 XI0_I1643_xan I0_ha282_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1643_MN8 (VSS XI0_I1643_xbn XI0_I1643_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1643_MN6 (XI0_I1643_xn1 I0_cm232_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1643_MN1 (VSS I0_cm231_1 XI0_I1643_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1643_MN14 (XI0_I1643_an I0_cm232_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1643_MN13 (XI0_I1643_con I0_cm231_1 XI0_I1643_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1643_MN17 (I0_ha282_1 XI0_I1643_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1643_MN3 (VSS I0_cm232_0 XI0_I1643_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1645_MN5 (I0_ha284_0 I0_cm233_1 XI0_I1645_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1645_MN7 (XI0_I1645_xn2 XI0_I1645_xan I0_ha284_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1645_MN8 (VSS XI0_I1645_xbn XI0_I1645_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1645_MN6 (XI0_I1645_xn1 I0_cm234_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1645_MN1 (VSS I0_cm233_1 XI0_I1645_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1645_MN14 (XI0_I1645_an I0_cm234_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1645_MN13 (XI0_I1645_con I0_cm233_1 XI0_I1645_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1645_MN17 (I0_ha284_1 XI0_I1645_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1645_MN3 (VSS I0_cm234_0 XI0_I1645_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1647_MN5 (I0_ha286_0 I0_cm235_1 XI0_I1647_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1647_MN7 (XI0_I1647_xn2 XI0_I1647_xan I0_ha286_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1647_MN8 (VSS XI0_I1647_xbn XI0_I1647_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1647_MN6 (XI0_I1647_xn1 I0_cm236_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1647_MN1 (VSS I0_cm235_1 XI0_I1647_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1647_MN14 (XI0_I1647_an I0_cm236_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1647_MN13 (XI0_I1647_con I0_cm235_1 XI0_I1647_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1647_MN17 (I0_ha286_1 XI0_I1647_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1647_MN3 (VSS I0_cm236_0 XI0_I1647_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1649_MN5 (I0_ha288_0 I0_fa237_1 XI0_I1649_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1649_MN7 (XI0_I1649_xn2 XI0_I1649_xan I0_ha288_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1649_MN8 (VSS XI0_I1649_xbn XI0_I1649_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1649_MN6 (XI0_I1649_xn1 I0_cm238_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1649_MN1 (VSS I0_fa237_1 XI0_I1649_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1649_MN14 (XI0_I1649_an I0_cm238_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1649_MN13 (XI0_I1649_con I0_fa237_1 XI0_I1649_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1649_MN17 (I0_ha288_1 XI0_I1649_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1649_MN3 (VSS I0_cm238_0 XI0_I1649_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1651_MN5 (I0_ha290_0 I0_fa239_1 XI0_I1651_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1651_MN7 (XI0_I1651_xn2 XI0_I1651_xan I0_ha290_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1651_MN8 (VSS XI0_I1651_xbn XI0_I1651_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1651_MN6 (XI0_I1651_xn1 I0_cm240_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1651_MN1 (VSS I0_fa239_1 XI0_I1651_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1651_MN14 (XI0_I1651_an I0_cm240_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1651_MN13 (XI0_I1651_con I0_fa239_1 XI0_I1651_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1651_MN17 (I0_ha290_1 XI0_I1651_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1651_MN3 (VSS I0_cm240_0 XI0_I1651_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1653_MN5 (I0_ha292_0 I0_fa241_1 XI0_I1653_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1653_MN7 (XI0_I1653_xn2 XI0_I1653_xan I0_ha292_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1653_MN8 (VSS XI0_I1653_xbn XI0_I1653_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1653_MN6 (XI0_I1653_xn1 I0_fa242_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1653_MN1 (VSS I0_fa241_1 XI0_I1653_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1653_MN14 (XI0_I1653_an I0_fa242_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1653_MN13 (XI0_I1653_con I0_fa241_1 XI0_I1653_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1653_MN17 (I0_ha292_1 XI0_I1653_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1653_MN3 (VSS I0_fa242_0 XI0_I1653_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1655_MN5 (I0_ha294_0 I0_cm199_1 XI0_I1655_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1655_MN7 (XI0_I1655_xn2 XI0_I1655_xan I0_ha294_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1655_MN8 (VSS XI0_I1655_xbn XI0_I1655_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1655_MN6 (XI0_I1655_xn1 I0_cm200_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1655_MN1 (VSS I0_cm199_1 XI0_I1655_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI0_I1655_MN14 (XI0_I1655_an I0_cm200_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI0_I1655_MN13 (XI0_I1655_con I0_cm199_1 XI0_I1655_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1655_MN17 (I0_ha294_1 XI0_I1655_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1655_MN3 (VSS I0_cm200_0 XI0_I1655_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1344_I127_XG_MN2 (I1_I1344_G31_28n I1_I1344_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I127_XG_MN0 (XI1_I1344_I127_XG_n1 I1_I1344_P31_30 I1_I1344_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I127_XG_MN1 (VSS I1_I1344_G29_28 XI1_I1344_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I182_XG_MN2 (I1_I1344_G31_16n I1_I1344_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I182_XG_MN0 (XI1_I1344_I182_XG_n1 I1_I1344_P31_24 I1_I1344_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I182_XG_MN1 (VSS I1_I1344_G23_16 XI1_I1344_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I182_XG_MN2 (I1_I1298_G31_16n I1_I1298_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I182_XG_MN0 (XI1_I1298_I182_XG_n1 I1_I1298_P31_24 I1_I1298_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I182_XG_MN1 (VSS I1_I1298_G23_16 XI1_I1298_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I125_XG_MN2 (I1_I1298_G29_26n I1_I1298_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I125_XG_MN0 (XI1_I1298_I125_XG_n1 I1_I1298_P29_28 I1_I1298_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I125_XG_MN1 (VSS I1_I1298_G27_26 XI1_I1298_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I127_XG_MN2 (I1_I1298_G31_28n I1_I1298_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I127_XG_MN0 (XI1_I1298_I127_XG_n1 I1_I1298_P31_30 I1_I1298_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I127_XG_MN1 (VSS I1_I1298_G29_28 XI1_I1298_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I126_XG_MN2 (I1_I1298_G30_27n I1_I1298_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I126_XG_MN0 (XI1_I1298_I126_XG_n1 I1_I1298_P30_29 I1_I1298_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I126_XG_MN1 (VSS I1_I1298_G28_27 XI1_I1298_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I126_XG_MN2 (I1_I1252_G30_27n I1_I1252_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I126_XG_MN0 (XI1_I1252_I126_XG_n1 I1_I1252_P30_29 I1_I1252_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I126_XG_MN1 (VSS I1_I1252_G28_27 XI1_I1252_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I125_XG_MN2 (I1_I1252_G29_26n I1_I1252_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I125_XG_MN0 (XI1_I1252_I125_XG_n1 I1_I1252_P29_28 I1_I1252_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I125_XG_MN1 (VSS I1_I1252_G27_26 XI1_I1252_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I127_XG_MN2 (I1_I1252_G31_28n I1_I1252_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I127_XG_MN0 (XI1_I1252_I127_XG_n1 I1_I1252_P31_30 I1_I1252_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I127_XG_MN1 (VSS I1_I1252_G29_28 XI1_I1252_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I125_XG_MN2 (I1_I838_G29_26n I1_I838_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I125_XG_MN0 (XI1_I838_I125_XG_n1 I1_I838_P29_28 I1_I838_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I125_XG_MN1 (VSS I1_I838_G27_26 XI1_I838_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I127_XG_MN2 (I1_I838_G31_28n I1_I838_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I127_XG_MN0 (XI1_I838_I127_XG_n1 I1_I838_P31_30 I1_I838_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I127_XG_MN1 (VSS I1_I838_G29_28 XI1_I838_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I123_XG_MN2 (I1_I838_G27_24n I1_I838_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I123_XG_MN0 (XI1_I838_I123_XG_n1 I1_I838_P27_26 I1_I838_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I123_XG_MN1 (VSS I1_I838_G25_24 XI1_I838_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I180_XG_MN2 (I1_I838_G29_14n I1_I838_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I180_XG_MN0 (XI1_I838_I180_XG_n1 I1_I838_P29_22 I1_I838_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I180_XG_MN1 (VSS I1_I838_G21_14 XI1_I838_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I178_XG_MN2 (I1_I838_G27_12n I1_I838_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I178_XG_MN0 (XI1_I838_I178_XG_n1 I1_I838_P27_20 I1_I838_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I178_XG_MN1 (VSS I1_I838_G19_12 XI1_I838_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I182_XG_MN2 (I1_I838_G31_16n I1_I838_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I182_XG_MN0 (XI1_I838_I182_XG_n1 I1_I838_P31_24 I1_I838_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I182_XG_MN1 (VSS I1_I838_G23_16 XI1_I838_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I174_XG_MN2 (I1_I838_G23_8n I1_I838_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I174_XG_MN0 (XI1_I838_I174_XG_n1 I1_I838_P23_16 I1_I838_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I174_XG_MN1 (VSS I1_I838_G15_8 XI1_I838_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I166_XG_MN2 (I1_I838_G15_0n I1_I838_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I166_XG_MN0 (XI1_I838_I166_XG_n1 I1_I838_P15_8 I1_I838_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I166_XG_MN1 (VSS I1_I838_G7_0 XI1_I838_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I170_XG_MN2 (I1_I838_G19_4n I1_I838_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I170_XG_MN0 (XI1_I838_I170_XG_n1 I1_I838_P19_12 I1_I838_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I170_XG_MN1 (VSS I1_I838_G11_4 XI1_I838_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I162_XG_MN2 (I1_I838_G11_0n I1_I838_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I162_XG_MN0 (XI1_I838_I162_XG_n1 I1_I838_P11_4 I1_I838_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I162_XG_MN1 (VSS I1_I838_G3_0np XI1_I838_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I180_XG_MN2 (I1_I792_G29_14n I1_I792_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I180_XG_MN0 (XI1_I792_I180_XG_n1 I1_I792_P29_22 I1_I792_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I180_XG_MN1 (VSS I1_I792_G21_14 XI1_I792_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I178_XG_MN2 (I1_I792_G27_12n I1_I792_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I178_XG_MN0 (XI1_I792_I178_XG_n1 I1_I792_P27_20 I1_I792_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I178_XG_MN1 (VSS I1_I792_G19_12 XI1_I792_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I182_XG_MN2 (I1_I792_G31_16n I1_I792_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I182_XG_MN0 (XI1_I792_I182_XG_n1 I1_I792_P31_24 I1_I792_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I182_XG_MN1 (VSS I1_I792_G23_16 XI1_I792_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I123_XG_MN2 (I1_I792_G27_24n I1_I792_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I123_XG_MN0 (XI1_I792_I123_XG_n1 I1_I792_P27_26 I1_I792_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I123_XG_MN1 (VSS I1_I792_G25_24 XI1_I792_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I125_XG_MN2 (I1_I792_G29_26n I1_I792_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I125_XG_MN0 (XI1_I792_I125_XG_n1 I1_I792_P29_28 I1_I792_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I125_XG_MN1 (VSS I1_I792_G27_26 XI1_I792_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I127_XG_MN2 (I1_I792_G31_28n I1_I792_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I127_XG_MN0 (XI1_I792_I127_XG_n1 I1_I792_P31_30 I1_I792_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I127_XG_MN1 (VSS I1_I792_G29_28 XI1_I792_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I181_XG_MN2 (I1_I792_G30_15n I1_I792_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I181_XG_MN0 (XI1_I792_I181_XG_n1 I1_I792_P30_23 I1_I792_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I181_XG_MN1 (VSS I1_I792_G22_15 XI1_I792_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I124_XG_MN2 (I1_I792_G28_25n I1_I792_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I124_XG_MN0 (XI1_I792_I124_XG_n1 I1_I792_P28_27 I1_I792_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I124_XG_MN1 (VSS I1_I792_G26_25 XI1_I792_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I126_XG_MN2 (I1_I792_G30_27n I1_I792_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I126_XG_MN0 (XI1_I792_I126_XG_n1 I1_I792_P30_29 I1_I792_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I126_XG_MN1 (VSS I1_I792_G28_27 XI1_I792_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I125_XG_MN2 (I1_I1344_G29_26n I1_I1344_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I125_XG_MN0 (XI1_I1344_I125_XG_n1 I1_I1344_P29_28 I1_I1344_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I125_XG_MN1 (VSS I1_I1344_G27_26 XI1_I1344_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I178_XG_MN2 (I1_I1344_G27_12n I1_I1344_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I178_XG_MN0 (XI1_I1344_I178_XG_n1 I1_I1344_P27_20 I1_I1344_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I178_XG_MN1 (VSS I1_I1344_G19_12 XI1_I1344_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I174_XG_MN2 (I1_I1344_G23_8n I1_I1344_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I174_XG_MN0 (XI1_I1344_I174_XG_n1 I1_I1344_P23_16 I1_I1344_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I174_XG_MN1 (VSS I1_I1344_G15_8 XI1_I1344_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I178_XG_MN2 (I1_I1298_G27_12n I1_I1298_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I178_XG_MN0 (XI1_I1298_I178_XG_n1 I1_I1298_P27_20 I1_I1298_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I178_XG_MN1 (VSS I1_I1298_G19_12 XI1_I1298_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I123_XG_MN2 (I1_I1298_G27_24n I1_I1298_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I123_XG_MN0 (XI1_I1298_I123_XG_n1 I1_I1298_P27_26 I1_I1298_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I123_XG_MN1 (VSS I1_I1298_G25_24 XI1_I1298_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I124_XG_MN2 (I1_I1298_G28_25n I1_I1298_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I124_XG_MN0 (XI1_I1298_I124_XG_n1 I1_I1298_P28_27 I1_I1298_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I124_XG_MN1 (VSS I1_I1298_G26_25 XI1_I1298_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I181_XG_MN2 (I1_I1252_G30_15n I1_I1252_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I181_XG_MN0 (XI1_I1252_I181_XG_n1 I1_I1252_P30_23 I1_I1252_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I181_XG_MN1 (VSS I1_I1252_G22_15 XI1_I1252_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I124_XG_MN2 (I1_I1252_G28_25n I1_I1252_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I124_XG_MN0 (XI1_I1252_I124_XG_n1 I1_I1252_P28_27 I1_I1252_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I124_XG_MN1 (VSS I1_I1252_G26_25 XI1_I1252_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I182_XG_MN2 (I1_I1252_G31_16n I1_I1252_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I182_XG_MN0 (XI1_I1252_I182_XG_n1 I1_I1252_P31_24 I1_I1252_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I182_XG_MN1 (VSS I1_I1252_G23_16 XI1_I1252_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I123_XG_MN2 (I1_I1252_G27_24n I1_I1252_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I123_XG_MN0 (XI1_I1252_I123_XG_n1 I1_I1252_P27_26 I1_I1252_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I123_XG_MN1 (VSS I1_I1252_G25_24 XI1_I1252_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I127_XG_MN2 (I1_I1206_G31_28n I1_I1206_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I127_XG_MN0 (XI1_I1206_I127_XG_n1 I1_I1206_P31_30 I1_I1206_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I127_XG_MN1 (VSS I1_I1206_G29_28 XI1_I1206_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I125_XG_MN2 (I1_I1206_G29_26n I1_I1206_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I125_XG_MN0 (XI1_I1206_I125_XG_n1 I1_I1206_P29_28 I1_I1206_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I125_XG_MN1 (VSS I1_I1206_G27_26 XI1_I1206_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I126_XG_MN2 (I1_I1206_G30_27n I1_I1206_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I126_XG_MN0 (XI1_I1206_I126_XG_n1 I1_I1206_P30_29 I1_I1206_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I126_XG_MN1 (VSS I1_I1206_G28_27 XI1_I1206_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I124_XG_MN2 (I1_I1206_G28_25n I1_I1206_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I124_XG_MN0 (XI1_I1206_I124_XG_n1 I1_I1206_P28_27 I1_I1206_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I124_XG_MN1 (VSS I1_I1206_G26_25 XI1_I1206_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I121_XG_MN2 (I1_I838_G25_22n I1_I838_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I121_XG_MN0 (XI1_I838_I121_XG_n1 I1_I838_P25_24 I1_I838_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I121_XG_MN1 (VSS I1_I838_G23_22 XI1_I838_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I119_XG_MN2 (I1_I838_G23_20n I1_I838_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I119_XG_MN0 (XI1_I838_I119_XG_n1 I1_I838_P23_22 I1_I838_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I119_XG_MN1 (VSS I1_I838_G21_20 XI1_I838_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I113_XG_MN2 (I1_I838_G17_14n I1_I838_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I113_XG_MN0 (XI1_I838_I113_XG_n1 I1_I838_P17_16 I1_I838_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I113_XG_MN1 (VSS I1_I838_G15_14 XI1_I838_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I111_XG_MN2 (I1_I838_G15_12n I1_I838_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I111_XG_MN0 (XI1_I838_I111_XG_n1 I1_I838_P15_14 I1_I838_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I111_XG_MN1 (VSS I1_I838_G13_12 XI1_I838_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I176_XG_MN2 (I1_I838_G25_10n I1_I838_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I176_XG_MN0 (XI1_I838_I176_XG_n1 I1_I838_P25_18 I1_I838_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I176_XG_MN1 (VSS I1_I838_G17_10 XI1_I838_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I172_XG_MN2 (I1_I838_G21_6n I1_I838_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I172_XG_MN0 (XI1_I838_I172_XG_n1 I1_I838_P21_14 I1_I838_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I172_XG_MN1 (VSS I1_I838_G13_6 XI1_I838_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I164_XG_MN2 (I1_I838_G13_0n I1_I838_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I164_XG_MN0 (XI1_I838_I164_XG_n1 I1_I838_P13_6 I1_I838_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I164_XG_MN1 (VSS I1_I838_G5_0 XI1_I838_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I168_XG_MN2 (I1_I838_G17_2n I1_I838_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I168_XG_MN0 (XI1_I838_I168_XG_n1 I1_I838_P17_10 I1_I838_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I168_XG_MN1 (VSS I1_I838_G9_2 XI1_I838_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I176_XG_MN2 (I1_I792_G25_10n I1_I792_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I176_XG_MN0 (XI1_I792_I176_XG_n1 I1_I792_P25_18 I1_I792_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I176_XG_MN1 (VSS I1_I792_G17_10 XI1_I792_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I174_XG_MN2 (I1_I792_G23_8n I1_I792_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I174_XG_MN0 (XI1_I792_I174_XG_n1 I1_I792_P23_16 I1_I792_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I174_XG_MN1 (VSS I1_I792_G15_8 XI1_I792_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I119_XG_MN2 (I1_I792_G23_20n I1_I792_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I119_XG_MN0 (XI1_I792_I119_XG_n1 I1_I792_P23_22 I1_I792_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I119_XG_MN1 (VSS I1_I792_G21_20 XI1_I792_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I121_XG_MN2 (I1_I792_G25_22n I1_I792_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I121_XG_MN0 (XI1_I792_I121_XG_n1 I1_I792_P25_24 I1_I792_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I121_XG_MN1 (VSS I1_I792_G23_22 XI1_I792_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I173_XG_MN2 (I1_I792_G22_7n I1_I792_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I173_XG_MN0 (XI1_I792_I173_XG_n1 I1_I792_P22_15 I1_I792_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I173_XG_MN1 (VSS I1_I792_G14_7 XI1_I792_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I179_XG_MN2 (I1_I792_G28_13n I1_I792_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I179_XG_MN0 (XI1_I792_I179_XG_n1 I1_I792_P28_21 I1_I792_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I179_XG_MN1 (VSS I1_I792_G20_13 XI1_I792_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I122_XG_MN2 (I1_I792_G26_23n I1_I792_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I122_XG_MN0 (XI1_I792_I122_XG_n1 I1_I792_P26_25 I1_I792_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I122_XG_MN1 (VSS I1_I792_G24_23 XI1_I792_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I126_XG_MN2 (I1_I1344_G30_27n I1_I1344_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I126_XG_MN0 (XI1_I1344_I126_XG_n1 I1_I1344_P30_29 I1_I1344_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I126_XG_MN1 (VSS I1_I1344_G28_27 XI1_I1344_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I123_XG_MN2 (I1_I1344_G27_24n I1_I1344_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I123_XG_MN0 (XI1_I1344_I123_XG_n1 I1_I1344_P27_26 I1_I1344_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I123_XG_MN1 (VSS I1_I1344_G25_24 XI1_I1344_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I121_XG_MN2 (I1_I1344_G25_22n I1_I1344_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I121_XG_MN0 (XI1_I1344_I121_XG_n1 I1_I1344_P25_24 I1_I1344_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I121_XG_MN1 (VSS I1_I1344_G23_22 XI1_I1344_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I180_XG_MN2 (I1_I1344_G29_14n I1_I1344_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I180_XG_MN0 (XI1_I1344_I180_XG_n1 I1_I1344_P29_22 I1_I1344_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I180_XG_MN1 (VSS I1_I1344_G21_14 XI1_I1344_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I166_XG_MN2 (I1_I1344_G15_0n I1_I1344_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I166_XG_MN0 (XI1_I1344_I166_XG_n1 I1_I1344_P15_8 I1_I1344_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I166_XG_MN1 (VSS I1_I1344_G7_0 XI1_I1344_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I170_XG_MN2 (I1_I1344_G19_4n I1_I1344_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I170_XG_MN0 (XI1_I1344_I170_XG_n1 I1_I1344_P19_12 I1_I1344_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I170_XG_MN1 (VSS I1_I1344_G11_4 XI1_I1344_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I162_XG_MN2 (I1_I1344_G11_0n I1_I1344_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I162_XG_MN0 (XI1_I1344_I162_XG_n1 I1_I1344_P11_4 I1_I1344_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I162_XG_MN1 (VSS I1_I1344_G3_0np XI1_I1344_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I174_XG_MN2 (I1_I1298_G23_8n I1_I1298_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I174_XG_MN0 (XI1_I1298_I174_XG_n1 I1_I1298_P23_16 I1_I1298_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I174_XG_MN1 (VSS I1_I1298_G15_8 XI1_I1298_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I180_XG_MN2 (I1_I1298_G29_14n I1_I1298_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I180_XG_MN0 (XI1_I1298_I180_XG_n1 I1_I1298_P29_22 I1_I1298_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I180_XG_MN1 (VSS I1_I1298_G21_14 XI1_I1298_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I121_XG_MN2 (I1_I1298_G25_22n I1_I1298_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I121_XG_MN0 (XI1_I1298_I121_XG_n1 I1_I1298_P25_24 I1_I1298_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I121_XG_MN1 (VSS I1_I1298_G23_22 XI1_I1298_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I181_XG_MN2 (I1_I1298_G30_15n I1_I1298_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I181_XG_MN0 (XI1_I1298_I181_XG_n1 I1_I1298_P30_23 I1_I1298_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I181_XG_MN1 (VSS I1_I1298_G22_15 XI1_I1298_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I122_XG_MN2 (I1_I1298_G26_23n I1_I1298_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I122_XG_MN0 (XI1_I1298_I122_XG_n1 I1_I1298_P26_25 I1_I1298_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I122_XG_MN1 (VSS I1_I1298_G24_23 XI1_I1298_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I179_XG_MN2 (I1_I1252_G28_13n I1_I1252_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I179_XG_MN0 (XI1_I1252_I179_XG_n1 I1_I1252_P28_21 I1_I1252_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I179_XG_MN1 (VSS I1_I1252_G20_13 XI1_I1252_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I122_XG_MN2 (I1_I1252_G26_23n I1_I1252_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I122_XG_MN0 (XI1_I1252_I122_XG_n1 I1_I1252_P26_25 I1_I1252_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I122_XG_MN1 (VSS I1_I1252_G24_23 XI1_I1252_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I120_XG_MN2 (I1_I1252_G24_21n I1_I1252_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I120_XG_MN0 (XI1_I1252_I120_XG_n1 I1_I1252_P24_23 I1_I1252_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I120_XG_MN1 (VSS I1_I1252_G22_21 XI1_I1252_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I180_XG_MN2 (I1_I1252_G29_14n I1_I1252_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I180_XG_MN0 (XI1_I1252_I180_XG_n1 I1_I1252_P29_22 I1_I1252_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I180_XG_MN1 (VSS I1_I1252_G21_14 XI1_I1252_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I121_XG_MN2 (I1_I1252_G25_22n I1_I1252_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I121_XG_MN0 (XI1_I1252_I121_XG_n1 I1_I1252_P25_24 I1_I1252_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I121_XG_MN1 (VSS I1_I1252_G23_22 XI1_I1252_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I123_XG_MN2 (I1_I1206_G27_24n I1_I1206_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I123_XG_MN0 (XI1_I1206_I123_XG_n1 I1_I1206_P27_26 I1_I1206_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I123_XG_MN1 (VSS I1_I1206_G25_24 XI1_I1206_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I122_XG_MN2 (I1_I1206_G26_23n I1_I1206_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I122_XG_MN0 (XI1_I1206_I122_XG_n1 I1_I1206_P26_25 I1_I1206_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I122_XG_MN1 (VSS I1_I1206_G24_23 XI1_I1206_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I109_XG_MN2 (I1_I838_G13_10n I1_I838_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I109_XG_MN0 (XI1_I838_I109_XG_n1 I1_I838_P13_12 I1_I838_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I109_XG_MN1 (VSS I1_I838_G11_10 XI1_I838_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I158_XG_MN2 (I1_I838_G9_0n I1_I838_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I158_XG_MN0 (XI1_I838_I158_XG_n1 I1_I838_P9_2 I1_I838_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I158_XG_MN1 (VSS I1_I838_G1_0 XI1_I838_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I172_XG_MN2 (I1_I792_G21_6n I1_I792_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I172_XG_MN0 (XI1_I792_I172_XG_n1 I1_I792_P21_14 I1_I792_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I172_XG_MN1 (VSS I1_I792_G13_6 XI1_I792_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I170_XG_MN2 (I1_I792_G19_4n I1_I792_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I170_XG_MN0 (XI1_I792_I170_XG_n1 I1_I792_P19_12 I1_I792_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I170_XG_MN1 (VSS I1_I792_G11_4 XI1_I792_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I166_XG_MN2 (I1_I792_G15_0n I1_I792_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I166_XG_MN0 (XI1_I792_I166_XG_n1 I1_I792_P15_8 I1_I792_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I166_XG_MN1 (VSS I1_I792_G7_0 XI1_I792_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I115_XG_MN2 (I1_I792_G19_16n I1_I792_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I115_XG_MN0 (XI1_I792_I115_XG_n1 I1_I792_P19_18 I1_I792_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I115_XG_MN1 (VSS I1_I792_G17_16 XI1_I792_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I117_XG_MN2 (I1_I792_G21_18n I1_I792_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I117_XG_MN0 (XI1_I792_I117_XG_n1 I1_I792_P21_20 I1_I792_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I117_XG_MN1 (VSS I1_I792_G19_18 XI1_I792_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I177_XG_MN2 (I1_I792_G26_11n I1_I792_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I177_XG_MN0 (XI1_I792_I177_XG_n1 I1_I792_P26_19 I1_I792_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I177_XG_MN1 (VSS I1_I792_G18_11 XI1_I792_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I118_XG_MN2 (I1_I792_G22_19n I1_I792_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I118_XG_MN0 (XI1_I792_I118_XG_n1 I1_I792_P22_21 I1_I792_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I118_XG_MN1 (VSS I1_I792_G20_19 XI1_I792_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I120_XG_MN2 (I1_I792_G24_21n I1_I792_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I120_XG_MN0 (XI1_I792_I120_XG_n1 I1_I792_P24_23 I1_I792_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I120_XG_MN1 (VSS I1_I792_G22_21 XI1_I792_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I119_XG_MN2 (I1_I1344_G23_20n I1_I1344_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I119_XG_MN0 (XI1_I1344_I119_XG_n1 I1_I1344_P23_22 I1_I1344_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I119_XG_MN1 (VSS I1_I1344_G21_20 XI1_I1344_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I117_XG_MN2 (I1_I1344_G21_18n I1_I1344_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I117_XG_MN0 (XI1_I1344_I117_XG_n1 I1_I1344_P21_20 I1_I1344_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I117_XG_MN1 (VSS I1_I1344_G19_18 XI1_I1344_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I176_XG_MN2 (I1_I1344_G25_10n I1_I1344_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I176_XG_MN0 (XI1_I1344_I176_XG_n1 I1_I1344_P25_18 I1_I1344_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I176_XG_MN1 (VSS I1_I1344_G17_10 XI1_I1344_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I115_XG_MN2 (I1_I1344_G19_16n I1_I1344_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I115_XG_MN0 (XI1_I1344_I115_XG_n1 I1_I1344_P19_18 I1_I1344_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I115_XG_MN1 (VSS I1_I1344_G17_16 XI1_I1344_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I113_XG_MN2 (I1_I1344_G17_14n I1_I1344_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I113_XG_MN0 (XI1_I1344_I113_XG_n1 I1_I1344_P17_16 I1_I1344_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I113_XG_MN1 (VSS I1_I1344_G15_14 XI1_I1344_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I111_XG_MN2 (I1_I1344_G15_12n I1_I1344_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I111_XG_MN0 (XI1_I1344_I111_XG_n1 I1_I1344_P15_14 I1_I1344_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I111_XG_MN1 (VSS I1_I1344_G13_12 XI1_I1344_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I176_XG_MN2 (I1_I1298_G25_10n I1_I1298_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I176_XG_MN0 (XI1_I1298_I176_XG_n1 I1_I1298_P25_18 I1_I1298_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I176_XG_MN1 (VSS I1_I1298_G17_10 XI1_I1298_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I119_XG_MN2 (I1_I1298_G23_20n I1_I1298_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I119_XG_MN0 (XI1_I1298_I119_XG_n1 I1_I1298_P23_22 I1_I1298_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I119_XG_MN1 (VSS I1_I1298_G21_20 XI1_I1298_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I179_XG_MN2 (I1_I1298_G28_13n I1_I1298_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I179_XG_MN0 (XI1_I1298_I179_XG_n1 I1_I1298_P28_21 I1_I1298_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I179_XG_MN1 (VSS I1_I1298_G20_13 XI1_I1298_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I120_XG_MN2 (I1_I1298_G24_21n I1_I1298_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I120_XG_MN0 (XI1_I1298_I120_XG_n1 I1_I1298_P24_23 I1_I1298_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I120_XG_MN1 (VSS I1_I1298_G22_21 XI1_I1298_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I177_XG_MN2 (I1_I1252_G26_11n I1_I1252_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I177_XG_MN0 (XI1_I1252_I177_XG_n1 I1_I1252_P26_19 I1_I1252_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I177_XG_MN1 (VSS I1_I1252_G18_11 XI1_I1252_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I174_XG_MN2 (I1_I1252_G23_8n I1_I1252_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I174_XG_MN0 (XI1_I1252_I174_XG_n1 I1_I1252_P23_16 I1_I1252_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I174_XG_MN1 (VSS I1_I1252_G15_8 XI1_I1252_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I119_XG_MN2 (I1_I1252_G23_20n I1_I1252_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I119_XG_MN0 (XI1_I1252_I119_XG_n1 I1_I1252_P23_22 I1_I1252_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I119_XG_MN1 (VSS I1_I1252_G21_20 XI1_I1252_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I119_XG_MN2 (I1_I1206_G23_20n I1_I1206_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I119_XG_MN0 (XI1_I1206_I119_XG_n1 I1_I1206_P23_22 I1_I1206_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I119_XG_MN1 (VSS I1_I1206_G21_20 XI1_I1206_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I121_XG_MN2 (I1_I1206_G25_22n I1_I1206_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I121_XG_MN0 (XI1_I1206_I121_XG_n1 I1_I1206_P25_24 I1_I1206_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I121_XG_MN1 (VSS I1_I1206_G23_22 XI1_I1206_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I120_XG_MN2 (I1_I1206_G24_21n I1_I1206_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I120_XG_MN0 (XI1_I1206_I120_XG_n1 I1_I1206_P24_23 I1_I1206_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I120_XG_MN1 (VSS I1_I1206_G22_21 XI1_I1206_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I181_XG_MN2 (I1_I1206_G30_15n I1_I1206_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I181_XG_MN0 (XI1_I1206_I181_XG_n1 I1_I1206_P30_23 I1_I1206_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I181_XG_MN1 (VSS I1_I1206_G22_15 XI1_I1206_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I126_XG_MN2 (I1_I838_G30_27n I1_I838_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I126_XG_MN0 (XI1_I838_I126_XG_n1 I1_I838_P30_29 I1_I838_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I126_XG_MN1 (VSS I1_I838_G28_27 XI1_I838_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I124_XG_MN2 (I1_I838_G28_25n I1_I838_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I124_XG_MN0 (XI1_I838_I124_XG_n1 I1_I838_P28_27 I1_I838_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I124_XG_MN1 (VSS I1_I838_G26_25 XI1_I838_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I122_XG_MN2 (I1_I838_G26_23n I1_I838_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I122_XG_MN0 (XI1_I838_I122_XG_n1 I1_I838_P26_25 I1_I838_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I122_XG_MN1 (VSS I1_I838_G24_23 XI1_I838_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I120_XG_MN2 (I1_I838_G24_21n I1_I838_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I120_XG_MN0 (XI1_I838_I120_XG_n1 I1_I838_P24_23 I1_I838_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I120_XG_MN1 (VSS I1_I838_G22_21 XI1_I838_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I118_XG_MN2 (I1_I838_G22_19n I1_I838_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I118_XG_MN0 (XI1_I838_I118_XG_n1 I1_I838_P22_21 I1_I838_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I118_XG_MN1 (VSS I1_I838_G20_19 XI1_I838_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I116_XG_MN2 (I1_I838_G20_17n I1_I838_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I116_XG_MN0 (XI1_I838_I116_XG_n1 I1_I838_P20_19 I1_I838_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I116_XG_MN1 (VSS I1_I838_G18_17 XI1_I838_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I107_XG_MN2 (I1_I838_G11_8n I1_I838_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I107_XG_MN0 (XI1_I838_I107_XG_n1 I1_I838_P11_10 I1_I838_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I107_XG_MN1 (VSS I1_I838_G9_8 XI1_I838_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I105_XG_MN2 (I1_I838_G9_6n I1_I838_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I105_XG_MN0 (XI1_I838_I105_XG_n1 I1_I838_P9_8 I1_I838_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I105_XG_MN1 (VSS I1_I838_G7_6 XI1_I838_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I103_XG_MN2 (I1_I838_G7_4n I1_I838_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I103_XG_MN0 (XI1_I838_I103_XG_n1 I1_I838_P7_6 I1_I838_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I103_XG_MN1 (VSS I1_I838_G5_4 XI1_I838_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I101_XG_MN2 (I1_I838_G5_2n I1_I838_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I101_XG_MN0 (XI1_I838_I101_XG_n1 I1_I838_P5_4 I1_I838_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I101_XG_MN1 (VSS I1_I838_G3_2 XI1_I838_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I164_XG_MN2 (I1_I792_G13_0n I1_I792_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I164_XG_MN0 (XI1_I792_I164_XG_n1 I1_I792_P13_6 I1_I792_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I164_XG_MN1 (VSS I1_I792_G5_0 XI1_I792_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I162_XG_MN2 (I1_I792_G11_0n I1_I792_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I162_XG_MN0 (XI1_I792_I162_XG_n1 I1_I792_P11_4 I1_I792_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I162_XG_MN1 (VSS I1_I792_G3_0np XI1_I792_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I113_XG_MN2 (I1_I792_G17_14n I1_I792_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I113_XG_MN0 (XI1_I792_I113_XG_n1 I1_I792_P17_16 I1_I792_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I113_XG_MN1 (VSS I1_I792_G15_14 XI1_I792_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I171_XG_MN2 (I1_I792_G20_5n I1_I792_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I171_XG_MN0 (XI1_I792_I171_XG_n1 I1_I792_P20_13 I1_I792_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I171_XG_MN1 (VSS I1_I792_G12_5 XI1_I792_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I165_XG_MN2 (I1_I792_G14_0n I1_I792_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I165_XG_MN0 (XI1_I792_I165_XG_n1 I1_I792_P14_7 I1_I792_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I165_XG_MN1 (VSS I1_I792_G6_0 XI1_I792_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I114_XG_MN2 (I1_I792_G18_15n I1_I792_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I114_XG_MN0 (XI1_I792_I114_XG_n1 I1_I792_P18_17 I1_I792_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I114_XG_MN1 (VSS I1_I792_G16_15 XI1_I792_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I116_XG_MN2 (I1_I792_G20_17n I1_I792_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I116_XG_MN0 (XI1_I792_I116_XG_n1 I1_I792_P20_19 I1_I792_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I116_XG_MN1 (VSS I1_I792_G18_17 XI1_I792_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I173_XG_MN2 (I1_I746_G22_7n I1_I746_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I173_XG_MN0 (XI1_I746_I173_XG_n1 I1_I746_P22_15 I1_I746_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I173_XG_MN1 (VSS I1_I746_G14_7 XI1_I746_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I181_XG_MN2 (I1_I746_G30_15n I1_I746_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I181_XG_MN0 (XI1_I746_I181_XG_n1 I1_I746_P30_23 I1_I746_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I181_XG_MN1 (VSS I1_I746_G22_15 XI1_I746_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I126_XG_MN2 (I1_I746_G30_27n I1_I746_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I126_XG_MN0 (XI1_I746_I126_XG_n1 I1_I746_P30_29 I1_I746_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I126_XG_MN1 (VSS I1_I746_G28_27 XI1_I746_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I122_XG_MN2 (I1_I1344_G26_23n I1_I1344_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I122_XG_MN0 (XI1_I1344_I122_XG_n1 I1_I1344_P26_25 I1_I1344_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I122_XG_MN1 (VSS I1_I1344_G24_23 XI1_I1344_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I124_XG_MN2 (I1_I1344_G28_25n I1_I1344_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I124_XG_MN0 (XI1_I1344_I124_XG_n1 I1_I1344_P28_27 I1_I1344_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I124_XG_MN1 (VSS I1_I1344_G26_25 XI1_I1344_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I172_XG_MN2 (I1_I1344_G21_6n I1_I1344_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I172_XG_MN0 (XI1_I1344_I172_XG_n1 I1_I1344_P21_14 I1_I1344_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I172_XG_MN1 (VSS I1_I1344_G13_6 XI1_I1344_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I164_XG_MN2 (I1_I1344_G13_0n I1_I1344_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I164_XG_MN0 (XI1_I1344_I164_XG_n1 I1_I1344_P13_6 I1_I1344_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I164_XG_MN1 (VSS I1_I1344_G5_0 XI1_I1344_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I109_XG_MN2 (I1_I1344_G13_10n I1_I1344_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I109_XG_MN0 (XI1_I1344_I109_XG_n1 I1_I1344_P13_12 I1_I1344_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I109_XG_MN1 (VSS I1_I1344_G11_10 XI1_I1344_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I166_XG_MN2 (I1_I1298_G15_0n I1_I1298_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I166_XG_MN0 (XI1_I1298_I166_XG_n1 I1_I1298_P15_8 I1_I1298_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I166_XG_MN1 (VSS I1_I1298_G7_0 XI1_I1298_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I172_XG_MN2 (I1_I1298_G21_6n I1_I1298_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I172_XG_MN0 (XI1_I1298_I172_XG_n1 I1_I1298_P21_14 I1_I1298_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I172_XG_MN1 (VSS I1_I1298_G13_6 XI1_I1298_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I117_XG_MN2 (I1_I1298_G21_18n I1_I1298_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I117_XG_MN0 (XI1_I1298_I117_XG_n1 I1_I1298_P21_20 I1_I1298_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I117_XG_MN1 (VSS I1_I1298_G19_18 XI1_I1298_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I177_XG_MN2 (I1_I1298_G26_11n I1_I1298_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I177_XG_MN0 (XI1_I1298_I177_XG_n1 I1_I1298_P26_19 I1_I1298_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I177_XG_MN1 (VSS I1_I1298_G18_11 XI1_I1298_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I173_XG_MN2 (I1_I1298_G22_7n I1_I1298_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I173_XG_MN0 (XI1_I1298_I173_XG_n1 I1_I1298_P22_15 I1_I1298_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I173_XG_MN1 (VSS I1_I1298_G14_7 XI1_I1298_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I118_XG_MN2 (I1_I1298_G22_19n I1_I1298_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I118_XG_MN0 (XI1_I1298_I118_XG_n1 I1_I1298_P22_21 I1_I1298_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I118_XG_MN1 (VSS I1_I1298_G20_19 XI1_I1298_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I173_XG_MN2 (I1_I1252_G22_7n I1_I1252_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I173_XG_MN0 (XI1_I1252_I173_XG_n1 I1_I1252_P22_15 I1_I1252_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I173_XG_MN1 (VSS I1_I1252_G14_7 XI1_I1252_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I118_XG_MN2 (I1_I1252_G22_19n I1_I1252_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I118_XG_MN0 (XI1_I1252_I118_XG_n1 I1_I1252_P22_21 I1_I1252_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I118_XG_MN1 (VSS I1_I1252_G20_19 XI1_I1252_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I166_XG_MN2 (I1_I1252_G15_0n I1_I1252_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I166_XG_MN0 (XI1_I1252_I166_XG_n1 I1_I1252_P15_8 I1_I1252_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I166_XG_MN1 (VSS I1_I1252_G7_0 XI1_I1252_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I178_XG_MN2 (I1_I1252_G27_12n I1_I1252_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I178_XG_MN0 (XI1_I1252_I178_XG_n1 I1_I1252_P27_20 I1_I1252_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I178_XG_MN1 (VSS I1_I1252_G19_12 XI1_I1252_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I117_XG_MN2 (I1_I1252_G21_18n I1_I1252_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I117_XG_MN0 (XI1_I1252_I117_XG_n1 I1_I1252_P21_20 I1_I1252_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I117_XG_MN1 (VSS I1_I1252_G19_18 XI1_I1252_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I178_XG_MN2 (I1_I1206_G27_12n I1_I1206_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I178_XG_MN0 (XI1_I1206_I178_XG_n1 I1_I1206_P27_20 I1_I1206_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I178_XG_MN1 (VSS I1_I1206_G19_12 XI1_I1206_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I180_XG_MN2 (I1_I1206_G29_14n I1_I1206_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I180_XG_MN0 (XI1_I1206_I180_XG_n1 I1_I1206_P29_22 I1_I1206_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I180_XG_MN1 (VSS I1_I1206_G21_14 XI1_I1206_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I118_XG_MN2 (I1_I1206_G22_19n I1_I1206_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I118_XG_MN0 (XI1_I1206_I118_XG_n1 I1_I1206_P22_21 I1_I1206_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I118_XG_MN1 (VSS I1_I1206_G20_19 XI1_I1206_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I179_XG_MN2 (I1_I1206_G28_13n I1_I1206_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I179_XG_MN0 (XI1_I1206_I179_XG_n1 I1_I1206_P28_21 I1_I1206_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I179_XG_MN1 (VSS I1_I1206_G20_13 XI1_I1206_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I181_XG_MN2 (I1_I838_G30_15n I1_I838_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I181_XG_MN0 (XI1_I838_I181_XG_n1 I1_I838_P30_23 I1_I838_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I181_XG_MN1 (VSS I1_I838_G22_15 XI1_I838_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I179_XG_MN2 (I1_I838_G28_13n I1_I838_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I179_XG_MN0 (XI1_I838_I179_XG_n1 I1_I838_P28_21 I1_I838_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I179_XG_MN1 (VSS I1_I838_G20_13 XI1_I838_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I114_XG_MN2 (I1_I838_G18_15n I1_I838_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I114_XG_MN0 (XI1_I838_I114_XG_n1 I1_I838_P18_17 I1_I838_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I114_XG_MN1 (VSS I1_I838_G16_15 XI1_I838_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I112_XG_MN2 (I1_I838_G16_13n I1_I838_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I112_XG_MN0 (XI1_I838_I112_XG_n1 I1_I838_P16_15 I1_I838_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I112_XG_MN1 (VSS I1_I838_G14_13 XI1_I838_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I110_XG_MN2 (I1_I838_G14_11n I1_I838_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I110_XG_MN0 (XI1_I838_I110_XG_n1 I1_I838_P14_13 I1_I838_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I110_XG_MN1 (VSS I1_I838_G12_11 XI1_I838_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I108_XG_MN2 (I1_I838_G12_9n I1_I838_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I108_XG_MN0 (XI1_I838_I108_XG_n1 I1_I838_P12_11 I1_I838_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I108_XG_MN1 (VSS I1_I838_G10_9 XI1_I838_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I99_XG_MN2 (I1_I838_G3_0n I1_I838_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I99_XG_MN0 (XI1_I838_I99_XG_n1 I1_I838_P3_2 I1_I838_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I99_XG_MN1 (VSS I1_I838_G1_0 XI1_I838_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I168_XG_MN2 (I1_I792_G17_2n I1_I792_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I168_XG_MN0 (XI1_I792_I168_XG_n1 I1_I792_P17_10 I1_I792_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I168_XG_MN1 (VSS I1_I792_G9_2 XI1_I792_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I107_XG_MN2 (I1_I792_G11_8n I1_I792_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I107_XG_MN0 (XI1_I792_I107_XG_n1 I1_I792_P11_10 I1_I792_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I107_XG_MN1 (VSS I1_I792_G9_8 XI1_I792_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I109_XG_MN2 (I1_I792_G13_10n I1_I792_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I109_XG_MN0 (XI1_I792_I109_XG_n1 I1_I792_P13_12 I1_I792_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I109_XG_MN1 (VSS I1_I792_G11_10 XI1_I792_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I111_XG_MN2 (I1_I792_G15_12n I1_I792_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I111_XG_MN0 (XI1_I792_I111_XG_n1 I1_I792_P15_14 I1_I792_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I111_XG_MN1 (VSS I1_I792_G13_12 XI1_I792_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I169_XG_MN2 (I1_I792_G18_3n I1_I792_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I169_XG_MN0 (XI1_I792_I169_XG_n1 I1_I792_P18_11 I1_I792_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I169_XG_MN1 (VSS I1_I792_G10_3 XI1_I792_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I163_XG_MN2 (I1_I792_G12_0n I1_I792_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I163_XG_MN0 (XI1_I792_I163_XG_n1 I1_I792_P12_5 I1_I792_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I163_XG_MN1 (VSS I1_I792_G4_0 XI1_I792_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I175_XG_MN2 (I1_I792_G24_9n I1_I792_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I175_XG_MN0 (XI1_I792_I175_XG_n1 I1_I792_P24_17 I1_I792_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I175_XG_MN1 (VSS I1_I792_G16_9 XI1_I792_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I112_XG_MN2 (I1_I792_G16_13n I1_I792_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I112_XG_MN0 (XI1_I792_I112_XG_n1 I1_I792_P16_15 I1_I792_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I112_XG_MN1 (VSS I1_I792_G14_13 XI1_I792_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I165_XG_MN2 (I1_I746_G14_0n I1_I746_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I165_XG_MN0 (XI1_I746_I165_XG_n1 I1_I746_P14_7 I1_I746_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I165_XG_MN1 (VSS I1_I746_G6_0 XI1_I746_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I179_XG_MN2 (I1_I746_G28_13n I1_I746_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I179_XG_MN0 (XI1_I746_I179_XG_n1 I1_I746_P28_21 I1_I746_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I179_XG_MN1 (VSS I1_I746_G20_13 XI1_I746_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I177_XG_MN2 (I1_I746_G26_11n I1_I746_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I177_XG_MN0 (XI1_I746_I177_XG_n1 I1_I746_P26_19 I1_I746_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I177_XG_MN1 (VSS I1_I746_G18_11 XI1_I746_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I122_XG_MN2 (I1_I746_G26_23n I1_I746_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I122_XG_MN0 (XI1_I746_I122_XG_n1 I1_I746_P26_25 I1_I746_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I122_XG_MN1 (VSS I1_I746_G24_23 XI1_I746_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I124_XG_MN2 (I1_I746_G28_25n I1_I746_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I124_XG_MN0 (XI1_I746_I124_XG_n1 I1_I746_P28_27 I1_I746_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I124_XG_MN1 (VSS I1_I746_G26_25 XI1_I746_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I120_XG_MN2 (I1_I1344_G24_21n I1_I1344_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I120_XG_MN0 (XI1_I1344_I120_XG_n1 I1_I1344_P24_23 I1_I1344_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I120_XG_MN1 (VSS I1_I1344_G22_21 XI1_I1344_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I118_XG_MN2 (I1_I1344_G22_19n I1_I1344_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I118_XG_MN0 (XI1_I1344_I118_XG_n1 I1_I1344_P22_21 I1_I1344_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I118_XG_MN1 (VSS I1_I1344_G20_19 XI1_I1344_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I168_XG_MN2 (I1_I1344_G17_2n I1_I1344_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I168_XG_MN0 (XI1_I1344_I168_XG_n1 I1_I1344_P17_10 I1_I1344_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I168_XG_MN1 (VSS I1_I1344_G9_2 XI1_I1344_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I158_XG_MN2 (I1_I1344_G9_0n I1_I1344_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I158_XG_MN0 (XI1_I1344_I158_XG_n1 I1_I1344_P9_2 I1_I1344_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I158_XG_MN1 (VSS I1_I1344_G1_0 XI1_I1344_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I107_XG_MN2 (I1_I1344_G11_8n I1_I1344_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I107_XG_MN0 (XI1_I1344_I107_XG_n1 I1_I1344_P11_10 I1_I1344_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I107_XG_MN1 (VSS I1_I1344_G9_8 XI1_I1344_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I170_XG_MN2 (I1_I1298_G19_4n I1_I1298_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I170_XG_MN0 (XI1_I1298_I170_XG_n1 I1_I1298_P19_12 I1_I1298_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I170_XG_MN1 (VSS I1_I1298_G11_4 XI1_I1298_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I115_XG_MN2 (I1_I1298_G19_16n I1_I1298_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I115_XG_MN0 (XI1_I1298_I115_XG_n1 I1_I1298_P19_18 I1_I1298_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I115_XG_MN1 (VSS I1_I1298_G17_16 XI1_I1298_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I165_XG_MN2 (I1_I1298_G14_0n I1_I1298_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I165_XG_MN0 (XI1_I1298_I165_XG_n1 I1_I1298_P14_7 I1_I1298_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I165_XG_MN1 (VSS I1_I1298_G6_0 XI1_I1298_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I171_XG_MN2 (I1_I1298_G20_5n I1_I1298_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I171_XG_MN0 (XI1_I1298_I171_XG_n1 I1_I1298_P20_13 I1_I1298_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I171_XG_MN1 (VSS I1_I1298_G12_5 XI1_I1298_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I116_XG_MN2 (I1_I1298_G20_17n I1_I1298_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I116_XG_MN0 (XI1_I1298_I116_XG_n1 I1_I1298_P20_19 I1_I1298_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I116_XG_MN1 (VSS I1_I1298_G18_17 XI1_I1298_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I175_XG_MN2 (I1_I1252_G24_9n I1_I1252_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I175_XG_MN0 (XI1_I1252_I175_XG_n1 I1_I1252_P24_17 I1_I1252_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I175_XG_MN1 (VSS I1_I1252_G16_9 XI1_I1252_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I165_XG_MN2 (I1_I1252_G14_0n I1_I1252_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I165_XG_MN0 (XI1_I1252_I165_XG_n1 I1_I1252_P14_7 I1_I1252_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I165_XG_MN1 (VSS I1_I1252_G6_0 XI1_I1252_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I116_XG_MN2 (I1_I1252_G20_17n I1_I1252_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I116_XG_MN0 (XI1_I1252_I116_XG_n1 I1_I1252_P20_19 I1_I1252_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I116_XG_MN1 (VSS I1_I1252_G18_17 XI1_I1252_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I164_XG_MN2 (I1_I1252_G13_0n I1_I1252_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I164_XG_MN0 (XI1_I1252_I164_XG_n1 I1_I1252_P13_6 I1_I1252_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I164_XG_MN1 (VSS I1_I1252_G5_0 XI1_I1252_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I172_XG_MN2 (I1_I1252_G21_6n I1_I1252_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I172_XG_MN0 (XI1_I1252_I172_XG_n1 I1_I1252_P21_14 I1_I1252_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I172_XG_MN1 (VSS I1_I1252_G13_6 XI1_I1252_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I115_XG_MN2 (I1_I1252_G19_16n I1_I1252_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I115_XG_MN0 (XI1_I1252_I115_XG_n1 I1_I1252_P19_18 I1_I1252_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I115_XG_MN1 (VSS I1_I1252_G17_16 XI1_I1252_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I117_XG_MN2 (I1_I1206_G21_18n I1_I1206_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I117_XG_MN0 (XI1_I1206_I117_XG_n1 I1_I1206_P21_20 I1_I1206_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I117_XG_MN1 (VSS I1_I1206_G19_18 XI1_I1206_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I182_XG_MN2 (I1_I1206_G31_16n I1_I1206_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I182_XG_MN0 (XI1_I1206_I182_XG_n1 I1_I1206_P31_24 I1_I1206_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I182_XG_MN1 (VSS I1_I1206_G23_16 XI1_I1206_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I174_XG_MN2 (I1_I1206_G23_8n I1_I1206_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I174_XG_MN0 (XI1_I1206_I174_XG_n1 I1_I1206_P23_16 I1_I1206_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I174_XG_MN1 (VSS I1_I1206_G15_8 XI1_I1206_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I172_XG_MN2 (I1_I1206_G21_6n I1_I1206_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I172_XG_MN0 (XI1_I1206_I172_XG_n1 I1_I1206_P21_14 I1_I1206_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I172_XG_MN1 (VSS I1_I1206_G13_6 XI1_I1206_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I116_XG_MN2 (I1_I1206_G20_17n I1_I1206_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I116_XG_MN0 (XI1_I1206_I116_XG_n1 I1_I1206_P20_19 I1_I1206_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I116_XG_MN1 (VSS I1_I1206_G18_17 XI1_I1206_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I173_XG_MN2 (I1_I1206_G22_7n I1_I1206_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I173_XG_MN0 (XI1_I1206_I173_XG_n1 I1_I1206_P22_15 I1_I1206_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I173_XG_MN1 (VSS I1_I1206_G14_7 XI1_I1206_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I177_XG_MN2 (I1_I1206_G26_11n I1_I1206_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I177_XG_MN0 (XI1_I1206_I177_XG_n1 I1_I1206_P26_19 I1_I1206_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I177_XG_MN1 (VSS I1_I1206_G18_11 XI1_I1206_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I165_XG_MN2 (I1_I838_G14_0n I1_I838_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I165_XG_MN0 (XI1_I838_I165_XG_n1 I1_I838_P14_7 I1_I838_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I165_XG_MN1 (VSS I1_I838_G6_0 XI1_I838_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I175_XG_MN2 (I1_I838_G24_9n I1_I838_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I175_XG_MN0 (XI1_I838_I175_XG_n1 I1_I838_P24_17 I1_I838_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I175_XG_MN1 (VSS I1_I838_G16_9 XI1_I838_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I160_XG_MN2 (I1_I838_G10_0n I1_I838_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I160_XG_MN0 (XI1_I838_I160_XG_n1 I1_I838_P10_3 I1_I838_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I160_XG_MN1 (VSS I1_I838_G2_0np XI1_I838_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I106_XG_MN2 (I1_I838_G10_7n I1_I838_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I106_XG_MN0 (XI1_I838_I106_XG_n1 I1_I838_P10_9 I1_I838_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I106_XG_MN1 (VSS I1_I838_G8_7 XI1_I838_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I158_XG_MN2 (I1_I792_G9_0n I1_I792_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I158_XG_MN0 (XI1_I792_I158_XG_n1 I1_I792_P9_2 I1_I792_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I158_XG_MN1 (VSS I1_I792_G1_0 XI1_I792_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I105_XG_MN2 (I1_I792_G9_6n I1_I792_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I105_XG_MN0 (XI1_I792_I105_XG_n1 I1_I792_P9_8 I1_I792_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I105_XG_MN1 (VSS I1_I792_G7_6 XI1_I792_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I160_XG_MN2 (I1_I792_G10_0n I1_I792_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I160_XG_MN0 (XI1_I792_I160_XG_n1 I1_I792_P10_3 I1_I792_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I160_XG_MN1 (VSS I1_I792_G2_0np XI1_I792_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I110_XG_MN2 (I1_I792_G14_11n I1_I792_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I110_XG_MN0 (XI1_I792_I110_XG_n1 I1_I792_P14_13 I1_I792_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I110_XG_MN1 (VSS I1_I792_G12_11 XI1_I792_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I160_XG_MN2 (I1_I746_G10_0n I1_I746_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I160_XG_MN0 (XI1_I746_I160_XG_n1 I1_I746_P10_3 I1_I746_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I160_XG_MN1 (VSS I1_I746_G2_0np XI1_I746_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I169_XG_MN2 (I1_I746_G18_3n I1_I746_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I169_XG_MN0 (XI1_I746_I169_XG_n1 I1_I746_P18_11 I1_I746_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I169_XG_MN1 (VSS I1_I746_G10_3 XI1_I746_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I175_XG_MN2 (I1_I746_G24_9n I1_I746_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I175_XG_MN0 (XI1_I746_I175_XG_n1 I1_I746_P24_17 I1_I746_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I175_XG_MN1 (VSS I1_I746_G16_9 XI1_I746_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I118_XG_MN2 (I1_I746_G22_19n I1_I746_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I118_XG_MN0 (XI1_I746_I118_XG_n1 I1_I746_P22_21 I1_I746_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I118_XG_MN1 (VSS I1_I746_G20_19 XI1_I746_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I120_XG_MN2 (I1_I746_G24_21n I1_I746_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I120_XG_MN0 (XI1_I746_I120_XG_n1 I1_I746_P24_23 I1_I746_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I120_XG_MN1 (VSS I1_I746_G22_21 XI1_I746_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I181_XG_MN2 (I1_I1344_G30_15n I1_I1344_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I181_XG_MN0 (XI1_I1344_I181_XG_n1 I1_I1344_P30_23 I1_I1344_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I181_XG_MN1 (VSS I1_I1344_G22_15 XI1_I1344_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I116_XG_MN2 (I1_I1344_G20_17n I1_I1344_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I116_XG_MN0 (XI1_I1344_I116_XG_n1 I1_I1344_P20_19 I1_I1344_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I116_XG_MN1 (VSS I1_I1344_G18_17 XI1_I1344_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I114_XG_MN2 (I1_I1344_G18_15n I1_I1344_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I114_XG_MN0 (XI1_I1344_I114_XG_n1 I1_I1344_P18_17 I1_I1344_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I114_XG_MN1 (VSS I1_I1344_G16_15 XI1_I1344_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I105_XG_MN2 (I1_I1344_G9_6n I1_I1344_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I105_XG_MN0 (XI1_I1344_I105_XG_n1 I1_I1344_P9_8 I1_I1344_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I105_XG_MN1 (VSS I1_I1344_G7_6 XI1_I1344_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I162_XG_MN2 (I1_I1298_G11_0n I1_I1298_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I162_XG_MN0 (XI1_I1298_I162_XG_n1 I1_I1298_P11_4 I1_I1298_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I162_XG_MN1 (VSS I1_I1298_G3_0np XI1_I1298_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I164_XG_MN2 (I1_I1298_G13_0n I1_I1298_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I164_XG_MN0 (XI1_I1298_I164_XG_n1 I1_I1298_P13_6 I1_I1298_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I164_XG_MN1 (VSS I1_I1298_G5_0 XI1_I1298_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I113_XG_MN2 (I1_I1298_G17_14n I1_I1298_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I113_XG_MN0 (XI1_I1298_I113_XG_n1 I1_I1298_P17_16 I1_I1298_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I113_XG_MN1 (VSS I1_I1298_G15_14 XI1_I1298_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I114_XG_MN2 (I1_I1298_G18_15n I1_I1298_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I114_XG_MN0 (XI1_I1298_I114_XG_n1 I1_I1298_P18_17 I1_I1298_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I114_XG_MN1 (VSS I1_I1298_G16_15 XI1_I1298_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I171_XG_MN2 (I1_I1252_G20_5n I1_I1252_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I171_XG_MN0 (XI1_I1252_I171_XG_n1 I1_I1252_P20_13 I1_I1252_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I171_XG_MN1 (VSS I1_I1252_G12_5 XI1_I1252_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I114_XG_MN2 (I1_I1252_G18_15n I1_I1252_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I114_XG_MN0 (XI1_I1252_I114_XG_n1 I1_I1252_P18_17 I1_I1252_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I114_XG_MN1 (VSS I1_I1252_G16_15 XI1_I1252_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I176_XG_MN2 (I1_I1252_G25_10n I1_I1252_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I176_XG_MN0 (XI1_I1252_I176_XG_n1 I1_I1252_P25_18 I1_I1252_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I176_XG_MN1 (VSS I1_I1252_G17_10 XI1_I1252_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I113_XG_MN2 (I1_I1252_G17_14n I1_I1252_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I113_XG_MN0 (XI1_I1252_I113_XG_n1 I1_I1252_P17_16 I1_I1252_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I113_XG_MN1 (VSS I1_I1252_G15_14 XI1_I1252_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I115_XG_MN2 (I1_I1206_G19_16n I1_I1206_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I115_XG_MN0 (XI1_I1206_I115_XG_n1 I1_I1206_P19_18 I1_I1206_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I115_XG_MN1 (VSS I1_I1206_G17_16 XI1_I1206_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I166_XG_MN2 (I1_I1206_G15_0n I1_I1206_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I166_XG_MN0 (XI1_I1206_I166_XG_n1 I1_I1206_P15_8 I1_I1206_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I166_XG_MN1 (VSS I1_I1206_G7_0 XI1_I1206_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I176_XG_MN2 (I1_I1206_G25_10n I1_I1206_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I176_XG_MN0 (XI1_I1206_I176_XG_n1 I1_I1206_P25_18 I1_I1206_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I176_XG_MN1 (VSS I1_I1206_G17_10 XI1_I1206_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I114_XG_MN2 (I1_I1206_G18_15n I1_I1206_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I114_XG_MN0 (XI1_I1206_I114_XG_n1 I1_I1206_P18_17 I1_I1206_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I114_XG_MN1 (VSS I1_I1206_G16_15 XI1_I1206_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I169_XG_MN2 (I1_I1206_G18_3n I1_I1206_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I169_XG_MN0 (XI1_I1206_I169_XG_n1 I1_I1206_P18_11 I1_I1206_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I169_XG_MN1 (VSS I1_I1206_G10_3 XI1_I1206_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I175_XG_MN2 (I1_I1206_G24_9n I1_I1206_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I175_XG_MN0 (XI1_I1206_I175_XG_n1 I1_I1206_P24_17 I1_I1206_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I175_XG_MN1 (VSS I1_I1206_G16_9 XI1_I1206_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I171_XG_MN2 (I1_I838_G20_5n I1_I838_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I171_XG_MN0 (XI1_I838_I171_XG_n1 I1_I838_P20_13 I1_I838_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I171_XG_MN1 (VSS I1_I838_G12_5 XI1_I838_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I163_XG_MN2 (I1_I838_G12_0n I1_I838_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I163_XG_MN0 (XI1_I838_I163_XG_n1 I1_I838_P12_5 I1_I838_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I163_XG_MN1 (VSS I1_I838_G4_0 XI1_I838_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I169_XG_MN2 (I1_I838_G18_3n I1_I838_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I169_XG_MN0 (XI1_I838_I169_XG_n1 I1_I838_P18_11 I1_I838_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I169_XG_MN1 (VSS I1_I838_G10_3 XI1_I838_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I167_XG_MN2 (I1_I838_G16_1n I1_I838_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I167_XG_MN0 (XI1_I838_I167_XG_n1 I1_I838_P16_9 I1_I838_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I167_XG_MN1 (VSS I1_I838_G8_1 XI1_I838_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I157_XG_MN2 (I1_I838_G8_0n I1_I838_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I157_XG_MN0 (XI1_I838_I157_XG_n1 I1_I838_P8_1 I1_I838_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I157_XG_MN1 (VSS I1_I838_G0_0 XI1_I838_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I104_XG_MN2 (I1_I838_G8_5n I1_I838_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I104_XG_MN0 (XI1_I838_I104_XG_n1 I1_I838_P8_7 I1_I838_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I104_XG_MN1 (VSS I1_I838_G6_5 XI1_I838_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I102_XG_MN2 (I1_I838_G6_3n I1_I838_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I102_XG_MN0 (XI1_I838_I102_XG_n1 I1_I838_P6_5 I1_I838_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I102_XG_MN1 (VSS I1_I838_G4_3 XI1_I838_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I103_XG_MN2 (I1_I792_G7_4n I1_I792_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I103_XG_MN0 (XI1_I792_I103_XG_n1 I1_I792_P7_6 I1_I792_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I103_XG_MN1 (VSS I1_I792_G5_4 XI1_I792_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I157_XG_MN2 (I1_I792_G8_0n I1_I792_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I157_XG_MN0 (XI1_I792_I157_XG_n1 I1_I792_P8_1 I1_I792_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I157_XG_MN1 (VSS I1_I792_G0_0 XI1_I792_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I167_XG_MN2 (I1_I792_G16_1n I1_I792_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I167_XG_MN0 (XI1_I792_I167_XG_n1 I1_I792_P16_9 I1_I792_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I167_XG_MN1 (VSS I1_I792_G8_1 XI1_I792_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I106_XG_MN2 (I1_I792_G10_7n I1_I792_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I106_XG_MN0 (XI1_I792_I106_XG_n1 I1_I792_P10_9 I1_I792_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I106_XG_MN1 (VSS I1_I792_G8_7 XI1_I792_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I108_XG_MN2 (I1_I792_G12_9n I1_I792_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I108_XG_MN0 (XI1_I792_I108_XG_n1 I1_I792_P12_11 I1_I792_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I108_XG_MN1 (VSS I1_I792_G10_9 XI1_I792_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I167_XG_MN2 (I1_I746_G16_1n I1_I746_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I167_XG_MN0 (XI1_I746_I167_XG_n1 I1_I746_P16_9 I1_I746_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I167_XG_MN1 (VSS I1_I746_G8_1 XI1_I746_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I163_XG_MN2 (I1_I746_G12_0n I1_I746_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I163_XG_MN0 (XI1_I746_I163_XG_n1 I1_I746_P12_5 I1_I746_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I163_XG_MN1 (VSS I1_I746_G4_0 XI1_I746_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I171_XG_MN2 (I1_I746_G20_5n I1_I746_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I171_XG_MN0 (XI1_I746_I171_XG_n1 I1_I746_P20_13 I1_I746_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I171_XG_MN1 (VSS I1_I746_G12_5 XI1_I746_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I114_XG_MN2 (I1_I746_G18_15n I1_I746_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I114_XG_MN0 (XI1_I746_I114_XG_n1 I1_I746_P18_17 I1_I746_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I114_XG_MN1 (VSS I1_I746_G16_15 XI1_I746_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I116_XG_MN2 (I1_I746_G20_17n I1_I746_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I116_XG_MN0 (XI1_I746_I116_XG_n1 I1_I746_P20_19 I1_I746_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I116_XG_MN1 (VSS I1_I746_G18_17 XI1_I746_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I125_XG_MN2 (I1_I746_G29_26n I1_I746_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I125_XG_MN0 (XI1_I746_I125_XG_n1 I1_I746_P29_28 I1_I746_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I125_XG_MN1 (VSS I1_I746_G27_26 XI1_I746_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I177_XG_MN2 (I1_I1344_G26_11n I1_I1344_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I177_XG_MN0 (XI1_I1344_I177_XG_n1 I1_I1344_P26_19 I1_I1344_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I177_XG_MN1 (VSS I1_I1344_G18_11 XI1_I1344_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I179_XG_MN2 (I1_I1344_G28_13n I1_I1344_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I179_XG_MN0 (XI1_I1344_I179_XG_n1 I1_I1344_P28_21 I1_I1344_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I179_XG_MN1 (VSS I1_I1344_G20_13 XI1_I1344_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I112_XG_MN2 (I1_I1344_G16_13n I1_I1344_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I112_XG_MN0 (XI1_I1344_I112_XG_n1 I1_I1344_P16_15 I1_I1344_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I112_XG_MN1 (VSS I1_I1344_G14_13 XI1_I1344_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I110_XG_MN2 (I1_I1344_G14_11n I1_I1344_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I110_XG_MN0 (XI1_I1344_I110_XG_n1 I1_I1344_P14_13 I1_I1344_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I110_XG_MN1 (VSS I1_I1344_G12_11 XI1_I1344_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I103_XG_MN2 (I1_I1344_G7_4n I1_I1344_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I103_XG_MN0 (XI1_I1344_I103_XG_n1 I1_I1344_P7_6 I1_I1344_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I103_XG_MN1 (VSS I1_I1344_G5_4 XI1_I1344_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I109_XG_MN2 (I1_I1298_G13_10n I1_I1298_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I109_XG_MN0 (XI1_I1298_I109_XG_n1 I1_I1298_P13_12 I1_I1298_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I109_XG_MN1 (VSS I1_I1298_G11_10 XI1_I1298_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I111_XG_MN2 (I1_I1298_G15_12n I1_I1298_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I111_XG_MN0 (XI1_I1298_I111_XG_n1 I1_I1298_P15_14 I1_I1298_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I111_XG_MN1 (VSS I1_I1298_G13_12 XI1_I1298_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I163_XG_MN2 (I1_I1298_G12_0n I1_I1298_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I163_XG_MN0 (XI1_I1298_I163_XG_n1 I1_I1298_P12_5 I1_I1298_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I163_XG_MN1 (VSS I1_I1298_G4_0 XI1_I1298_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I112_XG_MN2 (I1_I1298_G16_13n I1_I1298_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I112_XG_MN0 (XI1_I1298_I112_XG_n1 I1_I1298_P16_15 I1_I1298_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I112_XG_MN1 (VSS I1_I1298_G14_13 XI1_I1298_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I110_XG_MN2 (I1_I1298_G14_11n I1_I1298_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I110_XG_MN0 (XI1_I1298_I110_XG_n1 I1_I1298_P14_13 I1_I1298_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I110_XG_MN1 (VSS I1_I1298_G12_11 XI1_I1298_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I163_XG_MN2 (I1_I1252_G12_0n I1_I1252_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I163_XG_MN0 (XI1_I1252_I163_XG_n1 I1_I1252_P12_5 I1_I1252_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I163_XG_MN1 (VSS I1_I1252_G4_0 XI1_I1252_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I169_XG_MN2 (I1_I1252_G18_3n I1_I1252_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I169_XG_MN0 (XI1_I1252_I169_XG_n1 I1_I1252_P18_11 I1_I1252_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I169_XG_MN1 (VSS I1_I1252_G10_3 XI1_I1252_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I110_XG_MN2 (I1_I1252_G14_11n I1_I1252_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I110_XG_MN0 (XI1_I1252_I110_XG_n1 I1_I1252_P14_13 I1_I1252_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I110_XG_MN1 (VSS I1_I1252_G12_11 XI1_I1252_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I112_XG_MN2 (I1_I1252_G16_13n I1_I1252_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I112_XG_MN0 (XI1_I1252_I112_XG_n1 I1_I1252_P16_15 I1_I1252_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I112_XG_MN1 (VSS I1_I1252_G14_13 XI1_I1252_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I170_XG_MN2 (I1_I1252_G19_4n I1_I1252_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I170_XG_MN0 (XI1_I1252_I170_XG_n1 I1_I1252_P19_12 I1_I1252_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I170_XG_MN1 (VSS I1_I1252_G11_4 XI1_I1252_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I111_XG_MN2 (I1_I1252_G15_12n I1_I1252_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I111_XG_MN0 (XI1_I1252_I111_XG_n1 I1_I1252_P15_14 I1_I1252_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I111_XG_MN1 (VSS I1_I1252_G13_12 XI1_I1252_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I113_XG_MN2 (I1_I1206_G17_14n I1_I1206_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I113_XG_MN0 (XI1_I1206_I113_XG_n1 I1_I1206_P17_16 I1_I1206_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I113_XG_MN1 (VSS I1_I1206_G15_14 XI1_I1206_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I170_XG_MN2 (I1_I1206_G19_4n I1_I1206_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I170_XG_MN0 (XI1_I1206_I170_XG_n1 I1_I1206_P19_12 I1_I1206_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I170_XG_MN1 (VSS I1_I1206_G11_4 XI1_I1206_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I168_XG_MN2 (I1_I1206_G17_2n I1_I1206_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I168_XG_MN0 (XI1_I1206_I168_XG_n1 I1_I1206_P17_10 I1_I1206_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I168_XG_MN1 (VSS I1_I1206_G9_2 XI1_I1206_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I164_XG_MN2 (I1_I1206_G13_0n I1_I1206_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I164_XG_MN0 (XI1_I1206_I164_XG_n1 I1_I1206_P13_6 I1_I1206_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I164_XG_MN1 (VSS I1_I1206_G5_0 XI1_I1206_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I165_XG_MN2 (I1_I1206_G14_0n I1_I1206_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I165_XG_MN0 (XI1_I1206_I165_XG_n1 I1_I1206_P14_7 I1_I1206_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I165_XG_MN1 (VSS I1_I1206_G6_0 XI1_I1206_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I171_XG_MN2 (I1_I1206_G20_5n I1_I1206_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I171_XG_MN0 (XI1_I1206_I171_XG_n1 I1_I1206_P20_13 I1_I1206_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I171_XG_MN1 (VSS I1_I1206_G12_5 XI1_I1206_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I101_XG_MN2 (I1_I792_G5_2n I1_I792_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I101_XG_MN0 (XI1_I792_I101_XG_n1 I1_I792_P5_4 I1_I792_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I101_XG_MN1 (VSS I1_I792_G3_2 XI1_I792_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I102_XG_MN2 (I1_I792_G6_3n I1_I792_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I102_XG_MN0 (XI1_I792_I102_XG_n1 I1_I792_P6_5 I1_I792_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I102_XG_MN1 (VSS I1_I792_G4_3 XI1_I792_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I104_XG_MN2 (I1_I792_G8_5n I1_I792_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I104_XG_MN0 (XI1_I792_I104_XG_n1 I1_I792_P8_7 I1_I792_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I104_XG_MN1 (VSS I1_I792_G6_5 XI1_I792_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I157_XG_MN2 (I1_I746_G8_0n I1_I746_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I157_XG_MN0 (XI1_I746_I157_XG_n1 I1_I746_P8_1 I1_I746_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I157_XG_MN1 (VSS I1_I746_G0_0 XI1_I746_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I106_XG_MN2 (I1_I746_G10_7n I1_I746_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I106_XG_MN0 (XI1_I746_I106_XG_n1 I1_I746_P10_9 I1_I746_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I106_XG_MN1 (VSS I1_I746_G8_7 XI1_I746_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I108_XG_MN2 (I1_I746_G12_9n I1_I746_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I108_XG_MN0 (XI1_I746_I108_XG_n1 I1_I746_P12_11 I1_I746_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I108_XG_MN1 (VSS I1_I746_G10_9 XI1_I746_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I110_XG_MN2 (I1_I746_G14_11n I1_I746_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I110_XG_MN0 (XI1_I746_I110_XG_n1 I1_I746_P14_13 I1_I746_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I110_XG_MN1 (VSS I1_I746_G12_11 XI1_I746_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I112_XG_MN2 (I1_I746_G16_13n I1_I746_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I112_XG_MN0 (XI1_I746_I112_XG_n1 I1_I746_P16_15 I1_I746_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I112_XG_MN1 (VSS I1_I746_G14_13 XI1_I746_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I164_XG_MN2 (I1_I746_G13_0n I1_I746_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I164_XG_MN0 (XI1_I746_I164_XG_n1 I1_I746_P13_6 I1_I746_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I164_XG_MN1 (VSS I1_I746_G5_0 XI1_I746_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I176_XG_MN2 (I1_I746_G25_10n I1_I746_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I176_XG_MN0 (XI1_I746_I176_XG_n1 I1_I746_P25_18 I1_I746_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I176_XG_MN1 (VSS I1_I746_G17_10 XI1_I746_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I172_XG_MN2 (I1_I746_G21_6n I1_I746_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I172_XG_MN0 (XI1_I746_I172_XG_n1 I1_I746_P21_14 I1_I746_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I172_XG_MN1 (VSS I1_I746_G13_6 XI1_I746_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I180_XG_MN2 (I1_I746_G29_14n I1_I746_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I180_XG_MN0 (XI1_I746_I180_XG_n1 I1_I746_P29_22 I1_I746_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I180_XG_MN1 (VSS I1_I746_G21_14 XI1_I746_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I121_XG_MN2 (I1_I746_G25_22n I1_I746_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I121_XG_MN0 (XI1_I746_I121_XG_n1 I1_I746_P25_24 I1_I746_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I121_XG_MN1 (VSS I1_I746_G23_22 XI1_I746_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I123_XG_MN2 (I1_I746_G27_24n I1_I746_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I123_XG_MN0 (XI1_I746_I123_XG_n1 I1_I746_P27_26 I1_I746_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I123_XG_MN1 (VSS I1_I746_G25_24 XI1_I746_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I127_XG_MN2 (I1_I746_G31_28n I1_I746_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I127_XG_MN0 (XI1_I746_I127_XG_n1 I1_I746_P31_30 I1_I746_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I127_XG_MN1 (VSS I1_I746_G29_28 XI1_I746_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I173_XG_MN2 (I1_I1344_G22_7n I1_I1344_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I173_XG_MN0 (XI1_I1344_I173_XG_n1 I1_I1344_P22_15 I1_I1344_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I173_XG_MN1 (VSS I1_I1344_G14_7 XI1_I1344_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I165_XG_MN2 (I1_I1344_G14_0n I1_I1344_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I165_XG_MN0 (XI1_I1344_I165_XG_n1 I1_I1344_P14_7 I1_I1344_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I165_XG_MN1 (VSS I1_I1344_G6_0 XI1_I1344_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I175_XG_MN2 (I1_I1344_G24_9n I1_I1344_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I175_XG_MN0 (XI1_I1344_I175_XG_n1 I1_I1344_P24_17 I1_I1344_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I175_XG_MN1 (VSS I1_I1344_G16_9 XI1_I1344_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I171_XG_MN2 (I1_I1344_G20_5n I1_I1344_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I171_XG_MN0 (XI1_I1344_I171_XG_n1 I1_I1344_P20_13 I1_I1344_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I171_XG_MN1 (VSS I1_I1344_G12_5 XI1_I1344_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I108_XG_MN2 (I1_I1344_G12_9n I1_I1344_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I108_XG_MN0 (XI1_I1344_I108_XG_n1 I1_I1344_P12_11 I1_I1344_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I108_XG_MN1 (VSS I1_I1344_G10_9 XI1_I1344_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I168_XG_MN2 (I1_I1298_G17_2n I1_I1298_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I168_XG_MN0 (XI1_I1298_I168_XG_n1 I1_I1298_P17_10 I1_I1298_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I168_XG_MN1 (VSS I1_I1298_G9_2 XI1_I1298_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I107_XG_MN2 (I1_I1298_G11_8n I1_I1298_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I107_XG_MN0 (XI1_I1298_I107_XG_n1 I1_I1298_P11_10 I1_I1298_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I107_XG_MN1 (VSS I1_I1298_G9_8 XI1_I1298_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I169_XG_MN2 (I1_I1298_G18_3n I1_I1298_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I169_XG_MN0 (XI1_I1298_I169_XG_n1 I1_I1298_P18_11 I1_I1298_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I169_XG_MN1 (VSS I1_I1298_G10_3 XI1_I1298_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I175_XG_MN2 (I1_I1298_G24_9n I1_I1298_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I175_XG_MN0 (XI1_I1298_I175_XG_n1 I1_I1298_P24_17 I1_I1298_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I175_XG_MN1 (VSS I1_I1298_G16_9 XI1_I1298_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I108_XG_MN2 (I1_I1298_G12_9n I1_I1298_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I108_XG_MN0 (XI1_I1298_I108_XG_n1 I1_I1298_P12_11 I1_I1298_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I108_XG_MN1 (VSS I1_I1298_G10_9 XI1_I1298_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I160_XG_MN2 (I1_I1252_G10_0n I1_I1252_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I160_XG_MN0 (XI1_I1252_I160_XG_n1 I1_I1252_P10_3 I1_I1252_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I160_XG_MN1 (VSS I1_I1252_G2_0np XI1_I1252_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I168_XG_MN2 (I1_I1252_G17_2n I1_I1252_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I168_XG_MN0 (XI1_I1252_I168_XG_n1 I1_I1252_P17_10 I1_I1252_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I168_XG_MN1 (VSS I1_I1252_G9_2 XI1_I1252_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I162_XG_MN2 (I1_I1252_G11_0n I1_I1252_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I162_XG_MN0 (XI1_I1252_I162_XG_n1 I1_I1252_P11_4 I1_I1252_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I162_XG_MN1 (VSS I1_I1252_G3_0np XI1_I1252_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I111_XG_MN2 (I1_I1206_G15_12n I1_I1206_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I111_XG_MN0 (XI1_I1206_I111_XG_n1 I1_I1206_P15_14 I1_I1206_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I111_XG_MN1 (VSS I1_I1206_G13_12 XI1_I1206_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I162_XG_MN2 (I1_I1206_G11_0n I1_I1206_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I162_XG_MN0 (XI1_I1206_I162_XG_n1 I1_I1206_P11_4 I1_I1206_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I162_XG_MN1 (VSS I1_I1206_G3_0np XI1_I1206_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I110_XG_MN2 (I1_I1206_G14_11n I1_I1206_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I110_XG_MN0 (XI1_I1206_I110_XG_n1 I1_I1206_P14_13 I1_I1206_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I110_XG_MN1 (VSS I1_I1206_G12_11 XI1_I1206_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I112_XG_MN2 (I1_I1206_G16_13n I1_I1206_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I112_XG_MN0 (XI1_I1206_I112_XG_n1 I1_I1206_P16_15 I1_I1206_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I112_XG_MN1 (VSS I1_I1206_G14_13 XI1_I1206_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I160_XG_MN2 (I1_I1206_G10_0n I1_I1206_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I160_XG_MN0 (XI1_I1206_I160_XG_n1 I1_I1206_P10_3 I1_I1206_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I160_XG_MN1 (VSS I1_I1206_G2_0np XI1_I1206_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I163_XG_MN2 (I1_I1206_G12_0n I1_I1206_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I163_XG_MN0 (XI1_I1206_I163_XG_n1 I1_I1206_P12_5 I1_I1206_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I163_XG_MN1 (VSS I1_I1206_G4_0 XI1_I1206_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I123_XG_MN2 (I1_I884_G27_24n I1_I884_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I123_XG_MN0 (XI1_I884_I123_XG_n1 I1_I884_P27_26 I1_I884_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I123_XG_MN1 (VSS I1_I884_G25_24 XI1_I884_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I121_XG_MN2 (I1_I884_G25_22n I1_I884_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I121_XG_MN0 (XI1_I884_I121_XG_n1 I1_I884_P25_24 I1_I884_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I121_XG_MN1 (VSS I1_I884_G23_22 XI1_I884_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I119_XG_MN2 (I1_I884_G23_20n I1_I884_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I119_XG_MN0 (XI1_I884_I119_XG_n1 I1_I884_P23_22 I1_I884_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I119_XG_MN1 (VSS I1_I884_G21_20 XI1_I884_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I117_XG_MN2 (I1_I884_G21_18n I1_I884_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I117_XG_MN0 (XI1_I884_I117_XG_n1 I1_I884_P21_20 I1_I884_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I117_XG_MN1 (VSS I1_I884_G19_18 XI1_I884_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I100_XG_MN2 (I1_I838_G4_1n I1_I838_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I100_XG_MN0 (XI1_I838_I100_XG_n1 I1_I838_P4_3 I1_I838_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I100_XG_MN1 (VSS I1_I838_G2_1 XI1_I838_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I98_XG_MN2 (I1_I838_G2_0n I1_I838_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I838_I98_XG_MN0 (XI1_I838_I98_XG_n1 I1_I838_P2_1 I1_I838_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I838_I98_XG_MN1 (VSS I1_I838_G0_0 XI1_I838_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I99_XG_MN2 (I1_I792_G3_0n I1_I792_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I99_XG_MN0 (XI1_I792_I99_XG_n1 I1_I792_P3_2 I1_I792_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I99_XG_MN1 (VSS I1_I792_G1_0 XI1_I792_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I98_XG_MN2 (I1_I792_G2_0n I1_I792_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I98_XG_MN0 (XI1_I792_I98_XG_n1 I1_I792_P2_1 I1_I792_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I98_XG_MN1 (VSS I1_I792_G0_0 XI1_I792_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I792_I100_XG_MN2 (I1_I792_G4_1n I1_I792_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I792_I100_XG_MN0 (XI1_I792_I100_XG_n1 I1_I792_P4_3 I1_I792_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I792_I100_XG_MN1 (VSS I1_I792_G2_1 XI1_I792_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I102_XG_MN2 (I1_I746_G6_3n I1_I746_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I102_XG_MN0 (XI1_I746_I102_XG_n1 I1_I746_P6_5 I1_I746_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I102_XG_MN1 (VSS I1_I746_G4_3 XI1_I746_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I104_XG_MN2 (I1_I746_G8_5n I1_I746_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I104_XG_MN0 (XI1_I746_I104_XG_n1 I1_I746_P8_7 I1_I746_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I104_XG_MN1 (VSS I1_I746_G6_5 XI1_I746_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I158_XG_MN2 (I1_I746_G9_0n I1_I746_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I158_XG_MN0 (XI1_I746_I158_XG_n1 I1_I746_P9_2 I1_I746_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I158_XG_MN1 (VSS I1_I746_G1_0 XI1_I746_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I168_XG_MN2 (I1_I746_G17_2n I1_I746_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I168_XG_MN0 (XI1_I746_I168_XG_n1 I1_I746_P17_10 I1_I746_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I168_XG_MN1 (VSS I1_I746_G9_2 XI1_I746_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I162_XG_MN2 (I1_I746_G11_0n I1_I746_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I162_XG_MN0 (XI1_I746_I162_XG_n1 I1_I746_P11_4 I1_I746_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I162_XG_MN1 (VSS I1_I746_G3_0np XI1_I746_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I170_XG_MN2 (I1_I746_G19_4n I1_I746_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I170_XG_MN0 (XI1_I746_I170_XG_n1 I1_I746_P19_12 I1_I746_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I170_XG_MN1 (VSS I1_I746_G11_4 XI1_I746_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I115_XG_MN2 (I1_I746_G19_16n I1_I746_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I115_XG_MN0 (XI1_I746_I115_XG_n1 I1_I746_P19_18 I1_I746_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I115_XG_MN1 (VSS I1_I746_G17_16 XI1_I746_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I117_XG_MN2 (I1_I746_G21_18n I1_I746_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I117_XG_MN0 (XI1_I746_I117_XG_n1 I1_I746_P21_20 I1_I746_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I117_XG_MN1 (VSS I1_I746_G19_18 XI1_I746_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I178_XG_MN2 (I1_I746_G27_12n I1_I746_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I178_XG_MN0 (XI1_I746_I178_XG_n1 I1_I746_P27_20 I1_I746_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I178_XG_MN1 (VSS I1_I746_G19_12 XI1_I746_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I119_XG_MN2 (I1_I746_G23_20n I1_I746_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I119_XG_MN0 (XI1_I746_I119_XG_n1 I1_I746_P23_22 I1_I746_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I119_XG_MN1 (VSS I1_I746_G21_20 XI1_I746_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I182_XG_MN2 (I1_I746_G31_16n I1_I746_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I182_XG_MN0 (XI1_I746_I182_XG_n1 I1_I746_P31_24 I1_I746_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I182_XG_MN1 (VSS I1_I746_G23_16 XI1_I746_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I169_XG_MN2 (I1_I1344_G18_3n I1_I1344_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I169_XG_MN0 (XI1_I1344_I169_XG_n1 I1_I1344_P18_11 I1_I1344_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I169_XG_MN1 (VSS I1_I1344_G10_3 XI1_I1344_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I163_XG_MN2 (I1_I1344_G12_0n I1_I1344_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I163_XG_MN0 (XI1_I1344_I163_XG_n1 I1_I1344_P12_5 I1_I1344_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I163_XG_MN1 (VSS I1_I1344_G4_0 XI1_I1344_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I160_XG_MN2 (I1_I1344_G10_0n I1_I1344_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I160_XG_MN0 (XI1_I1344_I160_XG_n1 I1_I1344_P10_3 I1_I1344_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I160_XG_MN1 (VSS I1_I1344_G2_0np XI1_I1344_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1344_I106_XG_MN2 (I1_I1344_G10_7n I1_I1344_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1344_I106_XG_MN0 (XI1_I1344_I106_XG_n1 I1_I1344_P10_9 I1_I1344_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1344_I106_XG_MN1 (VSS I1_I1344_G8_7 XI1_I1344_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I158_XG_MN2 (I1_I1298_G9_0n I1_I1298_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I158_XG_MN0 (XI1_I1298_I158_XG_n1 I1_I1298_P9_2 I1_I1298_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I158_XG_MN1 (VSS I1_I1298_G1_0 XI1_I1298_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I105_XG_MN2 (I1_I1298_G9_6n I1_I1298_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I105_XG_MN0 (XI1_I1298_I105_XG_n1 I1_I1298_P9_8 I1_I1298_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I105_XG_MN1 (VSS I1_I1298_G7_6 XI1_I1298_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I160_XG_MN2 (I1_I1298_G10_0n I1_I1298_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I160_XG_MN0 (XI1_I1298_I160_XG_n1 I1_I1298_P10_3 I1_I1298_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I160_XG_MN1 (VSS I1_I1298_G2_0np XI1_I1298_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I167_XG_MN2 (I1_I1298_G16_1n I1_I1298_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I167_XG_MN0 (XI1_I1298_I167_XG_n1 I1_I1298_P16_9 I1_I1298_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I167_XG_MN1 (VSS I1_I1298_G8_1 XI1_I1298_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1298_I106_XG_MN2 (I1_I1298_G10_7n I1_I1298_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1298_I106_XG_MN0 (XI1_I1298_I106_XG_n1 I1_I1298_P10_9 I1_I1298_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1298_I106_XG_MN1 (VSS I1_I1298_G8_7 XI1_I1298_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I167_XG_MN2 (I1_I1252_G16_1n I1_I1252_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I167_XG_MN0 (XI1_I1252_I167_XG_n1 I1_I1252_P16_9 I1_I1252_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I167_XG_MN1 (VSS I1_I1252_G8_1 XI1_I1252_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I108_XG_MN2 (I1_I1252_G12_9n I1_I1252_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I108_XG_MN0 (XI1_I1252_I108_XG_n1 I1_I1252_P12_11 I1_I1252_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I108_XG_MN1 (VSS I1_I1252_G10_9 XI1_I1252_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I158_XG_MN2 (I1_I1252_G9_0n I1_I1252_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I158_XG_MN0 (XI1_I1252_I158_XG_n1 I1_I1252_P9_2 I1_I1252_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I158_XG_MN1 (VSS I1_I1252_G1_0 XI1_I1252_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I107_XG_MN2 (I1_I1252_G11_8n I1_I1252_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I107_XG_MN0 (XI1_I1252_I107_XG_n1 I1_I1252_P11_10 I1_I1252_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I107_XG_MN1 (VSS I1_I1252_G9_8 XI1_I1252_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1252_I109_XG_MN2 (I1_I1252_G13_10n I1_I1252_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1252_I109_XG_MN0 (XI1_I1252_I109_XG_n1 I1_I1252_P13_12 I1_I1252_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1252_I109_XG_MN1 (VSS I1_I1252_G11_10 XI1_I1252_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I109_XG_MN2 (I1_I1206_G13_10n I1_I1206_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I109_XG_MN0 (XI1_I1206_I109_XG_n1 I1_I1206_P13_12 I1_I1206_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I109_XG_MN1 (VSS I1_I1206_G11_10 XI1_I1206_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I107_XG_MN2 (I1_I1206_G11_8n I1_I1206_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I107_XG_MN0 (XI1_I1206_I107_XG_n1 I1_I1206_P11_10 I1_I1206_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I107_XG_MN1 (VSS I1_I1206_G9_8 XI1_I1206_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I158_XG_MN2 (I1_I1206_G9_0n I1_I1206_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I158_XG_MN0 (XI1_I1206_I158_XG_n1 I1_I1206_P9_2 I1_I1206_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I158_XG_MN1 (VSS I1_I1206_G1_0 XI1_I1206_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I108_XG_MN2 (I1_I1206_G12_9n I1_I1206_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I108_XG_MN0 (XI1_I1206_I108_XG_n1 I1_I1206_P12_11 I1_I1206_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I108_XG_MN1 (VSS I1_I1206_G10_9 XI1_I1206_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I167_XG_MN2 (I1_I1206_G16_1n I1_I1206_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I1206_I167_XG_MN0 (XI1_I1206_I167_XG_n1 I1_I1206_P16_9 I1_I1206_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I1206_I167_XG_MN1 (VSS I1_I1206_G8_1 XI1_I1206_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I127_XG_MN2 (I1_I884_G31_28n I1_I884_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I127_XG_MN0 (XI1_I884_I127_XG_n1 I1_I884_P31_30 I1_I884_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I127_XG_MN1 (VSS I1_I884_G29_28 XI1_I884_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I125_XG_MN2 (I1_I884_G29_26n I1_I884_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I125_XG_MN0 (XI1_I884_I125_XG_n1 I1_I884_P29_28 I1_I884_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I125_XG_MN1 (VSS I1_I884_G27_26 XI1_I884_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I178_XG_MN2 (I1_I884_G27_12n I1_I884_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I178_XG_MN0 (XI1_I884_I178_XG_n1 I1_I884_P27_20 I1_I884_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I178_XG_MN1 (VSS I1_I884_G19_12 XI1_I884_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I115_XG_MN2 (I1_I884_G19_16n I1_I884_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I115_XG_MN0 (XI1_I884_I115_XG_n1 I1_I884_P19_18 I1_I884_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I115_XG_MN1 (VSS I1_I884_G17_16 XI1_I884_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I113_XG_MN2 (I1_I884_G17_14n I1_I884_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I113_XG_MN0 (XI1_I884_I113_XG_n1 I1_I884_P17_16 I1_I884_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I113_XG_MN1 (VSS I1_I884_G15_14 XI1_I884_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I111_XG_MN2 (I1_I884_G15_12n I1_I884_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I111_XG_MN0 (XI1_I884_I111_XG_n1 I1_I884_P15_14 I1_I884_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I111_XG_MN1 (VSS I1_I884_G13_12 XI1_I884_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I884_I109_XG_MN2 (I1_I884_G13_10n I1_I884_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I884_I109_XG_MN0 (XI1_I884_I109_XG_n1 I1_I884_P13_12 I1_I884_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I884_I109_XG_MN1 (VSS I1_I884_G11_10 XI1_I884_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I98_XG_MN2 (I1_I746_G2_0n I1_I746_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I98_XG_MN0 (XI1_I746_I98_XG_n1 I1_I746_P2_1 I1_I746_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I98_XG_MN1 (VSS I1_I746_G0_0 XI1_I746_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I100_XG_MN2 (I1_I746_G4_1n I1_I746_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I100_XG_MN0 (XI1_I746_I100_XG_n1 I1_I746_P4_3 I1_I746_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I100_XG_MN1 (VSS I1_I746_G2_1 XI1_I746_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I101_XG_MN2 (I1_I746_G5_2n I1_I746_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I101_XG_MN0 (XI1_I746_I101_XG_n1 I1_I746_P5_4 I1_I746_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I101_XG_MN1 (VSS I1_I746_G3_2 XI1_I746_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I103_XG_MN2 (I1_I746_G7_4n I1_I746_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I103_XG_MN0 (XI1_I746_I103_XG_n1 I1_I746_P7_6 I1_I746_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I103_XG_MN1 (VSS I1_I746_G5_4 XI1_I746_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I105_XG_MN2 (I1_I746_G9_6n I1_I746_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I105_XG_MN0 (XI1_I746_I105_XG_n1 I1_I746_P9_8 I1_I746_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1_I746_I105_XG_MN1 (VSS I1_I746_G7_6 XI1_I746_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I746_I107_XG_MN2 (I1_I746_G11_8n I1_I746_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1_I746_I107_XG_MN0 (XI1_I746_I107_XG_n1 I1_I746_P11_10 I1_I746_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
