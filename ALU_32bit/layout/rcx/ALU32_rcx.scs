    I_MXI0_I1469_MN11_1 (XI0_I1469_an5 I0_pp10_23 XI0_I1469_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1469_MN12_1 (XI0_I1469_asn I0_pp11_21 XI0_I1469_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1469_MN10_1 (XI0_I1469_an4 I0_pp9_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN5 (XI0_I1469_acon I0_pp11_21 XI0_I1469_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1469_MN2 (XI0_I1469_an1 I0_pp10_23 XI0_I1469_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN1 (VSS I0_pp9_25 XI0_I1469_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN3 (XI0_I1469_an2 I0_pp9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN4 (VSS I0_pp10_23 XI0_I1469_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN27 (I0_cm108_2 XI0_I1469_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1469_MN7 (XI0_I1469_an3 I0_pp10_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1469_MN8 (VSS I0_pp11_21 XI0_I1469_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN34 (XI0_I1472_bn3 XI0_I1472_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN35 (VSS I0_pp12_20 XI0_I1472_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN36 (XI0_I1472_bn3 I0_cm108_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN37 (XI0_I1472_bsn XI0_I1472_bcon XI0_I1472_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN40 (XI0_I1472_bn5 I0_cm108_2 XI0_I1472_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN39 (XI0_I1472_bn4 I0_pp12_20 XI0_I1472_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN39_1 (XI0_I1472_bn5 I0_pp12_20 XI0_I1472_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN40_1 (XI0_I1472_bsn I0_cm108_2 XI0_I1472_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1472_MN53 (VSS XI0_I1472_bsn I0_cm111_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1472_MN29 (XI0_I1472_bn1 XI0_I1472_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN30 (XI0_I1472_bcon I0_pp12_20 XI0_I1472_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN33 (XI0_I1472_bn2 I0_cm108_2 XI0_I1472_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN31 (VSS XI0_I1472_s1 XI0_I1472_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN32 (XI0_I1472_bn2 I0_pp12_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1472_MN55 (VSS XI0_I1472_bcon I0_cm111_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1472_MN38 (XI0_I1472_bn4 XI0_I1472_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1472_MN38_1 (VSS XI0_I1472_s1 XI0_I1472_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1472_MN25 (VSS XI0_I1472_asn XI0_I1472_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1472_MN10 (VSS I0_pp9_26 XI0_I1472_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN6 (XI0_I1472_an3 I0_pp9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN9 (XI0_I1472_asn XI0_I1472_acon XI0_I1472_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN12 (XI0_I1472_an5 I0_pp11_22 XI0_I1472_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN11 (XI0_I1472_an4 I0_pp10_24 XI0_I1472_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1472_MN11_1 (XI0_I1472_an5 I0_pp10_24 XI0_I1472_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1472_MN12_1 (XI0_I1472_asn I0_pp11_22 XI0_I1472_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1472_MN10_1 (XI0_I1472_an4 I0_pp9_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN5 (XI0_I1472_acon I0_pp11_22 XI0_I1472_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1472_MN2 (XI0_I1472_an1 I0_pp10_24 XI0_I1472_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN1 (VSS I0_pp9_26 XI0_I1472_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN3 (XI0_I1472_an2 I0_pp9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN4 (VSS I0_pp10_24 XI0_I1472_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1472_MN27 (I0_cm111_2 XI0_I1472_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1472_MN7 (XI0_I1472_an3 I0_pp10_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1472_MN8 (VSS I0_pp11_22 XI0_I1472_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN34 (XI0_I1471_bn3 XI0_I1471_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN35 (VSS I0_pp8_28 XI0_I1471_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN36 (XI0_I1471_bn3 I0_cm107_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN37 (XI0_I1471_bsn XI0_I1471_bcon XI0_I1471_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN40 (XI0_I1471_bn5 I0_cm107_2 XI0_I1471_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN39 (XI0_I1471_bn4 I0_pp8_28 XI0_I1471_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN39_1 (XI0_I1471_bn5 I0_pp8_28 XI0_I1471_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN40_1 (XI0_I1471_bsn I0_cm107_2 XI0_I1471_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1471_MN53 (VSS XI0_I1471_bsn I0_cm110_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1471_MN29 (XI0_I1471_bn1 XI0_I1471_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN30 (XI0_I1471_bcon I0_pp8_28 XI0_I1471_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN33 (XI0_I1471_bn2 I0_cm107_2 XI0_I1471_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN31 (VSS XI0_I1471_s1 XI0_I1471_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN32 (XI0_I1471_bn2 I0_pp8_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1471_MN55 (VSS XI0_I1471_bcon I0_cm110_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1471_MN38 (XI0_I1471_bn4 XI0_I1471_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1471_MN38_1 (VSS XI0_I1471_s1 XI0_I1471_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1471_MN25 (VSS XI0_I1471_asn XI0_I1471_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1471_MN10 (VSS VDD XI0_I1471_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN6 (XI0_I1471_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN9 (XI0_I1471_asn XI0_I1471_acon XI0_I1471_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN12 (XI0_I1471_an5 I0_pp7_30 XI0_I1471_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN11 (XI0_I1471_an4 I0_pp6_32 XI0_I1471_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1471_MN11_1 (XI0_I1471_an5 I0_pp6_32 XI0_I1471_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1471_MN12_1 (XI0_I1471_asn I0_pp7_30 XI0_I1471_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1471_MN10_1 (XI0_I1471_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN5 (XI0_I1471_acon I0_pp7_30 XI0_I1471_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1471_MN2 (XI0_I1471_an1 I0_pp6_32 XI0_I1471_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN1 (VSS VDD XI0_I1471_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN3 (XI0_I1471_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN4 (VSS I0_pp6_32 XI0_I1471_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1471_MN27 (I0_cm110_2 XI0_I1471_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1471_MN7 (XI0_I1471_an3 I0_pp6_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1471_MN8 (VSS I0_pp7_30 XI0_I1471_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN34 (XI0_I1475_bn3 XI0_I1475_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN35 (VSS I0_pp13_19 XI0_I1475_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN36 (XI0_I1475_bn3 I0_cm111_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN37 (XI0_I1475_bsn XI0_I1475_bcon XI0_I1475_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN40 (XI0_I1475_bn5 I0_cm111_2 XI0_I1475_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN39 (XI0_I1475_bn4 I0_pp13_19 XI0_I1475_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN39_1 (XI0_I1475_bn5 I0_pp13_19 XI0_I1475_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN40_1 (XI0_I1475_bsn I0_cm111_2 XI0_I1475_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1475_MN53 (VSS XI0_I1475_bsn I0_cm114_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1475_MN29 (XI0_I1475_bn1 XI0_I1475_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN30 (XI0_I1475_bcon I0_pp13_19 XI0_I1475_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN33 (XI0_I1475_bn2 I0_cm111_2 XI0_I1475_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN31 (VSS XI0_I1475_s1 XI0_I1475_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN32 (XI0_I1475_bn2 I0_pp13_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1475_MN55 (VSS XI0_I1475_bcon I0_cm114_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1475_MN38 (XI0_I1475_bn4 XI0_I1475_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1475_MN38_1 (VSS XI0_I1475_s1 XI0_I1475_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1475_MN25 (VSS XI0_I1475_asn XI0_I1475_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1475_MN10 (VSS I0_pp10_25 XI0_I1475_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN6 (XI0_I1475_an3 I0_pp10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN9 (XI0_I1475_asn XI0_I1475_acon XI0_I1475_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN12 (XI0_I1475_an5 I0_pp12_21 XI0_I1475_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN11 (XI0_I1475_an4 I0_pp11_23 XI0_I1475_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1475_MN11_1 (XI0_I1475_an5 I0_pp11_23 XI0_I1475_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1475_MN12_1 (XI0_I1475_asn I0_pp12_21 XI0_I1475_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1475_MN10_1 (XI0_I1475_an4 I0_pp10_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN5 (XI0_I1475_acon I0_pp12_21 XI0_I1475_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1475_MN2 (XI0_I1475_an1 I0_pp11_23 XI0_I1475_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN1 (VSS I0_pp10_25 XI0_I1475_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN3 (XI0_I1475_an2 I0_pp10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN4 (VSS I0_pp11_23 XI0_I1475_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1475_MN27 (I0_cm114_2 XI0_I1475_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1475_MN7 (XI0_I1475_an3 I0_pp11_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1475_MN8 (VSS I0_pp12_21 XI0_I1475_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN34 (XI0_I1555_bn3 XI0_I1555_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN35 (VSS I0_cm113_0 XI0_I1555_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN36 (XI0_I1555_bn3 I0_cm193_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN37 (XI0_I1555_bsn XI0_I1555_bcon XI0_I1555_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN40 (XI0_I1555_bn5 I0_cm193_2 XI0_I1555_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN39 (XI0_I1555_bn4 I0_cm113_0 XI0_I1555_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN39_1 (XI0_I1555_bn5 I0_cm113_0 XI0_I1555_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN40_1 (XI0_I1555_bsn I0_cm193_2 XI0_I1555_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1555_MN53 (VSS XI0_I1555_bsn I0_cm194_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1555_MN29 (XI0_I1555_bn1 XI0_I1555_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN30 (XI0_I1555_bcon I0_cm113_0 XI0_I1555_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN33 (XI0_I1555_bn2 I0_cm193_2 XI0_I1555_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN31 (VSS XI0_I1555_s1 XI0_I1555_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN32 (XI0_I1555_bn2 I0_cm113_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1555_MN55 (VSS XI0_I1555_bcon I0_cm194_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1555_MN38 (XI0_I1555_bn4 XI0_I1555_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1555_MN38_1 (VSS XI0_I1555_s1 XI0_I1555_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1555_MN25 (VSS XI0_I1555_asn XI0_I1555_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1555_MN10 (VSS I0_cm110_1 XI0_I1555_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN6 (XI0_I1555_an3 I0_cm110_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN9 (XI0_I1555_asn XI0_I1555_acon XI0_I1555_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN12 (XI0_I1555_an5 I0_fa112_1 XI0_I1555_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN11 (XI0_I1555_an4 I0_cm111_1 XI0_I1555_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1555_MN11_1 (XI0_I1555_an5 I0_cm111_1 XI0_I1555_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1555_MN12_1 (XI0_I1555_asn I0_fa112_1 XI0_I1555_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1555_MN10_1 (XI0_I1555_an4 I0_cm110_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN5 (XI0_I1555_acon I0_fa112_1 XI0_I1555_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1555_MN2 (XI0_I1555_an1 I0_cm111_1 XI0_I1555_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN1 (VSS I0_cm110_1 XI0_I1555_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN3 (XI0_I1555_an2 I0_cm110_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN4 (VSS I0_cm111_1 XI0_I1555_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1555_MN27 (I0_cm194_2 XI0_I1555_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1555_MN7 (XI0_I1555_an3 I0_cm111_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1555_MN8 (VSS I0_fa112_1 XI0_I1555_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN34 (XI0_I1474_bn3 XI0_I1474_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN35 (VSS I0_pp9_27 XI0_I1474_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN36 (XI0_I1474_bn3 I0_cm110_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN37 (XI0_I1474_bsn XI0_I1474_bcon XI0_I1474_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN40 (XI0_I1474_bn5 I0_cm110_2 XI0_I1474_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN39 (XI0_I1474_bn4 I0_pp9_27 XI0_I1474_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN39_1 (XI0_I1474_bn5 I0_pp9_27 XI0_I1474_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN40_1 (XI0_I1474_bsn I0_cm110_2 XI0_I1474_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1474_MN53 (VSS XI0_I1474_bsn I0_cm113_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1474_MN29 (XI0_I1474_bn1 XI0_I1474_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN30 (XI0_I1474_bcon I0_pp9_27 XI0_I1474_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN33 (XI0_I1474_bn2 I0_cm110_2 XI0_I1474_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN31 (VSS XI0_I1474_s1 XI0_I1474_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN32 (XI0_I1474_bn2 I0_pp9_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1474_MN55 (VSS XI0_I1474_bcon I0_cm113_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1474_MN38 (XI0_I1474_bn4 XI0_I1474_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1474_MN38_1 (VSS XI0_I1474_s1 XI0_I1474_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1474_MN25 (VSS XI0_I1474_asn XI0_I1474_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1474_MN10 (VSS I0_sn6 XI0_I1474_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN6 (XI0_I1474_an3 I0_sn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN9 (XI0_I1474_asn XI0_I1474_acon XI0_I1474_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN12 (XI0_I1474_an5 I0_pp8_29 XI0_I1474_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN11 (XI0_I1474_an4 I0_pp7_31 XI0_I1474_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1474_MN11_1 (XI0_I1474_an5 I0_pp7_31 XI0_I1474_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1474_MN12_1 (XI0_I1474_asn I0_pp8_29 XI0_I1474_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1474_MN10_1 (XI0_I1474_an4 I0_sn6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN5 (XI0_I1474_acon I0_pp8_29 XI0_I1474_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1474_MN2 (XI0_I1474_an1 I0_pp7_31 XI0_I1474_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN1 (VSS I0_sn6 XI0_I1474_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN3 (XI0_I1474_an2 I0_sn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN4 (VSS I0_pp7_31 XI0_I1474_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1474_MN27 (I0_cm113_2 XI0_I1474_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1474_MN7 (XI0_I1474_an3 I0_pp7_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1474_MN8 (VSS I0_pp8_29 XI0_I1474_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN34 (XI0_I1492_bn3 XI0_I1492_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN35 (VSS I0_pp14_27 XI0_I1492_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN36 (XI0_I1492_bn3 I0_cm130_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN37 (XI0_I1492_bsn XI0_I1492_bcon XI0_I1492_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN40 (XI0_I1492_bn5 I0_cm130_2 XI0_I1492_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN39 (XI0_I1492_bn4 I0_pp14_27 XI0_I1492_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN39_1 (XI0_I1492_bn5 I0_pp14_27 XI0_I1492_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN40_1 (XI0_I1492_bsn I0_cm130_2 XI0_I1492_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1492_MN53 (VSS XI0_I1492_bsn I0_cm131_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1492_MN29 (XI0_I1492_bn1 XI0_I1492_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN30 (XI0_I1492_bcon I0_pp14_27 XI0_I1492_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN33 (XI0_I1492_bn2 I0_cm130_2 XI0_I1492_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN31 (VSS XI0_I1492_s1 XI0_I1492_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN32 (XI0_I1492_bn2 I0_pp14_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1492_MN55 (VSS XI0_I1492_bcon I0_cm131_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1492_MN38 (XI0_I1492_bn4 XI0_I1492_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1492_MN38_1 (VSS XI0_I1492_s1 XI0_I1492_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1492_MN25 (VSS XI0_I1492_asn XI0_I1492_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1492_MN10 (VSS I0_sn11 XI0_I1492_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN6 (XI0_I1492_an3 I0_sn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN9 (XI0_I1492_asn XI0_I1492_acon XI0_I1492_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN12 (XI0_I1492_an5 I0_pp13_29 XI0_I1492_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN11 (XI0_I1492_an4 I0_pp12_31 XI0_I1492_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1492_MN11_1 (XI0_I1492_an5 I0_pp12_31 XI0_I1492_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1492_MN12_1 (XI0_I1492_asn I0_pp13_29 XI0_I1492_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1492_MN10_1 (XI0_I1492_an4 I0_sn11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN5 (XI0_I1492_acon I0_pp13_29 XI0_I1492_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1492_MN2 (XI0_I1492_an1 I0_pp12_31 XI0_I1492_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN1 (VSS I0_sn11 XI0_I1492_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN3 (XI0_I1492_an2 I0_sn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN4 (VSS I0_pp12_31 XI0_I1492_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1492_MN27 (I0_cm131_2 XI0_I1492_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1492_MN7 (XI0_I1492_an3 I0_pp12_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1492_MN8 (VSS I0_pp13_29 XI0_I1492_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN34 (XI0_I1601_bn3 XI0_I1601_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN35 (VSS I0_pp14_18 XI0_I1601_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN36 (XI0_I1601_bn3 I0_pp15_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN37 (XI0_I1601_bsn XI0_I1601_bcon XI0_I1601_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN40 (XI0_I1601_bn5 I0_pp15_16 XI0_I1601_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN39 (XI0_I1601_bn4 I0_pp14_18 XI0_I1601_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN39_1 (XI0_I1601_bn5 I0_pp14_18 XI0_I1601_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN40_1 (XI0_I1601_bsn I0_pp15_16 XI0_I1601_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1601_MN53 (VSS XI0_I1601_bsn I0_cm240_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1601_MN29 (XI0_I1601_bn1 XI0_I1601_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN30 (XI0_I1601_bcon I0_pp14_18 XI0_I1601_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN33 (XI0_I1601_bn2 I0_pp15_16 XI0_I1601_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN31 (VSS XI0_I1601_s1 XI0_I1601_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN32 (XI0_I1601_bn2 I0_pp14_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1601_MN55 (VSS XI0_I1601_bcon I0_cm240_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1601_MN38 (XI0_I1601_bn4 XI0_I1601_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1601_MN38_1 (VSS XI0_I1601_s1 XI0_I1601_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1601_MN25 (VSS XI0_I1601_asn XI0_I1601_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1601_MN10 (VSS I0_cm194_1 XI0_I1601_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN6 (XI0_I1601_an3 I0_cm194_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN9 (XI0_I1601_asn XI0_I1601_acon XI0_I1601_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN12 (XI0_I1601_an5 I0_cm196_0 XI0_I1601_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN11 (XI0_I1601_an4 I0_fa195_1 XI0_I1601_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1601_MN11_1 (XI0_I1601_an5 I0_fa195_1 XI0_I1601_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1601_MN12_1 (XI0_I1601_asn I0_cm196_0 XI0_I1601_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1601_MN10_1 (XI0_I1601_an4 I0_cm194_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN5 (XI0_I1601_acon I0_cm196_0 XI0_I1601_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1601_MN2 (XI0_I1601_an1 I0_fa195_1 XI0_I1601_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN1 (VSS I0_cm194_1 XI0_I1601_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN3 (XI0_I1601_an2 I0_cm194_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN4 (VSS I0_fa195_1 XI0_I1601_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1601_MN27 (I0_cm240_2 XI0_I1601_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1601_MN7 (XI0_I1601_an3 I0_fa195_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1601_MN8 (VSS I0_cm196_0 XI0_I1601_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN34 (XI0_I1477_bn3 XI0_I1477_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN35 (VSS I0_pp13_20 XI0_I1477_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN36 (XI0_I1477_bn3 I0_cm114_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN37 (XI0_I1477_bsn XI0_I1477_bcon XI0_I1477_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN40 (XI0_I1477_bn5 I0_cm114_2 XI0_I1477_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN39 (XI0_I1477_bn4 I0_pp13_20 XI0_I1477_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN39_1 (XI0_I1477_bn5 I0_pp13_20 XI0_I1477_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN40_1 (XI0_I1477_bsn I0_cm114_2 XI0_I1477_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1477_MN53 (VSS XI0_I1477_bsn I0_cm116_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1477_MN29 (XI0_I1477_bn1 XI0_I1477_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN30 (XI0_I1477_bcon I0_pp13_20 XI0_I1477_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN33 (XI0_I1477_bn2 I0_cm114_2 XI0_I1477_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN31 (VSS XI0_I1477_s1 XI0_I1477_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN32 (XI0_I1477_bn2 I0_pp13_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1477_MN55 (VSS XI0_I1477_bcon I0_cm116_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1477_MN38 (XI0_I1477_bn4 XI0_I1477_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1477_MN38_1 (VSS XI0_I1477_s1 XI0_I1477_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1477_MN25 (VSS XI0_I1477_asn XI0_I1477_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1477_MN10 (VSS I0_pp10_26 XI0_I1477_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN6 (XI0_I1477_an3 I0_pp10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN9 (XI0_I1477_asn XI0_I1477_acon XI0_I1477_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN12 (XI0_I1477_an5 I0_pp12_22 XI0_I1477_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN11 (XI0_I1477_an4 I0_pp11_24 XI0_I1477_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1477_MN11_1 (XI0_I1477_an5 I0_pp11_24 XI0_I1477_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1477_MN12_1 (XI0_I1477_asn I0_pp12_22 XI0_I1477_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1477_MN10_1 (XI0_I1477_an4 I0_pp10_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN5 (XI0_I1477_acon I0_pp12_22 XI0_I1477_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1477_MN2 (XI0_I1477_an1 I0_pp11_24 XI0_I1477_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN1 (VSS I0_pp10_26 XI0_I1477_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN3 (XI0_I1477_an2 I0_pp10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN4 (VSS I0_pp11_24 XI0_I1477_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1477_MN27 (I0_cm116_2 XI0_I1477_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1477_MN7 (XI0_I1477_an3 I0_pp11_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1477_MN8 (VSS I0_pp12_22 XI0_I1477_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN34 (XI0_I1557_bn3 XI0_I1557_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN35 (VSS I0_cm116_0 XI0_I1557_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN36 (XI0_I1557_bn3 I0_cm194_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN37 (XI0_I1557_bsn XI0_I1557_bcon XI0_I1557_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN40 (XI0_I1557_bn5 I0_cm194_2 XI0_I1557_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN39 (XI0_I1557_bn4 I0_cm116_0 XI0_I1557_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN39_1 (XI0_I1557_bn5 I0_cm116_0 XI0_I1557_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN40_1 (XI0_I1557_bsn I0_cm194_2 XI0_I1557_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1557_MN53 (VSS XI0_I1557_bsn I0_cm196_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1557_MN29 (XI0_I1557_bn1 XI0_I1557_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN30 (XI0_I1557_bcon I0_cm116_0 XI0_I1557_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN33 (XI0_I1557_bn2 I0_cm194_2 XI0_I1557_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN31 (VSS XI0_I1557_s1 XI0_I1557_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN32 (XI0_I1557_bn2 I0_cm116_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1557_MN55 (VSS XI0_I1557_bcon I0_cm196_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1557_MN38 (XI0_I1557_bn4 XI0_I1557_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1557_MN38_1 (VSS XI0_I1557_s1 XI0_I1557_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1557_MN25 (VSS XI0_I1557_asn XI0_I1557_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1557_MN10 (VSS I0_cm113_1 XI0_I1557_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN6 (XI0_I1557_an3 I0_cm113_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN9 (XI0_I1557_asn XI0_I1557_acon XI0_I1557_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN12 (XI0_I1557_an5 I0_cm115_0 XI0_I1557_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN11 (XI0_I1557_an4 I0_cm114_1 XI0_I1557_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1557_MN11_1 (XI0_I1557_an5 I0_cm114_1 XI0_I1557_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1557_MN12_1 (XI0_I1557_asn I0_cm115_0 XI0_I1557_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1557_MN10_1 (XI0_I1557_an4 I0_cm113_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN5 (XI0_I1557_acon I0_cm115_0 XI0_I1557_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1557_MN2 (XI0_I1557_an1 I0_cm114_1 XI0_I1557_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN1 (VSS I0_cm113_1 XI0_I1557_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN3 (XI0_I1557_an2 I0_cm113_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN4 (VSS I0_cm114_1 XI0_I1557_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1557_MN27 (I0_cm196_2 XI0_I1557_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1557_MN7 (XI0_I1557_an3 I0_cm114_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1557_MN8 (VSS I0_cm115_0 XI0_I1557_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN34 (XI0_I1493_bn3 XI0_I1493_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN35 (VSS I0_pp14_28 XI0_I1493_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN36 (XI0_I1493_bn3 I0_cm131_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN37 (XI0_I1493_bsn XI0_I1493_bcon XI0_I1493_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN40 (XI0_I1493_bn5 I0_cm131_2 XI0_I1493_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN39 (XI0_I1493_bn4 I0_pp14_28 XI0_I1493_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN39_1 (XI0_I1493_bn5 I0_pp14_28 XI0_I1493_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN40_1 (XI0_I1493_bsn I0_cm131_2 XI0_I1493_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1493_MN53 (VSS XI0_I1493_bsn I0_cm132_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1493_MN29 (XI0_I1493_bn1 XI0_I1493_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN30 (XI0_I1493_bcon I0_pp14_28 XI0_I1493_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN33 (XI0_I1493_bn2 I0_cm131_2 XI0_I1493_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN31 (VSS XI0_I1493_s1 XI0_I1493_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN32 (XI0_I1493_bn2 I0_pp14_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1493_MN55 (VSS XI0_I1493_bcon I0_cm132_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1493_MN38 (XI0_I1493_bn4 XI0_I1493_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1493_MN38_1 (VSS XI0_I1493_s1 XI0_I1493_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1493_MN25 (VSS XI0_I1493_asn XI0_I1493_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1493_MN10 (VSS VDD XI0_I1493_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN6 (XI0_I1493_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN9 (XI0_I1493_asn XI0_I1493_acon XI0_I1493_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN12 (XI0_I1493_an5 I0_pp13_30 XI0_I1493_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN11 (XI0_I1493_an4 I0_pp12_32 XI0_I1493_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1493_MN11_1 (XI0_I1493_an5 I0_pp12_32 XI0_I1493_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1493_MN12_1 (XI0_I1493_asn I0_pp13_30 XI0_I1493_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1493_MN10_1 (XI0_I1493_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN5 (XI0_I1493_acon I0_pp13_30 XI0_I1493_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1493_MN2 (XI0_I1493_an1 I0_pp12_32 XI0_I1493_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN1 (VSS VDD XI0_I1493_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN3 (XI0_I1493_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN4 (VSS I0_pp12_32 XI0_I1493_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1493_MN27 (I0_cm132_2 XI0_I1493_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1493_MN7 (XI0_I1493_an3 I0_pp12_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1493_MN8 (VSS I0_pp13_30 XI0_I1493_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN34 (XI0_I1491_bn3 XI0_I1491_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN35 (VSS I0_pp13_28 XI0_I1491_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN36 (XI0_I1491_bn3 I0_cm129_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN37 (XI0_I1491_bsn XI0_I1491_bcon XI0_I1491_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN40 (XI0_I1491_bn5 I0_cm129_2 XI0_I1491_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN39 (XI0_I1491_bn4 I0_pp13_28 XI0_I1491_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN39_1 (XI0_I1491_bn5 I0_pp13_28 XI0_I1491_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN40_1 (XI0_I1491_bsn I0_cm129_2 XI0_I1491_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1491_MN53 (VSS XI0_I1491_bsn I0_cm130_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1491_MN29 (XI0_I1491_bn1 XI0_I1491_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN30 (XI0_I1491_bcon I0_pp13_28 XI0_I1491_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN33 (XI0_I1491_bn2 I0_cm129_2 XI0_I1491_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN31 (VSS XI0_I1491_s1 XI0_I1491_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN32 (XI0_I1491_bn2 I0_pp13_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1491_MN55 (VSS XI0_I1491_bcon I0_cm130_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1491_MN38 (XI0_I1491_bn4 XI0_I1491_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1491_MN38_1 (VSS XI0_I1491_s1 XI0_I1491_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1491_MN25 (VSS XI0_I1491_asn XI0_I1491_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1491_MN10 (VSS VDD XI0_I1491_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN6 (XI0_I1491_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN9 (XI0_I1491_asn XI0_I1491_acon XI0_I1491_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN12 (XI0_I1491_an5 I0_pp12_30 XI0_I1491_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN11 (XI0_I1491_an4 I0_pp11_32 XI0_I1491_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1491_MN11_1 (XI0_I1491_an5 I0_pp11_32 XI0_I1491_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1491_MN12_1 (XI0_I1491_asn I0_pp12_30 XI0_I1491_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1491_MN10_1 (XI0_I1491_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN5 (XI0_I1491_acon I0_pp12_30 XI0_I1491_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1491_MN2 (XI0_I1491_an1 I0_pp11_32 XI0_I1491_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN1 (VSS VDD XI0_I1491_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN3 (XI0_I1491_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN4 (VSS I0_pp11_32 XI0_I1491_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1491_MN27 (I0_cm130_2 XI0_I1491_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1491_MN7 (XI0_I1491_an3 I0_pp11_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1491_MN8 (VSS I0_pp12_30 XI0_I1491_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN34 (XI0_I1476_bn3 XI0_I1476_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN35 (VSS I0_pp9_28 XI0_I1476_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN36 (XI0_I1476_bn3 I0_cm113_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN37 (XI0_I1476_bsn XI0_I1476_bcon XI0_I1476_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN40 (XI0_I1476_bn5 I0_cm113_2 XI0_I1476_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN39 (XI0_I1476_bn4 I0_pp9_28 XI0_I1476_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN39_1 (XI0_I1476_bn5 I0_pp9_28 XI0_I1476_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN40_1 (XI0_I1476_bsn I0_cm113_2 XI0_I1476_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1476_MN53 (VSS XI0_I1476_bsn I0_cm115_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1476_MN29 (XI0_I1476_bn1 XI0_I1476_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN30 (XI0_I1476_bcon I0_pp9_28 XI0_I1476_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN33 (XI0_I1476_bn2 I0_cm113_2 XI0_I1476_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN31 (VSS XI0_I1476_s1 XI0_I1476_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN32 (XI0_I1476_bn2 I0_pp9_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1476_MN55 (VSS XI0_I1476_bcon I0_cm115_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1476_MN38 (XI0_I1476_bn4 XI0_I1476_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1476_MN38_1 (VSS XI0_I1476_s1 XI0_I1476_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1476_MN25 (VSS XI0_I1476_asn XI0_I1476_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1476_MN10 (VSS VDD XI0_I1476_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN6 (XI0_I1476_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN9 (XI0_I1476_asn XI0_I1476_acon XI0_I1476_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN12 (XI0_I1476_an5 I0_pp8_30 XI0_I1476_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN11 (XI0_I1476_an4 I0_pp7_32 XI0_I1476_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1476_MN11_1 (XI0_I1476_an5 I0_pp7_32 XI0_I1476_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1476_MN12_1 (XI0_I1476_asn I0_pp8_30 XI0_I1476_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1476_MN10_1 (XI0_I1476_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN5 (XI0_I1476_acon I0_pp8_30 XI0_I1476_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1476_MN2 (XI0_I1476_an1 I0_pp7_32 XI0_I1476_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN1 (VSS VDD XI0_I1476_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN3 (XI0_I1476_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN4 (VSS I0_pp7_32 XI0_I1476_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1476_MN27 (I0_cm115_2 XI0_I1476_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1476_MN7 (XI0_I1476_an3 I0_pp7_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1476_MN8 (VSS I0_pp8_30 XI0_I1476_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN34 (XI0_I1494_bn3 XI0_I1494_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN35 (VSS I0_pp15_27 XI0_I1494_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN36 (XI0_I1494_bn3 I0_cm132_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN37 (XI0_I1494_bsn XI0_I1494_bcon XI0_I1494_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN40 (XI0_I1494_bn5 I0_cm132_2 XI0_I1494_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN39 (XI0_I1494_bn4 I0_pp15_27 XI0_I1494_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN39_1 (XI0_I1494_bn5 I0_pp15_27 XI0_I1494_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN40_1 (XI0_I1494_bsn I0_cm132_2 XI0_I1494_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1494_MN53 (VSS XI0_I1494_bsn I0_cm133_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1494_MN29 (XI0_I1494_bn1 XI0_I1494_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN30 (XI0_I1494_bcon I0_pp15_27 XI0_I1494_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN33 (XI0_I1494_bn2 I0_cm132_2 XI0_I1494_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN31 (VSS XI0_I1494_s1 XI0_I1494_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN32 (XI0_I1494_bn2 I0_pp15_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1494_MN55 (VSS XI0_I1494_bcon I0_cm133_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1494_MN38 (XI0_I1494_bn4 XI0_I1494_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1494_MN38_1 (VSS XI0_I1494_s1 XI0_I1494_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1494_MN25 (VSS XI0_I1494_asn XI0_I1494_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1494_MN10 (VSS I0_sn12 XI0_I1494_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN6 (XI0_I1494_an3 I0_sn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN9 (XI0_I1494_asn XI0_I1494_acon XI0_I1494_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN12 (XI0_I1494_an5 I0_pp14_29 XI0_I1494_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN11 (XI0_I1494_an4 I0_pp13_31 XI0_I1494_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1494_MN11_1 (XI0_I1494_an5 I0_pp13_31 XI0_I1494_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1494_MN12_1 (XI0_I1494_asn I0_pp14_29 XI0_I1494_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1494_MN10_1 (XI0_I1494_an4 I0_sn12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN5 (XI0_I1494_acon I0_pp14_29 XI0_I1494_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1494_MN2 (XI0_I1494_an1 I0_pp13_31 XI0_I1494_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN1 (VSS I0_sn12 XI0_I1494_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN3 (XI0_I1494_an2 I0_sn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN4 (VSS I0_pp13_31 XI0_I1494_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1494_MN27 (I0_cm133_2 XI0_I1494_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1494_MN7 (XI0_I1494_an3 I0_pp13_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1494_MN8 (VSS I0_pp14_29 XI0_I1494_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN34 (XI0_I1490_bn3 XI0_I1490_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN35 (VSS I0_pp13_27 XI0_I1490_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN36 (XI0_I1490_bn3 I0_cm127_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN37 (XI0_I1490_bsn XI0_I1490_bcon XI0_I1490_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN40 (XI0_I1490_bn5 I0_cm127_2 XI0_I1490_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN39 (XI0_I1490_bn4 I0_pp13_27 XI0_I1490_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN39_1 (XI0_I1490_bn5 I0_pp13_27 XI0_I1490_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN40_1 (XI0_I1490_bsn I0_cm127_2 XI0_I1490_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1490_MN53 (VSS XI0_I1490_bsn I0_cm129_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1490_MN29 (XI0_I1490_bn1 XI0_I1490_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN30 (XI0_I1490_bcon I0_pp13_27 XI0_I1490_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN33 (XI0_I1490_bn2 I0_cm127_2 XI0_I1490_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN31 (VSS XI0_I1490_s1 XI0_I1490_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN32 (XI0_I1490_bn2 I0_pp13_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1490_MN55 (VSS XI0_I1490_bcon I0_cm129_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1490_MN38 (XI0_I1490_bn4 XI0_I1490_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1490_MN38_1 (VSS XI0_I1490_s1 XI0_I1490_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1490_MN25 (VSS XI0_I1490_asn XI0_I1490_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1490_MN10 (VSS I0_sn10 XI0_I1490_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN6 (XI0_I1490_an3 I0_sn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN9 (XI0_I1490_asn XI0_I1490_acon XI0_I1490_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN12 (XI0_I1490_an5 I0_pp12_29 XI0_I1490_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN11 (XI0_I1490_an4 I0_pp11_31 XI0_I1490_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1490_MN11_1 (XI0_I1490_an5 I0_pp11_31 XI0_I1490_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1490_MN12_1 (XI0_I1490_asn I0_pp12_29 XI0_I1490_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1490_MN10_1 (XI0_I1490_an4 I0_sn10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN5 (XI0_I1490_acon I0_pp12_29 XI0_I1490_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1490_MN2 (XI0_I1490_an1 I0_pp11_31 XI0_I1490_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN1 (VSS I0_sn10 XI0_I1490_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN3 (XI0_I1490_an2 I0_sn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN4 (VSS I0_pp11_31 XI0_I1490_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1490_MN27 (I0_cm129_2 XI0_I1490_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1490_MN7 (XI0_I1490_an3 I0_pp11_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1490_MN8 (VSS I0_pp12_29 XI0_I1490_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN34 (XI0_I1479_bn3 XI0_I1479_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN35 (VSS I0_pp14_19 XI0_I1479_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN36 (XI0_I1479_bn3 I0_cm116_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN37 (XI0_I1479_bsn XI0_I1479_bcon XI0_I1479_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN40 (XI0_I1479_bn5 I0_cm116_2 XI0_I1479_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN39 (XI0_I1479_bn4 I0_pp14_19 XI0_I1479_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN39_1 (XI0_I1479_bn5 I0_pp14_19 XI0_I1479_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN40_1 (XI0_I1479_bsn I0_cm116_2 XI0_I1479_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1479_MN53 (VSS XI0_I1479_bsn I0_cm118_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1479_MN29 (XI0_I1479_bn1 XI0_I1479_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN30 (XI0_I1479_bcon I0_pp14_19 XI0_I1479_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN33 (XI0_I1479_bn2 I0_cm116_2 XI0_I1479_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN31 (VSS XI0_I1479_s1 XI0_I1479_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN32 (XI0_I1479_bn2 I0_pp14_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1479_MN55 (VSS XI0_I1479_bcon I0_cm118_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1479_MN38 (XI0_I1479_bn4 XI0_I1479_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1479_MN38_1 (VSS XI0_I1479_s1 XI0_I1479_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1479_MN25 (VSS XI0_I1479_asn XI0_I1479_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1479_MN10 (VSS I0_pp11_25 XI0_I1479_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN6 (XI0_I1479_an3 I0_pp11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN9 (XI0_I1479_asn XI0_I1479_acon XI0_I1479_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN12 (XI0_I1479_an5 I0_pp13_21 XI0_I1479_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN11 (XI0_I1479_an4 I0_pp12_23 XI0_I1479_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1479_MN11_1 (XI0_I1479_an5 I0_pp12_23 XI0_I1479_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1479_MN12_1 (XI0_I1479_asn I0_pp13_21 XI0_I1479_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1479_MN10_1 (XI0_I1479_an4 I0_pp11_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN5 (XI0_I1479_acon I0_pp13_21 XI0_I1479_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1479_MN2 (XI0_I1479_an1 I0_pp12_23 XI0_I1479_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN1 (VSS I0_pp11_25 XI0_I1479_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN3 (XI0_I1479_an2 I0_pp11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN4 (VSS I0_pp12_23 XI0_I1479_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1479_MN27 (I0_cm118_2 XI0_I1479_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1479_MN7 (XI0_I1479_an3 I0_pp12_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1479_MN8 (VSS I0_pp13_21 XI0_I1479_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN34 (XI0_I1478_bn3 XI0_I1478_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN35 (VSS I0_pp10_27 XI0_I1478_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN36 (XI0_I1478_bn3 I0_cm115_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN37 (XI0_I1478_bsn XI0_I1478_bcon XI0_I1478_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN40 (XI0_I1478_bn5 I0_cm115_2 XI0_I1478_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN39 (XI0_I1478_bn4 I0_pp10_27 XI0_I1478_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN39_1 (XI0_I1478_bn5 I0_pp10_27 XI0_I1478_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN40_1 (XI0_I1478_bsn I0_cm115_2 XI0_I1478_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1478_MN53 (VSS XI0_I1478_bsn I0_cm117_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1478_MN29 (XI0_I1478_bn1 XI0_I1478_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN30 (XI0_I1478_bcon I0_pp10_27 XI0_I1478_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN33 (XI0_I1478_bn2 I0_cm115_2 XI0_I1478_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN31 (VSS XI0_I1478_s1 XI0_I1478_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN32 (XI0_I1478_bn2 I0_pp10_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1478_MN55 (VSS XI0_I1478_bcon I0_cm117_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1478_MN38 (XI0_I1478_bn4 XI0_I1478_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1478_MN38_1 (VSS XI0_I1478_s1 XI0_I1478_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1478_MN25 (VSS XI0_I1478_asn XI0_I1478_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1478_MN10 (VSS I0_sn7 XI0_I1478_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN6 (XI0_I1478_an3 I0_sn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN9 (XI0_I1478_asn XI0_I1478_acon XI0_I1478_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN12 (XI0_I1478_an5 I0_pp9_29 XI0_I1478_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN11 (XI0_I1478_an4 I0_pp8_31 XI0_I1478_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1478_MN11_1 (XI0_I1478_an5 I0_pp8_31 XI0_I1478_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1478_MN12_1 (XI0_I1478_asn I0_pp9_29 XI0_I1478_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1478_MN10_1 (XI0_I1478_an4 I0_sn7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN5 (XI0_I1478_acon I0_pp9_29 XI0_I1478_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1478_MN2 (XI0_I1478_an1 I0_pp8_31 XI0_I1478_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN1 (VSS I0_sn7 XI0_I1478_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN3 (XI0_I1478_an2 I0_sn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN4 (VSS I0_pp8_31 XI0_I1478_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1478_MN27 (I0_cm117_2 XI0_I1478_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1478_MN7 (XI0_I1478_an3 I0_pp8_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1478_MN8 (VSS I0_pp9_29 XI0_I1478_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN34 (XI0_I1495_bn3 XI0_I1495_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN35 (VSS I0_pp15_28 XI0_I1495_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN36 (XI0_I1495_bn3 I0_cm133_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN37 (XI0_I1495_bsn XI0_I1495_bcon XI0_I1495_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN40 (XI0_I1495_bn5 I0_cm133_2 XI0_I1495_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN39 (XI0_I1495_bn4 I0_pp15_28 XI0_I1495_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN39_1 (XI0_I1495_bn5 I0_pp15_28 XI0_I1495_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN40_1 (XI0_I1495_bsn I0_cm133_2 XI0_I1495_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1495_MN53 (VSS XI0_I1495_bsn I0_cm134_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1495_MN29 (XI0_I1495_bn1 XI0_I1495_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN30 (XI0_I1495_bcon I0_pp15_28 XI0_I1495_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN33 (XI0_I1495_bn2 I0_cm133_2 XI0_I1495_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN31 (VSS XI0_I1495_s1 XI0_I1495_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN32 (XI0_I1495_bn2 I0_pp15_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1495_MN55 (VSS XI0_I1495_bcon I0_cm134_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1495_MN38 (XI0_I1495_bn4 XI0_I1495_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1495_MN38_1 (VSS XI0_I1495_s1 XI0_I1495_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1495_MN25 (VSS XI0_I1495_asn XI0_I1495_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1495_MN10 (VSS VDD XI0_I1495_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN6 (XI0_I1495_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN9 (XI0_I1495_asn XI0_I1495_acon XI0_I1495_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN12 (XI0_I1495_an5 I0_pp14_30 XI0_I1495_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN11 (XI0_I1495_an4 I0_pp13_32 XI0_I1495_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1495_MN11_1 (XI0_I1495_an5 I0_pp13_32 XI0_I1495_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1495_MN12_1 (XI0_I1495_asn I0_pp14_30 XI0_I1495_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1495_MN10_1 (XI0_I1495_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN5 (XI0_I1495_acon I0_pp14_30 XI0_I1495_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1495_MN2 (XI0_I1495_an1 I0_pp13_32 XI0_I1495_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN1 (VSS VDD XI0_I1495_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN3 (XI0_I1495_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN4 (VSS I0_pp13_32 XI0_I1495_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1495_MN27 (I0_cm134_2 XI0_I1495_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1495_MN7 (XI0_I1495_an3 I0_pp13_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1495_MN8 (VSS I0_pp14_30 XI0_I1495_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN34 (XI0_I1558_bn3 XI0_I1558_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN35 (VSS I0_cm118_0 XI0_I1558_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN36 (XI0_I1558_bn3 I0_cm196_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN37 (XI0_I1558_bsn XI0_I1558_bcon XI0_I1558_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN40 (XI0_I1558_bn5 I0_cm196_2 XI0_I1558_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN39 (XI0_I1558_bn4 I0_cm118_0 XI0_I1558_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN39_1 (XI0_I1558_bn5 I0_cm118_0 XI0_I1558_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN40_1 (XI0_I1558_bsn I0_cm196_2 XI0_I1558_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1558_MN53 (VSS XI0_I1558_bsn I0_cm197_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1558_MN29 (XI0_I1558_bn1 XI0_I1558_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN30 (XI0_I1558_bcon I0_cm118_0 XI0_I1558_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN33 (XI0_I1558_bn2 I0_cm196_2 XI0_I1558_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN31 (VSS XI0_I1558_s1 XI0_I1558_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN32 (XI0_I1558_bn2 I0_cm118_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1558_MN55 (VSS XI0_I1558_bcon I0_cm197_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1558_MN38 (XI0_I1558_bn4 XI0_I1558_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1558_MN38_1 (VSS XI0_I1558_s1 XI0_I1558_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1558_MN25 (VSS XI0_I1558_asn XI0_I1558_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1558_MN10 (VSS I0_cm115_1 XI0_I1558_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN6 (XI0_I1558_an3 I0_cm115_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN9 (XI0_I1558_asn XI0_I1558_acon XI0_I1558_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN12 (XI0_I1558_an5 I0_cm117_0 XI0_I1558_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN11 (XI0_I1558_an4 I0_cm116_1 XI0_I1558_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1558_MN11_1 (XI0_I1558_an5 I0_cm116_1 XI0_I1558_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1558_MN12_1 (XI0_I1558_asn I0_cm117_0 XI0_I1558_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1558_MN10_1 (XI0_I1558_an4 I0_cm115_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN5 (XI0_I1558_acon I0_cm117_0 XI0_I1558_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1558_MN2 (XI0_I1558_an1 I0_cm116_1 XI0_I1558_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN1 (VSS I0_cm115_1 XI0_I1558_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN3 (XI0_I1558_an2 I0_cm115_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN4 (VSS I0_cm116_1 XI0_I1558_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1558_MN27 (I0_cm197_2 XI0_I1558_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1558_MN7 (XI0_I1558_an3 I0_cm116_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1558_MN8 (VSS I0_cm117_0 XI0_I1558_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN34 (XI0_I1559_bn3 XI0_I1559_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN35 (VSS I0_cm120_0 XI0_I1559_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN36 (XI0_I1559_bn3 I0_cm197_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN37 (XI0_I1559_bsn XI0_I1559_bcon XI0_I1559_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN40 (XI0_I1559_bn5 I0_cm197_2 XI0_I1559_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN39 (XI0_I1559_bn4 I0_cm120_0 XI0_I1559_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN39_1 (XI0_I1559_bn5 I0_cm120_0 XI0_I1559_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN40_1 (XI0_I1559_bsn I0_cm197_2 XI0_I1559_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1559_MN53 (VSS XI0_I1559_bsn I0_cm198_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1559_MN29 (XI0_I1559_bn1 XI0_I1559_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN30 (XI0_I1559_bcon I0_cm120_0 XI0_I1559_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN33 (XI0_I1559_bn2 I0_cm197_2 XI0_I1559_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN31 (VSS XI0_I1559_s1 XI0_I1559_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN32 (XI0_I1559_bn2 I0_cm120_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1559_MN55 (VSS XI0_I1559_bcon I0_cm198_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1559_MN38 (XI0_I1559_bn4 XI0_I1559_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1559_MN38_1 (VSS XI0_I1559_s1 XI0_I1559_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1559_MN25 (VSS XI0_I1559_asn XI0_I1559_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1559_MN10 (VSS I0_cm117_1 XI0_I1559_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN6 (XI0_I1559_an3 I0_cm117_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN9 (XI0_I1559_asn XI0_I1559_acon XI0_I1559_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN12 (XI0_I1559_an5 I0_cm119_0 XI0_I1559_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN11 (XI0_I1559_an4 I0_cm118_1 XI0_I1559_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1559_MN11_1 (XI0_I1559_an5 I0_cm118_1 XI0_I1559_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1559_MN12_1 (XI0_I1559_asn I0_cm119_0 XI0_I1559_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1559_MN10_1 (XI0_I1559_an4 I0_cm117_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN5 (XI0_I1559_acon I0_cm119_0 XI0_I1559_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1559_MN2 (XI0_I1559_an1 I0_cm118_1 XI0_I1559_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN1 (VSS I0_cm117_1 XI0_I1559_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN3 (XI0_I1559_an2 I0_cm117_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN4 (VSS I0_cm118_1 XI0_I1559_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1559_MN27 (I0_cm198_2 XI0_I1559_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1559_MN7 (XI0_I1559_an3 I0_cm118_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1559_MN8 (VSS I0_cm119_0 XI0_I1559_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN34 (XI0_I1565_bn3 XI0_I1565_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN35 (VSS I0_pp15_24 XI0_I1565_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN36 (XI0_I1565_bn3 I0_cm203_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN37 (XI0_I1565_bsn XI0_I1565_bcon XI0_I1565_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN40 (XI0_I1565_bn5 I0_cm203_2 XI0_I1565_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN39 (XI0_I1565_bn4 I0_pp15_24 XI0_I1565_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN39_1 (XI0_I1565_bn5 I0_pp15_24 XI0_I1565_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN40_1 (XI0_I1565_bsn I0_cm203_2 XI0_I1565_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1565_MN53 (VSS XI0_I1565_bsn I0_cm204_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1565_MN29 (XI0_I1565_bn1 XI0_I1565_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN30 (XI0_I1565_bcon I0_pp15_24 XI0_I1565_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN33 (XI0_I1565_bn2 I0_cm203_2 XI0_I1565_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN31 (VSS XI0_I1565_s1 XI0_I1565_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN32 (XI0_I1565_bn2 I0_pp15_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1565_MN55 (VSS XI0_I1565_bcon I0_cm204_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1565_MN38 (XI0_I1565_bn4 XI0_I1565_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1565_MN38_1 (VSS XI0_I1565_s1 XI0_I1565_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1565_MN25 (VSS XI0_I1565_asn XI0_I1565_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1565_MN10 (VSS I0_cm129_1 XI0_I1565_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN6 (XI0_I1565_an3 I0_cm129_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN9 (XI0_I1565_asn XI0_I1565_acon XI0_I1565_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN12 (XI0_I1565_an5 I0_pp14_26 XI0_I1565_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN11 (XI0_I1565_an4 I0_cm130_0 XI0_I1565_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1565_MN11_1 (XI0_I1565_an5 I0_cm130_0 XI0_I1565_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1565_MN12_1 (XI0_I1565_asn I0_pp14_26 XI0_I1565_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1565_MN10_1 (XI0_I1565_an4 I0_cm129_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN5 (XI0_I1565_acon I0_pp14_26 XI0_I1565_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1565_MN2 (XI0_I1565_an1 I0_cm130_0 XI0_I1565_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN1 (VSS I0_cm129_1 XI0_I1565_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN3 (XI0_I1565_an2 I0_cm129_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN4 (VSS I0_cm130_0 XI0_I1565_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1565_MN27 (I0_cm204_2 XI0_I1565_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1565_MN7 (XI0_I1565_an3 I0_cm130_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1565_MN8 (VSS I0_pp14_26 XI0_I1565_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN34 (XI0_I1483_bn3 XI0_I1483_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN35 (VSS I0_pp15_19 XI0_I1483_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN36 (XI0_I1483_bn3 I0_cm120_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN37 (XI0_I1483_bsn XI0_I1483_bcon XI0_I1483_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN40 (XI0_I1483_bn5 I0_cm120_2 XI0_I1483_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN39 (XI0_I1483_bn4 I0_pp15_19 XI0_I1483_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN39_1 (XI0_I1483_bn5 I0_pp15_19 XI0_I1483_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN40_1 (XI0_I1483_bsn I0_cm120_2 XI0_I1483_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1483_MN53 (VSS XI0_I1483_bsn I0_cm122_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1483_MN29 (XI0_I1483_bn1 XI0_I1483_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN30 (XI0_I1483_bcon I0_pp15_19 XI0_I1483_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN33 (XI0_I1483_bn2 I0_cm120_2 XI0_I1483_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN31 (VSS XI0_I1483_s1 XI0_I1483_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN32 (XI0_I1483_bn2 I0_pp15_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1483_MN55 (VSS XI0_I1483_bcon I0_cm122_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1483_MN38 (XI0_I1483_bn4 XI0_I1483_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1483_MN38_1 (VSS XI0_I1483_s1 XI0_I1483_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1483_MN25 (VSS XI0_I1483_asn XI0_I1483_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1483_MN10 (VSS I0_pp12_25 XI0_I1483_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN6 (XI0_I1483_an3 I0_pp12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN9 (XI0_I1483_asn XI0_I1483_acon XI0_I1483_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN12 (XI0_I1483_an5 I0_pp14_21 XI0_I1483_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN11 (XI0_I1483_an4 I0_pp13_23 XI0_I1483_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1483_MN11_1 (XI0_I1483_an5 I0_pp13_23 XI0_I1483_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1483_MN12_1 (XI0_I1483_asn I0_pp14_21 XI0_I1483_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1483_MN10_1 (XI0_I1483_an4 I0_pp12_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN5 (XI0_I1483_acon I0_pp14_21 XI0_I1483_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1483_MN2 (XI0_I1483_an1 I0_pp13_23 XI0_I1483_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN1 (VSS I0_pp12_25 XI0_I1483_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN3 (XI0_I1483_an2 I0_pp12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN4 (VSS I0_pp13_23 XI0_I1483_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1483_MN27 (I0_cm122_2 XI0_I1483_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1483_MN7 (XI0_I1483_an3 I0_pp13_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1483_MN8 (VSS I0_pp14_21 XI0_I1483_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN34 (XI0_I1481_bn3 XI0_I1481_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN35 (VSS I0_pp14_20 XI0_I1481_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN36 (XI0_I1481_bn3 I0_cm118_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN37 (XI0_I1481_bsn XI0_I1481_bcon XI0_I1481_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN40 (XI0_I1481_bn5 I0_cm118_2 XI0_I1481_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN39 (XI0_I1481_bn4 I0_pp14_20 XI0_I1481_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN39_1 (XI0_I1481_bn5 I0_pp14_20 XI0_I1481_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN40_1 (XI0_I1481_bsn I0_cm118_2 XI0_I1481_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1481_MN53 (VSS XI0_I1481_bsn I0_cm120_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1481_MN29 (XI0_I1481_bn1 XI0_I1481_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN30 (XI0_I1481_bcon I0_pp14_20 XI0_I1481_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN33 (XI0_I1481_bn2 I0_cm118_2 XI0_I1481_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN31 (VSS XI0_I1481_s1 XI0_I1481_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN32 (XI0_I1481_bn2 I0_pp14_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1481_MN55 (VSS XI0_I1481_bcon I0_cm120_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1481_MN38 (XI0_I1481_bn4 XI0_I1481_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1481_MN38_1 (VSS XI0_I1481_s1 XI0_I1481_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1481_MN25 (VSS XI0_I1481_asn XI0_I1481_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1481_MN10 (VSS I0_pp11_26 XI0_I1481_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN6 (XI0_I1481_an3 I0_pp11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN9 (XI0_I1481_asn XI0_I1481_acon XI0_I1481_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN12 (XI0_I1481_an5 I0_pp13_22 XI0_I1481_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN11 (XI0_I1481_an4 I0_pp12_24 XI0_I1481_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1481_MN11_1 (XI0_I1481_an5 I0_pp12_24 XI0_I1481_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1481_MN12_1 (XI0_I1481_asn I0_pp13_22 XI0_I1481_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1481_MN10_1 (XI0_I1481_an4 I0_pp11_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN5 (XI0_I1481_acon I0_pp13_22 XI0_I1481_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1481_MN2 (XI0_I1481_an1 I0_pp12_24 XI0_I1481_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN1 (VSS I0_pp11_26 XI0_I1481_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN3 (XI0_I1481_an2 I0_pp11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN4 (VSS I0_pp12_24 XI0_I1481_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1481_MN27 (I0_cm120_2 XI0_I1481_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1481_MN7 (XI0_I1481_an3 I0_pp12_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1481_MN8 (VSS I0_pp13_22 XI0_I1481_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN34 (XI0_I1480_bn3 XI0_I1480_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN35 (VSS I0_pp10_28 XI0_I1480_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN36 (XI0_I1480_bn3 I0_cm117_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN37 (XI0_I1480_bsn XI0_I1480_bcon XI0_I1480_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN40 (XI0_I1480_bn5 I0_cm117_2 XI0_I1480_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN39 (XI0_I1480_bn4 I0_pp10_28 XI0_I1480_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN39_1 (XI0_I1480_bn5 I0_pp10_28 XI0_I1480_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN40_1 (XI0_I1480_bsn I0_cm117_2 XI0_I1480_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1480_MN53 (VSS XI0_I1480_bsn I0_cm119_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1480_MN29 (XI0_I1480_bn1 XI0_I1480_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN30 (XI0_I1480_bcon I0_pp10_28 XI0_I1480_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN33 (XI0_I1480_bn2 I0_cm117_2 XI0_I1480_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN31 (VSS XI0_I1480_s1 XI0_I1480_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN32 (XI0_I1480_bn2 I0_pp10_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1480_MN55 (VSS XI0_I1480_bcon I0_cm119_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1480_MN38 (XI0_I1480_bn4 XI0_I1480_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1480_MN38_1 (VSS XI0_I1480_s1 XI0_I1480_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1480_MN25 (VSS XI0_I1480_asn XI0_I1480_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1480_MN10 (VSS VDD XI0_I1480_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN6 (XI0_I1480_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN9 (XI0_I1480_asn XI0_I1480_acon XI0_I1480_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN12 (XI0_I1480_an5 I0_pp9_30 XI0_I1480_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN11 (XI0_I1480_an4 I0_pp8_32 XI0_I1480_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1480_MN11_1 (XI0_I1480_an5 I0_pp8_32 XI0_I1480_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1480_MN12_1 (XI0_I1480_asn I0_pp9_30 XI0_I1480_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1480_MN10_1 (XI0_I1480_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN5 (XI0_I1480_acon I0_pp9_30 XI0_I1480_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1480_MN2 (XI0_I1480_an1 I0_pp8_32 XI0_I1480_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN1 (VSS VDD XI0_I1480_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN3 (XI0_I1480_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN4 (VSS I0_pp8_32 XI0_I1480_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1480_MN27 (I0_cm119_2 XI0_I1480_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1480_MN7 (XI0_I1480_an3 I0_pp8_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1480_MN8 (VSS I0_pp9_30 XI0_I1480_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN34 (XI0_I1564_bn3 XI0_I1564_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN35 (VSS I0_pp14_25 XI0_I1564_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN36 (XI0_I1564_bn3 I0_cm202_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN37 (XI0_I1564_bsn XI0_I1564_bcon XI0_I1564_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN40 (XI0_I1564_bn5 I0_cm202_2 XI0_I1564_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN39 (XI0_I1564_bn4 I0_pp14_25 XI0_I1564_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN39_1 (XI0_I1564_bn5 I0_pp14_25 XI0_I1564_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN40_1 (XI0_I1564_bsn I0_cm202_2 XI0_I1564_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1564_MN53 (VSS XI0_I1564_bsn I0_cm203_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1564_MN29 (XI0_I1564_bn1 XI0_I1564_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN30 (XI0_I1564_bcon I0_pp14_25 XI0_I1564_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN33 (XI0_I1564_bn2 I0_cm202_2 XI0_I1564_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN31 (VSS XI0_I1564_s1 XI0_I1564_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN32 (XI0_I1564_bn2 I0_pp14_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1564_MN55 (VSS XI0_I1564_bcon I0_cm203_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1564_MN38 (XI0_I1564_bn4 XI0_I1564_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1564_MN38_1 (VSS XI0_I1564_s1 XI0_I1564_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1564_MN25 (VSS XI0_I1564_asn XI0_I1564_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1564_MN10 (VSS I0_cm127_1 XI0_I1564_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN6 (XI0_I1564_an3 I0_cm127_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN9 (XI0_I1564_asn XI0_I1564_acon XI0_I1564_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN12 (XI0_I1564_an5 I0_cm129_0 XI0_I1564_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN11 (XI0_I1564_an4 I0_fa128_1 XI0_I1564_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1564_MN11_1 (XI0_I1564_an5 I0_fa128_1 XI0_I1564_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1564_MN12_1 (XI0_I1564_asn I0_cm129_0 XI0_I1564_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1564_MN10_1 (XI0_I1564_an4 I0_cm127_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN5 (XI0_I1564_acon I0_cm129_0 XI0_I1564_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1564_MN2 (XI0_I1564_an1 I0_fa128_1 XI0_I1564_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN1 (VSS I0_cm127_1 XI0_I1564_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN3 (XI0_I1564_an2 I0_cm127_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN4 (VSS I0_fa128_1 XI0_I1564_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1564_MN27 (I0_cm203_2 XI0_I1564_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1564_MN7 (XI0_I1564_an3 I0_fa128_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1564_MN8 (VSS I0_cm129_0 XI0_I1564_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN34 (XI0_I1488_bn3 XI0_I1488_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN35 (VSS I0_pp12_28 XI0_I1488_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN36 (XI0_I1488_bn3 I0_cm125_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN37 (XI0_I1488_bsn XI0_I1488_bcon XI0_I1488_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN40 (XI0_I1488_bn5 I0_cm125_2 XI0_I1488_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN39 (XI0_I1488_bn4 I0_pp12_28 XI0_I1488_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN39_1 (XI0_I1488_bn5 I0_pp12_28 XI0_I1488_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN40_1 (XI0_I1488_bsn I0_cm125_2 XI0_I1488_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1488_MN53 (VSS XI0_I1488_bsn I0_cm127_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1488_MN29 (XI0_I1488_bn1 XI0_I1488_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN30 (XI0_I1488_bcon I0_pp12_28 XI0_I1488_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN33 (XI0_I1488_bn2 I0_cm125_2 XI0_I1488_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN31 (VSS XI0_I1488_s1 XI0_I1488_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN32 (XI0_I1488_bn2 I0_pp12_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1488_MN55 (VSS XI0_I1488_bcon I0_cm127_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1488_MN38 (XI0_I1488_bn4 XI0_I1488_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1488_MN38_1 (VSS XI0_I1488_s1 XI0_I1488_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1488_MN25 (VSS XI0_I1488_asn XI0_I1488_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1488_MN10 (VSS VDD XI0_I1488_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN6 (XI0_I1488_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN9 (XI0_I1488_asn XI0_I1488_acon XI0_I1488_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN12 (XI0_I1488_an5 I0_pp11_30 XI0_I1488_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN11 (XI0_I1488_an4 I0_pp10_32 XI0_I1488_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1488_MN11_1 (XI0_I1488_an5 I0_pp10_32 XI0_I1488_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1488_MN12_1 (XI0_I1488_asn I0_pp11_30 XI0_I1488_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1488_MN10_1 (XI0_I1488_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN5 (XI0_I1488_acon I0_pp11_30 XI0_I1488_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1488_MN2 (XI0_I1488_an1 I0_pp10_32 XI0_I1488_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN1 (VSS VDD XI0_I1488_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN3 (XI0_I1488_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN4 (VSS I0_pp10_32 XI0_I1488_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1488_MN27 (I0_cm127_2 XI0_I1488_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1488_MN7 (XI0_I1488_an3 I0_pp10_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1488_MN8 (VSS I0_pp11_30 XI0_I1488_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN34 (XI0_I1485_bn3 XI0_I1485_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN35 (VSS I0_pp15_20 XI0_I1485_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN36 (XI0_I1485_bn3 I0_cm122_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN37 (XI0_I1485_bsn XI0_I1485_bcon XI0_I1485_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN40 (XI0_I1485_bn5 I0_cm122_2 XI0_I1485_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN39 (XI0_I1485_bn4 I0_pp15_20 XI0_I1485_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN39_1 (XI0_I1485_bn5 I0_pp15_20 XI0_I1485_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN40_1 (XI0_I1485_bsn I0_cm122_2 XI0_I1485_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1485_MN53 (VSS XI0_I1485_bsn I0_cm124_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1485_MN29 (XI0_I1485_bn1 XI0_I1485_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN30 (XI0_I1485_bcon I0_pp15_20 XI0_I1485_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN33 (XI0_I1485_bn2 I0_cm122_2 XI0_I1485_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN31 (VSS XI0_I1485_s1 XI0_I1485_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN32 (XI0_I1485_bn2 I0_pp15_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1485_MN55 (VSS XI0_I1485_bcon I0_cm124_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1485_MN38 (XI0_I1485_bn4 XI0_I1485_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1485_MN38_1 (VSS XI0_I1485_s1 XI0_I1485_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1485_MN25 (VSS XI0_I1485_asn XI0_I1485_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1485_MN10 (VSS I0_pp12_26 XI0_I1485_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN6 (XI0_I1485_an3 I0_pp12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN9 (XI0_I1485_asn XI0_I1485_acon XI0_I1485_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN12 (XI0_I1485_an5 I0_pp14_22 XI0_I1485_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN11 (XI0_I1485_an4 I0_pp13_24 XI0_I1485_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1485_MN11_1 (XI0_I1485_an5 I0_pp13_24 XI0_I1485_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1485_MN12_1 (XI0_I1485_asn I0_pp14_22 XI0_I1485_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1485_MN10_1 (XI0_I1485_an4 I0_pp12_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN5 (XI0_I1485_acon I0_pp14_22 XI0_I1485_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1485_MN2 (XI0_I1485_an1 I0_pp13_24 XI0_I1485_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN1 (VSS I0_pp12_26 XI0_I1485_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN3 (XI0_I1485_an2 I0_pp12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN4 (VSS I0_pp13_24 XI0_I1485_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1485_MN27 (I0_cm124_2 XI0_I1485_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1485_MN7 (XI0_I1485_an3 I0_pp13_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1485_MN8 (VSS I0_pp14_22 XI0_I1485_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN34 (XI0_I1560_bn3 XI0_I1560_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN35 (VSS I0_cm122_0 XI0_I1560_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN36 (XI0_I1560_bn3 I0_cm198_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN37 (XI0_I1560_bsn XI0_I1560_bcon XI0_I1560_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN40 (XI0_I1560_bn5 I0_cm198_2 XI0_I1560_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN39 (XI0_I1560_bn4 I0_cm122_0 XI0_I1560_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN39_1 (XI0_I1560_bn5 I0_cm122_0 XI0_I1560_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN40_1 (XI0_I1560_bsn I0_cm198_2 XI0_I1560_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1560_MN53 (VSS XI0_I1560_bsn I0_cm199_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1560_MN29 (XI0_I1560_bn1 XI0_I1560_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN30 (XI0_I1560_bcon I0_cm122_0 XI0_I1560_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN33 (XI0_I1560_bn2 I0_cm198_2 XI0_I1560_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN31 (VSS XI0_I1560_s1 XI0_I1560_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN32 (XI0_I1560_bn2 I0_cm122_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1560_MN55 (VSS XI0_I1560_bcon I0_cm199_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1560_MN38 (XI0_I1560_bn4 XI0_I1560_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1560_MN38_1 (VSS XI0_I1560_s1 XI0_I1560_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1560_MN25 (VSS XI0_I1560_asn XI0_I1560_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1560_MN10 (VSS I0_cm119_1 XI0_I1560_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN6 (XI0_I1560_an3 I0_cm119_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN9 (XI0_I1560_asn XI0_I1560_acon XI0_I1560_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN12 (XI0_I1560_an5 I0_cm121_0 XI0_I1560_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN11 (XI0_I1560_an4 I0_cm120_1 XI0_I1560_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1560_MN11_1 (XI0_I1560_an5 I0_cm120_1 XI0_I1560_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1560_MN12_1 (XI0_I1560_asn I0_cm121_0 XI0_I1560_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1560_MN10_1 (XI0_I1560_an4 I0_cm119_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN5 (XI0_I1560_acon I0_cm121_0 XI0_I1560_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1560_MN2 (XI0_I1560_an1 I0_cm120_1 XI0_I1560_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN1 (VSS I0_cm119_1 XI0_I1560_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN3 (XI0_I1560_an2 I0_cm119_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN4 (VSS I0_cm120_1 XI0_I1560_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1560_MN27 (I0_cm199_2 XI0_I1560_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1560_MN7 (XI0_I1560_an3 I0_cm120_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1560_MN8 (VSS I0_cm121_0 XI0_I1560_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN34 (XI0_I1561_bn3 XI0_I1561_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN35 (VSS I0_cm124_0 XI0_I1561_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN36 (XI0_I1561_bn3 I0_cm199_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN37 (XI0_I1561_bsn XI0_I1561_bcon XI0_I1561_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN40 (XI0_I1561_bn5 I0_cm199_2 XI0_I1561_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN39 (XI0_I1561_bn4 I0_cm124_0 XI0_I1561_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN39_1 (XI0_I1561_bn5 I0_cm124_0 XI0_I1561_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN40_1 (XI0_I1561_bsn I0_cm199_2 XI0_I1561_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1561_MN53 (VSS XI0_I1561_bsn I0_cm200_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1561_MN29 (XI0_I1561_bn1 XI0_I1561_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN30 (XI0_I1561_bcon I0_cm124_0 XI0_I1561_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN33 (XI0_I1561_bn2 I0_cm199_2 XI0_I1561_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN31 (VSS XI0_I1561_s1 XI0_I1561_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN32 (XI0_I1561_bn2 I0_cm124_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1561_MN55 (VSS XI0_I1561_bcon I0_cm200_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1561_MN38 (XI0_I1561_bn4 XI0_I1561_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1561_MN38_1 (VSS XI0_I1561_s1 XI0_I1561_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1561_MN25 (VSS XI0_I1561_asn XI0_I1561_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1561_MN10 (VSS I0_cm121_1 XI0_I1561_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN6 (XI0_I1561_an3 I0_cm121_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN9 (XI0_I1561_asn XI0_I1561_acon XI0_I1561_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN12 (XI0_I1561_an5 I0_cm123_0 XI0_I1561_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN11 (XI0_I1561_an4 I0_cm122_1 XI0_I1561_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1561_MN11_1 (XI0_I1561_an5 I0_cm122_1 XI0_I1561_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1561_MN12_1 (XI0_I1561_asn I0_cm123_0 XI0_I1561_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1561_MN10_1 (XI0_I1561_an4 I0_cm121_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN5 (XI0_I1561_acon I0_cm123_0 XI0_I1561_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1561_MN2 (XI0_I1561_an1 I0_cm122_1 XI0_I1561_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN1 (VSS I0_cm121_1 XI0_I1561_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN3 (XI0_I1561_an2 I0_cm121_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN4 (VSS I0_cm122_1 XI0_I1561_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1561_MN27 (I0_cm200_2 XI0_I1561_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1561_MN7 (XI0_I1561_an3 I0_cm122_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1561_MN8 (VSS I0_cm123_0 XI0_I1561_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN34 (XI0_I1482_bn3 XI0_I1482_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN35 (VSS I0_pp11_27 XI0_I1482_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN36 (XI0_I1482_bn3 I0_cm119_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN37 (XI0_I1482_bsn XI0_I1482_bcon XI0_I1482_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN40 (XI0_I1482_bn5 I0_cm119_2 XI0_I1482_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN39 (XI0_I1482_bn4 I0_pp11_27 XI0_I1482_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN39_1 (XI0_I1482_bn5 I0_pp11_27 XI0_I1482_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN40_1 (XI0_I1482_bsn I0_cm119_2 XI0_I1482_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1482_MN53 (VSS XI0_I1482_bsn I0_cm121_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1482_MN29 (XI0_I1482_bn1 XI0_I1482_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN30 (XI0_I1482_bcon I0_pp11_27 XI0_I1482_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN33 (XI0_I1482_bn2 I0_cm119_2 XI0_I1482_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN31 (VSS XI0_I1482_s1 XI0_I1482_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN32 (XI0_I1482_bn2 I0_pp11_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1482_MN55 (VSS XI0_I1482_bcon I0_cm121_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1482_MN38 (XI0_I1482_bn4 XI0_I1482_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1482_MN38_1 (VSS XI0_I1482_s1 XI0_I1482_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1482_MN25 (VSS XI0_I1482_asn XI0_I1482_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1482_MN10 (VSS I0_sn8 XI0_I1482_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN6 (XI0_I1482_an3 I0_sn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN9 (XI0_I1482_asn XI0_I1482_acon XI0_I1482_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN12 (XI0_I1482_an5 I0_pp10_29 XI0_I1482_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN11 (XI0_I1482_an4 I0_pp9_31 XI0_I1482_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1482_MN11_1 (XI0_I1482_an5 I0_pp9_31 XI0_I1482_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1482_MN12_1 (XI0_I1482_asn I0_pp10_29 XI0_I1482_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1482_MN10_1 (XI0_I1482_an4 I0_sn8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN5 (XI0_I1482_acon I0_pp10_29 XI0_I1482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1482_MN2 (XI0_I1482_an1 I0_pp9_31 XI0_I1482_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN1 (VSS I0_sn8 XI0_I1482_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN3 (XI0_I1482_an2 I0_sn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN4 (VSS I0_pp9_31 XI0_I1482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1482_MN27 (I0_cm121_2 XI0_I1482_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1482_MN7 (XI0_I1482_an3 I0_pp9_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1482_MN8 (VSS I0_pp10_29 XI0_I1482_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN34 (XI0_I1563_bn3 XI0_I1563_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN35 (VSS I0_fa128_0 XI0_I1563_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN36 (XI0_I1563_bn3 I0_cm201_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN37 (XI0_I1563_bsn XI0_I1563_bcon XI0_I1563_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN40 (XI0_I1563_bn5 I0_cm201_2 XI0_I1563_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN39 (XI0_I1563_bn4 I0_fa128_0 XI0_I1563_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN39_1 (XI0_I1563_bn5 I0_fa128_0 XI0_I1563_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN40_1 (XI0_I1563_bsn I0_cm201_2 XI0_I1563_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1563_MN53 (VSS XI0_I1563_bsn I0_cm202_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1563_MN29 (XI0_I1563_bn1 XI0_I1563_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN30 (XI0_I1563_bcon I0_fa128_0 XI0_I1563_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN33 (XI0_I1563_bn2 I0_cm201_2 XI0_I1563_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN31 (VSS XI0_I1563_s1 XI0_I1563_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN32 (XI0_I1563_bn2 I0_fa128_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1563_MN55 (VSS XI0_I1563_bcon I0_cm202_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1563_MN38 (XI0_I1563_bn4 XI0_I1563_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1563_MN38_1 (VSS XI0_I1563_s1 XI0_I1563_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1563_MN25 (VSS XI0_I1563_asn XI0_I1563_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1563_MN10 (VSS I0_cm125_1 XI0_I1563_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN6 (XI0_I1563_an3 I0_cm125_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN9 (XI0_I1563_asn XI0_I1563_acon XI0_I1563_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN12 (XI0_I1563_an5 I0_cm127_0 XI0_I1563_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN11 (XI0_I1563_an4 I0_fa126_1 XI0_I1563_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1563_MN11_1 (XI0_I1563_an5 I0_fa126_1 XI0_I1563_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1563_MN12_1 (XI0_I1563_asn I0_cm127_0 XI0_I1563_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1563_MN10_1 (XI0_I1563_an4 I0_cm125_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN5 (XI0_I1563_acon I0_cm127_0 XI0_I1563_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1563_MN2 (XI0_I1563_an1 I0_fa126_1 XI0_I1563_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN1 (VSS I0_cm125_1 XI0_I1563_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN3 (XI0_I1563_an2 I0_cm125_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN4 (VSS I0_fa126_1 XI0_I1563_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1563_MN27 (I0_cm202_2 XI0_I1563_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1563_MN7 (XI0_I1563_an3 I0_fa126_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1563_MN8 (VSS I0_cm127_0 XI0_I1563_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN34 (XI0_I1486_bn3 XI0_I1486_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN35 (VSS I0_pp12_27 XI0_I1486_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN36 (XI0_I1486_bn3 I0_cm123_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN37 (XI0_I1486_bsn XI0_I1486_bcon XI0_I1486_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN40 (XI0_I1486_bn5 I0_cm123_2 XI0_I1486_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN39 (XI0_I1486_bn4 I0_pp12_27 XI0_I1486_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN39_1 (XI0_I1486_bn5 I0_pp12_27 XI0_I1486_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN40_1 (XI0_I1486_bsn I0_cm123_2 XI0_I1486_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1486_MN53 (VSS XI0_I1486_bsn I0_cm125_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1486_MN29 (XI0_I1486_bn1 XI0_I1486_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN30 (XI0_I1486_bcon I0_pp12_27 XI0_I1486_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN33 (XI0_I1486_bn2 I0_cm123_2 XI0_I1486_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN31 (VSS XI0_I1486_s1 XI0_I1486_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN32 (XI0_I1486_bn2 I0_pp12_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1486_MN55 (VSS XI0_I1486_bcon I0_cm125_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1486_MN38 (XI0_I1486_bn4 XI0_I1486_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1486_MN38_1 (VSS XI0_I1486_s1 XI0_I1486_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1486_MN25 (VSS XI0_I1486_asn XI0_I1486_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1486_MN10 (VSS I0_sn9 XI0_I1486_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN6 (XI0_I1486_an3 I0_sn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN9 (XI0_I1486_asn XI0_I1486_acon XI0_I1486_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN12 (XI0_I1486_an5 I0_pp11_29 XI0_I1486_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN11 (XI0_I1486_an4 I0_pp10_31 XI0_I1486_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1486_MN11_1 (XI0_I1486_an5 I0_pp10_31 XI0_I1486_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1486_MN12_1 (XI0_I1486_asn I0_pp11_29 XI0_I1486_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1486_MN10_1 (XI0_I1486_an4 I0_sn9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN5 (XI0_I1486_acon I0_pp11_29 XI0_I1486_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1486_MN2 (XI0_I1486_an1 I0_pp10_31 XI0_I1486_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN1 (VSS I0_sn9 XI0_I1486_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN3 (XI0_I1486_an2 I0_sn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN4 (VSS I0_pp10_31 XI0_I1486_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1486_MN27 (I0_cm125_2 XI0_I1486_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1486_MN7 (XI0_I1486_an3 I0_pp10_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1486_MN8 (VSS I0_pp11_29 XI0_I1486_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN34 (XI0_I1562_bn3 XI0_I1562_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN35 (VSS I0_fa126_0 XI0_I1562_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN36 (XI0_I1562_bn3 I0_cm200_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN37 (XI0_I1562_bsn XI0_I1562_bcon XI0_I1562_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN40 (XI0_I1562_bn5 I0_cm200_2 XI0_I1562_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN39 (XI0_I1562_bn4 I0_fa126_0 XI0_I1562_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN39_1 (XI0_I1562_bn5 I0_fa126_0 XI0_I1562_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN40_1 (XI0_I1562_bsn I0_cm200_2 XI0_I1562_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1562_MN53 (VSS XI0_I1562_bsn I0_cm201_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1562_MN29 (XI0_I1562_bn1 XI0_I1562_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN30 (XI0_I1562_bcon I0_fa126_0 XI0_I1562_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN33 (XI0_I1562_bn2 I0_cm200_2 XI0_I1562_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN31 (VSS XI0_I1562_s1 XI0_I1562_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN32 (XI0_I1562_bn2 I0_fa126_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1562_MN55 (VSS XI0_I1562_bcon I0_cm201_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1562_MN38 (XI0_I1562_bn4 XI0_I1562_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1562_MN38_1 (VSS XI0_I1562_s1 XI0_I1562_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1562_MN25 (VSS XI0_I1562_asn XI0_I1562_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1562_MN10 (VSS I0_cm123_1 XI0_I1562_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN6 (XI0_I1562_an3 I0_cm123_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN9 (XI0_I1562_asn XI0_I1562_acon XI0_I1562_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN12 (XI0_I1562_an5 I0_cm125_0 XI0_I1562_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN11 (XI0_I1562_an4 I0_cm124_1 XI0_I1562_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1562_MN11_1 (XI0_I1562_an5 I0_cm124_1 XI0_I1562_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1562_MN12_1 (XI0_I1562_asn I0_cm125_0 XI0_I1562_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1562_MN10_1 (XI0_I1562_an4 I0_cm123_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN5 (XI0_I1562_acon I0_cm125_0 XI0_I1562_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1562_MN2 (XI0_I1562_an1 I0_cm124_1 XI0_I1562_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN1 (VSS I0_cm123_1 XI0_I1562_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN3 (XI0_I1562_an2 I0_cm123_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN4 (VSS I0_cm124_1 XI0_I1562_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1562_MN27 (I0_cm201_2 XI0_I1562_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1562_MN7 (XI0_I1562_an3 I0_cm124_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1562_MN8 (VSS I0_cm125_0 XI0_I1562_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN34 (XI0_I1484_bn3 XI0_I1484_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN35 (VSS I0_pp11_28 XI0_I1484_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN36 (XI0_I1484_bn3 I0_cm121_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN37 (XI0_I1484_bsn XI0_I1484_bcon XI0_I1484_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN40 (XI0_I1484_bn5 I0_cm121_2 XI0_I1484_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN39 (XI0_I1484_bn4 I0_pp11_28 XI0_I1484_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN39_1 (XI0_I1484_bn5 I0_pp11_28 XI0_I1484_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN40_1 (XI0_I1484_bsn I0_cm121_2 XI0_I1484_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1484_MN53 (VSS XI0_I1484_bsn I0_cm123_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1484_MN29 (XI0_I1484_bn1 XI0_I1484_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN30 (XI0_I1484_bcon I0_pp11_28 XI0_I1484_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN33 (XI0_I1484_bn2 I0_cm121_2 XI0_I1484_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN31 (VSS XI0_I1484_s1 XI0_I1484_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN32 (XI0_I1484_bn2 I0_pp11_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1484_MN55 (VSS XI0_I1484_bcon I0_cm123_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1484_MN38 (XI0_I1484_bn4 XI0_I1484_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1484_MN38_1 (VSS XI0_I1484_s1 XI0_I1484_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1484_MN25 (VSS XI0_I1484_asn XI0_I1484_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1484_MN10 (VSS VDD XI0_I1484_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN6 (XI0_I1484_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN9 (XI0_I1484_asn XI0_I1484_acon XI0_I1484_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN12 (XI0_I1484_an5 I0_pp10_30 XI0_I1484_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN11 (XI0_I1484_an4 I0_pp9_32 XI0_I1484_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1484_MN11_1 (XI0_I1484_an5 I0_pp9_32 XI0_I1484_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1484_MN12_1 (XI0_I1484_asn I0_pp10_30 XI0_I1484_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1484_MN10_1 (XI0_I1484_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN5 (XI0_I1484_acon I0_pp10_30 XI0_I1484_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1484_MN2 (XI0_I1484_an1 I0_pp9_32 XI0_I1484_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN1 (VSS VDD XI0_I1484_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN3 (XI0_I1484_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN4 (VSS I0_pp9_32 XI0_I1484_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1484_MN27 (I0_cm123_2 XI0_I1484_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1484_MN7 (XI0_I1484_an3 I0_pp9_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1484_MN8 (VSS I0_pp10_30 XI0_I1484_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I193_MN0 (I1_I838_G7_0n I1_I838_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I189_MN0 (I1_I838_G5_0n I1_I838_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I161_MN0 (I1_I838_G3_0np I1_I838_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I796_MN0 (I1_qu26_b0 I1_qu26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I193_MN0 (I1_I1344_G7_0n I1_I1344_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1348_MN0 (I1_qu14_b0 I1_qu14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1302_MN0 (I1_qu15_b0 I1_qu15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1256_MN0 (I1_qu16_b0 I1_qu16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I842_MN0 (I1_qu25_b0 I1_qu25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I193_MN0 (I1_I792_G7_0n I1_I792_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I161_MN0 (I1_I1344_G3_0np I1_I1344_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I129_MN0 (I1_I838_G1_0n I1_I838_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I189_MN0 (I1_I792_G5_0n I1_I792_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I191_MN0 (I1_I792_G6_0n I1_I792_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I161_MN0 (I1_I792_G3_0np I1_I792_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I187_MN0 (I1_I792_G4_0n I1_I792_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I191_MN0 (I1_I746_G6_0n I1_I746_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I189_MN0 (I1_I1344_G5_0n I1_I1344_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I193_MN0 (I1_I1298_G7_0n I1_I1298_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I191_MN0 (I1_I1252_G6_0n I1_I1252_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I193_MN0 (I1_I1252_G7_0n I1_I1252_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I189_MN0 (I1_I1298_G5_0n I1_I1298_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I191_MN0 (I1_I1298_G6_0n I1_I1298_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I189_MN0 (I1_I1252_G5_0n I1_I1252_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I191_MN0 (I1_I838_G6_0n I1_I838_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I159_MN0 (I1_I792_G2_0np I1_I792_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I159_MN0 (I1_I746_G2_0np I1_I746_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I187_MN0 (I1_I746_G4_0n I1_I746_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I129_MN0 (I1_I1344_G1_0n I1_I1344_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I187_MN0 (I1_I1298_G4_0n I1_I1298_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I193_MN0 (I1_I1206_G7_0n I1_I1206_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I189_MN0 (I1_I1206_G5_0n I1_I1206_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I187_MN0 (I1_I838_G4_0n I1_I838_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I159_MN0 (I1_I838_G2_0np I1_I838_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I129_MN0 (I1_I792_G1_0n I1_I792_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I161_MN0 (I1_I1298_G3_0np I1_I1298_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I187_MN0 (I1_I1252_G4_0n I1_I1252_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I191_MN0 (I1_I1206_G6_0n I1_I1206_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I66_MN0 (I1_I838_G0_0n I1_I838_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I189_MN0 (I1_I746_G5_0n I1_I746_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I159_MN0 (I1_I1252_G2_0np I1_I1252_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I161_MN0 (I1_I1252_G3_0np I1_I1252_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I161_MN0 (I1_I1206_G3_0np I1_I1206_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I159_MN0 (I1_I1206_G2_0np I1_I1206_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I187_MN0 (I1_I1206_G4_0n I1_I1206_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I66_MN0 (I1_I792_G0_0n I1_I792_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I66_MN0 (I1_I746_G0_0n I1_I746_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I129_MN0 (I1_I746_G1_0n I1_I746_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I161_MN0 (I1_I746_G3_0np I1_I746_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I191_MN0 (I1_I1344_G6_0n I1_I1344_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I187_MN0 (I1_I1344_G4_0n I1_I1344_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I159_MN0 (I1_I1298_G2_0np I1_I1298_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I129_MN0 (I1_I1206_G1_0n I1_I1206_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I193_MN0 (I1_I746_G7_0n I1_I746_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I159_MN0 (I1_I1344_G2_0np I1_I1344_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I129_MN0 (I1_I1298_G1_0n I1_I1298_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I129_MN0 (I1_I1252_G1_0n I1_I1252_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I750_MN0 (I1_qu27_b0 I1_qu27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I704_MN0 (I1_qu28_b0 I1_qu28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1164_MN0 (I1_qu18_b0 I1_qu18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1210_MN0 (I1_qu17_b0 I1_qu17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I193_MN0 (I1_I884_G7_0n I1_I884_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I189_MN0 (I1_I884_G5_0n I1_I884_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I161_MN0 (I1_I884_G3_0np I1_I884_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I193_MN0 (I1_I700_G7_0n I1_I700_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I161_MN0 (I1_I1160_G3_0np I1_I1160_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I66_MN0 (I1_I1206_G0_0n I1_I1206_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I129_MN0 (I1_I884_G1_0n I1_I884_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I161_MN0 (I1_I700_G3_0np I1_I700_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I189_MN0 (I1_I700_G5_0n I1_I700_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I66_MN0 (I1_I1252_G0_0n I1_I1252_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I193_MN0 (I1_I1160_G7_0n I1_I1160_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I189_MN0 (I1_I1160_G5_0n I1_I1160_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I888_MN0 (I1_qu24_b0 I1_qu24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I191_MN0 (I1_I884_G6_0n I1_I884_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I187_MN0 (I1_I884_G4_0n I1_I884_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I159_MN0 (I1_I884_G2_0np I1_I884_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I129_MN0 (I1_I700_G1_0n I1_I700_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I66_MN0 (I1_I1298_G0_0n I1_I1298_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I129_MN0 (I1_I1160_G1_0n I1_I1160_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I66_MN0 (I1_I884_G0_0n I1_I884_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I64_MN0 (I1_I792_cinn I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I159_MN0 (I1_I700_G2_0np I1_I700_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I187_MN0 (I1_I700_G4_0n I1_I700_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I191_MN0 (I1_I700_G6_0n I1_I700_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I193_MN0 (I1_I1390_G7_0n I1_I1390_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I189_MN0 (I1_I1390_G5_0n I1_I1390_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I161_MN0 (I1_I1390_G3_0np I1_I1390_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I66_MN0 (I1_I1344_G0_0n I1_I1344_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I64_MN0 (I1_I1252_cinn I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I64_MN0 (I1_I1206_cinn I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I66_MN0 (I1_I700_G0_0n I1_I700_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I129_MN0 (I1_I1390_G1_0n I1_I1390_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I64_MN0 (I1_I1298_cinn I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I191_MN0 (I1_I1160_G6_0n I1_I1160_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I187_MN0 (I1_I1160_G4_0n I1_I1160_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I66_MN0 (I1_I1160_G0_0n I1_I1160_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I64_MN0 (I1_I838_cinn I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I159_MN0 (I1_I1160_G2_0np I1_I1160_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1160_I64_MN0 (I1_I1160_cinn I1_qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I64_MN0 (I1_I746_cinn I1_qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1394_MN0 (I1_qu13_b0 I1_qu13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I191_MN0 (I1_I1390_G6_0n I1_I1390_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I187_MN0 (I1_I1390_G4_0n I1_I1390_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I159_MN0 (I1_I1390_G2_0np I1_I1390_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I193_MN0 (I1_I930_G7_0n I1_I930_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I189_MN0 (I1_I930_G5_0n I1_I930_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I161_MN0 (I1_I930_G3_0np I1_I930_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I129_MN0 (I1_I930_G1_0n I1_I930_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I66_MN0 (I1_I1390_G0_0n I1_I1390_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I64_MN0 (I1_I1344_cinn I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I934_MN0 (I1_qu23_b0 I1_qu23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I700_I64_MN0 (I1_I700_cinn I1_qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I129_MN0 (I1_I654_G1_0n I1_I654_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I161_MN0 (I1_I654_G3_0np I1_I654_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I189_MN0 (I1_I654_G5_0n I1_I654_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I193_MN0 (I1_I654_G7_0n I1_I654_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I658_MN0 (I1_qu29_b0 I1_qu29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1390_I64_MN0 (I1_I1390_cinn I1_qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I191_MN0 (I1_I930_G6_0n I1_I930_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I187_MN0 (I1_I930_G4_0n I1_I930_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I159_MN0 (I1_I930_G2_0np I1_I930_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I66_MN0 (I1_I654_G0_0n I1_I654_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I187_MN0 (I1_I654_G4_0n I1_I654_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I191_MN0 (I1_I1114_G6_0n I1_I1114_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1118_MN0 (I1_qu19_b0 I1_qu19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I884_I64_MN0 (I1_I884_cinn I1_qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I66_MN0 (I1_I930_G0_0n I1_I930_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I159_MN0 (I1_I654_G2_0np I1_I654_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I191_MN0 (I1_I654_G6_0n I1_I654_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I191_MN0 (I1_I1436_G6_0n I1_I1436_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I159_MN0 (I1_I1436_G2_0np I1_I1436_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1072_MN0 (I1_qu20_b0 I1_qu20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I187_MN0 (I1_I1436_G4_0n I1_I1436_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I66_MN0 (I1_I1436_G0_0n I1_I1436_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I189_MN0 (I1_I1436_G5_0n I1_I1436_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I64_MN0 (I1_I1436_cinn I1_qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I193_MN0 (I1_I1114_G7_0n I1_I1114_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I191_MN0 (I1_I1068_G6_0n I1_I1068_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I193_MN0 (I1_I1068_G7_0n I1_I1068_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I980_MN0 (I1_qu22_b0 I1_qu22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I193_MN0 (I1_I976_G7_0n I1_I976_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I189_MN0 (I1_I976_G5_0n I1_I976_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I654_I64_MN0 (I1_I654_cinn I1_qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I161_MN0 (I1_I1436_G3_0np I1_I1436_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I129_MN0 (I1_I1436_G1_0n I1_I1436_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I189_MN0 (I1_I1114_G5_0n I1_I1114_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I159_MN0 (I1_I1114_G2_0np I1_I1114_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I161_MN0 (I1_I976_G3_0np I1_I976_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I129_MN0 (I1_I976_G1_0n I1_I976_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I66_MN0 (I1_I608_G0_0n I1_I608_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I159_MN0 (I1_I608_G2_0np I1_I608_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I187_MN0 (I1_I608_G4_0n I1_I608_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I191_MN0 (I1_I608_G6_0n I1_I608_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1436_I193_MN0 (I1_I1436_G7_0n I1_I1436_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I187_MN0 (I1_I1114_G4_0n I1_I1114_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I187_MN0 (I1_I1068_G4_0n I1_I1068_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I189_MN0 (I1_I1068_G5_0n I1_I1068_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I612_MN0 (I1_qu30_b0 I1_qu30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1440_MN0 (I1_qu12_b0 I1_qu12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I161_MN0 (I1_I1114_G3_0np I1_I1114_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I161_MN0 (I1_I1068_G3_0np I1_I1068_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1026_MN0 (I1_qu21_b0 I1_qu21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I191_MN0 (I1_I976_G6_0n I1_I976_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I129_MN0 (I1_I1114_G1_0n I1_I1114_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I159_MN0 (I1_I1068_G2_0np I1_I1068_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I187_MN0 (I1_I976_G4_0n I1_I976_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I159_MN0 (I1_I976_G2_0np I1_I976_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I64_MN0 (I1_I608_cinn I1_qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I129_MN0 (I1_I608_G1_0n I1_I608_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I161_MN0 (I1_I608_G3_0np I1_I608_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I189_MN0 (I1_I608_G5_0n I1_I608_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I608_I193_MN0 (I1_I608_G7_0n I1_I608_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I193_MN0 (I1_I1482_G7_0n I1_I1482_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I189_MN0 (I1_I1482_G5_0n I1_I1482_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I161_MN0 (I1_I1482_G3_0np I1_I1482_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I129_MN0 (I1_I1482_G1_0n I1_I1482_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I66_MN0 (I1_I1114_G0_0n I1_I1114_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I191_MN0 (I1_I1022_G6_0n I1_I1022_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I193_MN0 (I1_I1022_G7_0n I1_I1022_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I66_MN0 (I1_I976_G0_0n I1_I976_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I930_I64_MN0 (I1_I930_cinn I1_qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1486_MN0 (I1_qu11_b0 I1_qu11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I66_MN0 (I1_I1482_G0_0n I1_I1482_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I64_MN0 (I1_I1482_cinn I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I129_MN0 (I1_I1068_G1_0n I1_I1068_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1114_I64_MN0 (I1_I1114_cinn I1_qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I161_MN0 (I1_I1022_G3_0np I1_I1022_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I187_MN0 (I1_I1482_G4_0n I1_I1482_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I159_MN0 (I1_I1482_G2_0np I1_I1482_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I66_MN0 (I1_I1068_G0_0n I1_I1068_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1068_I64_MN0 (I1_I1068_cinn I1_qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I159_MN0 (I1_I1022_G2_0np I1_I1022_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I187_MN0 (I1_I1022_G4_0n I1_I1022_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I189_MN0 (I1_I1022_G5_0n I1_I1022_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I976_I64_MN0 (I1_I976_cinn I1_qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1482_I191_MN0 (I1_I1482_G6_0n I1_I1482_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I66_MN0 (I1_I1022_G0_0n I1_I1022_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I129_MN0 (I1_I1022_G1_0n I1_I1022_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2158_MN0 (I1_nqk27 I1_nqkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2161_MN0 (I1_nqk28 I1_nqkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2164_MN0 (I1_nqk29 I1_nqkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2167_MN0 (I1_nqk30 I1_nqkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I66_MN0 (I1_I562_G0_0n I1_I562_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I159_MN0 (I1_I1528_G2_0np I1_I1528_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2125_MN0 (I1_nqk16 I1_nqkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2128_MN0 (I1_nqk17 I1_nqkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2131_MN0 (I1_nqk18 I1_nqkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2134_MN0 (I1_nqk19 I1_nqkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2137_MN0 (I1_nqk20 I1_nqkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2140_MN0 (I1_nqk21 I1_nqkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I364_MN0 (I1_dd19_b0 I1_dd19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I377_MN0 (I1_dd20_b0 I1_dd20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1022_I64_MN0 (I1_I1022_cinn I1_qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I494_MN0 (I1_dd29_b0 I1_dd29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2143_MN0 (I1_nqk22 I1_nqkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2146_MN0 (I1_nqk23 I1_nqkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2149_MN0 (I1_nqk24 I1_nqkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2152_MN0 (I1_nqk25 I1_nqkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2155_MN0 (I1_nqk26 I1_nqkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2293_MN0 (I1_sqn I1_sq_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I104_MN0 (I1_nak23 I1_nakn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I125_MN0 (I1_nak30 I1_nakn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I122_MN0 (I1_nak29 I1_nakn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I64_MN0 (I1_I562_cinn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I159_MN0 (I1_I562_G2_0np I1_I562_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I187_MN0 (I1_I562_G4_0n I1_I562_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I191_MN0 (I1_I562_G6_0n I1_I562_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I191_MN0 (I1_I1528_G6_0n I1_I1528_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I187_MN0 (I1_I1528_G4_0n I1_I1528_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I66_MN0 (I1_I1528_G0_0n I1_I1528_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I64_MN0 (I1_I1528_cinn I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2119_MN0 (I1_nqk14 I1_nqkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2122_MN0 (I1_nqk15 I1_nqkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I260_MN0 (I1_dd11_b0 I1_dd11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I221_MN0 (I1_dd8_b0 I1_dd8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I273_MN0 (I1_dd12_b0 I1_dd12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I208_MN0 (I1_dd7_b0 I1_dd7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I195_MN0 (I1_dd6_b0 I1_dd6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I169_MN0 (I1_dd4_b0 I1_dd4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I286_MN0 (I1_dd13_b0 I1_dd13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I299_MN0 (I1_dd14_b0 I1_dd14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I143_MN0 (I1_dd2_b0 I1_dd2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I130_MN0 (I1_dd1_b0 I1_dd1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I312_MN0 (I1_dd15_b0 I1_dd15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I403_MN0 (I1_dd22_b0 I1_dd22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I89_MN0 (I1_nak18 I1_nakn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I507_MN0 (I1_dd30_b0 I1_dd30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I92_MN0 (I1_nak19 I1_nakn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I390_MN0 (I1_dd21_b0 I1_dd21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I520_MN0 (I1_dd31_b0 I1_dd31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I95_MN0 (I1_nak20 I1_nakn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2068_MN0 (I1_sq_b0 I1_sq VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I481_MN0 (I1_dd28_b0 I1_dd28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I98_MN0 (I1_nak21 I1_nakn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I517_MN0 (I1_nbk30 I1_nbkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I504_MN0 (I1_nbk29 I1_nbkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I491_MN0 (I1_nbk28 I1_nbkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I117_MN0 (I2_OR_19 I2_I2_nor19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I101_MN0 (I1_nak22 I1_nakn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I119_MN0 (I2_NOT_19 A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I113_MN0 (I2_NOT_18 A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I125_MN0 (I2_NOT_20 A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I107_MN0 (I1_nak24 I1_nakn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I110_MN0 (I1_nak25 I1_nakn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I113_MN0 (I1_nak26 I1_nakn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I119_MN0 (I1_nak28 I1_nakn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I77_MN0 (I1_nak14 I1_nakn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I80_MN0 (I1_nak15 I1_nakn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2116_MN0 (I1_nqk13 I1_nqkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I247_MN0 (I1_dd10_b0 I1_dd10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I234_MN0 (I1_dd9_b0 I1_dd9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I83_MN0 (I1_nak16 I1_nakn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I182_MN0 (I1_dd5_b0 I1_dd5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I156_MN0 (I1_dd3_b0 I1_dd3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I309_MN0 (I1_nbk14 I1_nbkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I322_MN0 (I1_nbk15 I1_nbkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I325_MN0 (I1_dd16_b0 I1_dd16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I86_MN0 (I1_nak17 I1_nakn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I338_MN0 (I1_dd17_b0 I1_dd17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I351_MN0 (I1_dd18_b0 I1_dd18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I416_MN0 (I1_dd23_b0 I1_dd23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I361_MN0 (I1_nbk18 I1_nbkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I374_MN0 (I1_nbk19 I1_nbkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I387_MN0 (I1_nbk20 I1_nbkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I400_MN0 (I1_nbk21 I1_nbkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I413_MN0 (I1_nbk22 I1_nbkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I442_MN0 (I1_dd25_b0 I1_dd25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I426_MN0 (I1_nbk23 I1_nbkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I455_MN0 (I1_dd26_b0 I1_dd26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I468_MN0 (I1_dd27_b0 I1_dd27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I478_MN0 (I1_nbk27 I1_nbkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I115_MN0 (I2_AND_19 I2_I2_nand19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I109_MN0 (I2_AND_18 I2_I2_nand18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I121_MN0 (I2_AND_20 I2_I2_nand20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I116_MN0 (I1_nak27 I1_nakn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I133_MN0 (I2_AND_22 I2_I2_nand22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I129_MN0 (I1_I1528_G1_0n I1_I1528_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I161_MN0 (I1_I1574_G3_0np I1_I1574_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I74_MN0 (I1_nak13 I1_nakn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I71_MN0 (I1_nak12 I1_nakn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2113_MN0 (I1_nqk12 I1_nqkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I257_MN0 (I1_nbk10 I1_nbkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I270_MN0 (I1_nbk11 I1_nbkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I192_MN0 (I1_nbk5 I1_nbkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I283_MN0 (I1_nbk12 I1_nbkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I179_MN0 (I1_nbk4 I1_nbkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I296_MN0 (I1_nbk13 I1_nbkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I335_MN0 (I1_nbk16 I1_nbkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I348_MN0 (I1_nbk17 I1_nbkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I429_MN0 (I1_dd24_b0 I1_dd24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I439_MN0 (I1_nbk24 I1_nbkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I452_MN0 (I1_nbk25 I1_nbkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I465_MN0 (I1_nbk26 I1_nbkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I127_MN0 (I2_AND_21 I2_I2_nand21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I129_MN0 (I2_OR_21 I2_I2_nor21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I131_MN0 (I2_NOT_21 A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I111_MN0 (I2_OR_18 I2_I2_nor18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I101_MN0 (I2_NOT_16 A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I123_MN0 (I2_OR_20 I2_I2_nor20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I139_MN0 (I2_AND_23 I2_I2_nand23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I143_MN0 (I2_NOT_23 A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I137_MN0 (I2_NOT_22 A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I193_MN0 (I1_I1712_G7_0n I1_I1712_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I193_MN0 (I1_I1574_G7_0n I1_I1574_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2110_MN0 (I1_nqk11 I1_nqkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I244_MN0 (I1_nbk9 I1_nbkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I231_MN0 (I1_nbk8 I1_nbkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I218_MN0 (I1_nbk7 I1_nbkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I205_MN0 (I1_nbk6 I1_nbkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I166_MN0 (I1_nbk3 I1_nbkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I153_MN0 (I1_nbk2 I1_nbkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I140_MN0 (I1_nbk1 I1_nbkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I103_MN0 (I2_AND_17 I2_I2_nand17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I141_MN0 (I2_OR_23 I2_I2_nor23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I155_MN0 (I2_NOT_25 A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I135_MN0 (I2_OR_22 I2_I2_nor22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I163_MN0 (I2_AND_27 I2_I2_nand27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I175_MN0 (I2_AND_29 I2_I2_nand29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I129_MN0 (I1_I562_G1_0n I1_I562_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I189_MN0 (I1_I562_G5_0n I1_I562_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I161_MN0 (I1_I1712_G3_0np I1_I1712_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I193_MN0 (I1_I1528_G7_0n I1_I1528_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I189_MN0 (I1_I1528_G5_0n I1_I1528_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1528_I161_MN0 (I1_I1528_G3_0np I1_I1528_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I68_MN0 (I1_nak11 I1_nakn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I65_MN0 (I1_nak10 I1_nakn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I83_MN0 (I2_NOT_13 A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I95_MN0 (I2_NOT_15 A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I187_MN0 (I2_I1_I42_G4_0n I2_I1_I42_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I16_MN0 (I1_B_31_b0 B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I105_MN0 (I2_OR_17 I2_I2_nor17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I107_MN0 (I2_NOT_17 A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I99_MN0 (I2_OR_16 I2_I2_nor16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I97_MN0 (I2_AND_16 I2_I2_nand16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I151_MN0 (I2_AND_25 I2_I2_nand25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I153_MN0 (I2_OR_25 I2_I2_nor25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I149_MN0 (I2_NOT_24 A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I161_MN0 (I2_NOT_26 A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I165_MN0 (I2_OR_27 I2_I2_nor27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I177_MN0 (I2_OR_29 I2_I2_nor29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I179_MN0 (I2_NOT_29 A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I161_MN0 (I1_I562_G3_0np I1_I562_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I129_MN0 (I1_I1712_G1_0n I1_I1712_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1532_MN0 (I1_qu10_b0 I1_qu10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I189_MN0 (I1_I1574_G5_0n I1_I1574_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I129_MN0 (I1_I1574_G1_0n I1_I1574_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I81_MN0 (I2_OR_13 I2_I2_nor13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I93_MN0 (I2_OR_15 I2_I2_nor15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I89_MN0 (I2_NOT_14 A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I191_MN0 (I2_I1_I42_G6_0n I2_I1_I42_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I145_MN0 (I2_AND_24 I2_I2_nand24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I185_MN0 (I2_NOT_30 A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I167_MN0 (I2_NOT_27 A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I169_MN0 (I2_AND_28 I2_I2_nand28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I173_MN0 (I2_NOT_28 A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I452_MN0 (I0_B_27_b0 B_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I442_MN0 (I0_B_25_b0 B_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I432_MN0 (I0_B_23_b0 B_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I190_MN0 (I0_A_18_b0 A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I180_MN0 (I0_A_17_b0 A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I200_MN0 (I0_A_19_b0 A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I220_MN0 (I0_A_21_b0 A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I210_MN0 (I0_A_20_b0 A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I230_MN0 (I0_A_22_b0 A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I566_MN0 (I1_qu31_b0 I1_qu31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I402_MN0 (I0_B_17_b0 B_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I412_MN0 (I0_B_19_b0 B_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I4_I71_MN0 (DZ I2_I4_dzn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I189_MN0 (I1_I1712_G5_0n I1_I1712_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I187_MN0 (I1_I1712_G4_0n I1_I1712_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I79_MN0 (I2_AND_13 I2_I2_nand13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I77_MN0 (I2_NOT_12 A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I91_MN0 (I2_AND_15 I2_I2_nand15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I0_MN0 (I2_I1_SUB_b0 OP_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I10_MN0 (I2_I3_SEL_OR_b0 I2_SEL_OR VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I30_MN0 (I2_I3_SEL_NOT_b0 I2_SEL_NOT VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I20_MN0 (I2_I3_SEL_XOR_b0 I2_SEL_XOR VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I0_MN0 (I2_I3_SEL_AND_b0 I2_SEL_AND VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I147_MN0 (I2_OR_24 I2_I2_nor24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I157_MN0 (I2_AND_26 I2_I2_nand26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I171_MN0 (I2_OR_28 I2_I2_nor28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I462_MN0 (I0_B_29_b0 B_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I170_MN0 (I0_A_16_b0 A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I260_MN0 (I0_A_25_b0 A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I240_MN0 (I0_A_23_b0 A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I280_MN0 (I0_A_27_b0 A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I562_I193_MN0 (I1_I562_G7_0n I1_I562_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I250_MN0 (I0_A_24_b0 A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I422_MN0 (I0_B_21_b0 B_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I290_MN0 (I0_A_28_b0 A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I159_MN0 (I1_I1712_G2_0np I1_I1712_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I66_MN0 (I1_I1712_G0_0n I1_I1712_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I71_MN0 (I2_NOT_11 A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I87_MN0 (I2_OR_14 I2_I2_nor14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I160_MN0 (I0_A_15_b0 A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I72_MN0 (I2_I3_SEL_AS_b0 I2_SEL_AS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I0_I1_MN0 (I2_I0_opn1 OP_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I0_I0_MN0 (I2_I0_opn0 OP_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I0_I3_MN0 (I2_I0_opn3 OP_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I0_I2_MN0 (I2_I0_opn2 OP_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I159_MN0 (I2_OR_26 I2_I2_nor26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I4_I65_MN0 (C I2_I4_cn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I183_MN0 (I2_OR_30 I2_I2_nor30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I181_MN0 (I2_AND_30 I2_I2_nand30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I189_MN0 (I2_OR_31 I2_I2_nor31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I187_MN0 (I2_AND_31 I2_I2_nand31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I191_MN0 (I2_NOT_31 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I591_MN0 (I0_sn1 I0_pp1_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I270_MN0 (I0_A_26_b0 A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I310_MN0 (I0_A_30_b0 A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I300_MN0 (I0_A_29_b0 A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I187_MN0 (I1_I1574_G4_0n I1_I1574_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I66_MN0 (I1_I1574_G0_0n I1_I1574_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I75_MN0 (I2_OR_12 I2_I2_nor12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I69_MN0 (I2_OR_11 I2_I2_nor11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I85_MN0 (I2_AND_14 I2_I2_nand14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I159_MN0 (I2_I1_I42_G2_0np I2_I1_I42_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I189_MN0 (I2_I1_I42_G5_0n I2_I1_I42_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I150_MN0 (I0_A_14_b0 A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I392_MN0 (I0_B_15_b0 B_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I382_MN0 (I0_B_13_b0 B_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I56_MN0 (I2_I3_SEL_DIV_b0 I2_SEL_DIV VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I472_MN0 (I0_B_31_b0 B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I536_MN0 (I0_sn0 I0_pp0_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I320_MN0 (I0_A_31_b0 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I191_MN0 (I1_I1712_G6_0n I1_I1712_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I64_MN0 (I1_I1666_cinn I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I159_MN0 (I1_I1574_G2_0np I1_I1574_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I73_MN0 (I2_AND_12 I2_I2_nand12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I67_MN0 (I2_AND_11 I2_I2_nand11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I372_MN0 (I0_B_11_b0 B_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I120_MN0 (I0_A_11_b0 A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I161_MN0 (I2_I1_I42_G3_0np I2_I1_I42_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I140_MN0 (I0_A_13_b0 A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I193_MN0 (I2_I1_I42_G7_0n I2_I1_I42_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I130_MN0 (I0_A_12_b0 A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I3_I40_MN0 (I2_I3_SEL_MUL_b0 I2_SEL_MUL VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I0_MN0 (I1_A_31_b0 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1712_I64_MN0 (I1_I1712_cinn I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1578_MN0 (I1_qu9_b0 I1_qu9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I191_MN0 (I1_I1574_G6_0n I1_I1574_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1574_I64_MN0 (I1_I1574_cinn I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I62_MN0 (I1_nak9 I1_nakn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I593_MN0 (I0_one2_b0 I0_one2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I603_MN0 (I0_two2_b0 I0_two2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I758_MN0 (I0_one5_b0 I0_one5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I648_MN0 (I0_one3_b0 I0_one3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I658_MN0 (I0_two3_b0 I0_two3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I813_MN0 (I0_one6_b0 I0_one6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I823_MN0 (I0_two6_b0 I0_two6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I646_MN0 (I0_sn2 I0_pp2_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I66_MN0 (I1_I1666_G0_0n I1_I1666_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I53_MN0 (I1_nak6 I1_nakn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I56_MN0 (I1_nak7 I1_nakn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I59_MN0 (I1_nak8 I1_nakn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I342_MN0 (I0_B_5_b0 B_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I352_MN0 (I0_B_7_b0 B_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I332_MN0 (I0_B_3_b0 B_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I0_MN0 (I0_B_1_b0 B_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I548_MN0 (I0_two1_b0 I0_two1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I538_MN0 (I0_one1_b0 I0_one1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I129_MN0 (I2_I1_I42_G1_0n I2_I1_I42_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I768_MN0 (I0_two5_b0 I0_two5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I701_MN0 (I0_sn3 I0_pp3_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I159_MN0 (I1_I1666_G2_0np I1_I1666_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I129_MN0 (I1_I1666_G1_0n I1_I1666_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I64_MN0 (I1_I1620_cinn I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I703_MN0 (I0_one4_b0 I0_one4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1716_MN0 (I1_qu6_b0 I1_qu6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I57_MN0 (I2_OR_9 I2_I2_nor9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I49_MN0 (I2_AND_8 I2_I2_nand8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I51_MN0 (I2_OR_8 I2_I2_nor8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I26_MN0 (I1_B_0_b0 B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I66_MN0 (I2_I1_I42_G0_0n I2_I1_I42_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I362_MN0 (I0_B_9_b0 B_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I483_MN0 (I0_one0_b0 I0_one0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I493_MN0 (I0_two0_b0 I0_two0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I868_MN0 (I0_one7_b0 I0_one7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I878_MN0 (I0_two7_b0 I0_two7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1670_MN0 (I1_qu7_b0 I1_qu7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I187_MN0 (I1_I1666_G4_0n I1_I1666_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I161_MN0 (I1_I1666_G3_0np I1_I1666_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I55_MN0 (I2_AND_9 I2_I2_nand9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I61_MN0 (I2_AND_10 I2_I2_nand10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I43_MN0 (I2_AND_7 I2_I2_nand7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I713_MN0 (I0_two4_b0 I0_two4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I756_MN0 (I0_sn4 I0_pp4_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I189_MN0 (I1_I1666_G5_0n I1_I1666_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1624_MN0 (I1_qu8_b0 I1_qu8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I66_MN0 (I1_I1620_G0_0n I1_I1620_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I63_MN0 (I2_OR_10 I2_I2_nor10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I47_MN0 (I2_NOT_7 A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I45_MN0 (I2_OR_7 I2_I2_nor7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I37_MN0 (I2_AND_6 I2_I2_nand6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I39_MN0 (I2_OR_6 I2_I2_nor6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I159_MN0 (I1_I1620_G2_0np I1_I1620_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I65_MN0 (I2_NOT_10 A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I110_MN0 (I0_A_10_b0 A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I191_MN0 (I1_I1666_G6_0n I1_I1666_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I191_MN0 (I1_I1620_G6_0n I1_I1620_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2107_MN0 (I1_nqk10 I1_nqkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I59_MN0 (I2_NOT_9 A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I53_MN0 (I2_NOT_8 A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I41_MN0 (I2_NOT_6 A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I1_I42_I64_MN0 (I2_I1_I42_cinn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I811_MN0 (I0_sn5 I0_pp5_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I193_MN0 (I1_I1758_G7_0n I1_I1758_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1666_I193_MN0 (I1_I1666_G7_0n I1_I1666_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I187_MN0 (I1_I1620_G4_0n I1_I1620_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I129_MN0 (I1_I1620_G1_0n I1_I1620_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2104_MN0 (I1_nqk9 I1_nqkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I80_MN0 (I0_A_7_b0 A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I189_MN0 (I1_I1758_G5_0n I1_I1758_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I161_MN0 (I1_I1758_G3_0np I1_I1758_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I161_MN0 (I1_I1620_G3_0np I1_I1620_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2101_MN0 (I1_nqk8 I1_nqkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I33_MN0 (I2_OR_5 I2_I2_nor5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I31_MN0 (I2_AND_5 I2_I2_nand5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I100_MN0 (I0_A_9_b0 A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I90_MN0 (I0_A_8_b0 A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I70_MN0 (I0_A_6_b0 A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I129_MN0 (I1_I1758_G1_0n I1_I1758_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I189_MN0 (I1_I1620_G5_0n I1_I1620_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2098_MN0 (I1_nqk7 I1_nqkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I3_MN0 (I2_OR_0 I2_I2_nor0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1762_MN0 (I1_qu5_b0 I1_qu5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2095_MN0 (I1_nqk6 I1_nqkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I35_MN0 (I2_NOT_5 A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I7_MN0 (I2_AND_1 I2_I2_nand1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I19_MN0 (I2_AND_3 I2_I2_nand3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I5_MN0 (I2_NOT_0 A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I13_MN0 (I2_AND_2 I2_I2_nand2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I25_MN0 (I2_AND_4 I2_I2_nand4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I1_MN0 (I2_AND_0 I2_I2_nand0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I191_MN0 (I1_I1758_G6_0n I1_I1758_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I187_MN0 (I1_I1758_G4_0n I1_I1758_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I159_MN0 (I1_I1758_G2_0np I1_I1758_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1620_I193_MN0 (I1_I1620_G7_0n I1_I1620_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I50_MN0 (I1_nak5 I1_nakn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I9_MN0 (I2_OR_1 I2_I2_nor1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I15_MN0 (I2_OR_2 I2_I2_nor2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I27_MN0 (I2_OR_4 I2_I2_nor4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I60_MN0 (I0_A_5_b0 A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I933_MN0 (I0_two8_b0 I0_two8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I923_MN0 (I0_one8_b0 I0_one8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I66_MN0 (I1_I1758_G0_0n I1_I1758_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1758_I64_MN0 (I1_I1758_cinn I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I47_MN0 (I1_nak4 I1_nakn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2092_MN0 (I1_nqk5 I1_nqkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I21_MN0 (I2_OR_3 I2_I2_nor3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I23_MN0 (I2_NOT_3 A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I17_MN0 (I2_NOT_2 A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I29_MN0 (I2_NOT_4 A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I50_MN0 (I0_A_4_b0 A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I20_MN0 (I0_A_1_b0 A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1033_MN0 (I0_one10_b0 I0_one10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I41_MN0 (I1_nak2 I1_nakn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I44_MN0 (I1_nak3 I1_nakn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I2_I11_MN0 (I2_NOT_1 A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I40_MN0 (I0_A_3_b0 A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I128_MN0 (I0_I1660_cinn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I988_MN0 (I0_two9_b0 I0_two9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1043_MN0 (I0_two10_b0 I0_two10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I64_MN0 (I1_I1804_cinn I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I64_MN0 (I1_I1896_cinn I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I38_MN0 (I1_nak1 I1_nakn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2089_MN0 (I1_nqk4 I1_nqkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2086_MN0 (I1_nqk3 I1_nqkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2083_MN0 (I1_nqk2 I1_nqkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2080_MN0 (I1_nqk1 I1_nqkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I10_MN0 (I0_A_0_b0 A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I30_MN0 (I0_A_2_b0 A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I978_MN0 (I0_one9_b0 I0_one9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I64_MN0 (I1_I1850_cinn I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I64_MN0 (I1_I1942_cinn I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2001_MN0 (DIVQ_0 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2005_MN0 (I1_dm1 I1_dmn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I66_MN0 (I1_I1804_G0_0n I1_I1804_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2007_MN0 (I1_dm2 I1_dmn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I64_MN0 (I1_I1988_cinn I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2003_MN0 (I1_dm0 I1_dmn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I64_MN0 (I1_I2066_cinn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I191_MN0 (I1_I1804_G6_0n I1_I1804_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I187_MN0 (I1_I1804_G4_0n I1_I1804_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I159_MN0 (I1_I1804_G2_0np I1_I1804_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I66_MN0 (I1_I1896_G0_0n I1_I1896_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I66_MN0 (I1_I1942_G0_0n I1_I1942_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2011_MN0 (I1_dm4 I1_dmn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2009_MN0 (I1_dm3 I1_dmn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I129_MN0 (I1_I1942_G1_0n I1_I1942_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I66_MN0 (I1_I1988_G0_0n I1_I1988_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2015_MN0 (I1_dm6 I1_dmn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2013_MN0 (I1_dm5 I1_dmn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I385_MN0 (I0_I1660_G7_0n I0_I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I129_MN0 (I1_I1804_G1_0n I1_I1804_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I159_MN0 (I1_I1942_G2_0np I1_I1942_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I129_MN0 (I1_I1988_G1_0n I1_I1988_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2021_MN0 (I1_dm9 I1_dmn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2019_MN0 (I1_dm8 I1_dmn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2017_MN0 (I1_dm7 I1_dmn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I257_MN0 (I0_I1660_G1_0n I0_I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I321_MN0 (I0_I1660_G3_0np I0_I1660_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I381_MN0 (I0_I1660_G5_0n I0_I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1088_MN0 (I0_one11_b0 I0_one11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I189_MN0 (I1_I1804_G5_0n I1_I1804_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I129_MN0 (I1_I1896_G1_0n I1_I1896_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I161_MN0 (I1_I1942_G3_0np I1_I1942_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I159_MN0 (I1_I1988_G2_0np I1_I1988_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2023_MN0 (I1_dm10 I1_dmn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I130_MN0 (I0_I1660_G0_0n I0_I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2172_MN0 (I1_nrk1 I1_nrkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I441_MN0 (I0_I1660_G11_0np I0_I1660_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1208_MN0 (I0_two13_b0 I0_two13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1198_MN0 (I0_one13_b0 I0_one13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1153_MN0 (I0_two12_b0 I0_two12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1143_MN0 (I0_one12_b0 I0_one12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1098_MN0 (I0_two11_b0 I0_two11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I161_MN0 (I1_I1804_G3_0np I1_I1804_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I161_MN0 (I1_I1988_G3_0np I1_I1988_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2025_MN0 (I1_dm11 I1_dmn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I66_MN0 (I1_I2066_G0_0n I1_I2066_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I379_MN0 (I0_I1660_G4_0n I0_I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I437_MN0 (I0_I1660_G9_0np I0_I1660_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I449_MN0 (I0_I1660_G15_0np I0_I1660_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1253_MN0 (I0_one14_b0 I0_one14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1263_MN0 (I0_two14_b0 I0_two14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1308_MN0 (I0_one15_b0 I0_one15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1318_MN0 (I0_two15_b0 I0_two15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1808_MN0 (I1_qu4_b0 I1_qu4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1804_I193_MN0 (I1_I1804_G7_0n I1_I1804_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I66_MN0 (I1_I1850_G0_0n I1_I1850_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I159_MN0 (I1_I1896_G2_0np I1_I1896_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2027_MN0 (I1_dm12 I1_dmn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I129_MN0 (I1_I2066_G1_0n I1_I2066_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2175_MN0 (I1_nrk2 I1_nrkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2178_MN0 (I1_nrk3 I1_nrkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2181_MN0 (I1_nrk4 I1_nrkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I319_MN0 (I0_I1660_G2_0np I0_I1660_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I435_MN0 (I0_I1660_G8_0np I0_I1660_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I445_MN0 (I0_I1660_G13_0np I0_I1660_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I161_MN0 (I1_I1850_G3_0np I1_I1850_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I129_MN0 (I1_I1850_G1_0n I1_I1850_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I161_MN0 (I1_I1896_G3_0np I1_I1896_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I189_MN0 (I1_I1942_G5_0n I1_I1942_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I187_MN0 (I1_I1942_G4_0n I1_I1942_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I189_MN0 (I1_I1988_G5_0n I1_I1988_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2031_MN0 (I1_dm14 I1_dmn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I187_MN0 (I1_I1988_G4_0n I1_I1988_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2029_MN0 (I1_dm13 I1_dmn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2187_MN0 (I1_nrk6 I1_nrkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2184_MN0 (I1_nrk5 I1_nrkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I443_MN0 (I0_I1660_G12_0np I0_I1660_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I532_MN0 (I0_kco I0_I1660_G63_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1854_MN0 (I1_qu3_b0 I1_qu3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I187_MN0 (I1_I1896_G4_0n I1_I1896_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2033_MN0 (I1_dm15 I1_dmn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I159_MN0 (I1_I2066_G2_0np I1_I2066_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2190_MN0 (I1_nrk7 I1_nrkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2196_MN0 (I1_nrk9 I1_nrkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I866_MN0 (I0_sn6 I0_pp6_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I189_MN0 (I1_I1850_G5_0n I1_I1850_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I191_MN0 (I1_I1942_G6_0n I1_I1942_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2035_MN0 (I1_dm16 I1_dmn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2037_MN0 (I1_dm17 I1_dmn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I191_MN0 (I1_I1988_G6_0n I1_I1988_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I161_MN0 (I1_I2066_G3_0np I1_I2066_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2193_MN0 (I1_nrk8 I1_nrkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2199_MN0 (I1_nrk10 I1_nrkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I383_MN0 (I0_I1660_G6_0n I0_I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I439_MN0 (I0_I1660_G10_0np I0_I1660_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1196_MN0 (I0_sn12 I0_pp12_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I193_MN0 (I1_I1850_G7_0n I1_I1850_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I187_MN0 (I1_I1850_G4_0n I1_I1850_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I159_MN0 (I1_I1850_G2_0np I1_I1850_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I189_MN0 (I1_I1896_G5_0n I1_I1896_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1942_I193_MN0 (I1_I1942_G7_0n I1_I1942_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1988_I193_MN0 (I1_I1988_G7_0n I1_I1988_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2039_MN0 (I1_dm18 I1_dmn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I187_MN0 (I1_I2066_G4_0n I1_I2066_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2202_MN0 (I1_nrk11 I1_nrkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2208_MN0 (I1_nrk13 I1_nrkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2205_MN0 (I1_nrk12 I1_nrkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1141_MN0 (I0_sn11 I0_pp11_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1086_MN0 (I0_sn10 I0_pp10_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I921_MN0 (I0_sn7 I0_pp7_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2041_MN0 (I1_dm19 I1_dmn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2043_MN0 (I1_dm20 I1_dmn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I189_MN0 (I1_I2066_G5_0n I1_I2066_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2211_MN0 (I1_nrk14 I1_nrkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2226_MN0 (I1_nrk19 I1_nrkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2223_MN0 (I1_nrk18 I1_nrkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2220_MN0 (I1_nrk17 I1_nrkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I447_MN0 (I0_I1660_G14_0np I0_I1660_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1850_I191_MN0 (I1_I1850_G6_0n I1_I1850_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I193_MN0 (I1_I1896_G7_0n I1_I1896_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1896_I191_MN0 (I1_I1896_G6_0n I1_I1896_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1991_MN0 (I1_p31_32_b0 I1_p31_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2045_MN0 (I1_dm21 I1_dmn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I193_MN0 (I1_I2066_G7_0n I1_I2066_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2229_MN0 (I1_nrk20 I1_nrkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2214_MN0 (I1_nrk15 I1_nrkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2217_MN0 (I1_nrk16 I1_nrkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2047_MN0 (I1_dm22 I1_dmn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2049_MN0 (I1_dm23 I1_dmn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2066_I191_MN0 (I1_I2066_G6_0n I1_I2066_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2232_MN0 (I1_nrk21 I1_nrkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2241_MN0 (I1_nrk24 I1_nrkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1251_MN0 (I0_sn13 I0_pp13_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1946_MN0 (I1_qu1_b0 I1_qu1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2051_MN0 (I1_dm24 I1_dmn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2055_MN0 (I1_dm26 I1_dmn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2053_MN0 (I1_dm25 I1_dmn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2235_MN0 (I1_nrk22 I1_nrkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2238_MN0 (I1_nrk23 I1_nrkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2244_MN0 (I1_nrk25 I1_nrkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1900_MN0 (I1_qu2_b0 I1_qu2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2057_MN0 (I1_dm27 I1_dmn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2059_MN0 (I1_dm28 I1_dmn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2259_MN0 (I1_nrk30 I1_nrkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2256_MN0 (I1_nrk29 I1_nrkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2247_MN0 (I1_nrk26 I1_nrkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1660_I531_MN0 (I0_kcm I0_I1660_G62_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I976_MN0 (I0_sn8 I0_pp8_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2065_MN0 (I1_dm31 I1_dmn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2063_MN0 (I1_dm30 I1_dmn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2061_MN0 (I1_dm29 I1_dmn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2250_MN0 (I1_nrk27 I1_nrkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I2253_MN0 (I1_nrk28 I1_nrkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI2_I4_I63_MN0 (Z I2_I4_z5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1361_MN0 (I0_sn15 I0_pp15_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1306_MN0 (I0_sn14 I0_pp14_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1031_MN0 (I0_sn9 I0_pp9_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I647_MN5 (I0_one3 B_6 XI0_I647_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I647_MN7 (XI0_I647_an2 XI0_I647_aan I0_one3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I647_MN8 (VSS XI0_I647_abn XI0_I647_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I647_MN6 (XI0_I647_an1 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I647_MN1 (XI0_I647_aan B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I647_MN3 (VSS I0_B_5_b3_5 XI0_I647_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I647_MN15 (XI0_I647_bbn B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I647_MN13 (XI0_I647_ban I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I647_MN19 (XI0_I647_bn2 XI0_I647_ban XI0_I647_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I647_MN20 (VSS B_6 XI0_I647_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I647_MN18 (XI0_I647_bn1 XI0_I647_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I647_MN17 (XI0_I647_e I0_B_7_b3_0 XI0_I647_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I647_MN26 (I0_two3 I0_one3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I647_MN25 (VSS XI0_I647_e I0_two3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I812_MN5 (I0_one6 B_12 XI0_I812_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I812_MN7 (XI0_I812_an2 XI0_I812_aan I0_one6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I812_MN8 (VSS XI0_I812_abn XI0_I812_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I812_MN6 (XI0_I812_an1 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I812_MN1 (XI0_I812_aan B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I812_MN3 (VSS I0_B_11_b3_5 XI0_I812_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I812_MN15 (XI0_I812_bbn B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I812_MN13 (XI0_I812_ban I0_B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I812_MN19 (XI0_I812_bn2 XI0_I812_ban XI0_I812_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I812_MN20 (VSS B_12 XI0_I812_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I812_MN18 (XI0_I812_bn1 XI0_I812_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I812_MN17 (XI0_I812_e I0_B_13_b3_0 XI0_I812_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I812_MN26 (I0_two6 I0_one6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I812_MN25 (VSS XI0_I812_e I0_two6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I757_MN5 (I0_one5 B_10 XI0_I757_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I757_MN7 (XI0_I757_an2 XI0_I757_aan I0_one5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I757_MN8 (VSS XI0_I757_abn XI0_I757_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I757_MN6 (XI0_I757_an1 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I757_MN1 (XI0_I757_aan B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I757_MN3 (VSS I0_B_9_b3_5 XI0_I757_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I757_MN15 (XI0_I757_bbn B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I757_MN13 (XI0_I757_ban I0_B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I757_MN19 (XI0_I757_bn2 XI0_I757_ban XI0_I757_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I757_MN20 (VSS B_10 XI0_I757_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I757_MN18 (XI0_I757_bn1 XI0_I757_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I757_MN17 (XI0_I757_e I0_B_11_b3_0 XI0_I757_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I757_MN26 (I0_two5 I0_one5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I757_MN25 (VSS XI0_I757_e I0_two5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I592_MN5 (I0_one2 B_4 XI0_I592_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I592_MN7 (XI0_I592_an2 XI0_I592_aan I0_one2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I592_MN8 (VSS XI0_I592_abn XI0_I592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I592_MN6 (XI0_I592_an1 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I592_MN1 (XI0_I592_aan B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I592_MN3 (VSS I0_B_3_b3_5 XI0_I592_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I592_MN15 (XI0_I592_bbn B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I592_MN13 (XI0_I592_ban I0_B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I592_MN19 (XI0_I592_bn2 XI0_I592_ban XI0_I592_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I592_MN20 (VSS B_4 XI0_I592_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I592_MN18 (XI0_I592_bn1 XI0_I592_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I592_MN17 (XI0_I592_e I0_B_5_b3_0 XI0_I592_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I592_MN26 (I0_two2 I0_one2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I592_MN25 (VSS XI0_I592_e I0_two2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I537_MN5 (I0_one1 B_2 XI0_I537_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I537_MN7 (XI0_I537_an2 XI0_I537_aan I0_one1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I537_MN8 (VSS XI0_I537_abn XI0_I537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I537_MN6 (XI0_I537_an1 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I537_MN1 (XI0_I537_aan B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I537_MN3 (VSS I0_B_1_b3_5 XI0_I537_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I537_MN15 (XI0_I537_bbn B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I537_MN13 (XI0_I537_ban I0_B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I537_MN19 (XI0_I537_bn2 XI0_I537_ban XI0_I537_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I537_MN20 (VSS B_2 XI0_I537_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I537_MN18 (XI0_I537_bn1 XI0_I537_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I537_MN17 (XI0_I537_e I0_B_3_b3_0 XI0_I537_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I537_MN26 (I0_two1 I0_one1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I537_MN25 (VSS XI0_I537_e I0_two1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I482_MN5 (I0_one0 B_0 XI0_I482_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I482_MN7 (XI0_I482_an2 XI0_I482_aan I0_one0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I482_MN8 (VSS XI0_I482_abn XI0_I482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I482_MN6 (XI0_I482_an1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I482_MN1 (XI0_I482_aan B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I482_MN3 (VSS VSS XI0_I482_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I482_MN15 (XI0_I482_bbn B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I482_MN13 (XI0_I482_ban I0_B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I482_MN19 (XI0_I482_bn2 XI0_I482_ban XI0_I482_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I482_MN20 (VSS B_0 XI0_I482_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I482_MN18 (XI0_I482_bn1 XI0_I482_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I482_MN17 (XI0_I482_e I0_B_1_b3_0 XI0_I482_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I482_MN26 (I0_two0 I0_one0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I482_MN25 (VSS XI0_I482_e I0_two0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I702_MN5 (I0_one4 B_8 XI0_I702_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I702_MN7 (XI0_I702_an2 XI0_I702_aan I0_one4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I702_MN8 (VSS XI0_I702_abn XI0_I702_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I702_MN6 (XI0_I702_an1 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I702_MN1 (XI0_I702_aan B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I702_MN3 (VSS I0_B_7_b3_5 XI0_I702_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I702_MN15 (XI0_I702_bbn B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I702_MN13 (XI0_I702_ban I0_B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I702_MN19 (XI0_I702_bn2 XI0_I702_ban XI0_I702_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I702_MN20 (VSS B_8 XI0_I702_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I702_MN18 (XI0_I702_bn1 XI0_I702_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I702_MN17 (XI0_I702_e I0_B_9_b3_0 XI0_I702_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I702_MN26 (I0_two4 I0_one4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I702_MN25 (VSS XI0_I702_e I0_two4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I867_MN5 (I0_one7 B_14 XI0_I867_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I867_MN7 (XI0_I867_an2 XI0_I867_aan I0_one7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I867_MN8 (VSS XI0_I867_abn XI0_I867_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I867_MN6 (XI0_I867_an1 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I867_MN1 (XI0_I867_aan B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I867_MN3 (VSS I0_B_13_b3_5 XI0_I867_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I867_MN15 (XI0_I867_bbn B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I867_MN13 (XI0_I867_ban I0_B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I867_MN19 (XI0_I867_bn2 XI0_I867_ban XI0_I867_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I867_MN20 (VSS B_14 XI0_I867_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I867_MN18 (XI0_I867_bn1 XI0_I867_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I867_MN17 (XI0_I867_e I0_B_15_b3_0 XI0_I867_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I867_MN26 (I0_two7 I0_one7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I867_MN25 (VSS XI0_I867_e I0_two7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I922_MN5 (I0_one8 B_16 XI0_I922_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I922_MN7 (XI0_I922_an2 XI0_I922_aan I0_one8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I922_MN8 (VSS XI0_I922_abn XI0_I922_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I922_MN6 (XI0_I922_an1 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I922_MN1 (XI0_I922_aan B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I922_MN3 (VSS I0_B_15_b3_5 XI0_I922_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I922_MN15 (XI0_I922_bbn B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I922_MN13 (XI0_I922_ban I0_B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I922_MN19 (XI0_I922_bn2 XI0_I922_ban XI0_I922_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I922_MN20 (VSS B_16 XI0_I922_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I922_MN18 (XI0_I922_bn1 XI0_I922_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I922_MN17 (XI0_I922_e I0_B_17_b3_0 XI0_I922_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I922_MN26 (I0_two8 I0_one8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I922_MN25 (VSS XI0_I922_e I0_two8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1032_MN5 (I0_one10 B_20 XI0_I1032_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1032_MN7 (XI0_I1032_an2 XI0_I1032_aan I0_one10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1032_MN8 (VSS XI0_I1032_abn XI0_I1032_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1032_MN6 (XI0_I1032_an1 I0_B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1032_MN1 (XI0_I1032_aan B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1032_MN3 (VSS I0_B_19_b3_5 XI0_I1032_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1032_MN15 (XI0_I1032_bbn B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1032_MN13 (XI0_I1032_ban I0_B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1032_MN19 (XI0_I1032_bn2 XI0_I1032_ban XI0_I1032_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1032_MN20 (VSS B_20 XI0_I1032_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1032_MN18 (XI0_I1032_bn1 XI0_I1032_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1032_MN17 (XI0_I1032_e I0_B_21_b3_0 XI0_I1032_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1032_MN26 (I0_two10 I0_one10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1032_MN25 (VSS XI0_I1032_e I0_two10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I977_MN5 (I0_one9 B_18 XI0_I977_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I977_MN7 (XI0_I977_an2 XI0_I977_aan I0_one9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I977_MN8 (VSS XI0_I977_abn XI0_I977_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I977_MN6 (XI0_I977_an1 I0_B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I977_MN1 (XI0_I977_aan B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I977_MN3 (VSS I0_B_17_b3_5 XI0_I977_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I977_MN15 (XI0_I977_bbn B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I977_MN13 (XI0_I977_ban I0_B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I977_MN19 (XI0_I977_bn2 XI0_I977_ban XI0_I977_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I977_MN20 (VSS B_18 XI0_I977_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I977_MN18 (XI0_I977_bn1 XI0_I977_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I977_MN17 (XI0_I977_e I0_B_19_b3_0 XI0_I977_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I977_MN26 (I0_two9 I0_one9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I977_MN25 (VSS XI0_I977_e I0_two9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1197_MN5 (I0_one13 B_26 XI0_I1197_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1197_MN7 (XI0_I1197_an2 XI0_I1197_aan I0_one13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1197_MN8 (VSS XI0_I1197_abn XI0_I1197_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1197_MN6 (XI0_I1197_an1 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1197_MN1 (XI0_I1197_aan B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1197_MN3 (VSS I0_B_25_b3_5 XI0_I1197_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1197_MN15 (XI0_I1197_bbn B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1197_MN13 (XI0_I1197_ban I0_B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1197_MN19 (XI0_I1197_bn2 XI0_I1197_ban XI0_I1197_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1197_MN20 (VSS B_26 XI0_I1197_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1197_MN18 (XI0_I1197_bn1 XI0_I1197_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1197_MN17 (XI0_I1197_e I0_B_27_b3_0 XI0_I1197_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1197_MN26 (I0_two13 I0_one13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1197_MN25 (VSS XI0_I1197_e I0_two13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1142_MN5 (I0_one12 B_24 XI0_I1142_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1142_MN7 (XI0_I1142_an2 XI0_I1142_aan I0_one12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1142_MN8 (VSS XI0_I1142_abn XI0_I1142_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1142_MN6 (XI0_I1142_an1 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1142_MN1 (XI0_I1142_aan B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1142_MN3 (VSS I0_B_23_b3_5 XI0_I1142_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1142_MN15 (XI0_I1142_bbn B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1142_MN13 (XI0_I1142_ban I0_B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1142_MN19 (XI0_I1142_bn2 XI0_I1142_ban XI0_I1142_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1142_MN20 (VSS B_24 XI0_I1142_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1142_MN18 (XI0_I1142_bn1 XI0_I1142_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1142_MN17 (XI0_I1142_e I0_B_25_b3_0 XI0_I1142_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1142_MN26 (I0_two12 I0_one12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1142_MN25 (VSS XI0_I1142_e I0_two12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1087_MN5 (I0_one11 B_22 XI0_I1087_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1087_MN7 (XI0_I1087_an2 XI0_I1087_aan I0_one11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1087_MN8 (VSS XI0_I1087_abn XI0_I1087_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1087_MN6 (XI0_I1087_an1 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1087_MN1 (XI0_I1087_aan B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1087_MN3 (VSS I0_B_21_b3_5 XI0_I1087_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1087_MN15 (XI0_I1087_bbn B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1087_MN13 (XI0_I1087_ban I0_B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1087_MN19 (XI0_I1087_bn2 XI0_I1087_ban XI0_I1087_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1087_MN20 (VSS B_22 XI0_I1087_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1087_MN18 (XI0_I1087_bn1 XI0_I1087_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1087_MN17 (XI0_I1087_e I0_B_23_b3_0 XI0_I1087_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1087_MN26 (I0_two11 I0_one11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1087_MN25 (VSS XI0_I1087_e I0_two11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1307_MN5 (I0_one15 B_30 XI0_I1307_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1307_MN7 (XI0_I1307_an2 XI0_I1307_aan I0_one15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1307_MN8 (VSS XI0_I1307_abn XI0_I1307_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1307_MN6 (XI0_I1307_an1 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1307_MN1 (XI0_I1307_aan B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1307_MN3 (VSS I0_B_29_b3_5 XI0_I1307_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1307_MN15 (XI0_I1307_bbn B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1307_MN13 (XI0_I1307_ban I0_B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1307_MN19 (XI0_I1307_bn2 XI0_I1307_ban XI0_I1307_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1307_MN20 (VSS B_30 XI0_I1307_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1307_MN18 (XI0_I1307_bn1 XI0_I1307_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1307_MN17 (XI0_I1307_e I0_B_31_b3_0 XI0_I1307_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1307_MN26 (I0_two15 I0_one15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1307_MN25 (VSS XI0_I1307_e I0_two15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI0_I1252_MN5 (I0_one14 B_28 XI0_I1252_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1252_MN7 (XI0_I1252_an2 XI0_I1252_aan I0_one14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1252_MN8 (VSS XI0_I1252_abn XI0_I1252_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1252_MN6 (XI0_I1252_an1 I0_B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1252_MN1 (XI0_I1252_aan B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1252_MN3 (VSS I0_B_27_b3_5 XI0_I1252_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1252_MN15 (XI0_I1252_bbn B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15997u ps=0.67997u
    I_MXI0_I1252_MN13 (XI0_I1252_ban I0_B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1252_MN19 (XI0_I1252_bn2 XI0_I1252_ban XI0_I1252_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1252_MN20 (VSS B_28 XI0_I1252_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1252_MN18 (XI0_I1252_bn1 XI0_I1252_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1252_MN17 (XI0_I1252_e I0_B_29_b3_0 XI0_I1252_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1252_MN26 (I0_two14 I0_one14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1252_MN25 (VSS XI0_I1252_e I0_two14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.04078p pd=0.67997u ps=0.67997u
    I_MXI1_I1346_MN1 (XI1_I1346_Bn I1_c17_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1346_MN5 (XI1_I1346_n2 XI1_I1346_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1346_MN4 (I1_p17_32 XI1_I1346_An XI1_I1346_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1346_MN2 (XI1_I1346_n1 I1_h17 I1_p17_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1346_MN3 (VSS I1_c17_o XI1_I1346_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1346_MN0 (XI1_I1346_An I1_h17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1345_MN1 (XI1_I1345_Bn I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1345_MN5 (XI1_I1345_n2 XI1_I1345_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1345_MN4 (I1_h17 XI1_I1345_An XI1_I1345_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1345_MN2 (XI1_I1345_n1 I1_p16_31 I1_h17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1345_MN3 (VSS I1_qu15_b3_5 XI1_I1345_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1345_MN0 (XI1_I1345_An I1_p16_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1300_MN1 (XI1_I1300_Bn I1_c16_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1300_MN5 (XI1_I1300_n2 XI1_I1300_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1300_MN4 (I1_p16_32 XI1_I1300_An XI1_I1300_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1300_MN2 (XI1_I1300_n1 I1_h16 I1_p16_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1300_MN3 (VSS I1_c16_o XI1_I1300_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1300_MN0 (XI1_I1300_An I1_h16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1295_MN1 (XI1_I1295_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1295_MN5 (XI1_I1295_n2 XI1_I1295_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1295_MN4 (I1_b16_29 XI1_I1295_An XI1_I1295_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1295_MN2 (XI1_I1295_n1 I1_dd29_b3_2 I1_b16_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1295_MN3 (VSS I1_qu16_b3_4 XI1_I1295_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1295_MN0 (XI1_I1295_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1299_MN1 (XI1_I1299_Bn I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1299_MN5 (XI1_I1299_n2 XI1_I1299_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1299_MN4 (I1_h16 XI1_I1299_An XI1_I1299_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1299_MN2 (XI1_I1299_n1 I1_p15_31 I1_h16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1299_MN3 (VSS I1_qu16_b3_5 XI1_I1299_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1299_MN0 (XI1_I1299_An I1_p15_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1297_MN1 (XI1_I1297_Bn I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1297_MN5 (XI1_I1297_n2 XI1_I1297_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1297_MN4 (I1_b16_31 XI1_I1297_An XI1_I1297_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1297_MN2 (XI1_I1297_n1 I1_dd31_b3_2 I1_b16_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1297_MN3 (VSS I1_qu16_b3_5 XI1_I1297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1297_MN0 (XI1_I1297_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1296_MN1 (XI1_I1296_Bn I1_qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1296_MN5 (XI1_I1296_n2 XI1_I1296_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1296_MN4 (I1_b16_30 XI1_I1296_An XI1_I1296_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1296_MN2 (XI1_I1296_n1 I1_dd30_b3_2 I1_b16_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1296_MN3 (VSS I1_qu16_b3_5 XI1_I1296_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1296_MN0 (XI1_I1296_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1249_MN1 (XI1_I1249_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1249_MN5 (XI1_I1249_n2 XI1_I1249_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1249_MN4 (I1_b15_29 XI1_I1249_An XI1_I1249_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1249_MN2 (XI1_I1249_n1 I1_dd29_b3_2 I1_b15_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1249_MN3 (VSS I1_qu17_b3_4 XI1_I1249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1249_MN0 (XI1_I1249_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1250_MN1 (XI1_I1250_Bn I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1250_MN5 (XI1_I1250_n2 XI1_I1250_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1250_MN4 (I1_b15_30 XI1_I1250_An XI1_I1250_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1250_MN2 (XI1_I1250_n1 I1_dd30_b3_2 I1_b15_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1250_MN3 (VSS I1_qu17_b3_5 XI1_I1250_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1250_MN0 (XI1_I1250_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1203_MN1 (XI1_I1203_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1203_MN5 (XI1_I1203_n2 XI1_I1203_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1203_MN4 (I1_b14_29 XI1_I1203_An XI1_I1203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1203_MN2 (XI1_I1203_n1 I1_dd29_b3_2 I1_b14_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1203_MN3 (VSS I1_qu18_b3_4 XI1_I1203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1203_MN0 (XI1_I1203_An I1_dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I840_MN1 (XI1_I840_Bn I1_c6_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I840_MN5 (XI1_I840_n2 XI1_I840_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I840_MN4 (I1_p6_32 XI1_I840_An XI1_I840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I840_MN2 (XI1_I840_n1 I1_h6 I1_p6_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I840_MN3 (VSS I1_c6_o XI1_I840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I840_MN0 (XI1_I840_An I1_h6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I839_MN1 (XI1_I839_Bn I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I839_MN5 (XI1_I839_n2 XI1_I839_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I839_MN4 (I1_h6 XI1_I839_An XI1_I839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I839_MN2 (XI1_I839_n1 I1_p5_31 I1_h6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I839_MN3 (VSS I1_qu26_b3_5 XI1_I839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I839_MN0 (XI1_I839_An I1_p5_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I794_MN1 (XI1_I794_Bn I1_c5_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I794_MN5 (XI1_I794_n2 XI1_I794_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I794_MN4 (I1_p5_32 XI1_I794_An XI1_I794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I794_MN2 (XI1_I794_n1 I1_h5 I1_p5_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I794_MN3 (VSS I1_c5_o XI1_I794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I794_MN0 (XI1_I794_An I1_h5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1343_MN1 (XI1_I1343_Bn I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1343_MN5 (XI1_I1343_n2 XI1_I1343_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1343_MN4 (I1_b17_31 XI1_I1343_An XI1_I1343_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1343_MN2 (XI1_I1343_n1 I1_dd31_b3_3 I1_b17_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1343_MN3 (VSS I1_qu15_b3_5 XI1_I1343_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1343_MN0 (XI1_I1343_An I1_dd31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1342_MN1 (XI1_I1342_Bn I1_qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1342_MN5 (XI1_I1342_n2 XI1_I1342_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1342_MN4 (I1_b17_30 XI1_I1342_An XI1_I1342_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1342_MN2 (XI1_I1342_n1 I1_dd30_b3_3 I1_b17_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1342_MN3 (VSS I1_qu15_b3_5 XI1_I1342_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1342_MN0 (XI1_I1342_An I1_dd30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1293_MN1 (XI1_I1293_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1293_MN5 (XI1_I1293_n2 XI1_I1293_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1293_MN4 (I1_b16_27 XI1_I1293_An XI1_I1293_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1293_MN2 (XI1_I1293_n1 I1_dd27_b3_2 I1_b16_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1293_MN3 (VSS I1_qu16_b3_4 XI1_I1293_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1293_MN0 (XI1_I1293_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1294_MN1 (XI1_I1294_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1294_MN5 (XI1_I1294_n2 XI1_I1294_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1294_MN4 (I1_b16_28 XI1_I1294_An XI1_I1294_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1294_MN2 (XI1_I1294_n1 I1_dd28_b3_2 I1_b16_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1294_MN3 (VSS I1_qu16_b3_4 XI1_I1294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1294_MN0 (XI1_I1294_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1292_MN1 (XI1_I1292_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1292_MN5 (XI1_I1292_n2 XI1_I1292_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1292_MN4 (I1_b16_26 XI1_I1292_An XI1_I1292_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1292_MN2 (XI1_I1292_n1 I1_dd26_b3_2 I1_b16_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1292_MN3 (VSS I1_qu16_b3_4 XI1_I1292_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1292_MN0 (XI1_I1292_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1254_MN1 (XI1_I1254_Bn I1_c15_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1254_MN5 (XI1_I1254_n2 XI1_I1254_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1254_MN4 (I1_p15_32 XI1_I1254_An XI1_I1254_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1254_MN2 (XI1_I1254_n1 I1_h15 I1_p15_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1254_MN3 (VSS I1_c15_o XI1_I1254_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1254_MN0 (XI1_I1254_An I1_h15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1246_MN1 (XI1_I1246_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1246_MN5 (XI1_I1246_n2 XI1_I1246_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1246_MN4 (I1_b15_26 XI1_I1246_An XI1_I1246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1246_MN2 (XI1_I1246_n1 I1_dd26_b3_2 I1_b15_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1246_MN3 (VSS I1_qu17_b3_4 XI1_I1246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1246_MN0 (XI1_I1246_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1248_MN1 (XI1_I1248_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1248_MN5 (XI1_I1248_n2 XI1_I1248_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1248_MN4 (I1_b15_28 XI1_I1248_An XI1_I1248_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1248_MN2 (XI1_I1248_n1 I1_dd28_b3_2 I1_b15_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1248_MN3 (VSS I1_qu17_b3_4 XI1_I1248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1248_MN0 (XI1_I1248_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1247_MN1 (XI1_I1247_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1247_MN5 (XI1_I1247_n2 XI1_I1247_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1247_MN4 (I1_b15_27 XI1_I1247_An XI1_I1247_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1247_MN2 (XI1_I1247_n1 I1_dd27_b3_2 I1_b15_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1247_MN3 (VSS I1_qu17_b3_4 XI1_I1247_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1247_MN0 (XI1_I1247_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1253_MN1 (XI1_I1253_Bn I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1253_MN5 (XI1_I1253_n2 XI1_I1253_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1253_MN4 (I1_h15 XI1_I1253_An XI1_I1253_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1253_MN2 (XI1_I1253_n1 I1_p14_31 I1_h15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1253_MN3 (VSS I1_qu17_b3_5 XI1_I1253_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1253_MN0 (XI1_I1253_An I1_p14_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1251_MN1 (XI1_I1251_Bn I1_qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1251_MN5 (XI1_I1251_n2 XI1_I1251_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1251_MN4 (I1_b15_31 XI1_I1251_An XI1_I1251_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1251_MN2 (XI1_I1251_n1 I1_dd31_b3_2 I1_b15_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1251_MN3 (VSS I1_qu17_b3_5 XI1_I1251_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1251_MN0 (XI1_I1251_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1202_MN1 (XI1_I1202_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1202_MN5 (XI1_I1202_n2 XI1_I1202_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1202_MN4 (I1_b14_28 XI1_I1202_An XI1_I1202_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1202_MN2 (XI1_I1202_n1 I1_dd28_b3_2 I1_b14_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1202_MN3 (VSS I1_qu18_b3_4 XI1_I1202_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1202_MN0 (XI1_I1202_An I1_dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1201_MN1 (XI1_I1201_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1201_MN5 (XI1_I1201_n2 XI1_I1201_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1201_MN4 (I1_b14_27 XI1_I1201_An XI1_I1201_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1201_MN2 (XI1_I1201_n1 I1_dd27_b3_2 I1_b14_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1201_MN3 (VSS I1_qu18_b3_4 XI1_I1201_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1201_MN0 (XI1_I1201_An I1_dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I786_MN1 (XI1_I786_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I786_MN5 (XI1_I786_n2 XI1_I786_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I786_MN4 (I1_b5_26 XI1_I786_An XI1_I786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I786_MN2 (XI1_I786_n1 I1_dd26_b3_0 I1_b5_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I786_MN3 (VSS I1_qu27_b3_4 XI1_I786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I786_MN0 (XI1_I786_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I784_MN1 (XI1_I784_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I784_MN5 (XI1_I784_n2 XI1_I784_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I784_MN4 (I1_b5_24 XI1_I784_An XI1_I784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I784_MN2 (XI1_I784_n1 I1_dd24_b3_0 I1_b5_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I784_MN3 (VSS I1_qu27_b3_4 XI1_I784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I784_MN0 (XI1_I784_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I788_MN1 (XI1_I788_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I788_MN5 (XI1_I788_n2 XI1_I788_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I788_MN4 (I1_b5_28 XI1_I788_An XI1_I788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I788_MN2 (XI1_I788_n1 I1_dd28_b3_0 I1_b5_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I788_MN3 (VSS I1_qu27_b3_4 XI1_I788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I788_MN0 (XI1_I788_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I787_MN1 (XI1_I787_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I787_MN5 (XI1_I787_n2 XI1_I787_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I787_MN4 (I1_b5_27 XI1_I787_An XI1_I787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I787_MN2 (XI1_I787_n1 I1_dd27_b3_0 I1_b5_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I787_MN3 (VSS I1_qu27_b3_4 XI1_I787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I787_MN0 (XI1_I787_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I789_MN1 (XI1_I789_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I789_MN5 (XI1_I789_n2 XI1_I789_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I789_MN4 (I1_b5_29 XI1_I789_An XI1_I789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I789_MN2 (XI1_I789_n1 I1_dd29_b3_0 I1_b5_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I789_MN3 (VSS I1_qu27_b3_4 XI1_I789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I789_MN0 (XI1_I789_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I740_MN1 (XI1_I740_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I740_MN5 (XI1_I740_n2 XI1_I740_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I740_MN4 (I1_b4_26 XI1_I740_An XI1_I740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I740_MN2 (XI1_I740_n1 I1_dd26_b3_0 I1_b4_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I740_MN3 (VSS I1_qu28_b3_4 XI1_I740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I740_MN0 (XI1_I740_An I1_dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1291_MN1 (XI1_I1291_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1291_MN5 (XI1_I1291_n2 XI1_I1291_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1291_MN4 (I1_b16_25 XI1_I1291_An XI1_I1291_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1291_MN2 (XI1_I1291_n1 I1_dd25_b3_2 I1_b16_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1291_MN3 (VSS I1_qu16_b3_4 XI1_I1291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1291_MN0 (XI1_I1291_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1290_MN1 (XI1_I1290_Bn I1_qu16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1290_MN5 (XI1_I1290_n2 XI1_I1290_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1290_MN4 (I1_b16_24 XI1_I1290_An XI1_I1290_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1290_MN2 (XI1_I1290_n1 I1_dd24_b3_2 I1_b16_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1290_MN3 (VSS I1_qu16_b3_4 XI1_I1290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1290_MN0 (XI1_I1290_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1245_MN1 (XI1_I1245_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1245_MN5 (XI1_I1245_n2 XI1_I1245_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1245_MN4 (I1_b15_25 XI1_I1245_An XI1_I1245_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1245_MN2 (XI1_I1245_n1 I1_dd25_b3_2 I1_b15_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1245_MN3 (VSS I1_qu17_b3_4 XI1_I1245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1245_MN0 (XI1_I1245_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1205_MN1 (XI1_I1205_Bn I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1205_MN5 (XI1_I1205_n2 XI1_I1205_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1205_MN4 (I1_b14_31 XI1_I1205_An XI1_I1205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1205_MN2 (XI1_I1205_n1 I1_dd31_b3_2 I1_b14_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1205_MN3 (VSS I1_qu18_b3_5 XI1_I1205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1205_MN0 (XI1_I1205_An I1_dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1204_MN1 (XI1_I1204_Bn I1_qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1204_MN5 (XI1_I1204_n2 XI1_I1204_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1204_MN4 (I1_b14_30 XI1_I1204_An XI1_I1204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1204_MN2 (XI1_I1204_n1 I1_dd30_b3_2 I1_b14_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1204_MN3 (VSS I1_qu18_b3_5 XI1_I1204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1204_MN0 (XI1_I1204_An I1_dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1198_MN1 (XI1_I1198_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1198_MN5 (XI1_I1198_n2 XI1_I1198_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1198_MN4 (I1_b14_24 XI1_I1198_An XI1_I1198_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1198_MN2 (XI1_I1198_n1 I1_dd24_b3_2 I1_b14_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1198_MN3 (VSS I1_qu18_b3_4 XI1_I1198_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1198_MN0 (XI1_I1198_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1200_MN1 (XI1_I1200_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1200_MN5 (XI1_I1200_n2 XI1_I1200_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1200_MN4 (I1_b14_26 XI1_I1200_An XI1_I1200_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1200_MN2 (XI1_I1200_n1 I1_dd26_b3_2 I1_b14_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1200_MN3 (VSS I1_qu18_b3_4 XI1_I1200_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1200_MN0 (XI1_I1200_An I1_dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I219_MN1 (XI1_I838_I219_Bn I1_I838_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I219_MN5 (XI1_I838_I219_n2 XI1_I838_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I219_MN4 (I1_p6_16 XI1_I838_I219_An XI1_I838_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I219_MN2 (XI1_I838_I219_n1 I1_I838_pn16 I1_p6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I219_MN3 (VSS I1_I838_G15_0n XI1_I838_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I219_MN0 (XI1_I838_I219_An I1_I838_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I217_MN1 (XI1_I838_I217_Bn I1_I838_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I217_MN5 (XI1_I838_I217_n2 XI1_I838_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I217_MN4 (I1_p6_14 XI1_I838_I217_An XI1_I838_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I217_MN2 (XI1_I838_I217_n1 I1_I838_pn14 I1_p6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I217_MN3 (VSS I1_I838_G13_0n XI1_I838_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I217_MN0 (XI1_I838_I217_An I1_I838_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I219_MN1 (XI1_I792_I219_Bn I1_I792_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I219_MN5 (XI1_I792_I219_n2 XI1_I792_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I219_MN4 (I1_p5_16 XI1_I792_I219_An XI1_I792_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I219_MN2 (XI1_I792_I219_n1 I1_I792_pn16 I1_p5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I219_MN3 (VSS I1_I792_G15_0n XI1_I792_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I219_MN0 (XI1_I792_I219_An I1_I792_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I793_MN1 (XI1_I793_Bn I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I793_MN5 (XI1_I793_n2 XI1_I793_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I793_MN4 (I1_h5 XI1_I793_An XI1_I793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I793_MN2 (XI1_I793_n1 I1_p4_31 I1_h5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I793_MN3 (VSS I1_qu27_b3_5 XI1_I793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I793_MN0 (XI1_I793_An I1_p4_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I790_MN1 (XI1_I790_Bn I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I790_MN5 (XI1_I790_n2 XI1_I790_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I790_MN4 (I1_b5_30 XI1_I790_An XI1_I790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I790_MN2 (XI1_I790_n1 I1_dd30_b3_0 I1_b5_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I790_MN3 (VSS I1_qu27_b3_5 XI1_I790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I790_MN0 (XI1_I790_An I1_dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I791_MN1 (XI1_I791_Bn I1_qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I791_MN5 (XI1_I791_n2 XI1_I791_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I791_MN4 (I1_b5_31 XI1_I791_An XI1_I791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I791_MN2 (XI1_I791_n1 I1_dd31_b3_0 I1_b5_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I791_MN3 (VSS I1_qu27_b3_5 XI1_I791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I791_MN0 (XI1_I791_An I1_dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I785_MN1 (XI1_I785_Bn I1_qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I785_MN5 (XI1_I785_n2 XI1_I785_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I785_MN4 (I1_b5_25 XI1_I785_An XI1_I785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I785_MN2 (XI1_I785_n1 I1_dd25_b3_0 I1_b5_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I785_MN3 (VSS I1_qu27_b3_4 XI1_I785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I785_MN0 (XI1_I785_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I741_MN1 (XI1_I741_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I741_MN5 (XI1_I741_n2 XI1_I741_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I741_MN4 (I1_b4_27 XI1_I741_An XI1_I741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I741_MN2 (XI1_I741_n1 I1_dd27_b3_0 I1_b4_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I741_MN3 (VSS I1_qu28_b3_4 XI1_I741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I741_MN0 (XI1_I741_An I1_dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1289_MN1 (XI1_I1289_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1289_MN5 (XI1_I1289_n2 XI1_I1289_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1289_MN4 (I1_b16_23 XI1_I1289_An XI1_I1289_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1289_MN2 (XI1_I1289_n1 I1_dd23_b3_2 I1_b16_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1289_MN3 (VSS I1_qu16_b3_3 XI1_I1289_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1289_MN0 (XI1_I1289_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1244_MN1 (XI1_I1244_Bn I1_qu17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1244_MN5 (XI1_I1244_n2 XI1_I1244_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1244_MN4 (I1_b15_24 XI1_I1244_An XI1_I1244_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1244_MN2 (XI1_I1244_n1 I1_dd24_b3_2 I1_b15_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1244_MN3 (VSS I1_qu17_b3_4 XI1_I1244_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1244_MN0 (XI1_I1244_An I1_dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1243_MN1 (XI1_I1243_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1243_MN5 (XI1_I1243_n2 XI1_I1243_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1243_MN4 (I1_b15_23 XI1_I1243_An XI1_I1243_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1243_MN2 (XI1_I1243_n1 I1_dd23_b3_2 I1_b15_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1243_MN3 (VSS I1_qu17_b3_3 XI1_I1243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1243_MN0 (XI1_I1243_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1242_MN1 (XI1_I1242_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1242_MN5 (XI1_I1242_n2 XI1_I1242_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1242_MN4 (I1_b15_22 XI1_I1242_An XI1_I1242_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1242_MN2 (XI1_I1242_n1 I1_dd22_b3_2 I1_b15_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1242_MN3 (VSS I1_qu17_b3_3 XI1_I1242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1242_MN0 (XI1_I1242_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1197_MN1 (XI1_I1197_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1197_MN5 (XI1_I1197_n2 XI1_I1197_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1197_MN4 (I1_b14_23 XI1_I1197_An XI1_I1197_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1197_MN2 (XI1_I1197_n1 I1_dd23_b3_2 I1_b14_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1197_MN3 (VSS I1_qu18_b3_3 XI1_I1197_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1197_MN0 (XI1_I1197_An I1_dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1196_MN1 (XI1_I1196_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1196_MN5 (XI1_I1196_n2 XI1_I1196_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1196_MN4 (I1_b14_22 XI1_I1196_An XI1_I1196_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1196_MN2 (XI1_I1196_n1 I1_dd22_b3_2 I1_b14_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1196_MN3 (VSS I1_qu18_b3_3 XI1_I1196_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1196_MN0 (XI1_I1196_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1199_MN1 (XI1_I1199_Bn I1_qu18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1199_MN5 (XI1_I1199_n2 XI1_I1199_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1199_MN4 (I1_b14_25 XI1_I1199_An XI1_I1199_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1199_MN2 (XI1_I1199_n1 I1_dd25_b3_2 I1_b14_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1199_MN3 (VSS I1_qu18_b3_4 XI1_I1199_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1199_MN0 (XI1_I1199_An I1_dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I836_MN1 (XI1_I836_Bn I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I836_MN5 (XI1_I836_n2 XI1_I836_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I836_MN4 (I1_b6_30 XI1_I836_An XI1_I836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I836_MN2 (XI1_I836_n1 I1_dd30_b3_1 I1_b6_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I836_MN3 (VSS I1_qu26_b3_5 XI1_I836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I836_MN0 (XI1_I836_An I1_dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I215_MN1 (XI1_I838_I215_Bn I1_I838_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I215_MN5 (XI1_I838_I215_n2 XI1_I838_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I215_MN4 (I1_p6_12 XI1_I838_I215_An XI1_I838_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I215_MN2 (XI1_I838_I215_n1 I1_I838_pn12 I1_p6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I215_MN3 (VSS I1_I838_G11_0n XI1_I838_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I215_MN0 (XI1_I838_I215_An I1_I838_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I213_MN1 (XI1_I838_I213_Bn I1_I838_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I213_MN5 (XI1_I838_I213_n2 XI1_I838_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I213_MN4 (I1_p6_10 XI1_I838_I213_An XI1_I838_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I213_MN2 (XI1_I838_I213_n1 I1_I838_pn10 I1_p6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I213_MN3 (VSS I1_I838_G9_0n XI1_I838_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I213_MN0 (XI1_I838_I213_An I1_I838_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I217_MN1 (XI1_I792_I217_Bn I1_I792_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I217_MN5 (XI1_I792_I217_n2 XI1_I792_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I217_MN4 (I1_p5_14 XI1_I792_I217_An XI1_I792_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I217_MN2 (XI1_I792_I217_n1 I1_I792_pn14 I1_p5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I217_MN3 (VSS I1_I792_G13_0n XI1_I792_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I217_MN0 (XI1_I792_I217_An I1_I792_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I215_MN1 (XI1_I792_I215_Bn I1_I792_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I215_MN5 (XI1_I792_I215_n2 XI1_I792_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I215_MN4 (I1_p5_12 XI1_I792_I215_An XI1_I792_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I215_MN2 (XI1_I792_I215_n1 I1_I792_pn12 I1_p5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I215_MN3 (VSS I1_I792_G11_0n XI1_I792_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I215_MN0 (XI1_I792_I215_An I1_I792_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I218_MN1 (XI1_I792_I218_Bn I1_I792_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I218_MN5 (XI1_I792_I218_n2 XI1_I792_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I218_MN4 (I1_p5_15 XI1_I792_I218_An XI1_I792_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I218_MN2 (XI1_I792_I218_n1 I1_I792_pn15 I1_p5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I218_MN3 (VSS I1_I792_G14_0n XI1_I792_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I218_MN0 (XI1_I792_I218_An I1_I792_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I781_MN1 (XI1_I781_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I781_MN5 (XI1_I781_n2 XI1_I781_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I781_MN4 (I1_b5_21 XI1_I781_An XI1_I781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I781_MN2 (XI1_I781_n1 I1_dd21_b3_0 I1_b5_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I781_MN3 (VSS I1_qu27_b3_3 XI1_I781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I781_MN0 (XI1_I781_An I1_dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I782_MN1 (XI1_I782_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I782_MN5 (XI1_I782_n2 XI1_I782_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I782_MN4 (I1_b5_22 XI1_I782_An XI1_I782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I782_MN2 (XI1_I782_n1 I1_dd22_b3_0 I1_b5_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I782_MN3 (VSS I1_qu27_b3_3 XI1_I782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I782_MN0 (XI1_I782_An I1_dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I742_MN1 (XI1_I742_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I742_MN5 (XI1_I742_n2 XI1_I742_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I742_MN4 (I1_b4_28 XI1_I742_An XI1_I742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I742_MN2 (XI1_I742_n1 I1_dd28_b3_0 I1_b4_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I742_MN3 (VSS I1_qu28_b3_4 XI1_I742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I742_MN0 (XI1_I742_An I1_dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I219_MN1 (XI1_I1298_I219_Bn I1_I1298_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I219_MN5 (XI1_I1298_I219_n2 XI1_I1298_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I219_MN4 (I1_p16_16 XI1_I1298_I219_An XI1_I1298_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I219_MN2 (XI1_I1298_I219_n1 I1_I1298_pn16 I1_p16_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I219_MN3 (VSS I1_I1298_G15_0n XI1_I1298_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I219_MN0 (XI1_I1298_I219_An I1_I1298_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1288_MN1 (XI1_I1288_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1288_MN5 (XI1_I1288_n2 XI1_I1288_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1288_MN4 (I1_b16_22 XI1_I1288_An XI1_I1288_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1288_MN2 (XI1_I1288_n1 I1_dd22_b3_2 I1_b16_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1288_MN3 (VSS I1_qu16_b3_3 XI1_I1288_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1288_MN0 (XI1_I1288_An I1_dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1287_MN1 (XI1_I1287_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1287_MN5 (XI1_I1287_n2 XI1_I1287_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1287_MN4 (I1_b16_21 XI1_I1287_An XI1_I1287_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1287_MN2 (XI1_I1287_n1 I1_dd21_b3_2 I1_b16_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1287_MN3 (VSS I1_qu16_b3_3 XI1_I1287_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1287_MN0 (XI1_I1287_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1241_MN1 (XI1_I1241_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1241_MN5 (XI1_I1241_n2 XI1_I1241_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1241_MN4 (I1_b15_21 XI1_I1241_An XI1_I1241_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1241_MN2 (XI1_I1241_n1 I1_dd21_b3_2 I1_b15_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1241_MN3 (VSS I1_qu17_b3_3 XI1_I1241_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1241_MN0 (XI1_I1241_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I834_MN1 (XI1_I834_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I834_MN5 (XI1_I834_n2 XI1_I834_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I834_MN4 (I1_b6_28 XI1_I834_An XI1_I834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I834_MN2 (XI1_I834_n1 I1_dd28_b3_1 I1_b6_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I834_MN3 (VSS I1_qu26_b3_4 XI1_I834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I834_MN0 (XI1_I834_An I1_dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I835_MN1 (XI1_I835_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I835_MN5 (XI1_I835_n2 XI1_I835_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I835_MN4 (I1_b6_29 XI1_I835_An XI1_I835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I835_MN2 (XI1_I835_n1 I1_dd29_b3_1 I1_b6_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I835_MN3 (VSS I1_qu26_b3_4 XI1_I835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I835_MN0 (XI1_I835_An I1_dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I833_MN1 (XI1_I833_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I833_MN5 (XI1_I833_n2 XI1_I833_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I833_MN4 (I1_b6_27 XI1_I833_An XI1_I833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I833_MN2 (XI1_I833_n1 I1_dd27_b3_1 I1_b6_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I833_MN3 (VSS I1_qu26_b3_4 XI1_I833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I833_MN0 (XI1_I833_An I1_dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I837_MN1 (XI1_I837_Bn I1_qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I837_MN5 (XI1_I837_n2 XI1_I837_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I837_MN4 (I1_b6_31 XI1_I837_An XI1_I837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I837_MN2 (XI1_I837_n1 I1_dd31_b3_1 I1_b6_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I837_MN3 (VSS I1_qu26_b3_5 XI1_I837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I837_MN0 (XI1_I837_An I1_dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I832_MN1 (XI1_I832_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I832_MN5 (XI1_I832_n2 XI1_I832_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I832_MN4 (I1_b6_26 XI1_I832_An XI1_I832_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I832_MN2 (XI1_I832_n1 I1_dd26_b3_1 I1_b6_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I832_MN3 (VSS I1_qu26_b3_4 XI1_I832_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I832_MN0 (XI1_I832_An I1_dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I831_MN1 (XI1_I831_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I831_MN5 (XI1_I831_n2 XI1_I831_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I831_MN4 (I1_b6_25 XI1_I831_An XI1_I831_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I831_MN2 (XI1_I831_n1 I1_dd25_b3_1 I1_b6_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I831_MN3 (VSS I1_qu26_b3_4 XI1_I831_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I831_MN0 (XI1_I831_An I1_dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I830_MN1 (XI1_I830_Bn I1_qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I830_MN5 (XI1_I830_n2 XI1_I830_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I830_MN4 (I1_b6_24 XI1_I830_An XI1_I830_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I830_MN2 (XI1_I830_n1 I1_dd24_b3_1 I1_b6_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I830_MN3 (VSS I1_qu26_b3_4 XI1_I830_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I830_MN0 (XI1_I830_An I1_dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I213_MN1 (XI1_I792_I213_Bn I1_I792_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I213_MN5 (XI1_I792_I213_n2 XI1_I792_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I213_MN4 (I1_p5_10 XI1_I792_I213_An XI1_I792_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I213_MN2 (XI1_I792_I213_n1 I1_I792_pn10 I1_p5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I213_MN3 (VSS I1_I792_G9_0n XI1_I792_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I213_MN0 (XI1_I792_I213_An I1_I792_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I216_MN1 (XI1_I792_I216_Bn I1_I792_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I216_MN5 (XI1_I792_I216_n2 XI1_I792_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I216_MN4 (I1_p5_13 XI1_I792_I216_An XI1_I792_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I216_MN2 (XI1_I792_I216_n1 I1_I792_pn13 I1_p5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I216_MN3 (VSS I1_I792_G12_0n XI1_I792_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I216_MN0 (XI1_I792_I216_An I1_I792_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I780_MN1 (XI1_I780_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I780_MN5 (XI1_I780_n2 XI1_I780_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I780_MN4 (I1_b5_20 XI1_I780_An XI1_I780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I780_MN2 (XI1_I780_n1 I1_dd20_b3_0 I1_b5_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I780_MN3 (VSS I1_qu27_b3_3 XI1_I780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I780_MN0 (XI1_I780_An I1_dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I778_MN1 (XI1_I778_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I778_MN5 (XI1_I778_n2 XI1_I778_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I778_MN4 (I1_b5_18 XI1_I778_An XI1_I778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I778_MN2 (XI1_I778_n1 I1_dd18_b3_0 I1_b5_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I778_MN3 (VSS I1_qu27_b3_3 XI1_I778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I778_MN0 (XI1_I778_An I1_dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I783_MN1 (XI1_I783_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I783_MN5 (XI1_I783_n2 XI1_I783_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I783_MN4 (I1_b5_23 XI1_I783_An XI1_I783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I783_MN2 (XI1_I783_n1 I1_dd23_b3_0 I1_b5_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I783_MN3 (VSS I1_qu27_b3_3 XI1_I783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I783_MN0 (XI1_I783_An I1_dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I218_MN1 (XI1_I746_I218_Bn I1_I746_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I746_I218_MN5 (XI1_I746_I218_n2 XI1_I746_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I746_I218_MN4 (I1_p4_15 XI1_I746_I218_An XI1_I746_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I218_MN2 (XI1_I746_I218_n1 I1_I746_pn15 I1_p4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I746_I218_MN3 (VSS I1_I746_G14_0n XI1_I746_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I746_I218_MN0 (XI1_I746_I218_An I1_I746_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I743_MN1 (XI1_I743_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I743_MN5 (XI1_I743_n2 XI1_I743_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I743_MN4 (I1_b4_29 XI1_I743_An XI1_I743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I743_MN2 (XI1_I743_n1 I1_dd29_b3_0 I1_b4_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I743_MN3 (VSS I1_qu28_b3_4 XI1_I743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I743_MN0 (XI1_I743_An I1_dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1338_MN1 (XI1_I1338_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1338_MN5 (XI1_I1338_n2 XI1_I1338_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1338_MN4 (I1_b17_26 XI1_I1338_An XI1_I1338_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1338_MN2 (XI1_I1338_n1 I1_dd26_b3_3 I1_b17_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1338_MN3 (VSS I1_qu15_b3_4 XI1_I1338_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1338_MN0 (XI1_I1338_An I1_dd26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1341_MN1 (XI1_I1341_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1341_MN5 (XI1_I1341_n2 XI1_I1341_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1341_MN4 (I1_b17_29 XI1_I1341_An XI1_I1341_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1341_MN2 (XI1_I1341_n1 I1_dd29_b3_3 I1_b17_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1341_MN3 (VSS I1_qu15_b3_4 XI1_I1341_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1341_MN0 (XI1_I1341_An I1_dd29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1336_MN1 (XI1_I1336_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1336_MN5 (XI1_I1336_n2 XI1_I1336_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1336_MN4 (I1_b17_24 XI1_I1336_An XI1_I1336_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1336_MN2 (XI1_I1336_n1 I1_dd24_b3_3 I1_b17_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1336_MN3 (VSS I1_qu15_b3_4 XI1_I1336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1336_MN0 (XI1_I1336_An I1_dd24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I219_MN1 (XI1_I1344_I219_Bn I1_I1344_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I219_MN5 (XI1_I1344_I219_n2 XI1_I1344_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I219_MN4 (I1_p17_16 XI1_I1344_I219_An XI1_I1344_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I219_MN2 (XI1_I1344_I219_n1 I1_I1344_pn16 I1_p17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I219_MN3 (VSS I1_I1344_G15_0n XI1_I1344_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I219_MN0 (XI1_I1344_I219_An I1_I1344_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1286_MN1 (XI1_I1286_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1286_MN5 (XI1_I1286_n2 XI1_I1286_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1286_MN4 (I1_b16_20 XI1_I1286_An XI1_I1286_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1286_MN2 (XI1_I1286_n1 I1_dd20_b3_2 I1_b16_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1286_MN3 (VSS I1_qu16_b3_3 XI1_I1286_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1286_MN0 (XI1_I1286_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1285_MN1 (XI1_I1285_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1285_MN5 (XI1_I1285_n2 XI1_I1285_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1285_MN4 (I1_b16_19 XI1_I1285_An XI1_I1285_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1285_MN2 (XI1_I1285_n1 I1_dd19_b3_2 I1_b16_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1285_MN3 (VSS I1_qu16_b3_3 XI1_I1285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1285_MN0 (XI1_I1285_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1240_MN1 (XI1_I1240_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1240_MN5 (XI1_I1240_n2 XI1_I1240_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1240_MN4 (I1_b15_20 XI1_I1240_An XI1_I1240_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1240_MN2 (XI1_I1240_n1 I1_dd20_b3_2 I1_b15_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1240_MN3 (VSS I1_qu17_b3_3 XI1_I1240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1240_MN0 (XI1_I1240_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1238_MN1 (XI1_I1238_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1238_MN5 (XI1_I1238_n2 XI1_I1238_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1238_MN4 (I1_b15_18 XI1_I1238_An XI1_I1238_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1238_MN2 (XI1_I1238_n1 I1_dd18_b3_2 I1_b15_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1238_MN3 (VSS I1_qu17_b3_3 XI1_I1238_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1238_MN0 (XI1_I1238_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1195_MN1 (XI1_I1195_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1195_MN5 (XI1_I1195_n2 XI1_I1195_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1195_MN4 (I1_b14_21 XI1_I1195_An XI1_I1195_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1195_MN2 (XI1_I1195_n1 I1_dd21_b3_2 I1_b14_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1195_MN3 (VSS I1_qu18_b3_3 XI1_I1195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1195_MN0 (XI1_I1195_An I1_dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1192_MN1 (XI1_I1192_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1192_MN5 (XI1_I1192_n2 XI1_I1192_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1192_MN4 (I1_b14_18 XI1_I1192_An XI1_I1192_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1192_MN2 (XI1_I1192_n1 I1_dd18_b3_2 I1_b14_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1192_MN3 (VSS I1_qu18_b3_3 XI1_I1192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1192_MN0 (XI1_I1192_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1194_MN1 (XI1_I1194_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1194_MN5 (XI1_I1194_n2 XI1_I1194_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1194_MN4 (I1_b14_20 XI1_I1194_An XI1_I1194_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1194_MN2 (XI1_I1194_n1 I1_dd20_b3_2 I1_b14_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1194_MN3 (VSS I1_qu18_b3_3 XI1_I1194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1194_MN0 (XI1_I1194_An I1_dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I829_MN1 (XI1_I829_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I829_MN5 (XI1_I829_n2 XI1_I829_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I829_MN4 (I1_b6_23 XI1_I829_An XI1_I829_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I829_MN2 (XI1_I829_n1 I1_dd23_b3_1 I1_b6_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I829_MN3 (VSS I1_qu26_b3_3 XI1_I829_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I829_MN0 (XI1_I829_An I1_dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I827_MN1 (XI1_I827_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I827_MN5 (XI1_I827_n2 XI1_I827_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I827_MN4 (I1_b6_21 XI1_I827_An XI1_I827_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I827_MN2 (XI1_I827_n1 I1_dd21_b3_1 I1_b6_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I827_MN3 (VSS I1_qu26_b3_3 XI1_I827_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I827_MN0 (XI1_I827_An I1_dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I825_MN1 (XI1_I825_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I825_MN5 (XI1_I825_n2 XI1_I825_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I825_MN4 (I1_b6_19 XI1_I825_An XI1_I825_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I825_MN2 (XI1_I825_n1 I1_dd19_b3_1 I1_b6_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I825_MN3 (VSS I1_qu26_b3_3 XI1_I825_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I825_MN0 (XI1_I825_An I1_dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I218_MN1 (XI1_I838_I218_Bn I1_I838_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I218_MN5 (XI1_I838_I218_n2 XI1_I838_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I218_MN4 (I1_p6_15 XI1_I838_I218_An XI1_I838_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I218_MN2 (XI1_I838_I218_n1 I1_I838_pn15 I1_p6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I218_MN3 (VSS I1_I838_G14_0n XI1_I838_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I218_MN0 (XI1_I838_I218_An I1_I838_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I214_MN1 (XI1_I838_I214_Bn I1_I838_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I214_MN5 (XI1_I838_I214_n2 XI1_I838_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I214_MN4 (I1_p6_11 XI1_I838_I214_An XI1_I838_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I214_MN2 (XI1_I838_I214_n1 I1_I838_pn11 I1_p6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I214_MN3 (VSS I1_I838_G10_0n XI1_I838_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I214_MN0 (XI1_I838_I214_An I1_I838_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I212_MN1 (XI1_I792_I212_Bn I1_I792_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I212_MN5 (XI1_I792_I212_n2 XI1_I792_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I212_MN4 (I1_p5_9 XI1_I792_I212_An XI1_I792_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I212_MN2 (XI1_I792_I212_n1 I1_I792_pn9 I1_p5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I212_MN3 (VSS I1_I792_G8_0n XI1_I792_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I212_MN0 (XI1_I792_I212_An I1_I792_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I214_MN1 (XI1_I792_I214_Bn I1_I792_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I792_I214_MN5 (XI1_I792_I214_n2 XI1_I792_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I792_I214_MN4 (I1_p5_11 XI1_I792_I214_An XI1_I792_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I214_MN2 (XI1_I792_I214_n1 I1_I792_pn11 I1_p5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I792_I214_MN3 (VSS I1_I792_G10_0n XI1_I792_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I792_I214_MN0 (XI1_I792_I214_An I1_I792_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I779_MN1 (XI1_I779_Bn I1_qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I779_MN5 (XI1_I779_n2 XI1_I779_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I779_MN4 (I1_b5_19 XI1_I779_An XI1_I779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I779_MN2 (XI1_I779_n1 I1_dd19_b3_0 I1_b5_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I779_MN3 (VSS I1_qu27_b3_3 XI1_I779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I779_MN0 (XI1_I779_An I1_dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I739_MN1 (XI1_I739_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I739_MN5 (XI1_I739_n2 XI1_I739_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I739_MN4 (I1_b4_25 XI1_I739_An XI1_I739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I739_MN2 (XI1_I739_n1 I1_dd25_b3_0 I1_b4_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I739_MN3 (VSS I1_qu28_b3_4 XI1_I739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I739_MN0 (XI1_I739_An I1_dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1339_MN1 (XI1_I1339_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1339_MN5 (XI1_I1339_n2 XI1_I1339_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1339_MN4 (I1_b17_27 XI1_I1339_An XI1_I1339_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1339_MN2 (XI1_I1339_n1 I1_dd27_b3_3 I1_b17_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1339_MN3 (VSS I1_qu15_b3_4 XI1_I1339_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1339_MN0 (XI1_I1339_An I1_dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1340_MN1 (XI1_I1340_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1340_MN5 (XI1_I1340_n2 XI1_I1340_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1340_MN4 (I1_b17_28 XI1_I1340_An XI1_I1340_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1340_MN2 (XI1_I1340_n1 I1_dd28_b3_3 I1_b17_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1340_MN3 (VSS I1_qu15_b3_4 XI1_I1340_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1340_MN0 (XI1_I1340_An I1_dd28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1337_MN1 (XI1_I1337_Bn I1_qu15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1337_MN5 (XI1_I1337_n2 XI1_I1337_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1337_MN4 (I1_b17_25 XI1_I1337_An XI1_I1337_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1337_MN2 (XI1_I1337_n1 I1_dd25_b3_3 I1_b17_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1337_MN3 (VSS I1_qu15_b3_4 XI1_I1337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1337_MN0 (XI1_I1337_An I1_dd25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I217_MN1 (XI1_I1344_I217_Bn I1_I1344_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I217_MN5 (XI1_I1344_I217_n2 XI1_I1344_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I217_MN4 (I1_p17_14 XI1_I1344_I217_An XI1_I1344_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I217_MN2 (XI1_I1344_I217_n1 I1_I1344_pn14 I1_p17_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I217_MN3 (VSS I1_I1344_G13_0n XI1_I1344_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I217_MN0 (XI1_I1344_I217_An I1_I1344_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I217_MN1 (XI1_I1298_I217_Bn I1_I1298_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I217_MN5 (XI1_I1298_I217_n2 XI1_I1298_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I217_MN4 (I1_p16_14 XI1_I1298_I217_An XI1_I1298_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I217_MN2 (XI1_I1298_I217_n1 I1_I1298_pn14 I1_p16_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I217_MN3 (VSS I1_I1298_G13_0n XI1_I1298_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I217_MN0 (XI1_I1298_I217_An I1_I1298_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I218_MN1 (XI1_I1298_I218_Bn I1_I1298_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I218_MN5 (XI1_I1298_I218_n2 XI1_I1298_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I218_MN4 (I1_p16_15 XI1_I1298_I218_An XI1_I1298_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I218_MN2 (XI1_I1298_I218_n1 I1_I1298_pn15 I1_p16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I218_MN3 (VSS I1_I1298_G14_0n XI1_I1298_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I218_MN0 (XI1_I1298_I218_An I1_I1298_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1284_MN1 (XI1_I1284_Bn I1_qu16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1284_MN5 (XI1_I1284_n2 XI1_I1284_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1284_MN4 (I1_b16_18 XI1_I1284_An XI1_I1284_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1284_MN2 (XI1_I1284_n1 I1_dd18_b3_2 I1_b16_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1284_MN3 (VSS I1_qu16_b3_3 XI1_I1284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1284_MN0 (XI1_I1284_An I1_dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I218_MN1 (XI1_I1252_I218_Bn I1_I1252_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I218_MN5 (XI1_I1252_I218_n2 XI1_I1252_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I218_MN4 (I1_p15_15 XI1_I1252_I218_An XI1_I1252_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I218_MN2 (XI1_I1252_I218_n1 I1_I1252_pn15 I1_p15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I218_MN3 (VSS I1_I1252_G14_0n XI1_I1252_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I218_MN0 (XI1_I1252_I218_An I1_I1252_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I219_MN1 (XI1_I1252_I219_Bn I1_I1252_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I219_MN5 (XI1_I1252_I219_n2 XI1_I1252_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I219_MN4 (I1_p15_16 XI1_I1252_I219_An XI1_I1252_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I219_MN2 (XI1_I1252_I219_n1 I1_I1252_pn16 I1_p15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I219_MN3 (VSS I1_I1252_G15_0n XI1_I1252_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I219_MN0 (XI1_I1252_I219_An I1_I1252_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1239_MN1 (XI1_I1239_Bn I1_qu17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1239_MN5 (XI1_I1239_n2 XI1_I1239_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1239_MN4 (I1_b15_19 XI1_I1239_An XI1_I1239_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1239_MN2 (XI1_I1239_n1 I1_dd19_b3_2 I1_b15_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1239_MN3 (VSS I1_qu17_b3_3 XI1_I1239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1239_MN0 (XI1_I1239_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1193_MN1 (XI1_I1193_Bn I1_qu18_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1193_MN5 (XI1_I1193_n2 XI1_I1193_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1193_MN4 (I1_b14_19 XI1_I1193_An XI1_I1193_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1193_MN2 (XI1_I1193_n1 I1_dd19_b3_2 I1_b14_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1193_MN3 (VSS I1_qu18_b3_3 XI1_I1193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1193_MN0 (XI1_I1193_An I1_dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I881_MN1 (XI1_I881_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I881_MN5 (XI1_I881_n2 XI1_I881_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I881_MN4 (I1_b7_29 XI1_I881_An XI1_I881_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I881_MN2 (XI1_I881_n1 I1_dd29_b3_1 I1_b7_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I881_MN3 (VSS I1_qu25_b3_4 XI1_I881_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I881_MN0 (XI1_I881_An I1_dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I880_MN1 (XI1_I880_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I880_MN5 (XI1_I880_n2 XI1_I880_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I880_MN4 (I1_b7_28 XI1_I880_An XI1_I880_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I880_MN2 (XI1_I880_n1 I1_dd28_b3_1 I1_b7_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I880_MN3 (VSS I1_qu25_b3_4 XI1_I880_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I880_MN0 (XI1_I880_An I1_dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I879_MN1 (XI1_I879_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I879_MN5 (XI1_I879_n2 XI1_I879_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I879_MN4 (I1_b7_27 XI1_I879_An XI1_I879_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I879_MN2 (XI1_I879_n1 I1_dd27_b3_1 I1_b7_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I879_MN3 (VSS I1_qu25_b3_4 XI1_I879_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I879_MN0 (XI1_I879_An I1_dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I877_MN1 (XI1_I877_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I877_MN5 (XI1_I877_n2 XI1_I877_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I877_MN4 (I1_b7_25 XI1_I877_An XI1_I877_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I877_MN2 (XI1_I877_n1 I1_dd25_b3_1 I1_b7_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I877_MN3 (VSS I1_qu25_b3_4 XI1_I877_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I877_MN0 (XI1_I877_An I1_dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I878_MN1 (XI1_I878_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I878_MN5 (XI1_I878_n2 XI1_I878_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I878_MN4 (I1_b7_26 XI1_I878_An XI1_I878_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I878_MN2 (XI1_I878_n1 I1_dd26_b3_1 I1_b7_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I878_MN3 (VSS I1_qu25_b3_4 XI1_I878_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I878_MN0 (XI1_I878_An I1_dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I876_MN1 (XI1_I876_Bn I1_qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I876_MN5 (XI1_I876_n2 XI1_I876_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I876_MN4 (I1_b7_24 XI1_I876_An XI1_I876_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I876_MN2 (XI1_I876_n1 I1_dd24_b3_1 I1_b7_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I876_MN3 (VSS I1_qu25_b3_4 XI1_I876_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I876_MN0 (XI1_I876_An I1_dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I875_MN1 (XI1_I875_Bn I1_qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I875_MN5 (XI1_I875_n2 XI1_I875_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I875_MN4 (I1_b7_23 XI1_I875_An XI1_I875_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I875_MN2 (XI1_I875_n1 I1_dd23_b3_1 I1_b7_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I875_MN3 (VSS I1_qu25_b3_3 XI1_I875_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I875_MN0 (XI1_I875_An I1_dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I828_MN1 (XI1_I828_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I828_MN5 (XI1_I828_n2 XI1_I828_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I828_MN4 (I1_b6_22 XI1_I828_An XI1_I828_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I828_MN2 (XI1_I828_n1 I1_dd22_b3_1 I1_b6_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I828_MN3 (VSS I1_qu26_b3_3 XI1_I828_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I828_MN0 (XI1_I828_An I1_dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I824_MN1 (XI1_I824_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I824_MN5 (XI1_I824_n2 XI1_I824_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I824_MN4 (I1_b6_18 XI1_I824_An XI1_I824_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I824_MN2 (XI1_I824_n1 I1_dd18_b3_1 I1_b6_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I824_MN3 (VSS I1_qu26_b3_3 XI1_I824_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I824_MN0 (XI1_I824_An I1_dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I826_MN1 (XI1_I826_Bn I1_qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I826_MN5 (XI1_I826_n2 XI1_I826_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I826_MN4 (I1_b6_20 XI1_I826_An XI1_I826_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I826_MN2 (XI1_I826_n1 I1_dd20_b3_1 I1_b6_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I826_MN3 (VSS I1_qu26_b3_3 XI1_I826_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I826_MN0 (XI1_I826_An I1_dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I216_MN1 (XI1_I838_I216_Bn I1_I838_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I216_MN5 (XI1_I838_I216_n2 XI1_I838_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I216_MN4 (I1_p6_13 XI1_I838_I216_An XI1_I838_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I216_MN2 (XI1_I838_I216_n1 I1_I838_pn13 I1_p6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I216_MN3 (VSS I1_I838_G12_0n XI1_I838_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I216_MN0 (XI1_I838_I216_An I1_I838_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I823_MN1 (XI1_I823_Bn I1_qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I823_MN5 (XI1_I823_n2 XI1_I823_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I823_MN4 (I1_b6_17 XI1_I823_An XI1_I823_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I823_MN2 (XI1_I823_n1 I1_dd17_b3_1 I1_b6_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I823_MN3 (VSS I1_qu26_b3_2 XI1_I823_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I823_MN0 (XI1_I823_An I1_dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I212_MN1 (XI1_I838_I212_Bn I1_I838_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I838_I212_MN5 (XI1_I838_I212_n2 XI1_I838_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I838_I212_MN4 (I1_p6_9 XI1_I838_I212_An XI1_I838_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I212_MN2 (XI1_I838_I212_n1 I1_I838_pn9 I1_p6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I838_I212_MN3 (VSS I1_I838_G8_0n XI1_I838_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I838_I212_MN0 (XI1_I838_I212_An I1_I838_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I738_MN1 (XI1_I738_Bn I1_qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I738_MN5 (XI1_I738_n2 XI1_I738_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I738_MN4 (I1_b4_24 XI1_I738_An XI1_I738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I738_MN2 (XI1_I738_n1 I1_dd24_b3_0 I1_b4_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I738_MN3 (VSS I1_qu28_b3_4 XI1_I738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I738_MN0 (XI1_I738_An I1_dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1385_MN1 (XI1_I1385_Bn I1_qu14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1385_MN5 (XI1_I1385_n2 XI1_I1385_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1385_MN4 (I1_b18_27 XI1_I1385_An XI1_I1385_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1385_MN2 (XI1_I1385_n1 I1_dd27_b3_3 I1_b18_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1385_MN3 (VSS I1_qu14_b3_4 XI1_I1385_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1385_MN0 (XI1_I1385_An I1_dd27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I218_MN1 (XI1_I1344_I218_Bn I1_I1344_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1344_I218_MN5 (XI1_I1344_I218_n2 XI1_I1344_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1344_I218_MN4 (I1_p17_15 XI1_I1344_I218_An XI1_I1344_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I218_MN2 (XI1_I1344_I218_n1 I1_I1344_pn15 I1_p17_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1344_I218_MN3 (VSS I1_I1344_G14_0n XI1_I1344_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1344_I218_MN0 (XI1_I1344_I218_An I1_I1344_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I215_MN1 (XI1_I1298_I215_Bn I1_I1298_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I215_MN5 (XI1_I1298_I215_n2 XI1_I1298_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I215_MN4 (I1_p16_12 XI1_I1298_I215_An XI1_I1298_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I215_MN2 (XI1_I1298_I215_n1 I1_I1298_pn12 I1_p16_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I215_MN3 (VSS I1_I1298_G11_0n XI1_I1298_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I215_MN0 (XI1_I1298_I215_An I1_I1298_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I216_MN1 (XI1_I1298_I216_Bn I1_I1298_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1298_I216_MN5 (XI1_I1298_I216_n2 XI1_I1298_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1298_I216_MN4 (I1_p16_13 XI1_I1298_I216_An XI1_I1298_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I216_MN2 (XI1_I1298_I216_n1 I1_I1298_pn13 I1_p16_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1298_I216_MN3 (VSS I1_I1298_G12_0n XI1_I1298_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1298_I216_MN0 (XI1_I1298_I216_An I1_I1298_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I217_MN1 (XI1_I1252_I217_Bn I1_I1252_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1252_I217_MN5 (XI1_I1252_I217_n2 XI1_I1252_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1252_I217_MN4 (I1_p15_14 XI1_I1252_I217_An XI1_I1252_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I217_MN2 (XI1_I1252_I217_n1 I1_I1252_pn14 I1_p15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1252_I217_MN3 (VSS I1_I1252_G13_0n XI1_I1252_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1252_I217_MN0 (XI1_I1252_I217_An I1_I1252_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I219_MN1 (XI1_I1206_I219_Bn I1_I1206_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I219_MN5 (XI1_I1206_I219_n2 XI1_I1206_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I219_MN4 (I1_p14_16 XI1_I1206_I219_An XI1_I1206_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I219_MN2 (XI1_I1206_I219_n1 I1_I1206_pn16 I1_p14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I219_MN3 (VSS I1_I1206_G15_0n XI1_I1206_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I219_MN0 (XI1_I1206_I219_An I1_I1206_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I217_MN1 (XI1_I1206_I217_Bn I1_I1206_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I217_MN5 (XI1_I1206_I217_n2 XI1_I1206_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I217_MN4 (I1_p14_14 XI1_I1206_I217_An XI1_I1206_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I217_MN2 (XI1_I1206_I217_n1 I1_I1206_pn14 I1_p14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I217_MN3 (VSS I1_I1206_G13_0n XI1_I1206_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I217_MN0 (XI1_I1206_I217_An I1_I1206_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I218_MN1 (XI1_I1206_I218_Bn I1_I1206_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI1_I1206_I218_MN5 (XI1_I1206_I218_n2 XI1_I1206_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI1_I1206_I218_MN4 (I1_p14_15 XI1_I1206_I218_An XI1_I1206_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I218_MN2 (XI1_I1206_I218_n1 I1_I1206_pn15 I1_p14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI1_I1206_I218_MN3 (VSS I1_I1206_G14_0n XI1_I1206_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI1_I1206_I218_MN0 (XI1_I1206_I218_An I1_I1206_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
