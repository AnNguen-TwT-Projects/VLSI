    I_MXI1_I1988_I211_MP5 (I1_p31_8 I1_I1988_G7_0 XI1_I1988_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I211_MP4 (XI1_I1988_I211_p1 XI1_I1988_I211_An I1_p31_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I211_MP2 (VDD I1_I1988_pn8 XI1_I1988_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I211_MP3 (XI1_I1988_I211_p1 XI1_I1988_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I211_MP0 (VDD I1_I1988_pn8 XI1_I1988_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I210_MP1 (VDD I1_I1988_G6_0 XI1_I1988_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I210_MP5 (I1_p31_7 I1_I1988_G6_0 XI1_I1988_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I210_MP4 (XI1_I1988_I210_p1 XI1_I1988_I210_An I1_p31_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I210_MP2 (VDD I1_I1988_pn7 XI1_I1988_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I210_MP3 (XI1_I1988_I210_p1 XI1_I1988_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I210_MP0 (VDD I1_I1988_pn7 XI1_I1988_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I39_MP1 (VDD I1_dm7 XI1_I2066_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I39_MP5 (I1_I2066_pn7 I1_dm7 XI1_I2066_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I39_MP4 (XI1_I2066_I39_p1 XI1_I2066_I39_An I1_I2066_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I39_MP2 (VDD I1_p31_7 XI1_I2066_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I39_MP3 (XI1_I2066_I39_p1 XI1_I2066_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I39_MP0 (VDD I1_p31_7 XI1_I2066_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I497_MP1 (VDD I0_I1660_G29_0 XI0_I1660_I497_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I497_MP5 (MULP_30 I0_I1660_G29_0 XI0_I1660_I497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I497_MP4 (XI0_I1660_I497_p1 XI0_I1660_I497_An MULP_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I497_MP2 (VDD I0_I1660_pn30 XI0_I1660_I497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I497_MP3 (XI0_I1660_I497_p1 XI0_I1660_I497_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I497_MP0 (VDD I0_I1660_pn30 XI0_I1660_I497_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I498_MP1 (VDD I0_I1660_G30_0 XI0_I1660_I498_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I498_MP5 (MULP_31 I0_I1660_G30_0 XI0_I1660_I498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I498_MP4 (XI0_I1660_I498_p1 XI0_I1660_I498_An MULP_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I498_MP2 (VDD I0_I1660_pn31 XI0_I1660_I498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I498_MP3 (XI0_I1660_I498_p1 XI0_I1660_I498_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I498_MP0 (VDD I0_I1660_pn31 XI0_I1660_I498_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I96_MP1 (VDD I0_ha276_0 XI0_I1660_I96_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I96_MP5 (I0_I1660_pn32 I0_ha276_0 XI0_I1660_I96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I96_MP4 (XI0_I1660_I96_p1 XI0_I1660_I96_An I0_I1660_pn32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I96_MP2 (VDD I0_ha275_1 XI0_I1660_I96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I96_MP3 (XI0_I1660_I96_p1 XI0_I1660_I96_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I96_MP0 (VDD I0_ha275_1 XI0_I1660_I96_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I95_MP1 (VDD I0_ha275_0 XI0_I1660_I95_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I95_MP5 (I0_I1660_pn31 I0_ha275_0 XI0_I1660_I95_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I95_MP4 (XI0_I1660_I95_p1 XI0_I1660_I95_An I0_I1660_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I95_MP2 (VDD I0_ha274_1 XI0_I1660_I95_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I95_MP3 (XI0_I1660_I95_p1 XI0_I1660_I95_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I95_MP0 (VDD I0_ha274_1 XI0_I1660_I95_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I233_MP1 (VDD I1_I1804_G29_0 XI1_I1804_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I233_MP5 (I1_p27_30 I1_I1804_G29_0 XI1_I1804_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I233_MP4 (XI1_I1804_I233_p1 XI1_I1804_I233_An I1_p27_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I233_MP2 (VDD I1_I1804_pn30 XI1_I1804_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I233_MP3 (XI1_I1804_I233_p1 XI1_I1804_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I233_MP0 (VDD I1_I1804_pn30 XI1_I1804_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I229_MP1 (VDD I1_I1804_G25_0 XI1_I1804_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I229_MP5 (I1_p27_26 I1_I1804_G25_0 XI1_I1804_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I229_MP4 (XI1_I1804_I229_p1 XI1_I1804_I229_An I1_p27_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I229_MP2 (VDD I1_I1804_pn26 XI1_I1804_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I229_MP3 (XI1_I1804_I229_p1 XI1_I1804_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I229_MP0 (VDD I1_I1804_pn26 XI1_I1804_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I225_MP1 (VDD I1_I1804_G21_0 XI1_I1804_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I225_MP5 (I1_p27_22 I1_I1804_G21_0 XI1_I1804_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I225_MP4 (XI1_I1804_I225_p1 XI1_I1804_I225_An I1_p27_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I225_MP2 (VDD I1_I1804_pn22 XI1_I1804_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I225_MP3 (XI1_I1804_I225_p1 XI1_I1804_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I225_MP0 (VDD I1_I1804_pn22 XI1_I1804_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I221_MP1 (VDD I1_I1804_G17_0 XI1_I1804_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I221_MP5 (I1_p27_18 I1_I1804_G17_0 XI1_I1804_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I221_MP4 (XI1_I1804_I221_p1 XI1_I1804_I221_An I1_p27_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I221_MP2 (VDD I1_I1804_pn18 XI1_I1804_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I221_MP3 (XI1_I1804_I221_p1 XI1_I1804_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I221_MP0 (VDD I1_I1804_pn18 XI1_I1804_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I211_MP1 (VDD I1_I1804_G7_0 XI1_I1804_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I211_MP5 (I1_p27_8 I1_I1804_G7_0 XI1_I1804_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I211_MP4 (XI1_I1804_I211_p1 XI1_I1804_I211_An I1_p27_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I211_MP2 (VDD I1_I1804_pn8 XI1_I1804_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I211_MP3 (XI1_I1804_I211_p1 XI1_I1804_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I211_MP0 (VDD I1_I1804_pn8 XI1_I1804_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I40_MP1 (VDD I1_b28_8 XI1_I1850_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I40_MP5 (I1_I1850_pn8 I1_b28_8 XI1_I1850_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I40_MP4 (XI1_I1850_I40_p1 XI1_I1850_I40_An I1_I1850_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I40_MP2 (VDD I1_p27_7 XI1_I1850_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I40_MP3 (XI1_I1850_I40_p1 XI1_I1850_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I40_MP0 (VDD I1_p27_7 XI1_I1850_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I38_MP1 (VDD I1_b28_6 XI1_I1850_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I38_MP5 (I1_I1850_pn6 I1_b28_6 XI1_I1850_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I38_MP4 (XI1_I1850_I38_p1 XI1_I1850_I38_An I1_I1850_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I38_MP2 (VDD I1_p27_5 XI1_I1850_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I38_MP3 (XI1_I1850_I38_p1 XI1_I1850_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I38_MP0 (VDD I1_p27_5 XI1_I1850_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I40_MP1 (VDD I1_b29_8 XI1_I1896_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I40_MP5 (I1_I1896_pn8 I1_b29_8 XI1_I1896_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I40_MP4 (XI1_I1896_I40_p1 XI1_I1896_I40_An I1_I1896_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I40_MP2 (VDD I1_p28_7 XI1_I1896_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I40_MP3 (XI1_I1896_I40_p1 XI1_I1896_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I40_MP0 (VDD I1_p28_7 XI1_I1896_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I211_MP1 (VDD I1_I1896_G7_0 XI1_I1896_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I211_MP5 (I1_p29_8 I1_I1896_G7_0 XI1_I1896_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I211_MP4 (XI1_I1896_I211_p1 XI1_I1896_I211_An I1_p29_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I211_MP2 (VDD I1_I1896_pn8 XI1_I1896_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I211_MP3 (XI1_I1896_I211_p1 XI1_I1896_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I211_MP0 (VDD I1_I1896_pn8 XI1_I1896_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I42_MP1 (VDD I1_b30_10 XI1_I1942_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I42_MP5 (I1_I1942_pn10 I1_b30_10 XI1_I1942_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I42_MP4 (XI1_I1942_I42_p1 XI1_I1942_I42_An I1_I1942_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I42_MP2 (VDD I1_p29_9 XI1_I1942_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I42_MP3 (XI1_I1942_I42_p1 XI1_I1942_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I42_MP0 (VDD I1_p29_9 XI1_I1942_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I43_MP1 (VDD I1_b31_11 XI1_I1988_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I43_MP5 (I1_I1988_pn11 I1_b31_11 XI1_I1988_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I43_MP4 (XI1_I1988_I43_p1 XI1_I1988_I43_An I1_I1988_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I43_MP2 (VDD I1_p30_10 XI1_I1988_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I43_MP3 (XI1_I1988_I43_p1 XI1_I1988_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I43_MP0 (VDD I1_p30_10 XI1_I1988_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I42_MP1 (VDD I1_b31_10 XI1_I1988_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I42_MP5 (I1_I1988_pn10 I1_b31_10 XI1_I1988_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I42_MP4 (XI1_I1988_I42_p1 XI1_I1988_I42_An I1_I1988_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I42_MP2 (VDD I1_p30_9 XI1_I1988_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I42_MP3 (XI1_I1988_I42_p1 XI1_I1988_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I42_MP0 (VDD I1_p30_9 XI1_I1988_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I41_MP1 (VDD I1_dm9 XI1_I2066_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I41_MP5 (I1_I2066_pn9 I1_dm9 XI1_I2066_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I41_MP4 (XI1_I2066_I41_p1 XI1_I2066_I41_An I1_I2066_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I41_MP2 (VDD I1_p31_9 XI1_I2066_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I41_MP3 (XI1_I2066_I41_p1 XI1_I2066_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I41_MP0 (VDD I1_p31_9 XI1_I2066_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I42_MP1 (VDD I1_dm10 XI1_I2066_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I42_MP5 (I1_I2066_pn10 I1_dm10 XI1_I2066_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I42_MP4 (XI1_I2066_I42_p1 XI1_I2066_I42_An I1_I2066_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I42_MP2 (VDD I1_p31_10 XI1_I2066_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I42_MP3 (XI1_I2066_I42_p1 XI1_I2066_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I42_MP0 (VDD I1_p31_10 XI1_I2066_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I40_MP1 (VDD I1_dm8 XI1_I2066_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I40_MP5 (I1_I2066_pn8 I1_dm8 XI1_I2066_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I40_MP4 (XI1_I2066_I40_p1 XI1_I2066_I40_An I1_I2066_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I40_MP2 (VDD I1_p31_8 XI1_I2066_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I40_MP3 (XI1_I2066_I40_p1 XI1_I2066_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I40_MP0 (VDD I1_p31_8 XI1_I2066_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I204_MP1 (VDD I1_I2066_G0_0 XI1_I2066_I204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I204_MP5 (I1_ru1 I1_I2066_G0_0 XI1_I2066_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I204_MP4 (XI1_I2066_I204_p1 XI1_I2066_I204_An I1_ru1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I204_MP2 (VDD I1_I2066_pn1 XI1_I2066_I204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I204_MP3 (XI1_I2066_I204_p1 XI1_I2066_I204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I204_MP0 (VDD I1_I2066_pn1 XI1_I2066_I204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I499_MP1 (VDD I0_I1660_G31_0 XI0_I1660_I499_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I499_MP5 (MULP_32 I0_I1660_G31_0 XI0_I1660_I499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I499_MP4 (XI0_I1660_I499_p1 XI0_I1660_I499_An MULP_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I499_MP2 (VDD I0_I1660_pn32 XI0_I1660_I499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I499_MP3 (XI0_I1660_I499_p1 XI0_I1660_I499_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I499_MP0 (VDD I0_I1660_pn32 XI0_I1660_I499_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I97_MP1 (VDD I0_ha277_0 XI0_I1660_I97_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I97_MP5 (I0_I1660_pn33 I0_ha277_0 XI0_I1660_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I97_MP4 (XI0_I1660_I97_p1 XI0_I1660_I97_An I0_I1660_pn33 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I97_MP2 (VDD I0_ha276_1 XI0_I1660_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I97_MP3 (XI0_I1660_I97_p1 XI0_I1660_I97_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I97_MP0 (VDD I0_ha276_1 XI0_I1660_I97_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I98_MP1 (VDD I0_ha278_0 XI0_I1660_I98_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I98_MP5 (I0_I1660_pn34 I0_ha278_0 XI0_I1660_I98_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I98_MP4 (XI0_I1660_I98_p1 XI0_I1660_I98_An I0_I1660_pn34 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I98_MP2 (VDD I0_ha277_1 XI0_I1660_I98_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I98_MP3 (XI0_I1660_I98_p1 XI0_I1660_I98_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I98_MP0 (VDD I0_ha277_1 XI0_I1660_I98_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I99_MP1 (VDD I0_ha279_0 XI0_I1660_I99_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I99_MP5 (I0_I1660_pn35 I0_ha279_0 XI0_I1660_I99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I99_MP4 (XI0_I1660_I99_p1 XI0_I1660_I99_An I0_I1660_pn35 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I99_MP2 (VDD I0_ha278_1 XI0_I1660_I99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I99_MP3 (XI0_I1660_I99_p1 XI0_I1660_I99_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I99_MP0 (VDD I0_ha278_1 XI0_I1660_I99_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I223_MP1 (VDD I1_I1804_G19_0 XI1_I1804_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I223_MP5 (I1_p27_20 I1_I1804_G19_0 XI1_I1804_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I223_MP4 (XI1_I1804_I223_p1 XI1_I1804_I223_An I1_p27_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I223_MP2 (VDD I1_I1804_pn20 XI1_I1804_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I223_MP3 (XI1_I1804_I223_p1 XI1_I1804_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I223_MP0 (VDD I1_I1804_pn20 XI1_I1804_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I43_MP1 (VDD I1_b28_11 XI1_I1850_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I43_MP5 (I1_I1850_pn11 I1_b28_11 XI1_I1850_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I43_MP4 (XI1_I1850_I43_p1 XI1_I1850_I43_An I1_I1850_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I43_MP2 (VDD I1_p27_10 XI1_I1850_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I43_MP3 (XI1_I1850_I43_p1 XI1_I1850_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I43_MP0 (VDD I1_p27_10 XI1_I1850_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I42_MP1 (VDD I1_b28_10 XI1_I1850_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I42_MP5 (I1_I1850_pn10 I1_b28_10 XI1_I1850_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I42_MP4 (XI1_I1850_I42_p1 XI1_I1850_I42_An I1_I1850_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I42_MP2 (VDD I1_p27_9 XI1_I1850_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I42_MP3 (XI1_I1850_I42_p1 XI1_I1850_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I42_MP0 (VDD I1_p27_9 XI1_I1850_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I41_MP1 (VDD I1_b28_9 XI1_I1850_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I41_MP5 (I1_I1850_pn9 I1_b28_9 XI1_I1850_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I41_MP4 (XI1_I1850_I41_p1 XI1_I1850_I41_An I1_I1850_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I41_MP2 (VDD I1_p27_8 XI1_I1850_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I41_MP3 (XI1_I1850_I41_p1 XI1_I1850_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I41_MP0 (VDD I1_p27_8 XI1_I1850_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I210_MP1 (VDD I1_I1850_G6_0 XI1_I1850_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I210_MP5 (I1_p28_7 I1_I1850_G6_0 XI1_I1850_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I210_MP4 (XI1_I1850_I210_p1 XI1_I1850_I210_An I1_p28_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I210_MP2 (VDD I1_I1850_pn7 XI1_I1850_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I210_MP3 (XI1_I1850_I210_p1 XI1_I1850_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I210_MP0 (VDD I1_I1850_pn7 XI1_I1850_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I209_MP1 (VDD I1_I1850_G5_0 XI1_I1850_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I209_MP5 (I1_p28_6 I1_I1850_G5_0 XI1_I1850_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I209_MP4 (XI1_I1850_I209_p1 XI1_I1850_I209_An I1_p28_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I209_MP2 (VDD I1_I1850_pn6 XI1_I1850_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I209_MP3 (XI1_I1850_I209_p1 XI1_I1850_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I209_MP0 (VDD I1_I1850_pn6 XI1_I1850_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I42_MP1 (VDD I1_b29_10 XI1_I1896_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I42_MP5 (I1_I1896_pn10 I1_b29_10 XI1_I1896_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I42_MP4 (XI1_I1896_I42_p1 XI1_I1896_I42_An I1_I1896_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I42_MP2 (VDD I1_p28_9 XI1_I1896_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I42_MP3 (XI1_I1896_I42_p1 XI1_I1896_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I42_MP0 (VDD I1_p28_9 XI1_I1896_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I43_MP1 (VDD I1_b29_11 XI1_I1896_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I43_MP5 (I1_I1896_pn11 I1_b29_11 XI1_I1896_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I43_MP4 (XI1_I1896_I43_p1 XI1_I1896_I43_An I1_I1896_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I43_MP2 (VDD I1_p28_10 XI1_I1896_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I43_MP3 (XI1_I1896_I43_p1 XI1_I1896_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I43_MP0 (VDD I1_p28_10 XI1_I1896_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I41_MP1 (VDD I1_b29_9 XI1_I1896_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I41_MP5 (I1_I1896_pn9 I1_b29_9 XI1_I1896_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I41_MP4 (XI1_I1896_I41_p1 XI1_I1896_I41_An I1_I1896_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I41_MP2 (VDD I1_p28_8 XI1_I1896_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I41_MP3 (XI1_I1896_I41_p1 XI1_I1896_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I41_MP0 (VDD I1_p28_8 XI1_I1896_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I43_MP1 (VDD I1_b30_11 XI1_I1942_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I43_MP5 (I1_I1942_pn11 I1_b30_11 XI1_I1942_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I43_MP4 (XI1_I1942_I43_p1 XI1_I1942_I43_An I1_I1942_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I43_MP2 (VDD I1_p29_10 XI1_I1942_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I43_MP3 (XI1_I1942_I43_p1 XI1_I1942_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I43_MP0 (VDD I1_p29_10 XI1_I1942_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I44_MP1 (VDD I1_b30_12 XI1_I1942_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I44_MP5 (I1_I1942_pn12 I1_b30_12 XI1_I1942_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I44_MP4 (XI1_I1942_I44_p1 XI1_I1942_I44_An I1_I1942_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I44_MP2 (VDD I1_p29_11 XI1_I1942_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I44_MP3 (XI1_I1942_I44_p1 XI1_I1942_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I44_MP0 (VDD I1_p29_11 XI1_I1942_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I45_MP1 (VDD I1_b31_13 XI1_I1988_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I45_MP5 (I1_I1988_pn13 I1_b31_13 XI1_I1988_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I45_MP4 (XI1_I1988_I45_p1 XI1_I1988_I45_An I1_I1988_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I45_MP2 (VDD I1_p30_12 XI1_I1988_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I45_MP3 (XI1_I1988_I45_p1 XI1_I1988_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I45_MP0 (VDD I1_p30_12 XI1_I1988_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I44_MP1 (VDD I1_b31_12 XI1_I1988_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I44_MP5 (I1_I1988_pn12 I1_b31_12 XI1_I1988_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I44_MP4 (XI1_I1988_I44_p1 XI1_I1988_I44_An I1_I1988_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I44_MP2 (VDD I1_p30_11 XI1_I1988_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I44_MP3 (XI1_I1988_I44_p1 XI1_I1988_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I44_MP0 (VDD I1_p30_11 XI1_I1988_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I43_MP1 (VDD I1_dm11 XI1_I2066_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I43_MP5 (I1_I2066_pn11 I1_dm11 XI1_I2066_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I43_MP4 (XI1_I2066_I43_p1 XI1_I2066_I43_An I1_I2066_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I43_MP2 (VDD I1_p31_11 XI1_I2066_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I43_MP3 (XI1_I2066_I43_p1 XI1_I2066_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I43_MP0 (VDD I1_p31_11 XI1_I2066_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I205_MP1 (VDD I1_I2066_G1_0 XI1_I2066_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I205_MP5 (I1_ru2 I1_I2066_G1_0 XI1_I2066_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I205_MP4 (XI1_I2066_I205_p1 XI1_I2066_I205_An I1_ru2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I205_MP2 (VDD I1_I2066_pn2 XI1_I2066_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I205_MP3 (XI1_I2066_I205_p1 XI1_I2066_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I205_MP0 (VDD I1_I2066_pn2 XI1_I2066_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2171_MP1 (VDD I1_nrkn1 XI1_I2171_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2171_MP5 (DIVR_1 I1_nrkn1 XI1_I2171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2171_MP4 (XI1_I2171_p1 XI1_I2171_An DIVR_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2171_MP2 (VDD I1_ru1 XI1_I2171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2171_MP3 (XI1_I2171_p1 XI1_I2171_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2171_MP0 (VDD I1_ru1 XI1_I2171_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2174_MP1 (VDD I1_nrkn2 XI1_I2174_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2174_MP5 (DIVR_2 I1_nrkn2 XI1_I2174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2174_MP4 (XI1_I2174_p1 XI1_I2174_An DIVR_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2174_MP2 (VDD I1_ru2 XI1_I2174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2174_MP3 (XI1_I2174_p1 XI1_I2174_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2174_MP0 (VDD I1_ru2 XI1_I2174_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I102_MP1 (VDD I0_ha282_0 XI0_I1660_I102_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I102_MP5 (I0_I1660_pn38 I0_ha282_0 XI0_I1660_I102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I102_MP4 (XI0_I1660_I102_p1 XI0_I1660_I102_An I0_I1660_pn38 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I102_MP2 (VDD I0_fa281_1 XI0_I1660_I102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I102_MP3 (XI0_I1660_I102_p1 XI0_I1660_I102_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I102_MP0 (VDD I0_fa281_1 XI0_I1660_I102_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I103_MP1 (VDD I0_fa283_0 XI0_I1660_I103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I103_MP5 (I0_I1660_pn39 I0_fa283_0 XI0_I1660_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I103_MP4 (XI0_I1660_I103_p1 XI0_I1660_I103_An I0_I1660_pn39 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I103_MP2 (VDD I0_ha282_1 XI0_I1660_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I103_MP3 (XI0_I1660_I103_p1 XI0_I1660_I103_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I103_MP0 (VDD I0_ha282_1 XI0_I1660_I103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I100_MP1 (VDD I0_fa280_0 XI0_I1660_I100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I100_MP5 (I0_I1660_pn36 I0_fa280_0 XI0_I1660_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I100_MP4 (XI0_I1660_I100_p1 XI0_I1660_I100_An I0_I1660_pn36 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I100_MP2 (VDD I0_ha279_1 XI0_I1660_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I100_MP3 (XI0_I1660_I100_p1 XI0_I1660_I100_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I100_MP0 (VDD I0_ha279_1 XI0_I1660_I100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I101_MP1 (VDD I0_fa281_0 XI0_I1660_I101_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I101_MP5 (I0_I1660_pn37 I0_fa281_0 XI0_I1660_I101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I101_MP4 (XI0_I1660_I101_p1 XI0_I1660_I101_An I0_I1660_pn37 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I101_MP2 (VDD I0_fa280_1 XI0_I1660_I101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I101_MP3 (XI0_I1660_I101_p1 XI0_I1660_I101_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I101_MP0 (VDD I0_fa280_1 XI0_I1660_I101_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I231_MP1 (VDD I1_I1804_G27_0 XI1_I1804_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I231_MP5 (I1_p27_28 I1_I1804_G27_0 XI1_I1804_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I231_MP4 (XI1_I1804_I231_p1 XI1_I1804_I231_An I1_p27_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I231_MP2 (VDD I1_I1804_pn28 XI1_I1804_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I231_MP3 (XI1_I1804_I231_p1 XI1_I1804_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I231_MP0 (VDD I1_I1804_pn28 XI1_I1804_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I227_MP1 (VDD I1_I1804_G23_0 XI1_I1804_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1804_I227_MP5 (I1_p27_24 I1_I1804_G23_0 XI1_I1804_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1804_I227_MP4 (XI1_I1804_I227_p1 XI1_I1804_I227_An I1_p27_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I227_MP2 (VDD I1_I1804_pn24 XI1_I1804_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1804_I227_MP3 (XI1_I1804_I227_p1 XI1_I1804_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I227_MP0 (VDD I1_I1804_pn24 XI1_I1804_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I45_MP1 (VDD I1_b28_13 XI1_I1850_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I45_MP5 (I1_I1850_pn13 I1_b28_13 XI1_I1850_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I45_MP4 (XI1_I1850_I45_p1 XI1_I1850_I45_An I1_I1850_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I45_MP2 (VDD I1_p27_12 XI1_I1850_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I45_MP3 (XI1_I1850_I45_p1 XI1_I1850_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I45_MP0 (VDD I1_p27_12 XI1_I1850_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I44_MP1 (VDD I1_b28_12 XI1_I1850_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I44_MP5 (I1_I1850_pn12 I1_b28_12 XI1_I1850_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I44_MP4 (XI1_I1850_I44_p1 XI1_I1850_I44_An I1_I1850_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I44_MP2 (VDD I1_p27_11 XI1_I1850_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I44_MP3 (XI1_I1850_I44_p1 XI1_I1850_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I44_MP0 (VDD I1_p27_11 XI1_I1850_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I211_MP1 (VDD I1_I1850_G7_0 XI1_I1850_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I211_MP5 (I1_p28_8 I1_I1850_G7_0 XI1_I1850_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I211_MP4 (XI1_I1850_I211_p1 XI1_I1850_I211_An I1_p28_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I211_MP2 (VDD I1_I1850_pn8 XI1_I1850_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I211_MP3 (XI1_I1850_I211_p1 XI1_I1850_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I211_MP0 (VDD I1_I1850_pn8 XI1_I1850_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I45_MP1 (VDD I1_b30_13 XI1_I1942_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I45_MP5 (I1_I1942_pn13 I1_b30_13 XI1_I1942_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I45_MP4 (XI1_I1942_I45_p1 XI1_I1942_I45_An I1_I1942_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I45_MP2 (VDD I1_p29_12 XI1_I1942_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I45_MP3 (XI1_I1942_I45_p1 XI1_I1942_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I45_MP0 (VDD I1_p29_12 XI1_I1942_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I46_MP1 (VDD I1_b31_14 XI1_I1988_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I46_MP5 (I1_I1988_pn14 I1_b31_14 XI1_I1988_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I46_MP4 (XI1_I1988_I46_p1 XI1_I1988_I46_An I1_I1988_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I46_MP2 (VDD I1_p30_13 XI1_I1988_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I46_MP3 (XI1_I1988_I46_p1 XI1_I1988_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I46_MP0 (VDD I1_p30_13 XI1_I1988_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I44_MP1 (VDD I1_dm12 XI1_I2066_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I44_MP5 (I1_I2066_pn12 I1_dm12 XI1_I2066_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I44_MP4 (XI1_I2066_I44_p1 XI1_I2066_I44_An I1_I2066_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I44_MP2 (VDD I1_p31_12 XI1_I2066_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I44_MP3 (XI1_I2066_I44_p1 XI1_I2066_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I44_MP0 (VDD I1_p31_12 XI1_I2066_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I208_MP1 (VDD I1_I2066_G4_0 XI1_I2066_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I208_MP5 (I1_ru5 I1_I2066_G4_0 XI1_I2066_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I208_MP4 (XI1_I2066_I208_p1 XI1_I2066_I208_An I1_ru5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I208_MP2 (VDD I1_I2066_pn5 XI1_I2066_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I208_MP3 (XI1_I2066_I208_p1 XI1_I2066_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I208_MP0 (VDD I1_I2066_pn5 XI1_I2066_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2180_MP1 (VDD I1_nrkn4 XI1_I2180_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2180_MP5 (DIVR_4 I1_nrkn4 XI1_I2180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2180_MP4 (XI1_I2180_p1 XI1_I2180_An DIVR_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2180_MP2 (VDD I1_ru4 XI1_I2180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2180_MP3 (XI1_I2180_p1 XI1_I2180_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2180_MP0 (VDD I1_ru4 XI1_I2180_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I104_MP1 (VDD I0_ha284_0 XI0_I1660_I104_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I104_MP5 (I0_I1660_pn40 I0_ha284_0 XI0_I1660_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I104_MP4 (XI0_I1660_I104_p1 XI0_I1660_I104_An I0_I1660_pn40 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I104_MP2 (VDD I0_fa283_1 XI0_I1660_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I104_MP3 (XI0_I1660_I104_p1 XI0_I1660_I104_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I104_MP0 (VDD I0_fa283_1 XI0_I1660_I104_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I105_MP1 (VDD I0_fa285_0 XI0_I1660_I105_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I105_MP5 (I0_I1660_pn41 I0_fa285_0 XI0_I1660_I105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I105_MP4 (XI0_I1660_I105_p1 XI0_I1660_I105_An I0_I1660_pn41 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I105_MP2 (VDD I0_ha284_1 XI0_I1660_I105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I105_MP3 (XI0_I1660_I105_p1 XI0_I1660_I105_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I105_MP0 (VDD I0_ha284_1 XI0_I1660_I105_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I47_MP1 (VDD I1_b28_15 XI1_I1850_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I47_MP5 (I1_I1850_pn15 I1_b28_15 XI1_I1850_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I47_MP4 (XI1_I1850_I47_p1 XI1_I1850_I47_An I1_I1850_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I47_MP2 (VDD I1_p27_14 XI1_I1850_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I47_MP3 (XI1_I1850_I47_p1 XI1_I1850_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I47_MP0 (VDD I1_p27_14 XI1_I1850_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I44_MP1 (VDD I1_b29_12 XI1_I1896_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I44_MP5 (I1_I1896_pn12 I1_b29_12 XI1_I1896_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I44_MP4 (XI1_I1896_I44_p1 XI1_I1896_I44_An I1_I1896_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I44_MP2 (VDD I1_p28_11 XI1_I1896_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I44_MP3 (XI1_I1896_I44_p1 XI1_I1896_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I44_MP0 (VDD I1_p28_11 XI1_I1896_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I45_MP1 (VDD I1_b29_13 XI1_I1896_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I45_MP5 (I1_I1896_pn13 I1_b29_13 XI1_I1896_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I45_MP4 (XI1_I1896_I45_p1 XI1_I1896_I45_An I1_I1896_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I45_MP2 (VDD I1_p28_12 XI1_I1896_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I45_MP3 (XI1_I1896_I45_p1 XI1_I1896_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I45_MP0 (VDD I1_p28_12 XI1_I1896_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I47_MP1 (VDD I1_b30_15 XI1_I1942_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I47_MP5 (I1_I1942_pn15 I1_b30_15 XI1_I1942_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I47_MP4 (XI1_I1942_I47_p1 XI1_I1942_I47_An I1_I1942_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I47_MP2 (VDD I1_p29_14 XI1_I1942_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I47_MP3 (XI1_I1942_I47_p1 XI1_I1942_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I47_MP0 (VDD I1_p29_14 XI1_I1942_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I46_MP1 (VDD I1_b30_14 XI1_I1942_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I46_MP5 (I1_I1942_pn14 I1_b30_14 XI1_I1942_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I46_MP4 (XI1_I1942_I46_p1 XI1_I1942_I46_An I1_I1942_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I46_MP2 (VDD I1_p29_13 XI1_I1942_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I46_MP3 (XI1_I1942_I46_p1 XI1_I1942_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I46_MP0 (VDD I1_p29_13 XI1_I1942_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I47_MP1 (VDD I1_b31_15 XI1_I1988_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I47_MP5 (I1_I1988_pn15 I1_b31_15 XI1_I1988_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I47_MP4 (XI1_I1988_I47_p1 XI1_I1988_I47_An I1_I1988_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I47_MP2 (VDD I1_p30_14 XI1_I1988_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I47_MP3 (XI1_I1988_I47_p1 XI1_I1988_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I47_MP0 (VDD I1_p30_14 XI1_I1988_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I46_MP1 (VDD I1_dm14 XI1_I2066_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I46_MP5 (I1_I2066_pn14 I1_dm14 XI1_I2066_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I46_MP4 (XI1_I2066_I46_p1 XI1_I2066_I46_An I1_I2066_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I46_MP2 (VDD I1_p31_14 XI1_I2066_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I46_MP3 (XI1_I2066_I46_p1 XI1_I2066_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I46_MP0 (VDD I1_p31_14 XI1_I2066_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I45_MP1 (VDD I1_dm13 XI1_I2066_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I45_MP5 (I1_I2066_pn13 I1_dm13 XI1_I2066_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I45_MP4 (XI1_I2066_I45_p1 XI1_I2066_I45_An I1_I2066_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I45_MP2 (VDD I1_p31_13 XI1_I2066_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I45_MP3 (XI1_I2066_I45_p1 XI1_I2066_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I45_MP0 (VDD I1_p31_13 XI1_I2066_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I210_MP1 (VDD I1_I2066_G6_0 XI1_I2066_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I210_MP5 (I1_ru7 I1_I2066_G6_0 XI1_I2066_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I210_MP4 (XI1_I2066_I210_p1 XI1_I2066_I210_An I1_ru7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I210_MP2 (VDD I1_I2066_pn7 XI1_I2066_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I210_MP3 (XI1_I2066_I210_p1 XI1_I2066_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I210_MP0 (VDD I1_I2066_pn7 XI1_I2066_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I209_MP1 (VDD I1_I2066_G5_0 XI1_I2066_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I209_MP5 (I1_ru6 I1_I2066_G5_0 XI1_I2066_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I209_MP4 (XI1_I2066_I209_p1 XI1_I2066_I209_An I1_ru6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I209_MP2 (VDD I1_I2066_pn6 XI1_I2066_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I209_MP3 (XI1_I2066_I209_p1 XI1_I2066_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I209_MP0 (VDD I1_I2066_pn6 XI1_I2066_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2177_MP1 (VDD I1_nrkn3 XI1_I2177_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2177_MP5 (DIVR_3 I1_nrkn3 XI1_I2177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2177_MP4 (XI1_I2177_p1 XI1_I2177_An DIVR_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2177_MP2 (VDD I1_ru3 XI1_I2177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2177_MP3 (XI1_I2177_p1 XI1_I2177_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2177_MP0 (VDD I1_ru3 XI1_I2177_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2186_MP1 (VDD I1_nrkn6 XI1_I2186_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2186_MP5 (DIVR_6 I1_nrkn6 XI1_I2186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2186_MP4 (XI1_I2186_p1 XI1_I2186_An DIVR_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2186_MP2 (VDD I1_ru6 XI1_I2186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2186_MP3 (XI1_I2186_p1 XI1_I2186_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2186_MP0 (VDD I1_ru6 XI1_I2186_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2183_MP1 (VDD I1_nrkn5 XI1_I2183_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2183_MP5 (DIVR_5 I1_nrkn5 XI1_I2183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2183_MP4 (XI1_I2183_p1 XI1_I2183_An DIVR_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2183_MP2 (VDD I1_ru5 XI1_I2183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2183_MP3 (XI1_I2183_p1 XI1_I2183_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2183_MP0 (VDD I1_ru5 XI1_I2183_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I108_MP1 (VDD I0_ha288_0 XI0_I1660_I108_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I108_MP5 (I0_I1660_pn44 I0_ha288_0 XI0_I1660_I108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I108_MP4 (XI0_I1660_I108_p1 XI0_I1660_I108_An I0_I1660_pn44 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I108_MP2 (VDD I0_fa287_1 XI0_I1660_I108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I108_MP3 (XI0_I1660_I108_p1 XI0_I1660_I108_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I108_MP0 (VDD I0_fa287_1 XI0_I1660_I108_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I107_MP1 (VDD I0_fa287_0 XI0_I1660_I107_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I107_MP5 (I0_I1660_pn43 I0_fa287_0 XI0_I1660_I107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I107_MP4 (XI0_I1660_I107_p1 XI0_I1660_I107_An I0_I1660_pn43 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I107_MP2 (VDD I0_ha286_1 XI0_I1660_I107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I107_MP3 (XI0_I1660_I107_p1 XI0_I1660_I107_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I107_MP0 (VDD I0_ha286_1 XI0_I1660_I107_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I106_MP1 (VDD I0_ha286_0 XI0_I1660_I106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I106_MP5 (I0_I1660_pn42 I0_ha286_0 XI0_I1660_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I106_MP4 (XI0_I1660_I106_p1 XI0_I1660_I106_An I0_I1660_pn42 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I106_MP2 (VDD I0_fa285_1 XI0_I1660_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I106_MP3 (XI0_I1660_I106_p1 XI0_I1660_I106_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I106_MP0 (VDD I0_fa285_1 XI0_I1660_I106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I49_MP1 (VDD I1_b28_17 XI1_I1850_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I49_MP5 (I1_I1850_pn17 I1_b28_17 XI1_I1850_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I49_MP4 (XI1_I1850_I49_p1 XI1_I1850_I49_An I1_I1850_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I49_MP2 (VDD I1_p27_16 XI1_I1850_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I49_MP3 (XI1_I1850_I49_p1 XI1_I1850_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I49_MP0 (VDD I1_p27_16 XI1_I1850_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I48_MP1 (VDD I1_b28_16 XI1_I1850_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I48_MP5 (I1_I1850_pn16 I1_b28_16 XI1_I1850_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I48_MP4 (XI1_I1850_I48_p1 XI1_I1850_I48_An I1_I1850_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I48_MP2 (VDD I1_p27_15 XI1_I1850_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I48_MP3 (XI1_I1850_I48_p1 XI1_I1850_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I48_MP0 (VDD I1_p27_15 XI1_I1850_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I46_MP1 (VDD I1_b28_14 XI1_I1850_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I46_MP5 (I1_I1850_pn14 I1_b28_14 XI1_I1850_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I46_MP4 (XI1_I1850_I46_p1 XI1_I1850_I46_An I1_I1850_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I46_MP2 (VDD I1_p27_13 XI1_I1850_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I46_MP3 (XI1_I1850_I46_p1 XI1_I1850_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I46_MP0 (VDD I1_p27_13 XI1_I1850_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I46_MP1 (VDD I1_b29_14 XI1_I1896_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I46_MP5 (I1_I1896_pn14 I1_b29_14 XI1_I1896_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I46_MP4 (XI1_I1896_I46_p1 XI1_I1896_I46_An I1_I1896_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I46_MP2 (VDD I1_p28_13 XI1_I1896_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I46_MP3 (XI1_I1896_I46_p1 XI1_I1896_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I46_MP0 (VDD I1_p28_13 XI1_I1896_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I48_MP1 (VDD I1_b30_16 XI1_I1942_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I48_MP5 (I1_I1942_pn16 I1_b30_16 XI1_I1942_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I48_MP4 (XI1_I1942_I48_p1 XI1_I1942_I48_An I1_I1942_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I48_MP2 (VDD I1_p29_15 XI1_I1942_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I48_MP3 (XI1_I1942_I48_p1 XI1_I1942_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I48_MP0 (VDD I1_p29_15 XI1_I1942_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I220_MP1 (VDD I1_I1942_G16_0 XI1_I1942_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I220_MP5 (I1_p30_17 I1_I1942_G16_0 XI1_I1942_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I220_MP4 (XI1_I1942_I220_p1 XI1_I1942_I220_An I1_p30_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I220_MP2 (VDD I1_I1942_pn17 XI1_I1942_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I220_MP3 (XI1_I1942_I220_p1 XI1_I1942_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I220_MP0 (VDD I1_I1942_pn17 XI1_I1942_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I49_MP1 (VDD I1_b31_17 XI1_I1988_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I49_MP5 (I1_I1988_pn17 I1_b31_17 XI1_I1988_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I49_MP4 (XI1_I1988_I49_p1 XI1_I1988_I49_An I1_I1988_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I49_MP2 (VDD I1_p30_16 XI1_I1988_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I49_MP3 (XI1_I1988_I49_p1 XI1_I1988_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I49_MP0 (VDD I1_p30_16 XI1_I1988_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I48_MP1 (VDD I1_b31_16 XI1_I1988_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I48_MP5 (I1_I1988_pn16 I1_b31_16 XI1_I1988_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I48_MP4 (XI1_I1988_I48_p1 XI1_I1988_I48_An I1_I1988_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I48_MP2 (VDD I1_p30_15 XI1_I1988_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I48_MP3 (XI1_I1988_I48_p1 XI1_I1988_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I48_MP0 (VDD I1_p30_15 XI1_I1988_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I220_MP1 (VDD I1_I1988_G16_0 XI1_I1988_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I220_MP5 (I1_p31_17 I1_I1988_G16_0 XI1_I1988_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I220_MP4 (XI1_I1988_I220_p1 XI1_I1988_I220_An I1_p31_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I220_MP2 (VDD I1_I1988_pn17 XI1_I1988_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I220_MP3 (XI1_I1988_I220_p1 XI1_I1988_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I220_MP0 (VDD I1_I1988_pn17 XI1_I1988_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I47_MP1 (VDD I1_dm15 XI1_I2066_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I47_MP5 (I1_I2066_pn15 I1_dm15 XI1_I2066_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I47_MP4 (XI1_I2066_I47_p1 XI1_I2066_I47_An I1_I2066_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I47_MP2 (VDD I1_p31_15 XI1_I2066_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I47_MP3 (XI1_I2066_I47_p1 XI1_I2066_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I47_MP0 (VDD I1_p31_15 XI1_I2066_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2192_MP1 (VDD I1_nrkn8 XI1_I2192_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2192_MP5 (DIVR_8 I1_nrkn8 XI1_I2192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2192_MP4 (XI1_I2192_p1 XI1_I2192_An DIVR_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2192_MP2 (VDD I1_ru8 XI1_I2192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2192_MP3 (XI1_I2192_p1 XI1_I2192_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2192_MP0 (VDD I1_ru8 XI1_I2192_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2189_MP1 (VDD I1_nrkn7 XI1_I2189_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2189_MP5 (DIVR_7 I1_nrkn7 XI1_I2189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2189_MP4 (XI1_I2189_p1 XI1_I2189_An DIVR_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2189_MP2 (VDD I1_ru7 XI1_I2189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2189_MP3 (XI1_I2189_p1 XI1_I2189_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2189_MP0 (VDD I1_ru7 XI1_I2189_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I110_MP1 (VDD I0_ha290_0 XI0_I1660_I110_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I110_MP5 (I0_I1660_pn46 I0_ha290_0 XI0_I1660_I110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I110_MP4 (XI0_I1660_I110_p1 XI0_I1660_I110_An I0_I1660_pn46 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I110_MP2 (VDD I0_fa289_1 XI0_I1660_I110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I110_MP3 (XI0_I1660_I110_p1 XI0_I1660_I110_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I110_MP0 (VDD I0_fa289_1 XI0_I1660_I110_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I109_MP1 (VDD I0_fa289_0 XI0_I1660_I109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I109_MP5 (I0_I1660_pn45 I0_fa289_0 XI0_I1660_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I109_MP4 (XI0_I1660_I109_p1 XI0_I1660_I109_An I0_I1660_pn45 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I109_MP2 (VDD I0_ha288_1 XI0_I1660_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I109_MP3 (XI0_I1660_I109_p1 XI0_I1660_I109_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I109_MP0 (VDD I0_ha288_1 XI0_I1660_I109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I221_MP1 (VDD I1_I1850_G17_0 XI1_I1850_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I221_MP5 (I1_p28_18 I1_I1850_G17_0 XI1_I1850_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I221_MP4 (XI1_I1850_I221_p1 XI1_I1850_I221_An I1_p28_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I221_MP2 (VDD I1_I1850_pn18 XI1_I1850_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I221_MP3 (XI1_I1850_I221_p1 XI1_I1850_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I221_MP0 (VDD I1_I1850_pn18 XI1_I1850_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I49_MP1 (VDD I1_b29_17 XI1_I1896_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I49_MP5 (I1_I1896_pn17 I1_b29_17 XI1_I1896_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I49_MP4 (XI1_I1896_I49_p1 XI1_I1896_I49_An I1_I1896_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I49_MP2 (VDD I1_p28_16 XI1_I1896_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I49_MP3 (XI1_I1896_I49_p1 XI1_I1896_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I49_MP0 (VDD I1_p28_16 XI1_I1896_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I48_MP1 (VDD I1_b29_16 XI1_I1896_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I48_MP5 (I1_I1896_pn16 I1_b29_16 XI1_I1896_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I48_MP4 (XI1_I1896_I48_p1 XI1_I1896_I48_An I1_I1896_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I48_MP2 (VDD I1_p28_15 XI1_I1896_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I48_MP3 (XI1_I1896_I48_p1 XI1_I1896_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I48_MP0 (VDD I1_p28_15 XI1_I1896_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I47_MP1 (VDD I1_b29_15 XI1_I1896_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I47_MP5 (I1_I1896_pn15 I1_b29_15 XI1_I1896_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I47_MP4 (XI1_I1896_I47_p1 XI1_I1896_I47_An I1_I1896_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I47_MP2 (VDD I1_p28_14 XI1_I1896_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I47_MP3 (XI1_I1896_I47_p1 XI1_I1896_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I47_MP0 (VDD I1_p28_14 XI1_I1896_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I220_MP1 (VDD I1_I1896_G16_0 XI1_I1896_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I220_MP5 (I1_p29_17 I1_I1896_G16_0 XI1_I1896_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I220_MP4 (XI1_I1896_I220_p1 XI1_I1896_I220_An I1_p29_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I220_MP2 (VDD I1_I1896_pn17 XI1_I1896_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I220_MP3 (XI1_I1896_I220_p1 XI1_I1896_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I220_MP0 (VDD I1_I1896_pn17 XI1_I1896_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I49_MP1 (VDD I1_b30_17 XI1_I1942_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I49_MP5 (I1_I1942_pn17 I1_b30_17 XI1_I1942_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I49_MP4 (XI1_I1942_I49_p1 XI1_I1942_I49_An I1_I1942_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I49_MP2 (VDD I1_p29_16 XI1_I1942_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I49_MP3 (XI1_I1942_I49_p1 XI1_I1942_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I49_MP0 (VDD I1_p29_16 XI1_I1942_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I50_MP1 (VDD I1_b30_18 XI1_I1942_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I50_MP5 (I1_I1942_pn18 I1_b30_18 XI1_I1942_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I50_MP4 (XI1_I1942_I50_p1 XI1_I1942_I50_An I1_I1942_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I50_MP2 (VDD I1_p29_17 XI1_I1942_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I50_MP3 (XI1_I1942_I50_p1 XI1_I1942_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I50_MP0 (VDD I1_p29_17 XI1_I1942_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I221_MP1 (VDD I1_I1942_G17_0 XI1_I1942_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I221_MP5 (I1_p30_18 I1_I1942_G17_0 XI1_I1942_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I221_MP4 (XI1_I1942_I221_p1 XI1_I1942_I221_An I1_p30_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I221_MP2 (VDD I1_I1942_pn18 XI1_I1942_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I221_MP3 (XI1_I1942_I221_p1 XI1_I1942_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I221_MP0 (VDD I1_I1942_pn18 XI1_I1942_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I50_MP1 (VDD I1_b31_18 XI1_I1988_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I50_MP5 (I1_I1988_pn18 I1_b31_18 XI1_I1988_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I50_MP4 (XI1_I1988_I50_p1 XI1_I1988_I50_An I1_I1988_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I50_MP2 (VDD I1_p30_17 XI1_I1988_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I50_MP3 (XI1_I1988_I50_p1 XI1_I1988_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I50_MP0 (VDD I1_p30_17 XI1_I1988_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I51_MP1 (VDD I1_b31_19 XI1_I1988_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I51_MP5 (I1_I1988_pn19 I1_b31_19 XI1_I1988_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I51_MP4 (XI1_I1988_I51_p1 XI1_I1988_I51_An I1_I1988_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I51_MP2 (VDD I1_p30_18 XI1_I1988_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I51_MP3 (XI1_I1988_I51_p1 XI1_I1988_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I51_MP0 (VDD I1_p30_18 XI1_I1988_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I221_MP1 (VDD I1_I1988_G17_0 XI1_I1988_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I221_MP5 (I1_p31_18 I1_I1988_G17_0 XI1_I1988_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I221_MP4 (XI1_I1988_I221_p1 XI1_I1988_I221_An I1_p31_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I221_MP2 (VDD I1_I1988_pn18 XI1_I1988_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I221_MP3 (XI1_I1988_I221_p1 XI1_I1988_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I221_MP0 (VDD I1_I1988_pn18 XI1_I1988_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I49_MP1 (VDD I1_dm17 XI1_I2066_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I49_MP5 (I1_I2066_pn17 I1_dm17 XI1_I2066_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I49_MP4 (XI1_I2066_I49_p1 XI1_I2066_I49_An I1_I2066_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I49_MP2 (VDD I1_p31_17 XI1_I2066_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I49_MP3 (XI1_I2066_I49_p1 XI1_I2066_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I49_MP0 (VDD I1_p31_17 XI1_I2066_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I48_MP1 (VDD I1_dm16 XI1_I2066_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I48_MP5 (I1_I2066_pn16 I1_dm16 XI1_I2066_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I48_MP4 (XI1_I2066_I48_p1 XI1_I2066_I48_An I1_I2066_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I48_MP2 (VDD I1_p31_16 XI1_I2066_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I48_MP3 (XI1_I2066_I48_p1 XI1_I2066_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I48_MP0 (VDD I1_p31_16 XI1_I2066_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I220_MP1 (VDD I1_I2066_G16_0 XI1_I2066_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I220_MP5 (I1_ru17 I1_I2066_G16_0 XI1_I2066_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I220_MP4 (XI1_I2066_I220_p1 XI1_I2066_I220_An I1_ru17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I220_MP2 (VDD I1_I2066_pn17 XI1_I2066_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I220_MP3 (XI1_I2066_I220_p1 XI1_I2066_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I220_MP0 (VDD I1_I2066_pn17 XI1_I2066_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I211_MP1 (VDD I1_I2066_G7_0 XI1_I2066_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I211_MP5 (I1_ru8 I1_I2066_G7_0 XI1_I2066_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I211_MP4 (XI1_I2066_I211_p1 XI1_I2066_I211_An I1_ru8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I211_MP2 (VDD I1_I2066_pn8 XI1_I2066_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I211_MP3 (XI1_I2066_I211_p1 XI1_I2066_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I211_MP0 (VDD I1_I2066_pn8 XI1_I2066_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2198_MP1 (VDD I1_nrkn10 XI1_I2198_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2198_MP5 (DIVR_10 I1_nrkn10 XI1_I2198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2198_MP4 (XI1_I2198_p1 XI1_I2198_An DIVR_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2198_MP2 (VDD I1_ru10 XI1_I2198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2198_MP3 (XI1_I2198_p1 XI1_I2198_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2198_MP0 (VDD I1_ru10 XI1_I2198_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2195_MP1 (VDD I1_nrkn9 XI1_I2195_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2195_MP5 (DIVR_9 I1_nrkn9 XI1_I2195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2195_MP4 (XI1_I2195_p1 XI1_I2195_An DIVR_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2195_MP2 (VDD I1_ru9 XI1_I2195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2195_MP3 (XI1_I2195_p1 XI1_I2195_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2195_MP0 (VDD I1_ru9 XI1_I2195_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I111_MP1 (VDD I0_fa291_0 XI0_I1660_I111_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I111_MP5 (I0_I1660_pn47 I0_fa291_0 XI0_I1660_I111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I111_MP4 (XI0_I1660_I111_p1 XI0_I1660_I111_An I0_I1660_pn47 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I111_MP2 (VDD I0_ha290_1 XI0_I1660_I111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I111_MP3 (XI0_I1660_I111_p1 XI0_I1660_I111_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I111_MP0 (VDD I0_ha290_1 XI0_I1660_I111_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I50_MP1 (VDD I1_b28_18 XI1_I1850_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I50_MP5 (I1_I1850_pn18 I1_b28_18 XI1_I1850_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I50_MP4 (XI1_I1850_I50_p1 XI1_I1850_I50_An I1_I1850_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I50_MP2 (VDD I1_p27_17 XI1_I1850_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I50_MP3 (XI1_I1850_I50_p1 XI1_I1850_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I50_MP0 (VDD I1_p27_17 XI1_I1850_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I220_MP1 (VDD I1_I1850_G16_0 XI1_I1850_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I220_MP5 (I1_p28_17 I1_I1850_G16_0 XI1_I1850_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I220_MP4 (XI1_I1850_I220_p1 XI1_I1850_I220_An I1_p28_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I220_MP2 (VDD I1_I1850_pn17 XI1_I1850_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I220_MP3 (XI1_I1850_I220_p1 XI1_I1850_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I220_MP0 (VDD I1_I1850_pn17 XI1_I1850_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I51_MP1 (VDD I1_b29_19 XI1_I1896_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I51_MP5 (I1_I1896_pn19 I1_b29_19 XI1_I1896_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I51_MP4 (XI1_I1896_I51_p1 XI1_I1896_I51_An I1_I1896_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I51_MP2 (VDD I1_p28_18 XI1_I1896_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I51_MP3 (XI1_I1896_I51_p1 XI1_I1896_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I51_MP0 (VDD I1_p28_18 XI1_I1896_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I50_MP1 (VDD I1_b29_18 XI1_I1896_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I50_MP5 (I1_I1896_pn18 I1_b29_18 XI1_I1896_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I50_MP4 (XI1_I1896_I50_p1 XI1_I1896_I50_An I1_I1896_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I50_MP2 (VDD I1_p28_17 XI1_I1896_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I50_MP3 (XI1_I1896_I50_p1 XI1_I1896_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I50_MP0 (VDD I1_p28_17 XI1_I1896_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I221_MP1 (VDD I1_I1896_G17_0 XI1_I1896_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I221_MP5 (I1_p29_18 I1_I1896_G17_0 XI1_I1896_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I221_MP4 (XI1_I1896_I221_p1 XI1_I1896_I221_An I1_p29_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I221_MP2 (VDD I1_I1896_pn18 XI1_I1896_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I221_MP3 (XI1_I1896_I221_p1 XI1_I1896_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I221_MP0 (VDD I1_I1896_pn18 XI1_I1896_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I222_MP1 (VDD I1_I1896_G18_0 XI1_I1896_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I222_MP5 (I1_p29_19 I1_I1896_G18_0 XI1_I1896_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I222_MP4 (XI1_I1896_I222_p1 XI1_I1896_I222_An I1_p29_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I222_MP2 (VDD I1_I1896_pn19 XI1_I1896_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I222_MP3 (XI1_I1896_I222_p1 XI1_I1896_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I222_MP0 (VDD I1_I1896_pn19 XI1_I1896_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I51_MP1 (VDD I1_b30_19 XI1_I1942_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I51_MP5 (I1_I1942_pn19 I1_b30_19 XI1_I1942_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I51_MP4 (XI1_I1942_I51_p1 XI1_I1942_I51_An I1_I1942_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I51_MP2 (VDD I1_p29_18 XI1_I1942_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I51_MP3 (XI1_I1942_I51_p1 XI1_I1942_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I51_MP0 (VDD I1_p29_18 XI1_I1942_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I52_MP1 (VDD I1_b30_20 XI1_I1942_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I52_MP5 (I1_I1942_pn20 I1_b30_20 XI1_I1942_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I52_MP4 (XI1_I1942_I52_p1 XI1_I1942_I52_An I1_I1942_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I52_MP2 (VDD I1_p29_19 XI1_I1942_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I52_MP3 (XI1_I1942_I52_p1 XI1_I1942_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I52_MP0 (VDD I1_p29_19 XI1_I1942_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I223_MP1 (VDD I1_I1942_G19_0 XI1_I1942_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I223_MP5 (I1_p30_20 I1_I1942_G19_0 XI1_I1942_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I223_MP4 (XI1_I1942_I223_p1 XI1_I1942_I223_An I1_p30_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I223_MP2 (VDD I1_I1942_pn20 XI1_I1942_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I223_MP3 (XI1_I1942_I223_p1 XI1_I1942_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I223_MP0 (VDD I1_I1942_pn20 XI1_I1942_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I222_MP1 (VDD I1_I1942_G18_0 XI1_I1942_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I222_MP5 (I1_p30_19 I1_I1942_G18_0 XI1_I1942_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I222_MP4 (XI1_I1942_I222_p1 XI1_I1942_I222_An I1_p30_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I222_MP2 (VDD I1_I1942_pn19 XI1_I1942_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I222_MP3 (XI1_I1942_I222_p1 XI1_I1942_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I222_MP0 (VDD I1_I1942_pn19 XI1_I1942_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I53_MP1 (VDD I1_b31_21 XI1_I1988_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I53_MP5 (I1_I1988_pn21 I1_b31_21 XI1_I1988_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I53_MP4 (XI1_I1988_I53_p1 XI1_I1988_I53_An I1_I1988_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I53_MP2 (VDD I1_p30_20 XI1_I1988_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I53_MP3 (XI1_I1988_I53_p1 XI1_I1988_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I53_MP0 (VDD I1_p30_20 XI1_I1988_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I52_MP1 (VDD I1_b31_20 XI1_I1988_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I52_MP5 (I1_I1988_pn20 I1_b31_20 XI1_I1988_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I52_MP4 (XI1_I1988_I52_p1 XI1_I1988_I52_An I1_I1988_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I52_MP2 (VDD I1_p30_19 XI1_I1988_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I52_MP3 (XI1_I1988_I52_p1 XI1_I1988_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I52_MP0 (VDD I1_p30_19 XI1_I1988_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I223_MP1 (VDD I1_I1988_G19_0 XI1_I1988_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I223_MP5 (I1_p31_20 I1_I1988_G19_0 XI1_I1988_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I223_MP4 (XI1_I1988_I223_p1 XI1_I1988_I223_An I1_p31_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I223_MP2 (VDD I1_I1988_pn20 XI1_I1988_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I223_MP3 (XI1_I1988_I223_p1 XI1_I1988_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I223_MP0 (VDD I1_I1988_pn20 XI1_I1988_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I50_MP1 (VDD I1_dm18 XI1_I2066_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I50_MP5 (I1_I2066_pn18 I1_dm18 XI1_I2066_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I50_MP4 (XI1_I2066_I50_p1 XI1_I2066_I50_An I1_I2066_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I50_MP2 (VDD I1_p31_18 XI1_I2066_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I50_MP3 (XI1_I2066_I50_p1 XI1_I2066_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I50_MP0 (VDD I1_p31_18 XI1_I2066_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I222_MP1 (VDD I1_I1988_G18_0 XI1_I1988_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I222_MP5 (I1_p31_19 I1_I1988_G18_0 XI1_I1988_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I222_MP4 (XI1_I1988_I222_p1 XI1_I1988_I222_An I1_p31_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I222_MP2 (VDD I1_I1988_pn19 XI1_I1988_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I222_MP3 (XI1_I1988_I222_p1 XI1_I1988_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I222_MP0 (VDD I1_I1988_pn19 XI1_I1988_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I221_MP1 (VDD I1_I2066_G17_0 XI1_I2066_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I221_MP5 (I1_ru18 I1_I2066_G17_0 XI1_I2066_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I221_MP4 (XI1_I2066_I221_p1 XI1_I2066_I221_An I1_ru18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I221_MP2 (VDD I1_I2066_pn18 XI1_I2066_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I221_MP3 (XI1_I2066_I221_p1 XI1_I2066_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I221_MP0 (VDD I1_I2066_pn18 XI1_I2066_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2201_MP1 (VDD I1_nrkn11 XI1_I2201_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2201_MP5 (DIVR_11 I1_nrkn11 XI1_I2201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2201_MP4 (XI1_I2201_p1 XI1_I2201_An DIVR_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2201_MP2 (VDD I1_ru11 XI1_I2201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2201_MP3 (XI1_I2201_p1 XI1_I2201_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2201_MP0 (VDD I1_ru11 XI1_I2201_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2207_MP1 (VDD I1_nrkn13 XI1_I2207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2207_MP5 (DIVR_13 I1_nrkn13 XI1_I2207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2207_MP4 (XI1_I2207_p1 XI1_I2207_An DIVR_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2207_MP2 (VDD I1_ru13 XI1_I2207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2207_MP3 (XI1_I2207_p1 XI1_I2207_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2207_MP0 (VDD I1_ru13 XI1_I2207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2204_MP1 (VDD I1_nrkn12 XI1_I2204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2204_MP5 (DIVR_12 I1_nrkn12 XI1_I2204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2204_MP4 (XI1_I2204_p1 XI1_I2204_An DIVR_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2204_MP2 (VDD I1_ru12 XI1_I2204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2204_MP3 (XI1_I2204_p1 XI1_I2204_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2204_MP0 (VDD I1_ru12 XI1_I2204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I112_MP1 (VDD I0_ha292_0 XI0_I1660_I112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I112_MP5 (I0_I1660_pn48 I0_ha292_0 XI0_I1660_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I112_MP4 (XI0_I1660_I112_p1 XI0_I1660_I112_An I0_I1660_pn48 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I112_MP2 (VDD I0_fa291_1 XI0_I1660_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I112_MP3 (XI0_I1660_I112_p1 XI0_I1660_I112_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I112_MP0 (VDD I0_fa291_1 XI0_I1660_I112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I223_MP1 (VDD I1_I1850_G19_0 XI1_I1850_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I223_MP5 (I1_p28_20 I1_I1850_G19_0 XI1_I1850_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I223_MP4 (XI1_I1850_I223_p1 XI1_I1850_I223_An I1_p28_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I223_MP2 (VDD I1_I1850_pn20 XI1_I1850_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I223_MP3 (XI1_I1850_I223_p1 XI1_I1850_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I223_MP0 (VDD I1_I1850_pn20 XI1_I1850_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I53_MP1 (VDD I1_b28_21 XI1_I1850_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I53_MP5 (I1_I1850_pn21 I1_b28_21 XI1_I1850_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I53_MP4 (XI1_I1850_I53_p1 XI1_I1850_I53_An I1_I1850_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I53_MP2 (VDD I1_p27_20 XI1_I1850_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I53_MP3 (XI1_I1850_I53_p1 XI1_I1850_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I53_MP0 (VDD I1_p27_20 XI1_I1850_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I52_MP1 (VDD I1_b28_20 XI1_I1850_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I52_MP5 (I1_I1850_pn20 I1_b28_20 XI1_I1850_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I52_MP4 (XI1_I1850_I52_p1 XI1_I1850_I52_An I1_I1850_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I52_MP2 (VDD I1_p27_19 XI1_I1850_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I52_MP3 (XI1_I1850_I52_p1 XI1_I1850_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I52_MP0 (VDD I1_p27_19 XI1_I1850_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I51_MP1 (VDD I1_b28_19 XI1_I1850_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I51_MP5 (I1_I1850_pn19 I1_b28_19 XI1_I1850_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I51_MP4 (XI1_I1850_I51_p1 XI1_I1850_I51_An I1_I1850_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I51_MP2 (VDD I1_p27_18 XI1_I1850_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I51_MP3 (XI1_I1850_I51_p1 XI1_I1850_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I51_MP0 (VDD I1_p27_18 XI1_I1850_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I222_MP1 (VDD I1_I1850_G18_0 XI1_I1850_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I222_MP5 (I1_p28_19 I1_I1850_G18_0 XI1_I1850_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I222_MP4 (XI1_I1850_I222_p1 XI1_I1850_I222_An I1_p28_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I222_MP2 (VDD I1_I1850_pn19 XI1_I1850_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I222_MP3 (XI1_I1850_I222_p1 XI1_I1850_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I222_MP0 (VDD I1_I1850_pn19 XI1_I1850_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I52_MP1 (VDD I1_b29_20 XI1_I1896_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I52_MP5 (I1_I1896_pn20 I1_b29_20 XI1_I1896_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I52_MP4 (XI1_I1896_I52_p1 XI1_I1896_I52_An I1_I1896_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I52_MP2 (VDD I1_p28_19 XI1_I1896_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I52_MP3 (XI1_I1896_I52_p1 XI1_I1896_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I52_MP0 (VDD I1_p28_19 XI1_I1896_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I223_MP1 (VDD I1_I1896_G19_0 XI1_I1896_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I223_MP5 (I1_p29_20 I1_I1896_G19_0 XI1_I1896_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I223_MP4 (XI1_I1896_I223_p1 XI1_I1896_I223_An I1_p29_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I223_MP2 (VDD I1_I1896_pn20 XI1_I1896_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I223_MP3 (XI1_I1896_I223_p1 XI1_I1896_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I223_MP0 (VDD I1_I1896_pn20 XI1_I1896_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I224_MP1 (VDD I1_I1896_G20_0 XI1_I1896_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I224_MP5 (I1_p29_21 I1_I1896_G20_0 XI1_I1896_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I224_MP4 (XI1_I1896_I224_p1 XI1_I1896_I224_An I1_p29_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I224_MP2 (VDD I1_I1896_pn21 XI1_I1896_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I224_MP3 (XI1_I1896_I224_p1 XI1_I1896_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I224_MP0 (VDD I1_I1896_pn21 XI1_I1896_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I53_MP1 (VDD I1_b30_21 XI1_I1942_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I53_MP5 (I1_I1942_pn21 I1_b30_21 XI1_I1942_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I53_MP4 (XI1_I1942_I53_p1 XI1_I1942_I53_An I1_I1942_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I53_MP2 (VDD I1_p29_20 XI1_I1942_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I53_MP3 (XI1_I1942_I53_p1 XI1_I1942_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I53_MP0 (VDD I1_p29_20 XI1_I1942_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I224_MP1 (VDD I1_I1942_G20_0 XI1_I1942_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I224_MP5 (I1_p30_21 I1_I1942_G20_0 XI1_I1942_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I224_MP4 (XI1_I1942_I224_p1 XI1_I1942_I224_An I1_p30_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I224_MP2 (VDD I1_I1942_pn21 XI1_I1942_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I224_MP3 (XI1_I1942_I224_p1 XI1_I1942_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I224_MP0 (VDD I1_I1942_pn21 XI1_I1942_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I54_MP1 (VDD I1_b31_22 XI1_I1988_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I54_MP5 (I1_I1988_pn22 I1_b31_22 XI1_I1988_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I54_MP4 (XI1_I1988_I54_p1 XI1_I1988_I54_An I1_I1988_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I54_MP2 (VDD I1_p30_21 XI1_I1988_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I54_MP3 (XI1_I1988_I54_p1 XI1_I1988_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I54_MP0 (VDD I1_p30_21 XI1_I1988_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I225_MP1 (VDD I1_I1988_G21_0 XI1_I1988_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I225_MP5 (I1_p31_22 I1_I1988_G21_0 XI1_I1988_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I225_MP4 (XI1_I1988_I225_p1 XI1_I1988_I225_An I1_p31_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I225_MP2 (VDD I1_I1988_pn22 XI1_I1988_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I225_MP3 (XI1_I1988_I225_p1 XI1_I1988_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I225_MP0 (VDD I1_I1988_pn22 XI1_I1988_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I224_MP1 (VDD I1_I1988_G20_0 XI1_I1988_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I224_MP5 (I1_p31_21 I1_I1988_G20_0 XI1_I1988_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I224_MP4 (XI1_I1988_I224_p1 XI1_I1988_I224_An I1_p31_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I224_MP2 (VDD I1_I1988_pn21 XI1_I1988_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I224_MP3 (XI1_I1988_I224_p1 XI1_I1988_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I224_MP0 (VDD I1_I1988_pn21 XI1_I1988_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I51_MP1 (VDD I1_dm19 XI1_I2066_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I51_MP5 (I1_I2066_pn19 I1_dm19 XI1_I2066_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I51_MP4 (XI1_I2066_I51_p1 XI1_I2066_I51_An I1_I2066_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I51_MP2 (VDD I1_p31_19 XI1_I2066_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I51_MP3 (XI1_I2066_I51_p1 XI1_I2066_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I51_MP0 (VDD I1_p31_19 XI1_I2066_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I222_MP1 (VDD I1_I2066_G18_0 XI1_I2066_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I222_MP5 (I1_ru19 I1_I2066_G18_0 XI1_I2066_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I222_MP4 (XI1_I2066_I222_p1 XI1_I2066_I222_An I1_ru19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I222_MP2 (VDD I1_I2066_pn19 XI1_I2066_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I222_MP3 (XI1_I2066_I222_p1 XI1_I2066_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I222_MP0 (VDD I1_I2066_pn19 XI1_I2066_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I223_MP1 (VDD I1_I2066_G19_0 XI1_I2066_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I223_MP5 (I1_ru20 I1_I2066_G19_0 XI1_I2066_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I223_MP4 (XI1_I2066_I223_p1 XI1_I2066_I223_An I1_ru20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I223_MP2 (VDD I1_I2066_pn20 XI1_I2066_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I223_MP3 (XI1_I2066_I223_p1 XI1_I2066_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I223_MP0 (VDD I1_I2066_pn20 XI1_I2066_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2210_MP1 (VDD I1_nrkn14 XI1_I2210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2210_MP5 (DIVR_14 I1_nrkn14 XI1_I2210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2210_MP4 (XI1_I2210_p1 XI1_I2210_An DIVR_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2210_MP2 (VDD I1_ru14 XI1_I2210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2210_MP3 (XI1_I2210_p1 XI1_I2210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2210_MP0 (VDD I1_ru14 XI1_I2210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2222_MP1 (VDD I1_nrkn18 XI1_I2222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2222_MP5 (DIVR_18 I1_nrkn18 XI1_I2222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2222_MP4 (XI1_I2222_p1 XI1_I2222_An DIVR_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2222_MP2 (VDD I1_ru18 XI1_I2222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2222_MP3 (XI1_I2222_p1 XI1_I2222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2222_MP0 (VDD I1_ru18 XI1_I2222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I113_MP1 (VDD I0_fa293_0 XI0_I1660_I113_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I113_MP5 (I0_I1660_pn49 I0_fa293_0 XI0_I1660_I113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I113_MP4 (XI0_I1660_I113_p1 XI0_I1660_I113_An I0_I1660_pn49 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I113_MP2 (VDD I0_ha292_1 XI0_I1660_I113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I113_MP3 (XI0_I1660_I113_p1 XI0_I1660_I113_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I113_MP0 (VDD I0_ha292_1 XI0_I1660_I113_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I55_MP1 (VDD I1_b28_23 XI1_I1850_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I55_MP5 (I1_I1850_pn23 I1_b28_23 XI1_I1850_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I55_MP4 (XI1_I1850_I55_p1 XI1_I1850_I55_An I1_I1850_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I55_MP2 (VDD I1_p27_22 XI1_I1850_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I55_MP3 (XI1_I1850_I55_p1 XI1_I1850_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I55_MP0 (VDD I1_p27_22 XI1_I1850_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I54_MP1 (VDD I1_b28_22 XI1_I1850_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I54_MP5 (I1_I1850_pn22 I1_b28_22 XI1_I1850_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I54_MP4 (XI1_I1850_I54_p1 XI1_I1850_I54_An I1_I1850_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I54_MP2 (VDD I1_p27_21 XI1_I1850_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I54_MP3 (XI1_I1850_I54_p1 XI1_I1850_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I54_MP0 (VDD I1_p27_21 XI1_I1850_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I224_MP1 (VDD I1_I1850_G20_0 XI1_I1850_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I224_MP5 (I1_p28_21 I1_I1850_G20_0 XI1_I1850_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I224_MP4 (XI1_I1850_I224_p1 XI1_I1850_I224_An I1_p28_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I224_MP2 (VDD I1_I1850_pn21 XI1_I1850_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I224_MP3 (XI1_I1850_I224_p1 XI1_I1850_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I224_MP0 (VDD I1_I1850_pn21 XI1_I1850_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I53_MP1 (VDD I1_b29_21 XI1_I1896_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I53_MP5 (I1_I1896_pn21 I1_b29_21 XI1_I1896_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I53_MP4 (XI1_I1896_I53_p1 XI1_I1896_I53_An I1_I1896_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I53_MP2 (VDD I1_p28_20 XI1_I1896_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I53_MP3 (XI1_I1896_I53_p1 XI1_I1896_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I53_MP0 (VDD I1_p28_20 XI1_I1896_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I54_MP1 (VDD I1_b29_22 XI1_I1896_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I54_MP5 (I1_I1896_pn22 I1_b29_22 XI1_I1896_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I54_MP4 (XI1_I1896_I54_p1 XI1_I1896_I54_An I1_I1896_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I54_MP2 (VDD I1_p28_21 XI1_I1896_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I54_MP3 (XI1_I1896_I54_p1 XI1_I1896_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I54_MP0 (VDD I1_p28_21 XI1_I1896_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I225_MP1 (VDD I1_I1896_G21_0 XI1_I1896_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I225_MP5 (I1_p29_22 I1_I1896_G21_0 XI1_I1896_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I225_MP4 (XI1_I1896_I225_p1 XI1_I1896_I225_An I1_p29_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I225_MP2 (VDD I1_I1896_pn22 XI1_I1896_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I225_MP3 (XI1_I1896_I225_p1 XI1_I1896_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I225_MP0 (VDD I1_I1896_pn22 XI1_I1896_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I54_MP1 (VDD I1_b30_22 XI1_I1942_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I54_MP5 (I1_I1942_pn22 I1_b30_22 XI1_I1942_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I54_MP4 (XI1_I1942_I54_p1 XI1_I1942_I54_An I1_I1942_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I54_MP2 (VDD I1_p29_21 XI1_I1942_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I54_MP3 (XI1_I1942_I54_p1 XI1_I1942_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I54_MP0 (VDD I1_p29_21 XI1_I1942_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I225_MP1 (VDD I1_I1942_G21_0 XI1_I1942_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I225_MP5 (I1_p30_22 I1_I1942_G21_0 XI1_I1942_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I225_MP4 (XI1_I1942_I225_p1 XI1_I1942_I225_An I1_p30_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I225_MP2 (VDD I1_I1942_pn22 XI1_I1942_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I225_MP3 (XI1_I1942_I225_p1 XI1_I1942_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I225_MP0 (VDD I1_I1942_pn22 XI1_I1942_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I226_MP1 (VDD I1_I1942_G22_0 XI1_I1942_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I226_MP5 (I1_p30_23 I1_I1942_G22_0 XI1_I1942_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I226_MP4 (XI1_I1942_I226_p1 XI1_I1942_I226_An I1_p30_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I226_MP2 (VDD I1_I1942_pn23 XI1_I1942_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I226_MP3 (XI1_I1942_I226_p1 XI1_I1942_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I226_MP0 (VDD I1_I1942_pn23 XI1_I1942_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I55_MP1 (VDD I1_b31_23 XI1_I1988_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I55_MP5 (I1_I1988_pn23 I1_b31_23 XI1_I1988_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I55_MP4 (XI1_I1988_I55_p1 XI1_I1988_I55_An I1_I1988_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I55_MP2 (VDD I1_p30_22 XI1_I1988_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I55_MP3 (XI1_I1988_I55_p1 XI1_I1988_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I55_MP0 (VDD I1_p30_22 XI1_I1988_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I226_MP1 (VDD I1_I1988_G22_0 XI1_I1988_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I226_MP5 (I1_p31_23 I1_I1988_G22_0 XI1_I1988_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I226_MP4 (XI1_I1988_I226_p1 XI1_I1988_I226_An I1_p31_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I226_MP2 (VDD I1_I1988_pn23 XI1_I1988_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I226_MP3 (XI1_I1988_I226_p1 XI1_I1988_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I226_MP0 (VDD I1_I1988_pn23 XI1_I1988_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I52_MP1 (VDD I1_dm20 XI1_I2066_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I52_MP5 (I1_I2066_pn20 I1_dm20 XI1_I2066_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I52_MP4 (XI1_I2066_I52_p1 XI1_I2066_I52_An I1_I2066_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I52_MP2 (VDD I1_p31_20 XI1_I2066_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I52_MP3 (XI1_I2066_I52_p1 XI1_I2066_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I52_MP0 (VDD I1_p31_20 XI1_I2066_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I53_MP1 (VDD I1_dm21 XI1_I2066_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I53_MP5 (I1_I2066_pn21 I1_dm21 XI1_I2066_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I53_MP4 (XI1_I2066_I53_p1 XI1_I2066_I53_An I1_I2066_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I53_MP2 (VDD I1_p31_21 XI1_I2066_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I53_MP3 (XI1_I2066_I53_p1 XI1_I2066_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I53_MP0 (VDD I1_p31_21 XI1_I2066_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I224_MP1 (VDD I1_I2066_G20_0 XI1_I2066_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I224_MP5 (I1_ru21 I1_I2066_G20_0 XI1_I2066_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I224_MP4 (XI1_I2066_I224_p1 XI1_I2066_I224_An I1_ru21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I224_MP2 (VDD I1_I2066_pn21 XI1_I2066_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I224_MP3 (XI1_I2066_I224_p1 XI1_I2066_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I224_MP0 (VDD I1_I2066_pn21 XI1_I2066_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I225_MP1 (VDD I1_I2066_G21_0 XI1_I2066_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I225_MP5 (I1_ru22 I1_I2066_G21_0 XI1_I2066_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I225_MP4 (XI1_I2066_I225_p1 XI1_I2066_I225_An I1_ru22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I225_MP2 (VDD I1_I2066_pn22 XI1_I2066_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I225_MP3 (XI1_I2066_I225_p1 XI1_I2066_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I225_MP0 (VDD I1_I2066_pn22 XI1_I2066_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2225_MP1 (VDD I1_nrkn19 XI1_I2225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2225_MP5 (DIVR_19 I1_nrkn19 XI1_I2225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2225_MP4 (XI1_I2225_p1 XI1_I2225_An DIVR_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2225_MP2 (VDD I1_ru19 XI1_I2225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2225_MP3 (XI1_I2225_p1 XI1_I2225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2225_MP0 (VDD I1_ru19 XI1_I2225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2219_MP1 (VDD I1_nrkn17 XI1_I2219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2219_MP5 (DIVR_17 I1_nrkn17 XI1_I2219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2219_MP4 (XI1_I2219_p1 XI1_I2219_An DIVR_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2219_MP2 (VDD I1_ru17 XI1_I2219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2219_MP3 (XI1_I2219_p1 XI1_I2219_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2219_MP0 (VDD I1_ru17 XI1_I2219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I122_MP1 (VDD VSS XI0_I1660_I122_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I122_MP5 (I0_I1660_pn58 VSS XI0_I1660_I122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I122_MP4 (XI0_I1660_I122_p1 XI0_I1660_I122_An I0_I1660_pn58 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I122_MP2 (VDD I0_fa298_0 XI0_I1660_I122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I122_MP3 (XI0_I1660_I122_p1 XI0_I1660_I122_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I122_MP0 (VDD I0_fa298_0 XI0_I1660_I122_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I225_MP1 (VDD I1_I1850_G21_0 XI1_I1850_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I225_MP5 (I1_p28_22 I1_I1850_G21_0 XI1_I1850_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I225_MP4 (XI1_I1850_I225_p1 XI1_I1850_I225_An I1_p28_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I225_MP2 (VDD I1_I1850_pn22 XI1_I1850_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I225_MP3 (XI1_I1850_I225_p1 XI1_I1850_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I225_MP0 (VDD I1_I1850_pn22 XI1_I1850_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I226_MP1 (VDD I1_I1850_G22_0 XI1_I1850_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I226_MP5 (I1_p28_23 I1_I1850_G22_0 XI1_I1850_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I226_MP4 (XI1_I1850_I226_p1 XI1_I1850_I226_An I1_p28_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I226_MP2 (VDD I1_I1850_pn23 XI1_I1850_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I226_MP3 (XI1_I1850_I226_p1 XI1_I1850_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I226_MP0 (VDD I1_I1850_pn23 XI1_I1850_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I56_MP1 (VDD I1_b29_24 XI1_I1896_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I56_MP5 (I1_I1896_pn24 I1_b29_24 XI1_I1896_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I56_MP4 (XI1_I1896_I56_p1 XI1_I1896_I56_An I1_I1896_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I56_MP2 (VDD I1_p28_23 XI1_I1896_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I56_MP3 (XI1_I1896_I56_p1 XI1_I1896_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I56_MP0 (VDD I1_p28_23 XI1_I1896_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I55_MP1 (VDD I1_b29_23 XI1_I1896_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I55_MP5 (I1_I1896_pn23 I1_b29_23 XI1_I1896_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I55_MP4 (XI1_I1896_I55_p1 XI1_I1896_I55_An I1_I1896_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I55_MP2 (VDD I1_p28_22 XI1_I1896_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I55_MP3 (XI1_I1896_I55_p1 XI1_I1896_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I55_MP0 (VDD I1_p28_22 XI1_I1896_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I226_MP1 (VDD I1_I1896_G22_0 XI1_I1896_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I226_MP5 (I1_p29_23 I1_I1896_G22_0 XI1_I1896_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I226_MP4 (XI1_I1896_I226_p1 XI1_I1896_I226_An I1_p29_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I226_MP2 (VDD I1_I1896_pn23 XI1_I1896_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I226_MP3 (XI1_I1896_I226_p1 XI1_I1896_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I226_MP0 (VDD I1_I1896_pn23 XI1_I1896_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I55_MP1 (VDD I1_b30_23 XI1_I1942_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I55_MP5 (I1_I1942_pn23 I1_b30_23 XI1_I1942_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I55_MP4 (XI1_I1942_I55_p1 XI1_I1942_I55_An I1_I1942_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I55_MP2 (VDD I1_p29_22 XI1_I1942_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I55_MP3 (XI1_I1942_I55_p1 XI1_I1942_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I55_MP0 (VDD I1_p29_22 XI1_I1942_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I56_MP1 (VDD I1_b30_24 XI1_I1942_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I56_MP5 (I1_I1942_pn24 I1_b30_24 XI1_I1942_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I56_MP4 (XI1_I1942_I56_p1 XI1_I1942_I56_An I1_I1942_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I56_MP2 (VDD I1_p29_23 XI1_I1942_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I56_MP3 (XI1_I1942_I56_p1 XI1_I1942_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I56_MP0 (VDD I1_p29_23 XI1_I1942_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I227_MP1 (VDD I1_I1942_G23_0 XI1_I1942_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I227_MP5 (I1_p30_24 I1_I1942_G23_0 XI1_I1942_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I227_MP4 (XI1_I1942_I227_p1 XI1_I1942_I227_An I1_p30_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I227_MP2 (VDD I1_I1942_pn24 XI1_I1942_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I227_MP3 (XI1_I1942_I227_p1 XI1_I1942_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I227_MP0 (VDD I1_I1942_pn24 XI1_I1942_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I234_MP1 (VDD I1_c30_m XI1_I1942_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I234_MP5 (I1_p30_31 I1_c30_m XI1_I1942_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I234_MP4 (XI1_I1942_I234_p1 XI1_I1942_I234_An I1_p30_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I234_MP2 (VDD I1_I1942_pn31 XI1_I1942_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I234_MP3 (XI1_I1942_I234_p1 XI1_I1942_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I234_MP0 (VDD I1_I1942_pn31 XI1_I1942_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I56_MP1 (VDD I1_b31_24 XI1_I1988_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I56_MP5 (I1_I1988_pn24 I1_b31_24 XI1_I1988_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I56_MP4 (XI1_I1988_I56_p1 XI1_I1988_I56_An I1_I1988_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I56_MP2 (VDD I1_p30_23 XI1_I1988_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I56_MP3 (XI1_I1988_I56_p1 XI1_I1988_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I56_MP0 (VDD I1_p30_23 XI1_I1988_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I227_MP1 (VDD I1_I1988_G23_0 XI1_I1988_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I227_MP5 (I1_p31_24 I1_I1988_G23_0 XI1_I1988_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I227_MP4 (XI1_I1988_I227_p1 XI1_I1988_I227_An I1_p31_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I227_MP2 (VDD I1_I1988_pn24 XI1_I1988_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I227_MP3 (XI1_I1988_I227_p1 XI1_I1988_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I227_MP0 (VDD I1_I1988_pn24 XI1_I1988_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I228_MP1 (VDD I1_I1988_G24_0 XI1_I1988_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I228_MP5 (I1_p31_25 I1_I1988_G24_0 XI1_I1988_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I228_MP4 (XI1_I1988_I228_p1 XI1_I1988_I228_An I1_p31_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I228_MP2 (VDD I1_I1988_pn25 XI1_I1988_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I228_MP3 (XI1_I1988_I228_p1 XI1_I1988_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I228_MP0 (VDD I1_I1988_pn25 XI1_I1988_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I54_MP1 (VDD I1_dm22 XI1_I2066_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I54_MP5 (I1_I2066_pn22 I1_dm22 XI1_I2066_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I54_MP4 (XI1_I2066_I54_p1 XI1_I2066_I54_An I1_I2066_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I54_MP2 (VDD I1_p31_22 XI1_I2066_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I54_MP3 (XI1_I2066_I54_p1 XI1_I2066_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I54_MP0 (VDD I1_p31_22 XI1_I2066_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2231_MP1 (VDD I1_nrkn21 XI1_I2231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2231_MP5 (DIVR_21 I1_nrkn21 XI1_I2231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2231_MP4 (XI1_I2231_p1 XI1_I2231_An DIVR_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2231_MP2 (VDD I1_ru21 XI1_I2231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2231_MP3 (XI1_I2231_p1 XI1_I2231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2231_MP0 (VDD I1_ru21 XI1_I2231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2228_MP1 (VDD I1_nrkn20 XI1_I2228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2228_MP5 (DIVR_20 I1_nrkn20 XI1_I2228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2228_MP4 (XI1_I2228_p1 XI1_I2228_An DIVR_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2228_MP2 (VDD I1_ru20 XI1_I2228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2228_MP3 (XI1_I2228_p1 XI1_I2228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2228_MP0 (VDD I1_ru20 XI1_I2228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2213_MP1 (VDD I1_nrkn15 XI1_I2213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2213_MP5 (DIVR_15 I1_nrkn15 XI1_I2213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2213_MP4 (XI1_I2213_p1 XI1_I2213_An DIVR_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2213_MP2 (VDD I1_ru15 XI1_I2213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2213_MP3 (XI1_I2213_p1 XI1_I2213_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2213_MP0 (VDD I1_ru15 XI1_I2213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2216_MP1 (VDD I1_nrkn16 XI1_I2216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2216_MP5 (DIVR_16 I1_nrkn16 XI1_I2216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2216_MP4 (XI1_I2216_p1 XI1_I2216_An DIVR_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2216_MP2 (VDD I1_ru16 XI1_I2216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2216_MP3 (XI1_I2216_p1 XI1_I2216_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2216_MP0 (VDD I1_ru16 XI1_I2216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I120_MP1 (VDD VSS XI0_I1660_I120_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I120_MP5 (I0_I1660_pn56 VSS XI0_I1660_I120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I120_MP4 (XI0_I1660_I120_p1 XI0_I1660_I120_An I0_I1660_pn56 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I120_MP2 (VDD I0_fa297_0 XI0_I1660_I120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I120_MP3 (XI0_I1660_I120_p1 XI0_I1660_I120_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I120_MP0 (VDD I0_fa297_0 XI0_I1660_I120_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I114_MP1 (VDD I0_ha294_0 XI0_I1660_I114_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I114_MP5 (I0_I1660_pn50 I0_ha294_0 XI0_I1660_I114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I114_MP4 (XI0_I1660_I114_p1 XI0_I1660_I114_An I0_I1660_pn50 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I114_MP2 (VDD I0_fa293_1 XI0_I1660_I114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I114_MP3 (XI0_I1660_I114_p1 XI0_I1660_I114_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I114_MP0 (VDD I0_fa293_1 XI0_I1660_I114_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I123_MP1 (VDD I0_fa207_0 XI0_I1660_I123_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I123_MP5 (I0_I1660_pn59 I0_fa207_0 XI0_I1660_I123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I123_MP4 (XI0_I1660_I123_p1 XI0_I1660_I123_An I0_I1660_pn59 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I123_MP2 (VDD I0_fa298_1 XI0_I1660_I123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I123_MP3 (XI0_I1660_I123_p1 XI0_I1660_I123_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I123_MP0 (VDD I0_fa298_1 XI0_I1660_I123_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I63_MP1 (VDD I1_b28_31 XI1_I1850_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I63_MP5 (I1_I1850_pn31 I1_b28_31 XI1_I1850_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I63_MP4 (XI1_I1850_I63_p1 XI1_I1850_I63_An I1_I1850_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I63_MP2 (VDD I1_p27_30 XI1_I1850_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I63_MP3 (XI1_I1850_I63_p1 XI1_I1850_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I63_MP0 (VDD I1_p27_30 XI1_I1850_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I62_MP1 (VDD I1_b28_30 XI1_I1850_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I62_MP5 (I1_I1850_pn30 I1_b28_30 XI1_I1850_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I62_MP4 (XI1_I1850_I62_p1 XI1_I1850_I62_An I1_I1850_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I62_MP2 (VDD I1_p27_29 XI1_I1850_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I62_MP3 (XI1_I1850_I62_p1 XI1_I1850_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I62_MP0 (VDD I1_p27_29 XI1_I1850_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I227_MP1 (VDD I1_I1850_G23_0 XI1_I1850_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I227_MP5 (I1_p28_24 I1_I1850_G23_0 XI1_I1850_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I227_MP4 (XI1_I1850_I227_p1 XI1_I1850_I227_An I1_p28_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I227_MP2 (VDD I1_I1850_pn24 XI1_I1850_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I227_MP3 (XI1_I1850_I227_p1 XI1_I1850_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I227_MP0 (VDD I1_I1850_pn24 XI1_I1850_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I57_MP1 (VDD I1_b28_25 XI1_I1850_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I57_MP5 (I1_I1850_pn25 I1_b28_25 XI1_I1850_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I57_MP4 (XI1_I1850_I57_p1 XI1_I1850_I57_An I1_I1850_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I57_MP2 (VDD I1_p27_24 XI1_I1850_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I57_MP3 (XI1_I1850_I57_p1 XI1_I1850_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I57_MP0 (VDD I1_p27_24 XI1_I1850_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I56_MP1 (VDD I1_b28_24 XI1_I1850_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I56_MP5 (I1_I1850_pn24 I1_b28_24 XI1_I1850_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I56_MP4 (XI1_I1850_I56_p1 XI1_I1850_I56_An I1_I1850_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I56_MP2 (VDD I1_p27_23 XI1_I1850_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I56_MP3 (XI1_I1850_I56_p1 XI1_I1850_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I56_MP0 (VDD I1_p27_23 XI1_I1850_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I228_MP1 (VDD I1_I1850_G24_0 XI1_I1850_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I228_MP5 (I1_p28_25 I1_I1850_G24_0 XI1_I1850_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I228_MP4 (XI1_I1850_I228_p1 XI1_I1850_I228_An I1_p28_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I228_MP2 (VDD I1_I1850_pn25 XI1_I1850_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I228_MP3 (XI1_I1850_I228_p1 XI1_I1850_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I228_MP0 (VDD I1_I1850_pn25 XI1_I1850_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I58_MP1 (VDD I1_b29_26 XI1_I1896_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I58_MP5 (I1_I1896_pn26 I1_b29_26 XI1_I1896_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I58_MP4 (XI1_I1896_I58_p1 XI1_I1896_I58_An I1_I1896_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I58_MP2 (VDD I1_p28_25 XI1_I1896_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I58_MP3 (XI1_I1896_I58_p1 XI1_I1896_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I58_MP0 (VDD I1_p28_25 XI1_I1896_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I57_MP1 (VDD I1_b29_25 XI1_I1896_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I57_MP5 (I1_I1896_pn25 I1_b29_25 XI1_I1896_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I57_MP4 (XI1_I1896_I57_p1 XI1_I1896_I57_An I1_I1896_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I57_MP2 (VDD I1_p28_24 XI1_I1896_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I57_MP3 (XI1_I1896_I57_p1 XI1_I1896_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I57_MP0 (VDD I1_p28_24 XI1_I1896_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I227_MP1 (VDD I1_I1896_G23_0 XI1_I1896_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I227_MP5 (I1_p29_24 I1_I1896_G23_0 XI1_I1896_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I227_MP4 (XI1_I1896_I227_p1 XI1_I1896_I227_An I1_p29_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I227_MP2 (VDD I1_I1896_pn24 XI1_I1896_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I227_MP3 (XI1_I1896_I227_p1 XI1_I1896_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I227_MP0 (VDD I1_I1896_pn24 XI1_I1896_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I228_MP1 (VDD I1_I1896_G24_0 XI1_I1896_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I228_MP5 (I1_p29_25 I1_I1896_G24_0 XI1_I1896_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I228_MP4 (XI1_I1896_I228_p1 XI1_I1896_I228_An I1_p29_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I228_MP2 (VDD I1_I1896_pn25 XI1_I1896_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I228_MP3 (XI1_I1896_I228_p1 XI1_I1896_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I228_MP0 (VDD I1_I1896_pn25 XI1_I1896_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I57_MP1 (VDD I1_b30_25 XI1_I1942_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I57_MP5 (I1_I1942_pn25 I1_b30_25 XI1_I1942_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I57_MP4 (XI1_I1942_I57_p1 XI1_I1942_I57_An I1_I1942_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I57_MP2 (VDD I1_p29_24 XI1_I1942_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I57_MP3 (XI1_I1942_I57_p1 XI1_I1942_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I57_MP0 (VDD I1_p29_24 XI1_I1942_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I58_MP1 (VDD I1_b30_26 XI1_I1942_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I58_MP5 (I1_I1942_pn26 I1_b30_26 XI1_I1942_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I58_MP4 (XI1_I1942_I58_p1 XI1_I1942_I58_An I1_I1942_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I58_MP2 (VDD I1_p29_25 XI1_I1942_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I58_MP3 (XI1_I1942_I58_p1 XI1_I1942_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I58_MP0 (VDD I1_p29_25 XI1_I1942_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I229_MP1 (VDD I1_I1942_G25_0 XI1_I1942_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I229_MP5 (I1_p30_26 I1_I1942_G25_0 XI1_I1942_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I229_MP4 (XI1_I1942_I229_p1 XI1_I1942_I229_An I1_p30_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I229_MP2 (VDD I1_I1942_pn26 XI1_I1942_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I229_MP3 (XI1_I1942_I229_p1 XI1_I1942_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I229_MP0 (VDD I1_I1942_pn26 XI1_I1942_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I228_MP1 (VDD I1_I1942_G24_0 XI1_I1942_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I228_MP5 (I1_p30_25 I1_I1942_G24_0 XI1_I1942_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I228_MP4 (XI1_I1942_I228_p1 XI1_I1942_I228_An I1_p30_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I228_MP2 (VDD I1_I1942_pn25 XI1_I1942_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I228_MP3 (XI1_I1942_I228_p1 XI1_I1942_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I228_MP0 (VDD I1_I1942_pn25 XI1_I1942_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I58_MP1 (VDD I1_b31_26 XI1_I1988_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I58_MP5 (I1_I1988_pn26 I1_b31_26 XI1_I1988_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I58_MP4 (XI1_I1988_I58_p1 XI1_I1988_I58_An I1_I1988_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I58_MP2 (VDD I1_p30_25 XI1_I1988_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I58_MP3 (XI1_I1988_I58_p1 XI1_I1988_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I58_MP0 (VDD I1_p30_25 XI1_I1988_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I57_MP1 (VDD I1_b31_25 XI1_I1988_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I57_MP5 (I1_I1988_pn25 I1_b31_25 XI1_I1988_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I57_MP4 (XI1_I1988_I57_p1 XI1_I1988_I57_An I1_I1988_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I57_MP2 (VDD I1_p30_24 XI1_I1988_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I57_MP3 (XI1_I1988_I57_p1 XI1_I1988_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I57_MP0 (VDD I1_p30_24 XI1_I1988_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I59_MP1 (VDD I1_b31_27 XI1_I1988_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I59_MP5 (I1_I1988_pn27 I1_b31_27 XI1_I1988_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I59_MP4 (XI1_I1988_I59_p1 XI1_I1988_I59_An I1_I1988_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I59_MP2 (VDD I1_p30_26 XI1_I1988_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I59_MP3 (XI1_I1988_I59_p1 XI1_I1988_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I59_MP0 (VDD I1_p30_26 XI1_I1988_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I229_MP1 (VDD I1_I1988_G25_0 XI1_I1988_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I229_MP5 (I1_p31_26 I1_I1988_G25_0 XI1_I1988_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I229_MP4 (XI1_I1988_I229_p1 XI1_I1988_I229_An I1_p31_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I229_MP2 (VDD I1_I1988_pn26 XI1_I1988_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I229_MP3 (XI1_I1988_I229_p1 XI1_I1988_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I229_MP0 (VDD I1_I1988_pn26 XI1_I1988_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I56_MP1 (VDD I1_dm24 XI1_I2066_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I56_MP5 (I1_I2066_pn24 I1_dm24 XI1_I2066_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I56_MP4 (XI1_I2066_I56_p1 XI1_I2066_I56_An I1_I2066_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I56_MP2 (VDD I1_p31_24 XI1_I2066_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I56_MP3 (XI1_I2066_I56_p1 XI1_I2066_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I56_MP0 (VDD I1_p31_24 XI1_I2066_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I55_MP1 (VDD I1_dm23 XI1_I2066_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I55_MP5 (I1_I2066_pn23 I1_dm23 XI1_I2066_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I55_MP4 (XI1_I2066_I55_p1 XI1_I2066_I55_An I1_I2066_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I55_MP2 (VDD I1_p31_23 XI1_I2066_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I55_MP3 (XI1_I2066_I55_p1 XI1_I2066_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I55_MP0 (VDD I1_p31_23 XI1_I2066_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I57_MP1 (VDD I1_dm25 XI1_I2066_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I57_MP5 (I1_I2066_pn25 I1_dm25 XI1_I2066_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I57_MP4 (XI1_I2066_I57_p1 XI1_I2066_I57_An I1_I2066_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I57_MP2 (VDD I1_p31_25 XI1_I2066_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I57_MP3 (XI1_I2066_I57_p1 XI1_I2066_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I57_MP0 (VDD I1_p31_25 XI1_I2066_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I226_MP1 (VDD I1_I2066_G22_0 XI1_I2066_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I226_MP5 (I1_ru23 I1_I2066_G22_0 XI1_I2066_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I226_MP4 (XI1_I2066_I226_p1 XI1_I2066_I226_An I1_ru23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I226_MP2 (VDD I1_I2066_pn23 XI1_I2066_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I226_MP3 (XI1_I2066_I226_p1 XI1_I2066_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I226_MP0 (VDD I1_I2066_pn23 XI1_I2066_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I228_MP1 (VDD I1_I2066_G24_0 XI1_I2066_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I228_MP5 (I1_ru25 I1_I2066_G24_0 XI1_I2066_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I228_MP4 (XI1_I2066_I228_p1 XI1_I2066_I228_An I1_ru25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I228_MP2 (VDD I1_I2066_pn25 XI1_I2066_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I228_MP3 (XI1_I2066_I228_p1 XI1_I2066_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I228_MP0 (VDD I1_I2066_pn25 XI1_I2066_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I227_MP1 (VDD I1_I2066_G23_0 XI1_I2066_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I227_MP5 (I1_ru24 I1_I2066_G23_0 XI1_I2066_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I227_MP4 (XI1_I2066_I227_p1 XI1_I2066_I227_An I1_ru24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I227_MP2 (VDD I1_I2066_pn24 XI1_I2066_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I227_MP3 (XI1_I2066_I227_p1 XI1_I2066_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I227_MP0 (VDD I1_I2066_pn24 XI1_I2066_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2237_MP1 (VDD I1_nrkn23 XI1_I2237_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2237_MP5 (DIVR_23 I1_nrkn23 XI1_I2237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2237_MP4 (XI1_I2237_p1 XI1_I2237_An DIVR_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2237_MP2 (VDD I1_ru23 XI1_I2237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2237_MP3 (XI1_I2237_p1 XI1_I2237_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2237_MP0 (VDD I1_ru23 XI1_I2237_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2240_MP1 (VDD I1_nrkn24 XI1_I2240_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2240_MP5 (DIVR_24 I1_nrkn24 XI1_I2240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2240_MP4 (XI1_I2240_p1 XI1_I2240_An DIVR_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2240_MP2 (VDD I1_ru24 XI1_I2240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2240_MP3 (XI1_I2240_p1 XI1_I2240_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2240_MP0 (VDD I1_ru24 XI1_I2240_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2243_MP1 (VDD I1_nrkn25 XI1_I2243_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2243_MP5 (DIVR_25 I1_nrkn25 XI1_I2243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2243_MP4 (XI1_I2243_p1 XI1_I2243_An DIVR_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2243_MP2 (VDD I1_ru25 XI1_I2243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2243_MP3 (XI1_I2243_p1 XI1_I2243_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2243_MP0 (VDD I1_ru25 XI1_I2243_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I121_MP1 (VDD I0_fa246_0 XI0_I1660_I121_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I121_MP5 (I0_I1660_pn57 I0_fa246_0 XI0_I1660_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I121_MP4 (XI0_I1660_I121_p1 XI0_I1660_I121_An I0_I1660_pn57 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I121_MP2 (VDD I0_fa297_1 XI0_I1660_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I121_MP3 (XI0_I1660_I121_p1 XI0_I1660_I121_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I121_MP0 (VDD I0_fa297_1 XI0_I1660_I121_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I233_MP1 (VDD I1_I1850_G29_0 XI1_I1850_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I233_MP5 (I1_p28_30 I1_I1850_G29_0 XI1_I1850_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I233_MP4 (XI1_I1850_I233_p1 XI1_I1850_I233_An I1_p28_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I233_MP2 (VDD I1_I1850_pn30 XI1_I1850_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I233_MP3 (XI1_I1850_I233_p1 XI1_I1850_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I233_MP0 (VDD I1_I1850_pn30 XI1_I1850_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I234_MP1 (VDD I1_c28_m XI1_I1850_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I234_MP5 (I1_p28_31 I1_c28_m XI1_I1850_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I234_MP4 (XI1_I1850_I234_p1 XI1_I1850_I234_An I1_p28_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I234_MP2 (VDD I1_I1850_pn31 XI1_I1850_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I234_MP3 (XI1_I1850_I234_p1 XI1_I1850_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I234_MP0 (VDD I1_I1850_pn31 XI1_I1850_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I63_MP1 (VDD I1_b29_31 XI1_I1896_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I63_MP5 (I1_I1896_pn31 I1_b29_31 XI1_I1896_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I63_MP4 (XI1_I1896_I63_p1 XI1_I1896_I63_An I1_I1896_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I63_MP2 (VDD I1_p28_30 XI1_I1896_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I63_MP3 (XI1_I1896_I63_p1 XI1_I1896_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I63_MP0 (VDD I1_p28_30 XI1_I1896_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I229_MP1 (VDD I1_I1896_G25_0 XI1_I1896_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I229_MP5 (I1_p29_26 I1_I1896_G25_0 XI1_I1896_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I229_MP4 (XI1_I1896_I229_p1 XI1_I1896_I229_An I1_p29_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I229_MP2 (VDD I1_I1896_pn26 XI1_I1896_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I229_MP3 (XI1_I1896_I229_p1 XI1_I1896_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I229_MP0 (VDD I1_I1896_pn26 XI1_I1896_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I59_MP1 (VDD I1_b30_27 XI1_I1942_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I59_MP5 (I1_I1942_pn27 I1_b30_27 XI1_I1942_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I59_MP4 (XI1_I1942_I59_p1 XI1_I1942_I59_An I1_I1942_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I59_MP2 (VDD I1_p29_26 XI1_I1942_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I59_MP3 (XI1_I1942_I59_p1 XI1_I1942_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I59_MP0 (VDD I1_p29_26 XI1_I1942_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I230_MP1 (VDD I1_I1942_G26_0 XI1_I1942_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I230_MP5 (I1_p30_27 I1_I1942_G26_0 XI1_I1942_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I230_MP4 (XI1_I1942_I230_p1 XI1_I1942_I230_An I1_p30_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I230_MP2 (VDD I1_I1942_pn27 XI1_I1942_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I230_MP3 (XI1_I1942_I230_p1 XI1_I1942_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I230_MP0 (VDD I1_I1942_pn27 XI1_I1942_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I60_MP1 (VDD I1_b31_28 XI1_I1988_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I60_MP5 (I1_I1988_pn28 I1_b31_28 XI1_I1988_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I60_MP4 (XI1_I1988_I60_p1 XI1_I1988_I60_An I1_I1988_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I60_MP2 (VDD I1_p30_27 XI1_I1988_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I60_MP3 (XI1_I1988_I60_p1 XI1_I1988_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I60_MP0 (VDD I1_p30_27 XI1_I1988_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I231_MP1 (VDD I1_I1988_G27_0 XI1_I1988_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I231_MP5 (I1_p31_28 I1_I1988_G27_0 XI1_I1988_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I231_MP4 (XI1_I1988_I231_p1 XI1_I1988_I231_An I1_p31_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I231_MP2 (VDD I1_I1988_pn28 XI1_I1988_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I231_MP3 (XI1_I1988_I231_p1 XI1_I1988_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I231_MP0 (VDD I1_I1988_pn28 XI1_I1988_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I230_MP1 (VDD I1_I1988_G26_0 XI1_I1988_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I230_MP5 (I1_p31_27 I1_I1988_G26_0 XI1_I1988_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I230_MP4 (XI1_I1988_I230_p1 XI1_I1988_I230_An I1_p31_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I230_MP2 (VDD I1_I1988_pn27 XI1_I1988_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I230_MP3 (XI1_I1988_I230_p1 XI1_I1988_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I230_MP0 (VDD I1_I1988_pn27 XI1_I1988_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I234_MP1 (VDD I1_c31_m XI1_I1988_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I234_MP5 (I1_p31_31 I1_c31_m XI1_I1988_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I234_MP4 (XI1_I1988_I234_p1 XI1_I1988_I234_An I1_p31_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I234_MP2 (VDD I1_I1988_pn31 XI1_I1988_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I234_MP3 (XI1_I1988_I234_p1 XI1_I1988_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I234_MP0 (VDD I1_I1988_pn31 XI1_I1988_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I232_MP1 (VDD I1_I1988_G28_0 XI1_I1988_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I232_MP5 (I1_p31_29 I1_I1988_G28_0 XI1_I1988_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I232_MP4 (XI1_I1988_I232_p1 XI1_I1988_I232_An I1_p31_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I232_MP2 (VDD I1_I1988_pn29 XI1_I1988_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I232_MP3 (XI1_I1988_I232_p1 XI1_I1988_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I232_MP0 (VDD I1_I1988_pn29 XI1_I1988_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I60_MP1 (VDD I1_dm28 XI1_I2066_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I60_MP5 (I1_I2066_pn28 I1_dm28 XI1_I2066_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I60_MP4 (XI1_I2066_I60_p1 XI1_I2066_I60_An I1_I2066_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I60_MP2 (VDD I1_p31_28 XI1_I2066_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I60_MP3 (XI1_I2066_I60_p1 XI1_I2066_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I60_MP0 (VDD I1_p31_28 XI1_I2066_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I58_MP1 (VDD I1_dm26 XI1_I2066_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I58_MP5 (I1_I2066_pn26 I1_dm26 XI1_I2066_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I58_MP4 (XI1_I2066_I58_p1 XI1_I2066_I58_An I1_I2066_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I58_MP2 (VDD I1_p31_26 XI1_I2066_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I58_MP3 (XI1_I2066_I58_p1 XI1_I2066_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I58_MP0 (VDD I1_p31_26 XI1_I2066_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I59_MP1 (VDD I1_dm27 XI1_I2066_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I59_MP5 (I1_I2066_pn27 I1_dm27 XI1_I2066_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I59_MP4 (XI1_I2066_I59_p1 XI1_I2066_I59_An I1_I2066_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I59_MP2 (VDD I1_p31_27 XI1_I2066_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I59_MP3 (XI1_I2066_I59_p1 XI1_I2066_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I59_MP0 (VDD I1_p31_27 XI1_I2066_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I230_MP1 (VDD I1_I2066_G26_0 XI1_I2066_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I230_MP5 (I1_ru27 I1_I2066_G26_0 XI1_I2066_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I230_MP4 (XI1_I2066_I230_p1 XI1_I2066_I230_An I1_ru27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I230_MP2 (VDD I1_I2066_pn27 XI1_I2066_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I230_MP3 (XI1_I2066_I230_p1 XI1_I2066_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I230_MP0 (VDD I1_I2066_pn27 XI1_I2066_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I229_MP1 (VDD I1_I2066_G25_0 XI1_I2066_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I229_MP5 (I1_ru26 I1_I2066_G25_0 XI1_I2066_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I229_MP4 (XI1_I2066_I229_p1 XI1_I2066_I229_An I1_ru26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I229_MP2 (VDD I1_I2066_pn26 XI1_I2066_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I229_MP3 (XI1_I2066_I229_p1 XI1_I2066_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I229_MP0 (VDD I1_I2066_pn26 XI1_I2066_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2234_MP1 (VDD I1_nrkn22 XI1_I2234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2234_MP5 (DIVR_22 I1_nrkn22 XI1_I2234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2234_MP4 (XI1_I2234_p1 XI1_I2234_An DIVR_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2234_MP2 (VDD I1_ru22 XI1_I2234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2234_MP3 (XI1_I2234_p1 XI1_I2234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2234_MP0 (VDD I1_ru22 XI1_I2234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2246_MP1 (VDD I1_nrkn26 XI1_I2246_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2246_MP5 (DIVR_26 I1_nrkn26 XI1_I2246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2246_MP4 (XI1_I2246_p1 XI1_I2246_An DIVR_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2246_MP2 (VDD I1_ru26 XI1_I2246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2246_MP3 (XI1_I2246_p1 XI1_I2246_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2246_MP0 (VDD I1_ru26 XI1_I2246_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I124_MP1 (VDD VSS XI0_I1660_I124_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I124_MP5 (I0_I1660_pn60 VSS XI0_I1660_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I124_MP4 (XI0_I1660_I124_p1 XI0_I1660_I124_An I0_I1660_pn60 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I124_MP2 (VDD I0_fa247_0 XI0_I1660_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I124_MP3 (XI0_I1660_I124_p1 XI0_I1660_I124_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I124_MP0 (VDD I0_fa247_0 XI0_I1660_I124_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I118_MP1 (VDD VSS XI0_I1660_I118_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I118_MP5 (I0_I1660_pn54 VSS XI0_I1660_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I118_MP4 (XI0_I1660_I118_p1 XI0_I1660_I118_An I0_I1660_pn54 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I118_MP2 (VDD I0_fa296_0 XI0_I1660_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I118_MP3 (XI0_I1660_I118_p1 XI0_I1660_I118_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I118_MP0 (VDD I0_fa296_0 XI0_I1660_I118_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I116_MP1 (VDD VSS XI0_I1660_I116_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I116_MP5 (I0_I1660_pn52 VSS XI0_I1660_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I116_MP4 (XI0_I1660_I116_p1 XI0_I1660_I116_An I0_I1660_pn52 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I116_MP2 (VDD I0_fa295_0 XI0_I1660_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I116_MP3 (XI0_I1660_I116_p1 XI0_I1660_I116_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I116_MP0 (VDD I0_fa295_0 XI0_I1660_I116_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I117_MP1 (VDD I0_fa244_0 XI0_I1660_I117_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I117_MP5 (I0_I1660_pn53 I0_fa244_0 XI0_I1660_I117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I117_MP4 (XI0_I1660_I117_p1 XI0_I1660_I117_An I0_I1660_pn53 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I117_MP2 (VDD I0_fa295_1 XI0_I1660_I117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I117_MP3 (XI0_I1660_I117_p1 XI0_I1660_I117_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I117_MP0 (VDD I0_fa295_1 XI0_I1660_I117_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I115_MP1 (VDD I0_fa243_0 XI0_I1660_I115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I115_MP5 (I0_I1660_pn51 I0_fa243_0 XI0_I1660_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I115_MP4 (XI0_I1660_I115_p1 XI0_I1660_I115_An I0_I1660_pn51 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I115_MP2 (VDD I0_ha294_1 XI0_I1660_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I115_MP3 (XI0_I1660_I115_p1 XI0_I1660_I115_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I115_MP0 (VDD I0_ha294_1 XI0_I1660_I115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I119_MP1 (VDD I0_fa245_0 XI0_I1660_I119_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I119_MP5 (I0_I1660_pn55 I0_fa245_0 XI0_I1660_I119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I119_MP4 (XI0_I1660_I119_p1 XI0_I1660_I119_An I0_I1660_pn55 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I119_MP2 (VDD I0_fa296_1 XI0_I1660_I119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I119_MP3 (XI0_I1660_I119_p1 XI0_I1660_I119_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I119_MP0 (VDD I0_fa296_1 XI0_I1660_I119_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I231_MP1 (VDD I1_I1850_G27_0 XI1_I1850_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I231_MP5 (I1_p28_28 I1_I1850_G27_0 XI1_I1850_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I231_MP4 (XI1_I1850_I231_p1 XI1_I1850_I231_An I1_p28_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I231_MP2 (VDD I1_I1850_pn28 XI1_I1850_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I231_MP3 (XI1_I1850_I231_p1 XI1_I1850_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I231_MP0 (VDD I1_I1850_pn28 XI1_I1850_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I61_MP1 (VDD I1_b28_29 XI1_I1850_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I61_MP5 (I1_I1850_pn29 I1_b28_29 XI1_I1850_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I61_MP4 (XI1_I1850_I61_p1 XI1_I1850_I61_An I1_I1850_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I61_MP2 (VDD I1_p27_28 XI1_I1850_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I61_MP3 (XI1_I1850_I61_p1 XI1_I1850_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I61_MP0 (VDD I1_p27_28 XI1_I1850_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I60_MP1 (VDD I1_b28_28 XI1_I1850_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I60_MP5 (I1_I1850_pn28 I1_b28_28 XI1_I1850_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I60_MP4 (XI1_I1850_I60_p1 XI1_I1850_I60_An I1_I1850_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I60_MP2 (VDD I1_p27_27 XI1_I1850_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I60_MP3 (XI1_I1850_I60_p1 XI1_I1850_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I60_MP0 (VDD I1_p27_27 XI1_I1850_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I59_MP1 (VDD I1_b28_27 XI1_I1850_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I59_MP5 (I1_I1850_pn27 I1_b28_27 XI1_I1850_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I59_MP4 (XI1_I1850_I59_p1 XI1_I1850_I59_An I1_I1850_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I59_MP2 (VDD I1_p27_26 XI1_I1850_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I59_MP3 (XI1_I1850_I59_p1 XI1_I1850_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I59_MP0 (VDD I1_p27_26 XI1_I1850_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I229_MP1 (VDD I1_I1850_G25_0 XI1_I1850_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I229_MP5 (I1_p28_26 I1_I1850_G25_0 XI1_I1850_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I229_MP4 (XI1_I1850_I229_p1 XI1_I1850_I229_An I1_p28_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I229_MP2 (VDD I1_I1850_pn26 XI1_I1850_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I229_MP3 (XI1_I1850_I229_p1 XI1_I1850_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I229_MP0 (VDD I1_I1850_pn26 XI1_I1850_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I58_MP1 (VDD I1_b28_26 XI1_I1850_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I58_MP5 (I1_I1850_pn26 I1_b28_26 XI1_I1850_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I58_MP4 (XI1_I1850_I58_p1 XI1_I1850_I58_An I1_I1850_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I58_MP2 (VDD I1_p27_25 XI1_I1850_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I58_MP3 (XI1_I1850_I58_p1 XI1_I1850_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I58_MP0 (VDD I1_p27_25 XI1_I1850_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I230_MP1 (VDD I1_I1850_G26_0 XI1_I1850_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I230_MP5 (I1_p28_27 I1_I1850_G26_0 XI1_I1850_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I230_MP4 (XI1_I1850_I230_p1 XI1_I1850_I230_An I1_p28_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I230_MP2 (VDD I1_I1850_pn27 XI1_I1850_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I230_MP3 (XI1_I1850_I230_p1 XI1_I1850_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I230_MP0 (VDD I1_I1850_pn27 XI1_I1850_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I232_MP1 (VDD I1_I1850_G28_0 XI1_I1850_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1850_I232_MP5 (I1_p28_29 I1_I1850_G28_0 XI1_I1850_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1850_I232_MP4 (XI1_I1850_I232_p1 XI1_I1850_I232_An I1_p28_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I232_MP2 (VDD I1_I1850_pn29 XI1_I1850_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1850_I232_MP3 (XI1_I1850_I232_p1 XI1_I1850_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I232_MP0 (VDD I1_I1850_pn29 XI1_I1850_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I59_MP1 (VDD I1_b29_27 XI1_I1896_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I59_MP5 (I1_I1896_pn27 I1_b29_27 XI1_I1896_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I59_MP4 (XI1_I1896_I59_p1 XI1_I1896_I59_An I1_I1896_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I59_MP2 (VDD I1_p28_26 XI1_I1896_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I59_MP3 (XI1_I1896_I59_p1 XI1_I1896_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I59_MP0 (VDD I1_p28_26 XI1_I1896_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I60_MP1 (VDD I1_b29_28 XI1_I1896_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I60_MP5 (I1_I1896_pn28 I1_b29_28 XI1_I1896_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I60_MP4 (XI1_I1896_I60_p1 XI1_I1896_I60_An I1_I1896_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I60_MP2 (VDD I1_p28_27 XI1_I1896_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I60_MP3 (XI1_I1896_I60_p1 XI1_I1896_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I60_MP0 (VDD I1_p28_27 XI1_I1896_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I61_MP1 (VDD I1_b29_29 XI1_I1896_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I61_MP5 (I1_I1896_pn29 I1_b29_29 XI1_I1896_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I61_MP4 (XI1_I1896_I61_p1 XI1_I1896_I61_An I1_I1896_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I61_MP2 (VDD I1_p28_28 XI1_I1896_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I61_MP3 (XI1_I1896_I61_p1 XI1_I1896_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I61_MP0 (VDD I1_p28_28 XI1_I1896_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I62_MP1 (VDD I1_b29_30 XI1_I1896_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I62_MP5 (I1_I1896_pn30 I1_b29_30 XI1_I1896_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I62_MP4 (XI1_I1896_I62_p1 XI1_I1896_I62_An I1_I1896_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I62_MP2 (VDD I1_p28_29 XI1_I1896_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I62_MP3 (XI1_I1896_I62_p1 XI1_I1896_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I62_MP0 (VDD I1_p28_29 XI1_I1896_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I233_MP1 (VDD I1_I1896_G29_0 XI1_I1896_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I233_MP5 (I1_p29_30 I1_I1896_G29_0 XI1_I1896_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I233_MP4 (XI1_I1896_I233_p1 XI1_I1896_I233_An I1_p29_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I233_MP2 (VDD I1_I1896_pn30 XI1_I1896_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I233_MP3 (XI1_I1896_I233_p1 XI1_I1896_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I233_MP0 (VDD I1_I1896_pn30 XI1_I1896_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I231_MP1 (VDD I1_I1896_G27_0 XI1_I1896_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I231_MP5 (I1_p29_28 I1_I1896_G27_0 XI1_I1896_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I231_MP4 (XI1_I1896_I231_p1 XI1_I1896_I231_An I1_p29_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I231_MP2 (VDD I1_I1896_pn28 XI1_I1896_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I231_MP3 (XI1_I1896_I231_p1 XI1_I1896_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I231_MP0 (VDD I1_I1896_pn28 XI1_I1896_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I230_MP1 (VDD I1_I1896_G26_0 XI1_I1896_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I230_MP5 (I1_p29_27 I1_I1896_G26_0 XI1_I1896_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I230_MP4 (XI1_I1896_I230_p1 XI1_I1896_I230_An I1_p29_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I230_MP2 (VDD I1_I1896_pn27 XI1_I1896_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I230_MP3 (XI1_I1896_I230_p1 XI1_I1896_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I230_MP0 (VDD I1_I1896_pn27 XI1_I1896_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I232_MP1 (VDD I1_I1896_G28_0 XI1_I1896_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I232_MP5 (I1_p29_29 I1_I1896_G28_0 XI1_I1896_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I232_MP4 (XI1_I1896_I232_p1 XI1_I1896_I232_An I1_p29_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I232_MP2 (VDD I1_I1896_pn29 XI1_I1896_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I232_MP3 (XI1_I1896_I232_p1 XI1_I1896_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I232_MP0 (VDD I1_I1896_pn29 XI1_I1896_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I234_MP1 (VDD I1_c29_m XI1_I1896_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1896_I234_MP5 (I1_p29_31 I1_c29_m XI1_I1896_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1896_I234_MP4 (XI1_I1896_I234_p1 XI1_I1896_I234_An I1_p29_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I234_MP2 (VDD I1_I1896_pn31 XI1_I1896_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1896_I234_MP3 (XI1_I1896_I234_p1 XI1_I1896_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1896_I234_MP0 (VDD I1_I1896_pn31 XI1_I1896_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I61_MP1 (VDD I1_b30_29 XI1_I1942_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I61_MP5 (I1_I1942_pn29 I1_b30_29 XI1_I1942_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I61_MP4 (XI1_I1942_I61_p1 XI1_I1942_I61_An I1_I1942_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I61_MP2 (VDD I1_p29_28 XI1_I1942_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I61_MP3 (XI1_I1942_I61_p1 XI1_I1942_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I61_MP0 (VDD I1_p29_28 XI1_I1942_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I60_MP1 (VDD I1_b30_28 XI1_I1942_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I60_MP5 (I1_I1942_pn28 I1_b30_28 XI1_I1942_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I60_MP4 (XI1_I1942_I60_p1 XI1_I1942_I60_An I1_I1942_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I60_MP2 (VDD I1_p29_27 XI1_I1942_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I60_MP3 (XI1_I1942_I60_p1 XI1_I1942_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I60_MP0 (VDD I1_p29_27 XI1_I1942_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I63_MP1 (VDD I1_b30_31 XI1_I1942_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I63_MP5 (I1_I1942_pn31 I1_b30_31 XI1_I1942_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I63_MP4 (XI1_I1942_I63_p1 XI1_I1942_I63_An I1_I1942_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I63_MP2 (VDD I1_p29_30 XI1_I1942_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I63_MP3 (XI1_I1942_I63_p1 XI1_I1942_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I63_MP0 (VDD I1_p29_30 XI1_I1942_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I231_MP1 (VDD I1_I1942_G27_0 XI1_I1942_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I231_MP5 (I1_p30_28 I1_I1942_G27_0 XI1_I1942_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I231_MP4 (XI1_I1942_I231_p1 XI1_I1942_I231_An I1_p30_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I231_MP2 (VDD I1_I1942_pn28 XI1_I1942_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I231_MP3 (XI1_I1942_I231_p1 XI1_I1942_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I231_MP0 (VDD I1_I1942_pn28 XI1_I1942_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I62_MP1 (VDD I1_b30_30 XI1_I1942_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I62_MP5 (I1_I1942_pn30 I1_b30_30 XI1_I1942_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I62_MP4 (XI1_I1942_I62_p1 XI1_I1942_I62_An I1_I1942_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I62_MP2 (VDD I1_p29_29 XI1_I1942_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I62_MP3 (XI1_I1942_I62_p1 XI1_I1942_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I62_MP0 (VDD I1_p29_29 XI1_I1942_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I233_MP1 (VDD I1_I1942_G29_0 XI1_I1942_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I233_MP5 (I1_p30_30 I1_I1942_G29_0 XI1_I1942_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I233_MP4 (XI1_I1942_I233_p1 XI1_I1942_I233_An I1_p30_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I233_MP2 (VDD I1_I1942_pn30 XI1_I1942_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I233_MP3 (XI1_I1942_I233_p1 XI1_I1942_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I233_MP0 (VDD I1_I1942_pn30 XI1_I1942_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I232_MP1 (VDD I1_I1942_G28_0 XI1_I1942_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1942_I232_MP5 (I1_p30_29 I1_I1942_G28_0 XI1_I1942_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1942_I232_MP4 (XI1_I1942_I232_p1 XI1_I1942_I232_An I1_p30_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I232_MP2 (VDD I1_I1942_pn29 XI1_I1942_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1942_I232_MP3 (XI1_I1942_I232_p1 XI1_I1942_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I232_MP0 (VDD I1_I1942_pn29 XI1_I1942_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I61_MP1 (VDD I1_b31_29 XI1_I1988_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I61_MP5 (I1_I1988_pn29 I1_b31_29 XI1_I1988_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I61_MP4 (XI1_I1988_I61_p1 XI1_I1988_I61_An I1_I1988_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I61_MP2 (VDD I1_p30_28 XI1_I1988_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I61_MP3 (XI1_I1988_I61_p1 XI1_I1988_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I61_MP0 (VDD I1_p30_28 XI1_I1988_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I63_MP1 (VDD I1_b31_31 XI1_I1988_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I63_MP5 (I1_I1988_pn31 I1_b31_31 XI1_I1988_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I63_MP4 (XI1_I1988_I63_p1 XI1_I1988_I63_An I1_I1988_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I63_MP2 (VDD I1_p30_30 XI1_I1988_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I63_MP3 (XI1_I1988_I63_p1 XI1_I1988_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I63_MP0 (VDD I1_p30_30 XI1_I1988_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I62_MP1 (VDD I1_b31_30 XI1_I1988_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I62_MP5 (I1_I1988_pn30 I1_b31_30 XI1_I1988_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I62_MP4 (XI1_I1988_I62_p1 XI1_I1988_I62_An I1_I1988_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I62_MP2 (VDD I1_p30_29 XI1_I1988_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I62_MP3 (XI1_I1988_I62_p1 XI1_I1988_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I62_MP0 (VDD I1_p30_29 XI1_I1988_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I233_MP1 (VDD I1_I1988_G29_0 XI1_I1988_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1988_I233_MP5 (I1_p31_30 I1_I1988_G29_0 XI1_I1988_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1988_I233_MP4 (XI1_I1988_I233_p1 XI1_I1988_I233_An I1_p31_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I233_MP2 (VDD I1_I1988_pn30 XI1_I1988_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1988_I233_MP3 (XI1_I1988_I233_p1 XI1_I1988_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1988_I233_MP0 (VDD I1_I1988_pn30 XI1_I1988_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I62_MP1 (VDD I1_dm30 XI1_I2066_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I62_MP5 (I1_I2066_pn30 I1_dm30 XI1_I2066_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I62_MP4 (XI1_I2066_I62_p1 XI1_I2066_I62_An I1_I2066_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I62_MP2 (VDD I1_p31_30 XI1_I2066_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I62_MP3 (XI1_I2066_I62_p1 XI1_I2066_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I62_MP0 (VDD I1_p31_30 XI1_I2066_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I63_MP1 (VDD I1_dm31 XI1_I2066_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I63_MP5 (I1_I2066_pn31 I1_dm31 XI1_I2066_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I63_MP4 (XI1_I2066_I63_p1 XI1_I2066_I63_An I1_I2066_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I63_MP2 (VDD I1_p31_31 XI1_I2066_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I63_MP3 (XI1_I2066_I63_p1 XI1_I2066_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I63_MP0 (VDD I1_p31_31 XI1_I2066_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I61_MP1 (VDD I1_dm29 XI1_I2066_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I61_MP5 (I1_I2066_pn29 I1_dm29 XI1_I2066_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I61_MP4 (XI1_I2066_I61_p1 XI1_I2066_I61_An I1_I2066_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I61_MP2 (VDD I1_p31_29 XI1_I2066_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I61_MP3 (XI1_I2066_I61_p1 XI1_I2066_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I61_MP0 (VDD I1_p31_29 XI1_I2066_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I234_MP1 (VDD I1_rcm XI1_I2066_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I234_MP5 (I1_ru31 I1_rcm XI1_I2066_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I234_MP4 (XI1_I2066_I234_p1 XI1_I2066_I234_An I1_ru31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I234_MP2 (VDD I1_I2066_pn31 XI1_I2066_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I234_MP3 (XI1_I2066_I234_p1 XI1_I2066_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I234_MP0 (VDD I1_I2066_pn31 XI1_I2066_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I232_MP1 (VDD I1_I2066_G28_0 XI1_I2066_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I232_MP5 (I1_ru29 I1_I2066_G28_0 XI1_I2066_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I232_MP4 (XI1_I2066_I232_p1 XI1_I2066_I232_An I1_ru29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I232_MP2 (VDD I1_I2066_pn29 XI1_I2066_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I232_MP3 (XI1_I2066_I232_p1 XI1_I2066_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I232_MP0 (VDD I1_I2066_pn29 XI1_I2066_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I233_MP1 (VDD I1_I2066_G29_0 XI1_I2066_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I233_MP5 (I1_ru30 I1_I2066_G29_0 XI1_I2066_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I233_MP4 (XI1_I2066_I233_p1 XI1_I2066_I233_An I1_ru30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I233_MP2 (VDD I1_I2066_pn30 XI1_I2066_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I233_MP3 (XI1_I2066_I233_p1 XI1_I2066_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I233_MP0 (VDD I1_I2066_pn30 XI1_I2066_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I231_MP1 (VDD I1_I2066_G27_0 XI1_I2066_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2066_I231_MP5 (I1_ru28 I1_I2066_G27_0 XI1_I2066_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2066_I231_MP4 (XI1_I2066_I231_p1 XI1_I2066_I231_An I1_ru28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I231_MP2 (VDD I1_I2066_pn28 XI1_I2066_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2066_I231_MP3 (XI1_I2066_I231_p1 XI1_I2066_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2066_I231_MP0 (VDD I1_I2066_pn28 XI1_I2066_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2261_MP1 (VDD I1_nrkn31 XI1_I2261_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2261_MP5 (DIVR_31 I1_nrkn31 XI1_I2261_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2261_MP4 (XI1_I2261_p1 XI1_I2261_An DIVR_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2261_MP2 (VDD I1_ru31 XI1_I2261_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2261_MP3 (XI1_I2261_p1 XI1_I2261_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2261_MP0 (VDD I1_ru31 XI1_I2261_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2258_MP1 (VDD I1_nrkn30 XI1_I2258_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2258_MP5 (DIVR_30 I1_nrkn30 XI1_I2258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2258_MP4 (XI1_I2258_p1 XI1_I2258_An DIVR_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2258_MP2 (VDD I1_ru30 XI1_I2258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2258_MP3 (XI1_I2258_p1 XI1_I2258_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2258_MP0 (VDD I1_ru30 XI1_I2258_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2255_MP1 (VDD I1_nrkn29 XI1_I2255_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2255_MP5 (DIVR_29 I1_nrkn29 XI1_I2255_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2255_MP4 (XI1_I2255_p1 XI1_I2255_An DIVR_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2255_MP2 (VDD I1_ru29 XI1_I2255_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2255_MP3 (XI1_I2255_p1 XI1_I2255_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2255_MP0 (VDD I1_ru29 XI1_I2255_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2249_MP1 (VDD I1_nrkn27 XI1_I2249_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2249_MP5 (DIVR_27 I1_nrkn27 XI1_I2249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2249_MP4 (XI1_I2249_p1 XI1_I2249_An DIVR_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2249_MP2 (VDD I1_ru27 XI1_I2249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2249_MP3 (XI1_I2249_p1 XI1_I2249_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2249_MP0 (VDD I1_ru27 XI1_I2249_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2252_MP1 (VDD I1_nrkn28 XI1_I2252_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I2252_MP5 (DIVR_28 I1_nrkn28 XI1_I2252_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2252_MP4 (XI1_I2252_p1 XI1_I2252_An DIVR_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2252_MP2 (VDD I1_ru28 XI1_I2252_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I2252_MP3 (XI1_I2252_p1 XI1_I2252_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2252_MP0 (VDD I1_ru28 XI1_I2252_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I126_MP1 (VDD VSS XI0_I1660_I126_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I126_MP5 (I0_I1660_pn62 VSS XI0_I1660_I126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I126_MP4 (XI0_I1660_I126_p1 XI0_I1660_I126_An I0_I1660_pn62 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I126_MP2 (VDD I0_fa248_0 XI0_I1660_I126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I126_MP3 (XI0_I1660_I126_p1 XI0_I1660_I126_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I126_MP0 (VDD I0_fa248_0 XI0_I1660_I126_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I127_MP1 (VDD I0_sn15 XI0_I1660_I127_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I127_MP5 (I0_I1660_pn63 I0_sn15 XI0_I1660_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I127_MP4 (XI0_I1660_I127_p1 XI0_I1660_I127_An I0_I1660_pn63 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I127_MP2 (VDD I0_fa248_1 XI0_I1660_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I127_MP3 (XI0_I1660_I127_p1 XI0_I1660_I127_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I127_MP0 (VDD I0_fa248_1 XI0_I1660_I127_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I125_MP1 (VDD I0_fa208_0 XI0_I1660_I125_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1660_I125_MP5 (I0_I1660_pn61 I0_fa208_0 XI0_I1660_I125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I125_MP4 (XI0_I1660_I125_p1 XI0_I1660_I125_An I0_I1660_pn61 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I125_MP2 (VDD I0_fa247_1 XI0_I1660_I125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1660_I125_MP3 (XI0_I1660_I125_p1 XI0_I1660_I125_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I125_MP0 (VDD I0_fa247_1 XI0_I1660_I125_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1301_MP2 (I1_qu15 I1_p16_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1301_MP2_1 (VDD I1_p16_32 I1_qu15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I841_MP2 (I1_qu25 I1_p6_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I841_MP2_1 (VDD I1_p6_32 I1_qu25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I797_MP2 (I1_qu26_b1_0 I1_qu26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I797_MP2_1 (VDD I1_qu26_b0 I1_qu26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I795_MP2 (I1_qu26 I1_p5_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I795_MP2_1 (VDD I1_p5_32 I1_qu26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1347_MP2 (I1_qu14 I1_p17_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1347_MP2_1 (VDD I1_p17_32 I1_qu14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1349_MP2 (I1_qu14_b1_0 I1_qu14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1349_MP2_1 (VDD I1_qu14_b0 I1_qu14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1303_MP2 (I1_qu15_b1_0 I1_qu15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1303_MP2_1 (VDD I1_qu15_b0 I1_qu15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1257_MP2 (I1_qu16_b1_0 I1_qu16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1257_MP2_1 (VDD I1_qu16_b0 I1_qu16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1255_MP2 (I1_qu16 I1_p15_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1255_MP2_1 (VDD I1_p15_32 I1_qu16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I758_MP2 (I1_qu27_b3_4 I1_qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I758_MP2_1 (VDD I1_qu27_b2_1 I1_qu27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1218_MP2 (I1_qu17_b3_4 I1_qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1218_MP2_1 (VDD I1_qu17_b2_1 I1_qu17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1172_MP2 (I1_qu18_b3_4 I1_qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1172_MP2_1 (VDD I1_qu18_b2_1 I1_qu18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I843_MP2 (I1_qu25_b1_0 I1_qu25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I843_MP2_1 (VDD I1_qu25_b0 I1_qu25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I759_MP2 (I1_qu27_b3_5 I1_qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I759_MP2_1 (VDD I1_qu27_b2_1 I1_qu27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1217_MP2 (I1_qu17_b3_3 I1_qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1217_MP2_1 (VDD I1_qu17_b2_1 I1_qu17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1171_MP2 (I1_qu18_b3_3 I1_qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1171_MP2_1 (VDD I1_qu18_b2_1 I1_qu18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I804_MP2 (I1_qu26_b3_4 I1_qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I804_MP2_1 (VDD I1_qu26_b2_1 I1_qu26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I757_MP2 (I1_qu27_b3_3 I1_qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I757_MP2_1 (VDD I1_qu27_b2_1 I1_qu27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I803_MP2 (I1_qu26_b3_3 I1_qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I803_MP2_1 (VDD I1_qu26_b2_1 I1_qu26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I712_MP2 (I1_qu28_b3_4 I1_qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I712_MP2_1 (VDD I1_qu28_b2_1 I1_qu28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1310_MP2 (I1_qu15_b3_4 I1_qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1310_MP2_1 (VDD I1_qu15_b2_1 I1_qu15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I850_MP2 (I1_qu25_b3_4 I1_qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I850_MP2_1 (VDD I1_qu25_b2_1 I1_qu25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I849_MP2 (I1_qu25_b3_3 I1_qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I849_MP2_1 (VDD I1_qu25_b2_1 I1_qu25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I845_MP2 (I1_qu25_b2_1 I1_qu25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I845_MP2_1 (VDD I1_qu25_b1_0 I1_qu25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I798_MP2 (I1_qu26_b2_0 I1_qu26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I798_MP2_1 (VDD I1_qu26_b1_0 I1_qu26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I753_MP2 (I1_qu27_b2_1 I1_qu27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I753_MP2_1 (VDD I1_qu27_b1_0 I1_qu27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1311_MP2 (I1_qu15_b3_5 I1_qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1311_MP2_1 (VDD I1_qu15_b2_1 I1_qu15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I851_MP2 (I1_qu25_b3_5 I1_qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I851_MP2_1 (VDD I1_qu25_b2_1 I1_qu25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I802_MP2 (I1_qu26_b3_2 I1_qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I802_MP2_1 (VDD I1_qu26_b2_0 I1_qu26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1305_MP2 (I1_qu15_b2_1 I1_qu15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1305_MP2_1 (VDD I1_qu15_b1_0 I1_qu15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I848_MP2 (I1_qu25_b3_2 I1_qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I848_MP2_1 (VDD I1_qu25_b2_0 I1_qu25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I844_MP2 (I1_qu25_b2_0 I1_qu25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I844_MP2_1 (VDD I1_qu25_b1_0 I1_qu25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1309_MP2 (I1_qu15_b3_3 I1_qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1309_MP2_1 (VDD I1_qu15_b2_1 I1_qu15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1304_MP2 (I1_qu15_b2_0 I1_qu15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1304_MP2_1 (VDD I1_qu15_b1_0 I1_qu15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1262_MP2 (I1_qu16_b3_2 I1_qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1262_MP2_1 (VDD I1_qu16_b2_0 I1_qu16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I847_MP2 (I1_qu25_b3_1 I1_qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I847_MP2_1 (VDD I1_qu25_b2_0 I1_qu25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I801_MP2 (I1_qu26_b3_1 I1_qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I801_MP2_1 (VDD I1_qu26_b2_0 I1_qu26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1357_MP2 (I1_qu14_b3_5 I1_qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1357_MP2_1 (VDD I1_qu14_b2_1 I1_qu14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1355_MP2 (I1_qu14_b3_3 I1_qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1355_MP2_1 (VDD I1_qu14_b2_1 I1_qu14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1350_MP2 (I1_qu14_b2_0 I1_qu14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1350_MP2_1 (VDD I1_qu14_b1_0 I1_qu14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1216_MP2 (I1_qu17_b3_2 I1_qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1216_MP2_1 (VDD I1_qu17_b2_0 I1_qu17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1213_MP2 (I1_qu17_b2_1 I1_qu17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1213_MP2_1 (VDD I1_qu17_b1_0 I1_qu17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1219_MP2 (I1_qu17_b3_5 I1_qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1219_MP2_1 (VDD I1_qu17_b2_1 I1_qu17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1167_MP2 (I1_qu18_b2_1 I1_qu18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1167_MP2_1 (VDD I1_qu18_b1_0 I1_qu18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1173_MP2 (I1_qu18_b3_5 I1_qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1173_MP2_1 (VDD I1_qu18_b2_1 I1_qu18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I846_MP2 (I1_qu25_b3_0 I1_qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I846_MP2_1 (VDD I1_qu25_b2_0 I1_qu25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I800_MP2 (I1_qu26_b3_0 I1_qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I800_MP2_1 (VDD I1_qu26_b2_0 I1_qu26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I756_MP2 (I1_qu27_b3_2 I1_qu27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I756_MP2_1 (VDD I1_qu27_b2_0 I1_qu27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I752_MP2 (I1_qu27_b2_0 I1_qu27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I752_MP2_1 (VDD I1_qu27_b1_0 I1_qu27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I751_MP2 (I1_qu27_b1_0 I1_qu27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I751_MP2_1 (VDD I1_qu27_b0 I1_qu27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I713_MP2 (I1_qu28_b3_5 I1_qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I713_MP2_1 (VDD I1_qu28_b2_1 I1_qu28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I749_MP2 (I1_qu27 I1_p4_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I749_MP2_1 (VDD I1_p4_32 I1_qu27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1308_MP2 (I1_qu15_b3_2 I1_qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1308_MP2_1 (VDD I1_qu15_b2_0 I1_qu15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1209_MP2 (I1_qu17 I1_p14_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1209_MP2_1 (VDD I1_p14_32 I1_qu17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1165_MP2 (I1_qu18_b1_0 I1_qu18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1165_MP2_1 (VDD I1_qu18_b0 I1_qu18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1166_MP2 (I1_qu18_b2_0 I1_qu18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1166_MP2_1 (VDD I1_qu18_b1_0 I1_qu18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1170_MP2 (I1_qu18_b3_2 I1_qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1170_MP2_1 (VDD I1_qu18_b2_0 I1_qu18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I703_MP2 (I1_qu28 I1_p3_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I703_MP2_1 (VDD I1_p3_32 I1_qu28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1354_MP2 (I1_qu14_b3_2 I1_qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1354_MP2_1 (VDD I1_qu14_b2_0 I1_qu14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1261_MP2 (I1_qu16_b3_1 I1_qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1261_MP2_1 (VDD I1_qu16_b2_0 I1_qu16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1214_MP2 (I1_qu17_b3_0 I1_qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1214_MP2_1 (VDD I1_qu17_b2_0 I1_qu17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1215_MP2 (I1_qu17_b3_1 I1_qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1215_MP2_1 (VDD I1_qu17_b2_0 I1_qu17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1163_MP2 (I1_qu18 I1_p13_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1163_MP2_1 (VDD I1_p13_32 I1_qu18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I887_MP2 (I1_qu24 I1_p7_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I887_MP2_1 (VDD I1_p7_32 I1_qu24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I754_MP2 (I1_qu27_b3_0 I1_qu27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I754_MP2_1 (VDD I1_qu27_b2_0 I1_qu27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I755_MP2 (I1_qu27_b3_1 I1_qu27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I755_MP2_1 (VDD I1_qu27_b2_0 I1_qu27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I708_MP2 (I1_qu28_b3_0 I1_qu28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I708_MP2_1 (VDD I1_qu28_b2_0 I1_qu28_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I709_MP2 (I1_qu28_b3_1 I1_qu28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I709_MP2_1 (VDD I1_qu28_b2_0 I1_qu28_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I710_MP2 (I1_qu28_b3_2 I1_qu28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I710_MP2_1 (VDD I1_qu28_b2_0 I1_qu28_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1307_MP2 (I1_qu15_b3_1 I1_qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1307_MP2_1 (VDD I1_qu15_b2_0 I1_qu15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1260_MP2 (I1_qu16_b3_0 I1_qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1260_MP2_1 (VDD I1_qu16_b2_0 I1_qu16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1169_MP2 (I1_qu18_b3_1 I1_qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1169_MP2_1 (VDD I1_qu18_b2_0 I1_qu18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1168_MP2 (I1_qu18_b3_0 I1_qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1168_MP2_1 (VDD I1_qu18_b2_0 I1_qu18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I889_MP2 (I1_qu24_b1_0 I1_qu24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I889_MP2_1 (VDD I1_qu24_b0 I1_qu24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1353_MP2 (I1_qu14_b3_1 I1_qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1353_MP2_1 (VDD I1_qu14_b2_0 I1_qu14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I890_MP2 (I1_qu24_b2_0 I1_qu24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I890_MP2_1 (VDD I1_qu24_b1_0 I1_qu24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I895_MP2 (I1_qu24_b3_3 I1_qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I895_MP2_1 (VDD I1_qu24_b2_1 I1_qu24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I894_MP2 (I1_qu24_b3_2 I1_qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I894_MP2_1 (VDD I1_qu24_b2_0 I1_qu24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I893_MP2 (I1_qu24_b3_1 I1_qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I893_MP2_1 (VDD I1_qu24_b2_0 I1_qu24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1393_MP2 (I1_qu13 I1_p18_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1393_MP2_1 (VDD I1_p18_32 I1_qu13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1306_MP2 (I1_qu15_b3_0 I1_qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1306_MP2_1 (VDD I1_qu15_b2_0 I1_qu15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1352_MP2 (I1_qu14_b3_0 I1_qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1352_MP2_1 (VDD I1_qu14_b2_0 I1_qu14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I897_MP2 (I1_qu24_b3_5 I1_qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I897_MP2_1 (VDD I1_qu24_b2_1 I1_qu24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I892_MP2 (I1_qu24_b3_0 I1_qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I892_MP2_1 (VDD I1_qu24_b2_0 I1_qu24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I933_MP2 (I1_qu23 I1_p8_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I933_MP2_1 (VDD I1_p8_32 I1_qu23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I663_MP2 (I1_qu29_b3_1 I1_qu29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I663_MP2_1 (VDD I1_qu29_b2_0 I1_qu29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I664_MP2 (I1_qu29_b3_2 I1_qu29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I664_MP2_1 (VDD I1_qu29_b2_0 I1_qu29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I665_MP2 (I1_qu29_b3_3 I1_qu29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I665_MP2_1 (VDD I1_qu29_b2_1 I1_qu29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1395_MP2 (I1_qu13_b1_0 I1_qu13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1395_MP2_1 (VDD I1_qu13_b0 I1_qu13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1397_MP2 (I1_qu13_b2_1 I1_qu13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1397_MP2_1 (VDD I1_qu13_b1_0 I1_qu13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1396_MP2 (I1_qu13_b2_0 I1_qu13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1396_MP2_1 (VDD I1_qu13_b1_0 I1_qu13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1399_MP2 (I1_qu13_b3_1 I1_qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1399_MP2_1 (VDD I1_qu13_b2_0 I1_qu13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1126_MP2 (I1_qu19_b3_4 I1_qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1126_MP2_1 (VDD I1_qu19_b2_1 I1_qu19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1125_MP2 (I1_qu19_b3_3 I1_qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1125_MP2_1 (VDD I1_qu19_b2_1 I1_qu19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I935_MP2 (I1_qu23_b1_0 I1_qu23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I935_MP2_1 (VDD I1_qu23_b0 I1_qu23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I498_MP2 (I1_dd29_b3_0 I1_dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I498_MP2_1 (VDD I1_dd29_b2_0 I1_dd29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I662_MP2 (I1_qu29_b3_0 I1_qu29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I662_MP2_1 (VDD I1_qu29_b2_0 I1_qu29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I660_MP2 (I1_qu29_b2_0 I1_qu29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I660_MP2_1 (VDD I1_qu29_b1_0 I1_qu29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I667_MP2 (I1_qu29_b3_5 I1_qu29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I667_MP2_1 (VDD I1_qu29_b2_1 I1_qu29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I666_MP2 (I1_qu29_b3_4 I1_qu29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I666_MP2_1 (VDD I1_qu29_b2_1 I1_qu29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I661_MP2 (I1_qu29_b2_1 I1_qu29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I661_MP2_1 (VDD I1_qu29_b1_0 I1_qu29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I659_MP2 (I1_qu29_b1_0 I1_qu29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I659_MP2_1 (VDD I1_qu29_b0 I1_qu29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I657_MP2 (I1_qu29 I1_p2_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I657_MP2_1 (VDD I1_p2_32 I1_qu29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1402_MP2 (I1_qu13_b3_4 I1_qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1402_MP2_1 (VDD I1_qu13_b2_1 I1_qu13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1401_MP2 (I1_qu13_b3_3 I1_qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1401_MP2_1 (VDD I1_qu13_b2_1 I1_qu13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1403_MP2 (I1_qu13_b3_5 I1_qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1403_MP2_1 (VDD I1_qu13_b2_1 I1_qu13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1400_MP2 (I1_qu13_b3_2 I1_qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1400_MP2_1 (VDD I1_qu13_b2_0 I1_qu13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1398_MP2 (I1_qu13_b3_0 I1_qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1398_MP2_1 (VDD I1_qu13_b2_0 I1_qu13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1127_MP2 (I1_qu19_b3_5 I1_qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1127_MP2_1 (VDD I1_qu19_b2_1 I1_qu19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1080_MP2 (I1_qu20_b3_4 I1_qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1080_MP2_1 (VDD I1_qu20_b2_1 I1_qu20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1121_MP2 (I1_qu19_b2_1 I1_qu19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1121_MP2_1 (VDD I1_qu19_b1_0 I1_qu19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I461_MP2 (I1_dd26_b3_2 I1_dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I461_MP2_1 (VDD I1_dd26_b2_0 I1_dd26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I448_MP2 (I1_dd25_b3_2 I1_dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I448_MP2_1 (VDD I1_dd25_b2_0 I1_dd25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I435_MP2 (I1_dd24_b3_2 I1_dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I435_MP2_1 (VDD I1_dd24_b2_0 I1_dd24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I431_MP2 (I1_dd24_b2_0 I1_dd24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I431_MP2_1 (VDD I1_dd24_b1_0 I1_dd24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I460_MP2 (I1_dd26_b3_1 I1_dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I460_MP2_1 (VDD I1_dd26_b2_0 I1_dd26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I447_MP2 (I1_dd25_b3_1 I1_dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I447_MP2_1 (VDD I1_dd25_b2_0 I1_dd25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I434_MP2 (I1_dd24_b3_1 I1_dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I434_MP2_1 (VDD I1_dd24_b2_0 I1_dd24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I433_MP2 (I1_dd24_b3_0 I1_dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I433_MP2_1 (VDD I1_dd24_b2_0 I1_dd24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I472_MP2 (I1_dd27_b3_0 I1_dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I472_MP2_1 (VDD I1_dd27_b2_0 I1_dd27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I446_MP2 (I1_dd25_b3_0 I1_dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I446_MP2_1 (VDD I1_dd25_b2_0 I1_dd25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I459_MP2 (I1_dd26_b3_0 I1_dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I459_MP2_1 (VDD I1_dd26_b2_0 I1_dd26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I485_MP2 (I1_dd28_b3_0 I1_dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I485_MP2_1 (VDD I1_dd28_b2_0 I1_dd28_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1119_MP2 (I1_qu19_b1_0 I1_qu19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1119_MP2_1 (VDD I1_qu19_b0 I1_qu19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1120_MP2 (I1_qu19_b2_0 I1_qu19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1120_MP2_1 (VDD I1_qu19_b1_0 I1_qu19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1124_MP2 (I1_qu19_b3_2 I1_qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1124_MP2_1 (VDD I1_qu19_b2_0 I1_qu19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1123_MP2 (I1_qu19_b3_1 I1_qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1123_MP2_1 (VDD I1_qu19_b2_0 I1_qu19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1122_MP2 (I1_qu19_b3_0 I1_qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1122_MP2_1 (VDD I1_qu19_b2_0 I1_qu19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1034_MP2 (I1_qu21_b3_4 I1_qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1034_MP2_1 (VDD I1_qu21_b2_1 I1_qu21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I513_MP2 (I1_dd30_b3_2 I1_dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I513_MP2_1 (VDD I1_dd30_b2_0 I1_dd30_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I942_MP2 (I1_qu23_b3_4 I1_qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I942_MP2_1 (VDD I1_qu23_b2_1 I1_qu23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I937_MP2 (I1_qu23_b2_1 I1_qu23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I937_MP2_1 (VDD I1_qu23_b1_0 I1_qu23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I943_MP2 (I1_qu23_b3_5 I1_qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I943_MP2_1 (VDD I1_qu23_b2_1 I1_qu23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I941_MP2 (I1_qu23_b3_3 I1_qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I941_MP2_1 (VDD I1_qu23_b2_1 I1_qu23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I936_MP2 (I1_qu23_b2_0 I1_qu23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I936_MP2_1 (VDD I1_qu23_b1_0 I1_qu23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I940_MP2 (I1_qu23_b3_2 I1_qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I940_MP2_1 (VDD I1_qu23_b2_0 I1_qu23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1079_MP2 (I1_qu20_b3_3 I1_qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1079_MP2_1 (VDD I1_qu20_b2_1 I1_qu20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1081_MP2 (I1_qu20_b3_5 I1_qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1081_MP2_1 (VDD I1_qu20_b2_1 I1_qu20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1117_MP2 (I1_qu19 I1_p12_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1117_MP2_1 (VDD I1_p12_32 I1_qu19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I526_MP2 (I1_dd31_b3_2 I1_dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I526_MP2_1 (VDD I1_dd31_b2_0 I1_dd31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I988_MP2 (I1_qu22_b3_4 I1_qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I988_MP2_1 (VDD I1_qu22_b2_1 I1_qu22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I939_MP2 (I1_qu23_b3_1 I1_qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I939_MP2_1 (VDD I1_qu23_b2_0 I1_qu23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1075_MP2 (I1_qu20_b2_1 I1_qu20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1075_MP2_1 (VDD I1_qu20_b1_0 I1_qu20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1073_MP2 (I1_qu20_b1_0 I1_qu20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1073_MP2_1 (VDD I1_qu20_b0 I1_qu20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1071_MP2 (I1_qu20 I1_p11_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1071_MP2_1 (VDD I1_p11_32 I1_qu20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1035_MP2 (I1_qu21_b3_5 I1_qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1035_MP2_1 (VDD I1_qu21_b2_1 I1_qu21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1033_MP2 (I1_qu21_b3_3 I1_qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1033_MP2_1 (VDD I1_qu21_b2_1 I1_qu21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I989_MP2 (I1_qu22_b3_5 I1_qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I989_MP2_1 (VDD I1_qu22_b2_1 I1_qu22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I979_MP2 (I1_qu22 I1_p9_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I979_MP2_1 (VDD I1_p9_32 I1_qu22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I938_MP2 (I1_qu23_b3_0 I1_qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I938_MP2_1 (VDD I1_qu23_b2_0 I1_qu23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1029_MP2 (I1_qu21_b2_1 I1_qu21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1029_MP2_1 (VDD I1_qu21_b1_0 I1_qu21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I396_MP2 (I1_dd21_b3_2 I1_dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I396_MP2_1 (VDD I1_dd21_b2_0 I1_dd21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I421_MP2 (I1_dd23_b3_1 I1_dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I421_MP2_1 (VDD I1_dd23_b2_0 I1_dd23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I987_MP2 (I1_qu22_b3_3 I1_qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I987_MP2_1 (VDD I1_qu22_b2_1 I1_qu22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I983_MP2 (I1_qu22_b2_1 I1_qu22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I983_MP2_1 (VDD I1_qu22_b1_0 I1_qu22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I981_MP2 (I1_qu22_b1_0 I1_qu22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I981_MP2_1 (VDD I1_qu22_b0 I1_qu22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I420_MP2 (I1_dd23_b3_0 I1_dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I420_MP2_1 (VDD I1_dd23_b2_0 I1_dd23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I511_MP2 (I1_dd30_b3_0 I1_dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I511_MP2_1 (VDD I1_dd30_b2_0 I1_dd30_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I616_MP2 (I1_qu30_b3_0 I1_qu30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I616_MP2_1 (VDD I1_qu30_b2_0 I1_qu30_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I619_MP2 (I1_qu30_b3_3 I1_qu30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I619_MP2_1 (VDD I1_qu30_b2_1 I1_qu30_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I620_MP2 (I1_qu30_b3_4 I1_qu30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I620_MP2_1 (VDD I1_qu30_b2_1 I1_qu30_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I408_MP2 (I1_dd22_b3_1 I1_dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I408_MP2_1 (VDD I1_dd22_b2_0 I1_dd22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I395_MP2 (I1_dd21_b3_1 I1_dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I395_MP2_1 (VDD I1_dd21_b2_0 I1_dd21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I524_MP2 (I1_dd31_b3_0 I1_dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I524_MP2_1 (VDD I1_dd31_b2_0 I1_dd31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I407_MP2 (I1_dd22_b3_0 I1_dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I407_MP2_1 (VDD I1_dd22_b2_0 I1_dd22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I381_MP2 (I1_dd20_b3_0 I1_dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I381_MP2_1 (VDD I1_dd20_b2_0 I1_dd20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I394_MP2 (I1_dd21_b3_0 I1_dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I394_MP2_1 (VDD I1_dd21_b2_0 I1_dd21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I617_MP2 (I1_qu30_b3_1 I1_qu30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I617_MP2_1 (VDD I1_qu30_b2_0 I1_qu30_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I618_MP2 (I1_qu30_b3_2 I1_qu30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I618_MP2_1 (VDD I1_qu30_b2_0 I1_qu30_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I614_MP2 (I1_qu30_b2_0 I1_qu30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I614_MP2_1 (VDD I1_qu30_b1_0 I1_qu30_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I621_MP2 (I1_qu30_b3_5 I1_qu30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I621_MP2_1 (VDD I1_qu30_b2_1 I1_qu30_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I615_MP2 (I1_qu30_b2_1 I1_qu30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I615_MP2_1 (VDD I1_qu30_b1_0 I1_qu30_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I613_MP2 (I1_qu30_b1_0 I1_qu30_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I613_MP2_1 (VDD I1_qu30_b0 I1_qu30_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1446_MP2 (I1_qu12_b3_2 I1_qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1446_MP2_1 (VDD I1_qu12_b2_0 I1_qu12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1445_MP2 (I1_qu12_b3_1 I1_qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1445_MP2_1 (VDD I1_qu12_b2_0 I1_qu12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1444_MP2 (I1_qu12_b3_0 I1_qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1444_MP2_1 (VDD I1_qu12_b2_0 I1_qu12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1027_MP2 (I1_qu21_b1_0 I1_qu21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1027_MP2_1 (VDD I1_qu21_b0 I1_qu21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I382_MP2 (I1_dd20_b3_1 I1_dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I382_MP2_1 (VDD I1_dd20_b2_0 I1_dd20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I369_MP2 (I1_dd19_b3_1 I1_dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I369_MP2_1 (VDD I1_dd19_b2_0 I1_dd19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I368_MP2 (I1_dd19_b3_0 I1_dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I368_MP2_1 (VDD I1_dd19_b2_0 I1_dd19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I611_MP2 (I1_qu30 I1_p1_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I611_MP2_1 (VDD I1_p1_32 I1_qu30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1441_MP2 (I1_qu12_b1_0 I1_qu12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1441_MP2_1 (VDD I1_qu12_b0 I1_qu12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1439_MP2 (I1_qu12 I1_p19_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1439_MP2_1 (VDD I1_p19_32 I1_qu12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1442_MP2 (I1_qu12_b2_0 I1_qu12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1442_MP2_1 (VDD I1_qu12_b1_0 I1_qu12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1443_MP2 (I1_qu12_b2_1 I1_qu12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1443_MP2_1 (VDD I1_qu12_b1_0 I1_qu12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1447_MP2 (I1_qu12_b3_3 I1_qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1447_MP2_1 (VDD I1_qu12_b2_1 I1_qu12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I344_MP2 (I1_dd17_b3_2 I1_dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I344_MP2_1 (VDD I1_dd17_b2_0 I1_dd17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1025_MP2 (I1_qu21 I1_p10_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1025_MP2_1 (VDD I1_p10_32 I1_qu21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I356_MP2 (I1_dd18_b3_1 I1_dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I356_MP2_1 (VDD I1_dd18_b2_0 I1_dd18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I343_MP2 (I1_dd17_b3_1 I1_dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I343_MP2_1 (VDD I1_dd17_b2_0 I1_dd17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I355_MP2 (I1_dd18_b3_0 I1_dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I355_MP2_1 (VDD I1_dd18_b2_0 I1_dd18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1448_MP2 (I1_qu12_b3_4 I1_qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1448_MP2_1 (VDD I1_qu12_b2_1 I1_qu12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1449_MP2 (I1_qu12_b3_5 I1_qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1449_MP2_1 (VDD I1_qu12_b2_1 I1_qu12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1074_MP2 (I1_qu20_b2_0 I1_qu20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1074_MP2_1 (VDD I1_qu20_b1_0 I1_qu20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1078_MP2 (I1_qu20_b3_2 I1_qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1078_MP2_1 (VDD I1_qu20_b2_0 I1_qu20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1485_MP2 (I1_qu11 I1_p20_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1485_MP2_1 (VDD I1_p20_32 I1_qu11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I279_MP2 (I1_dd12_b3_2 I1_dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I279_MP2_1 (VDD I1_dd12_b2_0 I1_dd12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I305_MP2 (I1_dd14_b3_2 I1_dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I305_MP2_1 (VDD I1_dd14_b2_0 I1_dd14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I292_MP2 (I1_dd13_b3_2 I1_dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I292_MP2_1 (VDD I1_dd13_b2_0 I1_dd13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1032_MP2 (I1_qu21_b3_2 I1_qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1032_MP2_1 (VDD I1_qu21_b2_0 I1_qu21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I330_MP2 (I1_dd16_b3_1 I1_dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I330_MP2_1 (VDD I1_dd16_b2_0 I1_dd16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I317_MP2 (I1_dd15_b3_1 I1_dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I317_MP2_1 (VDD I1_dd15_b2_0 I1_dd15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I304_MP2 (I1_dd14_b3_1 I1_dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I304_MP2_1 (VDD I1_dd14_b2_0 I1_dd14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I291_MP2 (I1_dd13_b3_1 I1_dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I291_MP2_1 (VDD I1_dd13_b2_0 I1_dd13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1487_MP2 (I1_qu11_b1_0 I1_qu11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1487_MP2_1 (VDD I1_qu11_b0 I1_qu11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1028_MP2 (I1_qu21_b2_0 I1_qu21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1028_MP2_1 (VDD I1_qu21_b1_0 I1_qu21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I982_MP2 (I1_qu22_b2_0 I1_qu22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I982_MP2_1 (VDD I1_qu22_b1_0 I1_qu22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I986_MP2 (I1_qu22_b3_2 I1_qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I986_MP2_1 (VDD I1_qu22_b2_0 I1_qu22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I278_MP2 (I1_dd12_b3_1 I1_dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I278_MP2_1 (VDD I1_dd12_b2_0 I1_dd12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I265_MP2 (I1_dd11_b3_1 I1_dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I265_MP2_1 (VDD I1_dd11_b2_0 I1_dd11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I135_MP2 (I1_dd1_b3_1 I1_dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I135_MP2_1 (VDD I1_dd1_b2_0 I1_dd1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I329_MP2 (I1_dd16_b3_0 I1_dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I329_MP2_1 (VDD I1_dd16_b2_0 I1_dd16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I134_MP2 (I1_dd1_b3_0 I1_dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I134_MP2_1 (VDD I1_dd1_b2_0 I1_dd1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I342_MP2 (I1_dd17_b3_0 I1_dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I342_MP2_1 (VDD I1_dd17_b2_0 I1_dd17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I277_MP2 (I1_dd12_b3_0 I1_dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I277_MP2_1 (VDD I1_dd12_b2_0 I1_dd12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I290_MP2 (I1_dd13_b3_0 I1_dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I290_MP2_1 (VDD I1_dd13_b2_0 I1_dd13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I570_MP2 (I1_qu31_b3_0 I1_qu31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I570_MP2_1 (VDD I1_qu31_b2_0 I1_qu31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1488_MP2 (I1_qu11_b2_0 I1_qu11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1488_MP2_1 (VDD I1_qu11_b1_0 I1_qu11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1492_MP2 (I1_qu11_b3_2 I1_qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1492_MP2_1 (VDD I1_qu11_b2_0 I1_qu11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1491_MP2 (I1_qu11_b3_1 I1_qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1491_MP2_1 (VDD I1_qu11_b2_0 I1_qu11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1490_MP2 (I1_qu11_b3_0 I1_qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1490_MP2_1 (VDD I1_qu11_b2_0 I1_qu11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I306_MP2 (I1_dd14_b3_3 I1_dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I306_MP2_1 (VDD I1_dd14_b2_1 I1_dd14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1077_MP2 (I1_qu20_b3_1 I1_qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1077_MP2_1 (VDD I1_qu20_b2_0 I1_qu20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1076_MP2 (I1_qu20_b3_0 I1_qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1076_MP2_1 (VDD I1_qu20_b2_0 I1_qu20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I253_MP2 (I1_dd10_b3_2 I1_dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I253_MP2_1 (VDD I1_dd10_b2_0 I1_dd10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I240_MP2 (I1_dd9_b3_2 I1_dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I240_MP2_1 (VDD I1_dd9_b2_0 I1_dd9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I266_MP2 (I1_dd11_b3_2 I1_dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I266_MP2_1 (VDD I1_dd11_b2_0 I1_dd11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I214_MP2 (I1_dd7_b3_2 I1_dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I214_MP2_1 (VDD I1_dd7_b2_0 I1_dd7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I379_MP2 (I1_dd20_b2_0 I1_dd20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I379_MP2_1 (VDD I1_dd20_b1_0 I1_dd20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I984_MP2 (I1_qu22_b3_0 I1_qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I984_MP2_1 (VDD I1_qu22_b2_0 I1_qu22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I985_MP2 (I1_qu22_b3_1 I1_qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I985_MP2_1 (VDD I1_qu22_b2_0 I1_qu22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I252_MP2 (I1_dd10_b3_1 I1_dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I252_MP2_1 (VDD I1_dd10_b2_0 I1_dd10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I239_MP2 (I1_dd9_b3_1 I1_dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I239_MP2_1 (VDD I1_dd9_b2_0 I1_dd9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I226_MP2 (I1_dd8_b3_1 I1_dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I226_MP2_1 (VDD I1_dd8_b2_0 I1_dd8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I174_MP2 (I1_dd4_b3_1 I1_dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I174_MP2_1 (VDD I1_dd4_b2_0 I1_dd4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I212_MP2 (I1_dd7_b3_0 I1_dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I212_MP2_1 (VDD I1_dd7_b2_0 I1_dd7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I187_MP2 (I1_dd5_b3_1 I1_dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I187_MP2_1 (VDD I1_dd5_b2_0 I1_dd5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I264_MP2 (I1_dd11_b3_0 I1_dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I264_MP2_1 (VDD I1_dd11_b2_0 I1_dd11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I225_MP2 (I1_dd8_b3_0 I1_dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I225_MP2_1 (VDD I1_dd8_b2_0 I1_dd8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I251_MP2 (I1_dd10_b3_0 I1_dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I251_MP2_1 (VDD I1_dd10_b2_0 I1_dd10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I173_MP2 (I1_dd4_b3_0 I1_dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I173_MP2_1 (VDD I1_dd4_b2_0 I1_dd4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I186_MP2 (I1_dd5_b3_0 I1_dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I186_MP2_1 (VDD I1_dd5_b2_0 I1_dd5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I316_MP2 (I1_dd15_b3_0 I1_dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I316_MP2_1 (VDD I1_dd15_b2_0 I1_dd15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I238_MP2 (I1_dd9_b3_0 I1_dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I238_MP2_1 (VDD I1_dd9_b2_0 I1_dd9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I303_MP2 (I1_dd14_b3_0 I1_dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I303_MP2_1 (VDD I1_dd14_b2_0 I1_dd14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I571_MP2 (I1_qu31_b3_1 I1_qu31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I571_MP2_1 (VDD I1_qu31_b2_0 I1_qu31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I332_MP2 (I1_dd16_b3_3 I1_dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I332_MP2_1 (VDD I1_dd16_b2_1 I1_dd16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I345_MP2 (I1_dd17_b3_3 I1_dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I345_MP2_1 (VDD I1_dd17_b2_1 I1_dd17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I319_MP2 (I1_dd15_b3_3 I1_dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I319_MP2_1 (VDD I1_dd15_b2_1 I1_dd15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I293_MP2 (I1_dd13_b3_3 I1_dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I293_MP2_1 (VDD I1_dd13_b2_1 I1_dd13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I227_MP2 (I1_dd8_b3_2 I1_dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I227_MP2_1 (VDD I1_dd8_b2_0 I1_dd8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I201_MP2 (I1_dd6_b3_2 I1_dd6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I201_MP2_1 (VDD I1_dd6_b2_0 I1_dd6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1031_MP2 (I1_qu21_b3_1 I1_qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1031_MP2_1 (VDD I1_qu21_b2_0 I1_qu21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1030_MP2 (I1_qu21_b3_0 I1_qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1030_MP2_1 (VDD I1_qu21_b2_0 I1_qu21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I314_MP2 (I1_dd15_b2_0 I1_dd15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I314_MP2_1 (VDD I1_dd15_b1_0 I1_dd15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I149_MP2 (I1_dd2_b3_2 I1_dd2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I149_MP2_1 (VDD I1_dd2_b2_0 I1_dd2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I136_MP2 (I1_dd1_b3_2 I1_dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I136_MP2_1 (VDD I1_dd1_b2_0 I1_dd1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I327_MP2 (I1_dd16_b2_0 I1_dd16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I327_MP2_1 (VDD I1_dd16_b1_0 I1_dd16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I522_MP2 (I1_dd31_b2_0 I1_dd31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I522_MP2_1 (VDD I1_dd31_b1_0 I1_dd31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I161_MP2 (I1_dd3_b3_1 I1_dd3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I161_MP2_1 (VDD I1_dd3_b2_0 I1_dd3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I148_MP2 (I1_dd2_b3_1 I1_dd2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I148_MP2_1 (VDD I1_dd2_b2_0 I1_dd2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I147_MP2 (I1_dd2_b3_0 I1_dd2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I147_MP2_1 (VDD I1_dd2_b2_0 I1_dd2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I160_MP2 (I1_dd3_b3_0 I1_dd3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I160_MP2_1 (VDD I1_dd3_b2_0 I1_dd3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I199_MP2 (I1_dd6_b3_0 I1_dd6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I199_MP2_1 (VDD I1_dd6_b2_0 I1_dd6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I572_MP2 (I1_qu31_b3_2 I1_qu31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I572_MP2_1 (VDD I1_qu31_b2_0 I1_qu31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I569_MP2 (I1_qu31_b2_1 I1_qu31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I569_MP2_1 (VDD I1_qu31_b1_0 I1_qu31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I568_MP2 (I1_qu31_b2_0 I1_qu31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I568_MP2_1 (VDD I1_qu31_b1_0 I1_qu31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I573_MP2 (I1_qu31_b3_3 I1_qu31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I573_MP2_1 (VDD I1_qu31_b2_1 I1_qu31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I575_MP2 (I1_qu31_b3_5 I1_qu31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I575_MP2_1 (VDD I1_qu31_b2_1 I1_qu31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I574_MP2 (I1_qu31_b3_4 I1_qu31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I574_MP2_1 (VDD I1_qu31_b2_1 I1_qu31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1489_MP2 (I1_qu11_b2_1 I1_qu11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1489_MP2_1 (VDD I1_qu11_b1_0 I1_qu11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I384_MP2 (I1_dd20_b3_3 I1_dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I384_MP2_1 (VDD I1_dd20_b2_1 I1_dd20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I371_MP2 (I1_dd19_b3_3 I1_dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I371_MP2_1 (VDD I1_dd19_b2_1 I1_dd19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I358_MP2 (I1_dd18_b3_3 I1_dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I358_MP2_1 (VDD I1_dd18_b2_1 I1_dd18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I280_MP2 (I1_dd12_b3_3 I1_dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I280_MP2_1 (VDD I1_dd12_b2_1 I1_dd12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I328_MP2 (I1_dd16_b2_1 I1_dd16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I328_MP2_1 (VDD I1_dd16_b1_0 I1_dd16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I241_MP2 (I1_dd9_b3_3 I1_dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I241_MP2_1 (VDD I1_dd9_b2_1 I1_dd9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I315_MP2 (I1_dd15_b2_1 I1_dd15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I315_MP2_1 (VDD I1_dd15_b1_0 I1_dd15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I228_MP2 (I1_dd8_b3_3 I1_dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I228_MP2_1 (VDD I1_dd8_b2_1 I1_dd8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I188_MP2 (I1_dd5_b3_2 I1_dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I188_MP2_1 (VDD I1_dd5_b2_0 I1_dd5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I175_MP2 (I1_dd4_b3_2 I1_dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I175_MP2_1 (VDD I1_dd4_b2_0 I1_dd4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I162_MP2 (I1_dd3_b3_2 I1_dd3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I162_MP2_1 (VDD I1_dd3_b2_0 I1_dd3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I288_MP2 (I1_dd13_b2_0 I1_dd13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I288_MP2_1 (VDD I1_dd13_b1_0 I1_dd13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I132_MP2 (I1_dd1_b2_0 I1_dd1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I132_MP2_1 (VDD I1_dd1_b1_0 I1_dd1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I313_MP2 (I1_dd15_b1_0 I1_dd15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I313_MP2_1 (VDD I1_dd15_b0 I1_dd15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I32_MP2 (I1_B_0_b3_2 I1_B_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I32_MP2_1 (VDD I1_B_0_b2_0 I1_B_0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I31_MP2 (I1_B_0_b3_1 I1_B_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I31_MP2_1 (VDD I1_B_0_b2_0 I1_B_0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I340_MP2 (I1_dd17_b2_0 I1_dd17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I340_MP2_1 (VDD I1_dd17_b1_0 I1_dd17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I30_MP2 (I1_B_0_b3_0 I1_B_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I30_MP2_1 (VDD I1_B_0_b2_0 I1_B_0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I405_MP2 (I1_dd22_b2_0 I1_dd22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I405_MP2_1 (VDD I1_dd22_b1_0 I1_dd22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I509_MP2 (I1_dd30_b2_0 I1_dd30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I509_MP2_1 (VDD I1_dd30_b1_0 I1_dd30_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I392_MP2 (I1_dd21_b2_0 I1_dd21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I392_MP2_1 (VDD I1_dd21_b1_0 I1_dd21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I353_MP2 (I1_dd18_b2_0 I1_dd18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I353_MP2_1 (VDD I1_dd18_b1_0 I1_dd18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I366_MP2 (I1_dd19_b2_0 I1_dd19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I366_MP2_1 (VDD I1_dd19_b1_0 I1_dd19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I567_MP2 (I1_qu31_b1_0 I1_qu31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I567_MP2_1 (VDD I1_qu31_b0 I1_qu31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1494_MP2 (I1_qu11_b3_4 I1_qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1494_MP2_1 (VDD I1_qu11_b2_1 I1_qu11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1493_MP2 (I1_qu11_b3_3 I1_qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1493_MP2_1 (VDD I1_qu11_b2_1 I1_qu11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I410_MP2 (I1_dd22_b3_3 I1_dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I410_MP2_1 (VDD I1_dd22_b2_1 I1_dd22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I497_MP2 (I1_dd29_b2_1 I1_dd29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I497_MP2_1 (VDD I1_dd29_b1_0 I1_dd29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I397_MP2 (I1_dd21_b3_3 I1_dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I397_MP2_1 (VDD I1_dd21_b2_1 I1_dd21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I267_MP2 (I1_dd11_b3_3 I1_dd11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I267_MP2_1 (VDD I1_dd11_b2_1 I1_dd11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I302_MP2 (I1_dd14_b2_1 I1_dd14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I302_MP2_1 (VDD I1_dd14_b1_0 I1_dd14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I215_MP2 (I1_dd7_b3_3 I1_dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I215_MP2_1 (VDD I1_dd7_b2_1 I1_dd7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I137_MP2 (I1_dd1_b3_3 I1_dd1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I137_MP2_1 (VDD I1_dd1_b2_1 I1_dd1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I237_MP2 (I1_dd9_b2_1 I1_dd9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I237_MP2_1 (VDD I1_dd9_b1_0 I1_dd9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I224_MP2 (I1_dd8_b2_1 I1_dd8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I224_MP2_1 (VDD I1_dd8_b1_0 I1_dd8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I367_MP2 (I1_dd19_b2_1 I1_dd19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I367_MP2_1 (VDD I1_dd19_b1_0 I1_dd19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I276_MP2 (I1_dd12_b2_1 I1_dd12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I276_MP2_1 (VDD I1_dd12_b1_0 I1_dd12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I393_MP2 (I1_dd21_b2_1 I1_dd21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I393_MP2_1 (VDD I1_dd21_b1_0 I1_dd21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I185_MP2 (I1_dd5_b2_1 I1_dd5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I185_MP2_1 (VDD I1_dd5_b1_0 I1_dd5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I133_MP2 (I1_dd1_b2_1 I1_dd1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I133_MP2_1 (VDD I1_dd1_b1_0 I1_dd1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I236_MP2 (I1_dd9_b2_0 I1_dd9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I236_MP2_1 (VDD I1_dd9_b1_0 I1_dd9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I223_MP2 (I1_dd8_b2_0 I1_dd8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I223_MP2_1 (VDD I1_dd8_b1_0 I1_dd8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I274_MP2 (I1_dd12_b1_0 I1_dd12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I274_MP2_1 (VDD I1_dd12_b0 I1_dd12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I275_MP2 (I1_dd12_b2_0 I1_dd12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I275_MP2_1 (VDD I1_dd12_b1_0 I1_dd12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I184_MP2 (I1_dd5_b2_0 I1_dd5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I184_MP2_1 (VDD I1_dd5_b1_0 I1_dd5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I197_MP2 (I1_dd6_b2_0 I1_dd6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I197_MP2_1 (VDD I1_dd6_b1_0 I1_dd6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I210_MP2 (I1_dd7_b2_0 I1_dd7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I210_MP2_1 (VDD I1_dd7_b1_0 I1_dd7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I171_MP2 (I1_dd4_b2_0 I1_dd4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I171_MP2_1 (VDD I1_dd4_b1_0 I1_dd4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I158_MP2 (I1_dd3_b2_0 I1_dd3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I158_MP2_1 (VDD I1_dd3_b1_0 I1_dd3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I287_MP2 (I1_dd13_b1_0 I1_dd13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I287_MP2_1 (VDD I1_dd13_b0 I1_dd13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I301_MP2 (I1_dd14_b2_0 I1_dd14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I301_MP2_1 (VDD I1_dd14_b1_0 I1_dd14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I145_MP2 (I1_dd2_b2_0 I1_dd2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I145_MP2_1 (VDD I1_dd2_b1_0 I1_dd2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I28_MP2 (I1_B_0_b2_0 I1_B_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I28_MP2_1 (VDD I1_B_0_b1_0 I1_B_0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2075_MP2 (I1_sq_b3_3 I1_sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2075_MP2_1 (VDD I1_sq_b2_1 I1_sq_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I378_MP2 (I1_dd20_b1_0 I1_dd20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I378_MP2_1 (VDD I1_dd20_b0 I1_dd20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I391_MP2 (I1_dd21_b1_0 I1_dd21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I391_MP2_1 (VDD I1_dd21_b0 I1_dd21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I365_MP2 (I1_dd19_b1_0 I1_dd19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I365_MP2_1 (VDD I1_dd19_b0 I1_dd19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I495_MP2 (I1_dd29_b1_0 I1_dd29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I495_MP2_1 (VDD I1_dd29_b0 I1_dd29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2076_MP2 (I1_sq_b3_4 I1_sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2076_MP2_1 (VDD I1_sq_b2_1 I1_sq_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2077_MP2 (I1_sq_b3_5 I1_sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2077_MP2_1 (VDD I1_sq_b2_1 I1_sq_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I514_MP2 (I1_dd30_b3_3 I1_dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I514_MP2_1 (VDD I1_dd30_b2_1 I1_dd30_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I501_MP2 (I1_dd29_b3_3 I1_dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I501_MP2_1 (VDD I1_dd29_b2_1 I1_dd29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1495_MP2 (I1_qu11_b3_5 I1_qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1495_MP2_1 (VDD I1_qu11_b2_1 I1_qu11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I423_MP2 (I1_dd23_b3_3 I1_dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I423_MP2_1 (VDD I1_dd23_b2_1 I1_dd23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I462_MP2 (I1_dd26_b3_3 I1_dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I462_MP2_1 (VDD I1_dd26_b2_1 I1_dd26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I419_MP2 (I1_dd23_b2_1 I1_dd23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I419_MP2_1 (VDD I1_dd23_b1_0 I1_dd23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I406_MP2 (I1_dd22_b2_1 I1_dd22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I406_MP2_1 (VDD I1_dd22_b1_0 I1_dd22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I484_MP2 (I1_dd28_b2_1 I1_dd28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I484_MP2_1 (VDD I1_dd28_b1_0 I1_dd28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I510_MP2 (I1_dd30_b2_1 I1_dd30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I510_MP2_1 (VDD I1_dd30_b1_0 I1_dd30_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I250_MP2 (I1_dd10_b2_1 I1_dd10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I250_MP2_1 (VDD I1_dd10_b1_0 I1_dd10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I263_MP2 (I1_dd11_b2_1 I1_dd11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I263_MP2_1 (VDD I1_dd11_b1_0 I1_dd11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I198_MP2 (I1_dd6_b2_1 I1_dd6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I198_MP2_1 (VDD I1_dd6_b1_0 I1_dd6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I172_MP2 (I1_dd4_b2_1 I1_dd4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I172_MP2_1 (VDD I1_dd4_b1_0 I1_dd4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I146_MP2 (I1_dd2_b2_1 I1_dd2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I146_MP2_1 (VDD I1_dd2_b1_0 I1_dd2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I249_MP2 (I1_dd10_b2_0 I1_dd10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I249_MP2_1 (VDD I1_dd10_b1_0 I1_dd10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I235_MP2 (I1_dd9_b1_0 I1_dd9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I235_MP2_1 (VDD I1_dd9_b0 I1_dd9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I262_MP2 (I1_dd11_b2_0 I1_dd11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I262_MP2_1 (VDD I1_dd11_b1_0 I1_dd11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I209_MP2 (I1_dd7_b1_0 I1_dd7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I209_MP2_1 (VDD I1_dd7_b0 I1_dd7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I183_MP2 (I1_dd5_b1_0 I1_dd5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I183_MP2_1 (VDD I1_dd5_b0 I1_dd5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I157_MP2 (I1_dd3_b1_0 I1_dd3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I157_MP2_1 (VDD I1_dd3_b0 I1_dd3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I300_MP2 (I1_dd14_b1_0 I1_dd14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I300_MP2_1 (VDD I1_dd14_b0 I1_dd14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I144_MP2 (I1_dd2_b1_0 I1_dd2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I144_MP2_1 (VDD I1_dd2_b0 I1_dd2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I131_MP2 (I1_dd1_b1_0 I1_dd1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I131_MP2_1 (VDD I1_dd1_b0 I1_dd1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I326_MP2 (I1_dd16_b1_0 I1_dd16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I326_MP2_1 (VDD I1_dd16_b0 I1_dd16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I404_MP2 (I1_dd22_b1_0 I1_dd22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I404_MP2_1 (VDD I1_dd22_b0 I1_dd22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I339_MP2 (I1_dd17_b1_0 I1_dd17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I339_MP2_1 (VDD I1_dd17_b0 I1_dd17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I508_MP2 (I1_dd30_b1_0 I1_dd30_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I508_MP2_1 (VDD I1_dd30_b0 I1_dd30_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I417_MP2 (I1_dd23_b1_0 I1_dd23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I417_MP2_1 (VDD I1_dd23_b0 I1_dd23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I521_MP2 (I1_dd31_b1_0 I1_dd31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I521_MP2_1 (VDD I1_dd31_b0 I1_dd31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2071_MP2 (I1_sq_b2_1 I1_sq_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2071_MP2_1 (VDD I1_sq_b1_0 I1_sq_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2069_MP2 (I1_sq_b1_0 I1_sq_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2069_MP2_1 (VDD I1_sq_b0 I1_sq_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I482_MP2 (I1_dd28_b1_0 I1_dd28_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I482_MP2_1 (VDD I1_dd28_b0 I1_dd28_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I469_MP2 (I1_dd27_b1_0 I1_dd27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I469_MP2_1 (VDD I1_dd27_b0 I1_dd27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I527_MP2 (I1_dd31_b3_3 I1_dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I527_MP2_1 (VDD I1_dd31_b2_1 I1_dd31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I449_MP2 (I1_dd25_b3_3 I1_dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I449_MP2_1 (VDD I1_dd25_b2_1 I1_dd25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I488_MP2 (I1_dd28_b3_3 I1_dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I488_MP2_1 (VDD I1_dd28_b2_1 I1_dd28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I475_MP2 (I1_dd27_b3_3 I1_dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I475_MP2_1 (VDD I1_dd27_b2_1 I1_dd27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I436_MP2 (I1_dd24_b3_3 I1_dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I436_MP2_1 (VDD I1_dd24_b2_1 I1_dd24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I471_MP2 (I1_dd27_b2_1 I1_dd27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I471_MP2_1 (VDD I1_dd27_b1_0 I1_dd27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I248_MP2 (I1_dd10_b1_0 I1_dd10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I248_MP2_1 (VDD I1_dd10_b0 I1_dd10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I7_MP2 (I1_A_31_b3_2 I1_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I7_MP2_1 (VDD I1_A_31_b2_0 I1_A_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I352_MP2 (I1_dd18_b1_0 I1_dd18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I352_MP2_1 (VDD I1_dd18_b0 I1_dd18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2070_MP2 (I1_sq_b2_0 I1_sq_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2070_MP2_1 (VDD I1_sq_b1_0 I1_sq_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I430_MP2 (I1_dd24_b1_0 I1_dd24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I430_MP2_1 (VDD I1_dd24_b0 I1_dd24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I443_MP2 (I1_dd25_b1_0 I1_dd25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I443_MP2_1 (VDD I1_dd25_b0 I1_dd25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I456_MP2 (I1_dd26_b1_0 I1_dd26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I456_MP2_1 (VDD I1_dd26_b0 I1_dd26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I8_MP2 (I1_A_31_b3_3 I1_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I8_MP2_1 (VDD I1_A_31_b2_0 I1_A_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I23_MP2 (I1_B_31_b3_3 I1_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I23_MP2_1 (VDD I1_B_31_b2_1 I1_B_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I25_MP2 (I1_B_31_b3_5 I1_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I25_MP2_1 (VDD I1_B_31_b2_1 I1_B_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2074_MP2 (I1_sq_b3_2 I1_sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2074_MP2_1 (VDD I1_sq_b2_0 I1_sq_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I21_MP2 (I1_B_31_b3_1 I1_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I21_MP2_1 (VDD I1_B_31_b2_0 I1_B_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I20_MP2 (I1_B_31_b3_0 I1_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I20_MP2_1 (VDD I1_B_31_b2_0 I1_B_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I22_MP2 (I1_B_31_b3_2 I1_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I22_MP2_1 (VDD I1_B_31_b2_0 I1_B_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I18_MP2 (I1_B_31_b2_0 I1_B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I18_MP2_1 (VDD I1_B_31_b1_0 I1_B_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I19_MP2 (I1_B_31_b2_1 I1_B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I19_MP2_1 (VDD I1_B_31_b1_0 I1_B_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I24_MP2 (I1_B_31_b3_4 I1_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I24_MP2_1 (VDD I1_B_31_b2_1 I1_B_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I64_MP2 (I2_I3_SEL_DIV_b3_3 I2_I3_SEL_DIV_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I64_MP2_1 (VDD I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I8_MP2 (I2_I1_SUB_b3_4 I2_I1_SUB_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I8_MP2_1 (VDD I2_I1_SUB_b2_1 I2_I1_SUB_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I7_MP2 (I2_I1_SUB_b3_3 I2_I1_SUB_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I7_MP2_1 (VDD I2_I1_SUB_b2_1 I2_I1_SUB_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I17_MP2 (I1_B_31_b1_0 I1_B_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I17_MP2_1 (VDD I1_B_31_b0 I1_B_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I63_MP2 (I2_I3_SEL_DIV_b3_2 I2_I3_SEL_DIV_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I63_MP2_1 (VDD I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I79_MP2 (I2_I3_SEL_AS_b3_3 I2_I3_SEL_AS_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I79_MP2_1 (VDD I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I80_MP2 (I2_I3_SEL_AS_b3_4 I2_I3_SEL_AS_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I80_MP2_1 (VDD I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I9_MP2 (I1_A_31_b3_4 I1_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I9_MP2_1 (VDD I1_A_31_b2_1 I1_A_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I17_MP2 (I2_I3_SEL_OR_b3_3 I2_I3_SEL_OR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I17_MP2_1 (VDD I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I7_MP2 (I2_I3_SEL_AND_b3_3 I2_I3_SEL_AND_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I7_MP2_1 (VDD I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I18_MP2 (I2_I3_SEL_OR_b3_4 I2_I3_SEL_OR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I18_MP2_1 (VDD I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I38_MP2 (I2_I3_SEL_NOT_b3_4 I2_I3_SEL_NOT_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I38_MP2_1 (VDD I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I19_MP2 (I2_I3_SEL_OR_b3_5 I2_I3_SEL_OR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I19_MP2_1 (VDD I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I29_MP2 (I2_I3_SEL_XOR_b3_5 I2_I3_SEL_XOR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I29_MP2_1 (VDD I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I28_MP2 (I2_I3_SEL_XOR_b3_4 I2_I3_SEL_XOR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I28_MP2_1 (VDD I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I9_MP2 (I2_I3_SEL_AND_b3_5 I2_I3_SEL_AND_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I9_MP2_1 (VDD I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1531_MP2 (I1_qu10 I1_p21_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1531_MP2_1 (VDD I1_p21_32 I1_qu10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I6_MP2 (I2_I1_SUB_b3_2 I2_I1_SUB_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I6_MP2_1 (VDD I2_I1_SUB_b2_0 I2_I1_SUB_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I75_MP2 (I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I75_MP2_1 (VDD I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I81_MP2 (I2_I3_SEL_AS_b3_5 I2_I3_SEL_AS_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I81_MP2_1 (VDD I2_I3_SEL_AS_b2_1 I2_I3_SEL_AS_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I13_MP2 (I2_I3_SEL_OR_b2_1 I2_I3_SEL_OR_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I13_MP2_1 (VDD I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I33_MP2 (I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I33_MP2_1 (VDD I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I23_MP2 (I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I23_MP2_1 (VDD I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I3_MP2 (I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I3_MP2_1 (VDD I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I8_MP2 (I2_I3_SEL_AND_b3_4 I2_I3_SEL_AND_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I8_MP2_1 (VDD I2_I3_SEL_AND_b2_1 I2_I3_SEL_AND_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I39_MP2 (I2_I3_SEL_NOT_b3_5 I2_I3_SEL_NOT_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I39_MP2_1 (VDD I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I565_MP2 (I1_qu31 I1_p0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I565_MP2_1 (VDD I1_p0_32 I1_qu31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1533_MP2 (I1_qu10_b1_0 I1_qu10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1533_MP2_1 (VDD I1_qu10_b0 I1_qu10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I22_MP2 (I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I22_MP2_1 (VDD I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I32_MP2 (I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I32_MP2_1 (VDD I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I2_MP2 (I2_I1_SUB_b2_0 I2_I1_SUB_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I2_MP2_1 (VDD I2_I1_SUB_b1_0 I2_I1_SUB_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I9_MP2 (I2_I1_SUB_b3_5 I2_I1_SUB_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I9_MP2_1 (VDD I2_I1_SUB_b2_1 I2_I1_SUB_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I3_MP2 (I2_I1_SUB_b2_1 I2_I1_SUB_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I3_MP2_1 (VDD I2_I1_SUB_b1_0 I2_I1_SUB_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I1_MP2 (I2_I1_SUB_b1_0 I2_I1_SUB_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I1_MP2_1 (VDD I2_I1_SUB_b0 I2_I1_SUB_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I11_MP2 (I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I11_MP2_1 (VDD I2_I3_SEL_OR_b0 I2_I3_SEL_OR_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I31_MP2 (I2_I3_SEL_NOT_b1_0 I2_I3_SEL_NOT_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I31_MP2_1 (VDD I2_I3_SEL_NOT_b0 I2_I3_SEL_NOT_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I21_MP2 (I2_I3_SEL_XOR_b1_0 I2_I3_SEL_XOR_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I21_MP2_1 (VDD I2_I3_SEL_XOR_b0 I2_I3_SEL_XOR_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I1_MP2 (I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I1_MP2_1 (VDD I2_I3_SEL_AND_b0 I2_I3_SEL_AND_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I443_MP2 (I0_B_25_b1_0 I0_B_25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I443_MP2_1 (VDD I0_B_25_b0 I0_B_25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I433_MP2 (I0_B_23_b1_0 I0_B_23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I433_MP2_1 (VDD I0_B_23_b0 I0_B_23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I191_MP2 (I0_A_18_b1_0 I0_A_18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I191_MP2_1 (VDD I0_A_18_b0 I0_A_18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I181_MP2 (I0_A_17_b1_0 I0_A_17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I181_MP2_1 (VDD I0_A_17_b0 I0_A_17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I201_MP2 (I0_A_19_b1_0 I0_A_19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I201_MP2_1 (VDD I0_A_19_b0 I0_A_19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I221_MP2 (I0_A_21_b1_0 I0_A_21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I221_MP2_1 (VDD I0_A_21_b0 I0_A_21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I211_MP2 (I0_A_20_b1_0 I0_A_20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I211_MP2_1 (VDD I0_A_20_b0 I0_A_20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I231_MP2 (I0_A_22_b1_0 I0_A_22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I231_MP2_1 (VDD I0_A_22_b0 I0_A_22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I261_MP2 (I0_A_25_b1_0 I0_A_25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I261_MP2_1 (VDD I0_A_25_b0 I0_A_25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I241_MP2 (I0_A_23_b1_0 I0_A_23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I241_MP2_1 (VDD I0_A_23_b0 I0_A_23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I281_MP2 (I0_A_27_b1_0 I0_A_27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I281_MP2_1 (VDD I0_A_27_b0 I0_A_27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I251_MP2 (I0_A_24_b1_0 I0_A_24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I251_MP2_1 (VDD I0_A_24_b0 I0_A_24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I423_MP2 (I0_B_21_b1_0 I0_B_21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I423_MP2_1 (VDD I0_B_21_b0 I0_B_21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I2_MP2 (I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I2_MP2_1 (VDD I2_I3_SEL_AND_b1_0 I2_I3_SEL_AND_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I12_MP2 (I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I12_MP2_1 (VDD I2_I3_SEL_OR_b1_0 I2_I3_SEL_OR_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I73_MP2 (I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I73_MP2_1 (VDD I2_I3_SEL_AS_b0 I2_I3_SEL_AS_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I501_MP2 (I0_two0_b3_4 I0_two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I501_MP2_1 (VDD I0_two0_b2_1 I0_two0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I453_MP2 (I0_B_27_b1_0 I0_B_27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I453_MP2_1 (VDD I0_B_27_b0 I0_B_27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I463_MP2 (I0_B_29_b1_0 I0_B_29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I463_MP2_1 (VDD I0_B_29_b0 I0_B_29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I314_MP2 (I0_A_30_b3_0 I0_A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I314_MP2_1 (VDD I0_A_30_b2_0 I0_A_30_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I291_MP2 (I0_A_28_b1_0 I0_A_28_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I291_MP2_1 (VDD I0_A_28_b0 I0_A_28_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I311_MP2 (I0_A_30_b1_0 I0_A_30_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I311_MP2_1 (VDD I0_A_30_b0 I0_A_30_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I312_MP2 (I0_A_30_b2_0 I0_A_30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I312_MP2_1 (VDD I0_A_30_b1_0 I0_A_30_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I301_MP2 (I0_A_29_b1_0 I0_A_29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I301_MP2_1 (VDD I0_A_29_b0 I0_A_29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I78_MP2 (I2_I3_SEL_AS_b3_2 I2_I3_SEL_AS_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I78_MP2_1 (VDD I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I151_MP2 (I0_A_14_b1_0 I0_A_14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I151_MP2_1 (VDD I0_A_14_b0 I0_A_14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I9_MP2 (I0_B_1_b3_5 I0_B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I9_MP2_1 (VDD I0_B_1_b2_1 I0_B_1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I161_MP2 (I0_A_15_b1_0 I0_A_15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I161_MP2_1 (VDD I0_A_15_b0 I0_A_15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I74_MP2 (I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I74_MP2_1 (VDD I2_I3_SEL_AS_b1_0 I2_I3_SEL_AS_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I383_MP2 (I0_B_13_b1_0 I0_B_13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I383_MP2_1 (VDD I0_B_13_b0 I0_B_13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I500_MP2 (I0_two0_b3_3 I0_two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I500_MP2_1 (VDD I0_two0_b2_1 I0_two0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I490_MP2 (I0_one0_b3_3 I0_one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I490_MP2_1 (VDD I0_one0_b2_1 I0_one0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I7_MP2 (I0_B_1_b3_3 I0_B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I7_MP2_1 (VDD I0_B_1_b2_1 I0_B_1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I545_MP2 (I0_one1_b3_3 I0_one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I545_MP2_1 (VDD I0_one1_b2_1 I0_one1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I555_MP2 (I0_two1_b3_3 I0_two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I555_MP2_1 (VDD I0_two1_b2_1 I0_two1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I8_MP2 (I0_B_1_b3_4 I0_B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I8_MP2_1 (VDD I0_B_1_b2_1 I0_B_1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I491_MP2 (I0_one0_b3_4 I0_one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I491_MP2_1 (VDD I0_one0_b2_1 I0_one0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I546_MP2 (I0_one1_b3_4 I0_one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I546_MP2_1 (VDD I0_one1_b2_1 I0_one1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I557_MP2 (I0_two1_b3_5 I0_two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I557_MP2_1 (VDD I0_two1_b2_1 I0_two1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I492_MP2 (I0_one0_b3_5 I0_one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I492_MP2_1 (VDD I0_one0_b2_1 I0_one0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I502_MP2 (I0_two0_b3_5 I0_two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I502_MP2_1 (VDD I0_two0_b2_1 I0_two0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I547_MP2 (I0_one1_b3_5 I0_one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I547_MP2_1 (VDD I0_one1_b2_1 I0_one1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I601_MP2 (I0_one2_b3_4 I0_one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I601_MP2_1 (VDD I0_one2_b2_1 I0_one2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I612_MP2 (I0_two2_b3_5 I0_two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I612_MP2_1 (VDD I0_two2_b2_1 I0_two2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I602_MP2 (I0_one2_b3_5 I0_one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I602_MP2_1 (VDD I0_one2_b2_1 I0_one2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I171_MP2 (I0_A_16_b1_0 I0_A_16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I171_MP2_1 (VDD I0_A_16_b0 I0_A_16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I284_MP2 (I0_A_27_b3_0 I0_A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I284_MP2_1 (VDD I0_A_27_b2_0 I0_A_27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I294_MP2 (I0_A_28_b3_0 I0_A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I294_MP2_1 (VDD I0_A_28_b2_0 I0_A_28_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I292_MP2 (I0_A_28_b2_0 I0_A_28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I292_MP2_1 (VDD I0_A_28_b1_0 I0_A_28_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I324_MP2 (I0_A_31_b3_0 I0_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I324_MP2_1 (VDD I0_A_31_b2_0 I0_A_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I325_MP2 (I0_A_31_b3_1 I0_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I325_MP2_1 (VDD I0_A_31_b2_0 I0_A_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I304_MP2 (I0_A_29_b3_0 I0_A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I304_MP2_1 (VDD I0_A_29_b2_0 I0_A_29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I302_MP2 (I0_A_29_b2_0 I0_A_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I302_MP2_1 (VDD I0_A_29_b1_0 I0_A_29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I403_MP2 (I0_B_17_b1_0 I0_B_17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I403_MP2_1 (VDD I0_B_17_b0 I0_B_17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I413_MP2 (I0_B_19_b1_0 I0_B_19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I413_MP2_1 (VDD I0_B_19_b0 I0_B_19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1674_MP2 (I1_qu7_b3_0 I1_qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1674_MP2_1 (VDD I1_qu7_b2_0 I1_qu7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1540_MP2 (I1_qu10_b3_4 I1_qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1540_MP2_1 (VDD I1_qu10_b2_1 I1_qu10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1541_MP2 (I1_qu10_b3_5 I1_qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1541_MP2_1 (VDD I1_qu10_b2_1 I1_qu10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1535_MP2 (I1_qu10_b2_1 I1_qu10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1535_MP2_1 (VDD I1_qu10_b1_0 I1_qu10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1539_MP2 (I1_qu10_b3_3 I1_qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1539_MP2_1 (VDD I1_qu10_b2_1 I1_qu10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1534_MP2 (I1_qu10_b2_0 I1_qu10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1534_MP2_1 (VDD I1_qu10_b1_0 I1_qu10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1536_MP2 (I1_qu10_b3_0 I1_qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1536_MP2_1 (VDD I1_qu10_b2_0 I1_qu10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I151_MP2 (I1_dd2_b3_4 I1_dd2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I151_MP2_1 (VDD I1_dd2_b2_1 I1_dd2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I34_MP2 (I1_B_0_b3_4 I1_B_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I34_MP2_1 (VDD I1_B_0_b2_1 I1_B_0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I33_MP2 (I1_B_0_b3_3 I1_B_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I33_MP2_1 (VDD I1_B_0_b2_1 I1_B_0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I35_MP2 (I1_B_0_b3_5 I1_B_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I35_MP2_1 (VDD I1_B_0_b2_1 I1_B_0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I6_MP2 (I1_A_31_b3_1 I1_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I6_MP2_1 (VDD I1_A_31_b2_0 I1_A_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I29_MP2 (I1_B_0_b2_1 I1_B_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I29_MP2_1 (VDD I1_B_0_b1_0 I1_B_0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I5_MP2 (I2_I1_SUB_b3_1 I2_I1_SUB_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I5_MP2_1 (VDD I2_I1_SUB_b2_0 I2_I1_SUB_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I58_MP2 (I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I58_MP2_1 (VDD I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I3_MP2 (I0_B_1_b2_1 I0_B_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I3_MP2_1 (VDD I0_B_1_b1_0 I0_B_1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I335_MP2 (I0_B_3_b2_1 I0_B_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I335_MP2_1 (VDD I0_B_3_b1_0 I0_B_3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I57_MP2 (I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I57_MP2_1 (VDD I2_I3_SEL_DIV_b0 I2_I3_SEL_DIV_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I541_MP2 (I0_one1_b2_1 I0_one1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I541_MP2_1 (VDD I0_one1_b1_0 I0_one1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I373_MP2 (I0_B_11_b1_0 I0_B_11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I373_MP2_1 (VDD I0_B_11_b0 I0_B_11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I551_MP2 (I0_two1_b2_1 I0_two1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I551_MP2_1 (VDD I0_two1_b1_0 I0_two1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I141_MP2 (I0_A_13_b1_0 I0_A_13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I141_MP2_1 (VDD I0_A_13_b0 I0_A_13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I131_MP2 (I0_A_12_b1_0 I0_A_12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I131_MP2_1 (VDD I0_A_12_b0 I0_A_12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I596_MP2 (I0_one2_b2_1 I0_one2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I596_MP2_1 (VDD I0_one2_b1_0 I0_one2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I606_MP2 (I0_two2_b2_1 I0_two2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I606_MP2_1 (VDD I0_two2_b1_0 I0_two2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I341_MP2 (I0_B_3_b3_5 I0_B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I341_MP2_1 (VDD I0_B_3_b2_1 I0_B_3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I351_MP2 (I0_B_5_b3_5 I0_B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I351_MP2_1 (VDD I0_B_5_b2_1 I0_B_5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I393_MP2 (I0_B_15_b1_0 I0_B_15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I393_MP2_1 (VDD I0_B_15_b0 I0_B_15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I340_MP2 (I0_B_3_b3_4 I0_B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I340_MP2_1 (VDD I0_B_3_b2_1 I0_B_3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I339_MP2 (I0_B_3_b3_3 I0_B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I339_MP2_1 (VDD I0_B_3_b2_1 I0_B_3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I600_MP2 (I0_one2_b3_3 I0_one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I600_MP2_1 (VDD I0_one2_b2_1 I0_one2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I610_MP2 (I0_two2_b3_3 I0_two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I610_MP2_1 (VDD I0_two2_b2_1 I0_two2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I349_MP2 (I0_B_5_b3_3 I0_B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I349_MP2_1 (VDD I0_B_5_b2_1 I0_B_5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I350_MP2 (I0_B_5_b3_4 I0_B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I350_MP2_1 (VDD I0_B_5_b2_1 I0_B_5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I556_MP2 (I0_two1_b3_4 I0_two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I556_MP2_1 (VDD I0_two1_b2_1 I0_two1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I611_MP2 (I0_two2_b3_4 I0_two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I611_MP2_1 (VDD I0_two2_b2_1 I0_two2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I274_MP2 (I0_A_26_b3_0 I0_A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I274_MP2_1 (VDD I0_A_26_b2_0 I0_A_26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I264_MP2 (I0_A_25_b3_0 I0_A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I264_MP2_1 (VDD I0_A_25_b2_0 I0_A_25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I271_MP2 (I0_A_26_b1_0 I0_A_26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I271_MP2_1 (VDD I0_A_26_b0 I0_A_26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I262_MP2 (I0_A_25_b2_0 I0_A_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I262_MP2_1 (VDD I0_A_25_b1_0 I0_A_25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I667_MP2 (I0_two3_b3_5 I0_two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I667_MP2_1 (VDD I0_two3_b2_1 I0_two3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I282_MP2 (I0_A_27_b2_0 I0_A_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I282_MP2_1 (VDD I0_A_27_b1_0 I0_A_27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I305_MP2 (I0_A_29_b3_1 I0_A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I305_MP2_1 (VDD I0_A_29_b2_0 I0_A_29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I306_MP2 (I0_A_29_b3_2 I0_A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I306_MP2_1 (VDD I0_A_29_b2_0 I0_A_29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I315_MP2 (I0_A_30_b3_1 I0_A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I315_MP2_1 (VDD I0_A_30_b2_0 I0_A_30_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I316_MP2 (I0_A_30_b3_2 I0_A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I316_MP2_1 (VDD I0_A_30_b2_0 I0_A_30_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I321_MP2 (I0_A_31_b1_0 I0_A_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I321_MP2_1 (VDD I0_A_31_b0 I0_A_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I322_MP2 (I0_A_31_b2_0 I0_A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I322_MP2_1 (VDD I0_A_31_b1_0 I0_A_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1577_MP2 (I1_qu9 I1_p22_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1577_MP2_1 (VDD I1_p22_32 I1_qu9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1537_MP2 (I1_qu10_b3_1 I1_qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1537_MP2_1 (VDD I1_qu10_b2_0 I1_qu10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I177_MP2 (I1_dd4_b3_4 I1_dd4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I177_MP2_1 (VDD I1_dd4_b2_1 I1_dd4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I190_MP2 (I1_dd5_b3_4 I1_dd5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I190_MP2_1 (VDD I1_dd5_b2_1 I1_dd5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I164_MP2 (I1_dd3_b3_4 I1_dd3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I164_MP2_1 (VDD I1_dd3_b2_1 I1_dd3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I138_MP2 (I1_dd1_b3_4 I1_dd1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I138_MP2_1 (VDD I1_dd1_b2_1 I1_dd1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I5_MP2 (I1_A_31_b3_0 I1_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I5_MP2_1 (VDD I1_A_31_b2_0 I1_A_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I121_MP2 (I0_A_11_b1_0 I0_A_11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I121_MP2_1 (VDD I0_A_11_b0 I0_A_11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I353_MP2 (I0_B_7_b1_0 I0_B_7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I353_MP2_1 (VDD I0_B_7_b0 I0_B_7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2_MP2 (I1_A_31_b2_0 I1_A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2_MP2_1 (VDD I1_A_31_b1_0 I1_A_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I594_MP2 (I0_one2_b1_0 I0_one2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I594_MP2_1 (VDD I0_one2_b0 I0_one2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I604_MP2 (I0_two2_b1_0 I0_two2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I604_MP2_1 (VDD I0_two2_b0 I0_two2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1_MP2 (I1_A_31_b1_0 I1_A_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1_MP2_1 (VDD I1_A_31_b0 I1_A_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I486_MP2 (I0_one0_b2_1 I0_one0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I486_MP2_1 (VDD I0_one0_b1_0 I0_one0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I605_MP2 (I0_two2_b2_0 I0_two2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I605_MP2_1 (VDD I0_two2_b1_0 I0_two2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I496_MP2 (I0_two0_b2_1 I0_two0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I496_MP2_1 (VDD I0_two0_b1_0 I0_two0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I345_MP2 (I0_B_5_b2_1 I0_B_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I345_MP2_1 (VDD I0_B_5_b1_0 I0_B_5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I356_MP2 (I0_B_7_b3_0 I0_B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I356_MP2_1 (VDD I0_B_7_b2_0 I0_B_7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I659_MP2 (I0_two3_b1_0 I0_two3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I659_MP2_1 (VDD I0_two3_b0 I0_two3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I354_MP2 (I0_B_7_b2_0 I0_B_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I354_MP2_1 (VDD I0_B_7_b1_0 I0_B_7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I355_MP2 (I0_B_7_b2_1 I0_B_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I355_MP2_1 (VDD I0_B_7_b1_0 I0_B_7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I649_MP2 (I0_one3_b1_0 I0_one3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I649_MP2_1 (VDD I0_one3_b0 I0_one3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I661_MP2 (I0_two3_b2_1 I0_two3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I661_MP2_1 (VDD I0_two3_b1_0 I0_two3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I660_MP2 (I0_two3_b2_0 I0_two3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I660_MP2_1 (VDD I0_two3_b1_0 I0_two3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I651_MP2 (I0_one3_b2_1 I0_one3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I651_MP2_1 (VDD I0_one3_b1_0 I0_one3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I824_MP2 (I0_two6_b1_0 I0_two6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I824_MP2_1 (VDD I0_two6_b0 I0_two6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I204_MP2 (I0_A_19_b3_0 I0_A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I204_MP2_1 (VDD I0_A_19_b2_0 I0_A_19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I214_MP2 (I0_A_20_b3_0 I0_A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I214_MP2_1 (VDD I0_A_20_b2_0 I0_A_20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I184_MP2 (I0_A_17_b3_0 I0_A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I184_MP2_1 (VDD I0_A_17_b2_0 I0_A_17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I234_MP2 (I0_A_22_b3_0 I0_A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I234_MP2_1 (VDD I0_A_22_b2_0 I0_A_22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I360_MP2 (I0_B_7_b3_4 I0_B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I360_MP2_1 (VDD I0_B_7_b2_1 I0_B_7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I244_MP2 (I0_A_23_b3_0 I0_A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I244_MP2_1 (VDD I0_A_23_b2_0 I0_A_23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I254_MP2 (I0_A_24_b3_0 I0_A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I254_MP2_1 (VDD I0_A_24_b2_0 I0_A_24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I666_MP2 (I0_two3_b3_4 I0_two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I666_MP2_1 (VDD I0_two3_b2_1 I0_two3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I255_MP2 (I0_A_24_b3_1 I0_A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I255_MP2_1 (VDD I0_A_24_b2_0 I0_A_24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I232_MP2 (I0_A_22_b2_0 I0_A_22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I232_MP2_1 (VDD I0_A_22_b1_0 I0_A_22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I272_MP2 (I0_A_26_b2_0 I0_A_26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I272_MP2_1 (VDD I0_A_26_b1_0 I0_A_26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I275_MP2 (I0_A_26_b3_1 I0_A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I275_MP2_1 (VDD I0_A_26_b2_0 I0_A_26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I285_MP2 (I0_A_27_b3_1 I0_A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I285_MP2_1 (VDD I0_A_27_b2_0 I0_A_27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I657_MP2 (I0_one3_b3_5 I0_one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I657_MP2_1 (VDD I0_one3_b2_1 I0_one3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I242_MP2 (I0_A_23_b2_0 I0_A_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I242_MP2_1 (VDD I0_A_23_b1_0 I0_A_23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I252_MP2 (I0_A_24_b2_0 I0_A_24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I252_MP2_1 (VDD I0_A_24_b1_0 I0_A_24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I256_MP2 (I0_A_24_b3_2 I0_A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I256_MP2_1 (VDD I0_A_24_b2_0 I0_A_24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1678_MP2 (I1_qu7_b3_4 I1_qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1678_MP2_1 (VDD I1_qu7_b2_1 I1_qu7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1677_MP2 (I1_qu7_b3_3 I1_qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1677_MP2_1 (VDD I1_qu7_b2_1 I1_qu7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1679_MP2 (I1_qu7_b3_5 I1_qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1679_MP2_1 (VDD I1_qu7_b2_1 I1_qu7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1673_MP2 (I1_qu7_b2_1 I1_qu7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1673_MP2_1 (VDD I1_qu7_b1_0 I1_qu7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1676_MP2 (I1_qu7_b3_2 I1_qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1676_MP2_1 (VDD I1_qu7_b2_0 I1_qu7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1675_MP2 (I1_qu7_b3_1 I1_qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1675_MP2_1 (VDD I1_qu7_b2_0 I1_qu7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1628_MP2 (I1_qu8_b3_0 I1_qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1628_MP2_1 (VDD I1_qu8_b2_0 I1_qu8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1579_MP2 (I1_qu9_b1_0 I1_qu9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1579_MP2_1 (VDD I1_qu9_b0 I1_qu9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1538_MP2 (I1_qu10_b3_2 I1_qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1538_MP2_1 (VDD I1_qu10_b2_0 I1_qu10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I203_MP2 (I1_dd6_b3_4 I1_dd6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I203_MP2_1 (VDD I1_dd6_b2_1 I1_dd6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I216_MP2 (I1_dd7_b3_4 I1_dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I216_MP2_1 (VDD I1_dd7_b2_1 I1_dd7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1_MP2 (I0_B_1_b1_0 I0_B_1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1_MP2_1 (VDD I0_B_1_b0 I0_B_1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I333_MP2 (I0_B_3_b1_0 I0_B_3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I333_MP2_1 (VDD I0_B_3_b0 I0_B_3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I343_MP2 (I0_B_5_b1_0 I0_B_5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I343_MP2_1 (VDD I0_B_5_b0 I0_B_5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I539_MP2 (I0_one1_b1_0 I0_one1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I539_MP2_1 (VDD I0_one1_b0 I0_one1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I549_MP2 (I0_two1_b1_0 I0_two1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I549_MP2_1 (VDD I0_two1_b0 I0_two1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I544_MP2 (I0_one1_b3_2 I0_one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I544_MP2_1 (VDD I0_one1_b2_0 I0_one1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I550_MP2 (I0_two1_b2_0 I0_two1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I550_MP2_1 (VDD I0_two1_b1_0 I0_two1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I346_MP2 (I0_B_5_b3_0 I0_B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I346_MP2_1 (VDD I0_B_5_b2_0 I0_B_5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I347_MP2 (I0_B_5_b3_1 I0_B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I347_MP2_1 (VDD I0_B_5_b2_0 I0_B_5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I344_MP2 (I0_B_5_b2_0 I0_B_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I344_MP2_1 (VDD I0_B_5_b1_0 I0_B_5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I348_MP2 (I0_B_5_b3_2 I0_B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I348_MP2_1 (VDD I0_B_5_b2_0 I0_B_5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I599_MP2 (I0_one2_b3_2 I0_one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I599_MP2_1 (VDD I0_one2_b2_0 I0_one2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I595_MP2 (I0_one2_b2_0 I0_one2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I595_MP2_1 (VDD I0_one2_b1_0 I0_one2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I609_MP2 (I0_two2_b3_2 I0_two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I609_MP2_1 (VDD I0_two2_b2_0 I0_two2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I769_MP2 (I0_two5_b1_0 I0_two5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I769_MP2_1 (VDD I0_two5_b0 I0_two5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I759_MP2 (I0_one5_b1_0 I0_one5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I759_MP2_1 (VDD I0_one5_b0 I0_one5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I814_MP2 (I0_one6_b1_0 I0_one6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I814_MP2_1 (VDD I0_one6_b0 I0_one6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I174_MP2 (I0_A_16_b3_0 I0_A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I174_MP2_1 (VDD I0_A_16_b2_0 I0_A_16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I365_MP2 (I0_B_9_b2_1 I0_B_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I365_MP2_1 (VDD I0_B_9_b1_0 I0_B_9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I175_MP2 (I0_A_16_b3_1 I0_A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I175_MP2_1 (VDD I0_A_16_b2_0 I0_A_16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I194_MP2 (I0_A_18_b3_0 I0_A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I194_MP2_1 (VDD I0_A_18_b2_0 I0_A_18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I371_MP2 (I0_B_9_b3_5 I0_B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I371_MP2_1 (VDD I0_B_9_b2_1 I0_B_9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I172_MP2 (I0_A_16_b2_0 I0_A_16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I172_MP2_1 (VDD I0_A_16_b1_0 I0_A_16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I215_MP2 (I0_A_20_b3_1 I0_A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I215_MP2_1 (VDD I0_A_20_b2_0 I0_A_20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I361_MP2 (I0_B_7_b3_5 I0_B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I361_MP2_1 (VDD I0_B_7_b2_1 I0_B_7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I182_MP2 (I0_A_17_b2_0 I0_A_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I182_MP2_1 (VDD I0_A_17_b1_0 I0_A_17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I224_MP2 (I0_A_21_b3_0 I0_A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I224_MP2_1 (VDD I0_A_21_b2_0 I0_A_21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I225_MP2 (I0_A_21_b3_1 I0_A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I225_MP2_1 (VDD I0_A_21_b2_0 I0_A_21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I370_MP2 (I0_B_9_b3_4 I0_B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I370_MP2_1 (VDD I0_B_9_b2_1 I0_B_9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I359_MP2 (I0_B_7_b3_3 I0_B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I359_MP2_1 (VDD I0_B_7_b2_1 I0_B_7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I192_MP2 (I0_A_18_b2_0 I0_A_18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I192_MP2_1 (VDD I0_A_18_b1_0 I0_A_18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I216_MP2 (I0_A_20_b3_2 I0_A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I216_MP2_1 (VDD I0_A_20_b2_0 I0_A_20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I235_MP2 (I0_A_22_b3_1 I0_A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I235_MP2_1 (VDD I0_A_22_b2_0 I0_A_22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I226_MP2 (I0_A_21_b3_2 I0_A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I226_MP2_1 (VDD I0_A_21_b2_0 I0_A_21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I656_MP2 (I0_one3_b3_4 I0_one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I656_MP2_1 (VDD I0_one3_b2_1 I0_one3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I245_MP2 (I0_A_23_b3_1 I0_A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I245_MP2_1 (VDD I0_A_23_b2_0 I0_A_23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I212_MP2 (I0_A_20_b2_0 I0_A_20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I212_MP2_1 (VDD I0_A_20_b1_0 I0_A_20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I222_MP2 (I0_A_21_b2_0 I0_A_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I222_MP2_1 (VDD I0_A_21_b1_0 I0_A_21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I722_MP2 (I0_two4_b3_5 I0_two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I722_MP2_1 (VDD I0_two4_b2_1 I0_two4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I266_MP2 (I0_A_25_b3_2 I0_A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I266_MP2_1 (VDD I0_A_25_b2_0 I0_A_25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I276_MP2 (I0_A_26_b3_2 I0_A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I276_MP2_1 (VDD I0_A_26_b2_0 I0_A_26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I246_MP2 (I0_A_23_b3_2 I0_A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I246_MP2_1 (VDD I0_A_23_b2_0 I0_A_23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I712_MP2 (I0_one4_b3_5 I0_one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I712_MP2_1 (VDD I0_one4_b2_1 I0_one4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I286_MP2 (I0_A_27_b3_2 I0_A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I286_MP2_1 (VDD I0_A_27_b2_0 I0_A_27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I295_MP2 (I0_A_28_b3_1 I0_A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I295_MP2_1 (VDD I0_A_28_b2_0 I0_A_28_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I296_MP2 (I0_A_28_b3_2 I0_A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I296_MP2_1 (VDD I0_A_28_b2_0 I0_A_28_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1672_MP2 (I1_qu7_b2_0 I1_qu7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1672_MP2_1 (VDD I1_qu7_b1_0 I1_qu7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1629_MP2 (I1_qu8_b3_1 I1_qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1629_MP2_1 (VDD I1_qu8_b2_0 I1_qu8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1580_MP2 (I1_qu9_b2_0 I1_qu9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1580_MP2_1 (VDD I1_qu9_b1_0 I1_qu9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1584_MP2 (I1_qu9_b3_2 I1_qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1584_MP2_1 (VDD I1_qu9_b2_0 I1_qu9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I268_MP2 (I1_dd11_b3_4 I1_dd11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I268_MP2_1 (VDD I1_dd11_b2_1 I1_dd11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I255_MP2 (I1_dd10_b3_4 I1_dd10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I255_MP2_1 (VDD I1_dd10_b2_1 I1_dd10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1583_MP2 (I1_qu9_b3_1 I1_qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1583_MP2_1 (VDD I1_qu9_b2_0 I1_qu9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1582_MP2 (I1_qu9_b3_0 I1_qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1582_MP2_1 (VDD I1_qu9_b2_0 I1_qu9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I62_MP2 (I2_I3_SEL_DIV_b3_1 I2_I3_SEL_DIV_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I62_MP2_1 (VDD I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I61_MP2 (I2_I3_SEL_DIV_b3_0 I2_I3_SEL_DIV_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I61_MP2_1 (VDD I2_I3_SEL_DIV_b2_0 I2_I3_SEL_DIV_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I484_MP2 (I0_one0_b1_0 I0_one0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I484_MP2_1 (VDD I0_one0_b0 I0_one0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I2_MP2 (I0_B_1_b2_0 I0_B_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I2_MP2_1 (VDD I0_B_1_b1_0 I0_B_1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I6_MP2 (I0_B_1_b3_2 I0_B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I6_MP2_1 (VDD I0_B_1_b2_0 I0_B_1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I336_MP2 (I0_B_3_b3_0 I0_B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I336_MP2_1 (VDD I0_B_3_b2_0 I0_B_3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I334_MP2 (I0_B_3_b2_0 I0_B_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I334_MP2_1 (VDD I0_B_3_b1_0 I0_B_3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I338_MP2 (I0_B_3_b3_2 I0_B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I338_MP2_1 (VDD I0_B_3_b2_0 I0_B_3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I540_MP2 (I0_one1_b2_0 I0_one1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I540_MP2_1 (VDD I0_one1_b1_0 I0_one1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I704_MP2 (I0_one4_b1_0 I0_one4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I704_MP2_1 (VDD I0_one4_b0 I0_one4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I554_MP2 (I0_two1_b3_2 I0_two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I554_MP2_1 (VDD I0_two1_b2_0 I0_two1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I357_MP2 (I0_B_7_b3_1 I0_B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I357_MP2_1 (VDD I0_B_7_b2_0 I0_B_7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I124_MP2 (I0_A_11_b3_0 I0_A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I124_MP2_1 (VDD I0_A_11_b2_0 I0_A_11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I358_MP2 (I0_B_7_b3_2 I0_B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I358_MP2_1 (VDD I0_B_7_b2_0 I0_B_7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I664_MP2 (I0_two3_b3_2 I0_two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I664_MP2_1 (VDD I0_two3_b2_0 I0_two3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I650_MP2 (I0_one3_b2_0 I0_one3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I650_MP2_1 (VDD I0_one3_b1_0 I0_one3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I716_MP2 (I0_two4_b2_1 I0_two4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I716_MP2_1 (VDD I0_two4_b1_0 I0_two4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I710_MP2 (I0_one4_b3_3 I0_one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I710_MP2_1 (VDD I0_one4_b2_1 I0_one4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I720_MP2 (I0_two4_b3_3 I0_two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I720_MP2_1 (VDD I0_two4_b2_1 I0_two4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I185_MP2 (I0_A_17_b3_1 I0_A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I185_MP2_1 (VDD I0_A_17_b2_0 I0_A_17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I195_MP2 (I0_A_18_b3_1 I0_A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I195_MP2_1 (VDD I0_A_18_b2_0 I0_A_18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I176_MP2 (I0_A_16_b3_2 I0_A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I176_MP2_1 (VDD I0_A_16_b2_0 I0_A_16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I761_MP2 (I0_one5_b2_1 I0_one5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I761_MP2_1 (VDD I0_one5_b1_0 I0_one5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I205_MP2 (I0_A_19_b3_1 I0_A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I205_MP2_1 (VDD I0_A_19_b2_0 I0_A_19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I765_MP2 (I0_one5_b3_3 I0_one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I765_MP2_1 (VDD I0_one5_b2_1 I0_one5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I375_MP2 (I0_B_11_b2_1 I0_B_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I375_MP2_1 (VDD I0_B_11_b1_0 I0_B_11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I369_MP2 (I0_B_9_b3_3 I0_B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I369_MP2_1 (VDD I0_B_9_b2_1 I0_B_9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I775_MP2 (I0_two5_b3_3 I0_two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I775_MP2_1 (VDD I0_two5_b2_1 I0_two5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I186_MP2 (I0_A_17_b3_2 I0_A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I186_MP2_1 (VDD I0_A_17_b2_0 I0_A_17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
