    I_MXI0_I1660_I20_MN0 (I0_I1660_gn20 I0_ha263_1 XI0_I1660_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I22_MN1 (XI0_I1660_I22_n1 I0_ha266_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I22_MN0 (I0_I1660_gn22 I0_ha265_1 XI0_I1660_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I23_MN1 (XI0_I1660_I23_n1 I0_ha267_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I23_MN0 (I0_I1660_gn23 I0_ha266_1 XI0_I1660_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I398_MN1 (XI2_I3_I398_n1 MULP_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I398_MN0 (I2_I3_n26_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I398_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I29_MN1 (XI1_I1804_I29_n1 I1_b27_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I29_MN0 (I1_I1804_gn29 I1_p26_28 XI1_I1804_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I124_XP_MN1 (XI1_I1804_I124_XP_n1 I1_I1804_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I124_XP_MN0 (I1_I1804_P28_25n I1_I1804_P28_27 XI1_I1804_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I122_XP_MN1 (XI1_I1804_I122_XP_n1 I1_I1804_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I122_XP_MN0 (I1_I1804_P26_23n I1_I1804_P26_25 XI1_I1804_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I177_XP_MN1 (XI1_I1804_I177_XP_n1 I1_I1804_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I177_XP_MN0 (I1_I1804_P26_11n I1_I1804_P26_19 XI1_I1804_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I171_XP_MN1 (XI1_I1804_I171_XP_n1 I1_I1804_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I171_XP_MN0 (I1_I1804_P20_5n I1_I1804_P20_13 XI1_I1804_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I175_XP_MN1 (XI1_I1804_I175_XP_n1 I1_I1804_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I175_XP_MN0 (I1_I1804_P24_9n I1_I1804_P24_17 XI1_I1804_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I167_XP_MN1 (XI1_I1804_I167_XP_n1 I1_I1804_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I167_XP_MN0 (I1_I1804_P16_1n I1_I1804_P16_9 XI1_I1804_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I104_XP_MN1 (XI1_I1804_I104_XP_n1 I1_I1804_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I104_XP_MN0 (I1_I1804_P8_5n I1_I1804_P8_7 XI1_I1804_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I102_XP_MN1 (XI1_I1804_I102_XP_n1 I1_I1804_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I102_XP_MN0 (I1_I1804_P6_3n I1_I1804_P6_5 XI1_I1804_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I100_XP_MN1 (XI1_I1804_I100_XP_n1 I1_I1804_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I100_XP_MN0 (I1_I1804_P4_1n I1_I1804_P4_3 XI1_I1804_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I2_MN1 (XI1_I1850_I2_n1 I1_b28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I2_MN0 (I1_I1850_gn2 I1_p27_1 XI1_I1850_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I3_MN1 (XI1_I1896_I3_n1 I1_b29_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I3_MN0 (I1_I1896_gn3 I1_p28_2 XI1_I1896_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I2_MN1 (XI1_I1896_I2_n1 I1_b29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I2_MN0 (I1_I1896_gn2 I1_p28_1 XI1_I1896_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I4_MN1 (XI1_I1942_I4_n1 I1_b30_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I4_MN0 (I1_I1942_gn4 I1_p29_3 XI1_I1942_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I3_MN1 (XI1_I1942_I3_n1 I1_b30_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I3_MN0 (I1_I1942_gn3 I1_p29_2 XI1_I1942_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I4_MN1 (XI1_I1988_I4_n1 I1_b31_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I4_MN0 (I1_I1988_gn4 I1_p30_3 XI1_I1988_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I3_MN1 (XI1_I1988_I3_n1 I1_b31_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I3_MN0 (I1_I1988_gn3 I1_p30_2 XI1_I1988_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I2_MN1 (XI1_I1988_I2_n1 I1_b31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I2_MN0 (I1_I1988_gn2 I1_p30_1 XI1_I1988_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2008_MN1 (XI1_I2008_n1 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2008_MN0 (I1_dmn3 I1_dd3_b3_5 XI1_I2008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I1_MN1 (XI1_I1988_I1_n1 I1_b31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I1_MN0 (I1_I1988_gn1 I1_p30_0 XI1_I1988_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2004_MN1 (XI1_I2004_n1 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2004_MN0 (I1_dmn1 I1_dd1_b3_5 XI1_I2004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I0_MN1 (XI1_I1988_I0_n1 I1_b31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I0_MN0 (I1_I1988_gn0 A_0 XI1_I1988_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I0_MN1 (XI1_I2066_I0_n1 I1_dm0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I0_MN0 (I1_I2066_gn0 I1_p31_0 XI1_I2066_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I122_MN1 (XI2_I3_I122_n1 MULP_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I122_MN0 (I2_I3_n3_4 I2_I3_SEL_MUL_b3_0 XI2_I3_I122_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I206_MN1 (XI2_I3_I206_n1 MULP_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I206_MN0 (I2_I3_n10_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I170_MN1 (XI2_I3_I170_n1 MULP_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I170_MN0 (I2_I3_n7_4 I2_I3_SEL_MUL_b3_1 XI2_I3_I170_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I5_MN1 (XI0_I1660_I5_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I5_MN0 (I0_I1660_gn5 I0_fa249_0 XI0_I1660_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I18_MN1 (XI0_I1660_I18_n1 I0_ha262_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I18_MN0 (I0_I1660_gn18 I0_ha261_1 XI0_I1660_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I21_MN1 (XI0_I1660_I21_n1 I0_ha265_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I21_MN0 (I0_I1660_gn21 I0_ha264_1 XI0_I1660_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I374_MN1 (XI2_I3_I374_n1 MULP_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I374_MN0 (I2_I3_n24_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I374_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I386_MN1 (XI2_I3_I386_n1 MULP_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I386_MN0 (I2_I3_n25_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I386_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I24_MN1 (XI0_I1660_I24_n1 I0_ha268_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I24_MN0 (I0_I1660_gn24 I0_ha267_1 XI0_I1660_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I25_MN1 (XI0_I1660_I25_n1 I0_ha269_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I25_MN0 (I0_I1660_gn25 I0_ha268_1 XI0_I1660_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I410_MN1 (XI2_I3_I410_n1 MULP_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I410_MN0 (I2_I3_n27_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I410_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I422_MN1 (XI2_I3_I422_n1 MULP_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I422_MN0 (I2_I3_n28_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I422_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I434_MN1 (XI2_I3_I434_n1 MULP_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I434_MN0 (I2_I3_n29_4 I2_I3_SEL_MUL_b3_4 XI2_I3_I434_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I26_MN1 (XI0_I1660_I26_n1 I0_ha270_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I26_MN0 (I0_I1660_gn26 I0_ha269_1 XI0_I1660_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I27_MN1 (XI0_I1660_I27_n1 I0_ha271_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I27_MN0 (I0_I1660_gn27 I0_ha270_1 XI0_I1660_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I28_MN1 (XI0_I1660_I28_n1 I0_ha272_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I28_MN0 (I0_I1660_gn28 I0_ha271_1 XI0_I1660_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I126_XP_MN1 (XI1_I1804_I126_XP_n1 I1_I1804_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I126_XP_MN0 (I1_I1804_P30_27n I1_I1804_P30_29 XI1_I1804_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I181_XP_MN1 (XI1_I1804_I181_XP_n1 I1_I1804_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I181_XP_MN0 (I1_I1804_P30_15n I1_I1804_P30_23 XI1_I1804_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I179_XP_MN1 (XI1_I1804_I179_XP_n1 I1_I1804_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I179_XP_MN0 (I1_I1804_P28_13n I1_I1804_P28_21 XI1_I1804_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I173_XP_MN1 (XI1_I1804_I173_XP_n1 I1_I1804_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I173_XP_MN0 (I1_I1804_P22_7n I1_I1804_P22_15 XI1_I1804_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I169_XP_MN1 (XI1_I1804_I169_XP_n1 I1_I1804_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I169_XP_MN0 (I1_I1804_P18_3n I1_I1804_P18_11 XI1_I1804_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I4_MN1 (XI1_I1850_I4_n1 I1_b28_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I4_MN0 (I1_I1850_gn4 I1_p27_3 XI1_I1850_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I3_MN1 (XI1_I1850_I3_n1 I1_b28_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I3_MN0 (I1_I1850_gn3 I1_p27_2 XI1_I1850_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I4_MN1 (XI1_I1896_I4_n1 I1_b29_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I4_MN0 (I1_I1896_gn4 I1_p28_3 XI1_I1896_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I5_MN1 (XI1_I1942_I5_n1 I1_b30_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I5_MN0 (I1_I1942_gn5 I1_p29_4 XI1_I1942_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I6_MN1 (XI1_I1942_I6_n1 I1_b30_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I6_MN0 (I1_I1942_gn6 I1_p29_5 XI1_I1942_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I101_XP_MN1 (XI1_I1942_I101_XP_n1 I1_I1942_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I101_XP_MN0 (I1_I1942_P5_2n I1_I1942_P5_4 XI1_I1942_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I102_XP_MN1 (XI1_I1942_I102_XP_n1 I1_I1942_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I102_XP_MN0 (I1_I1942_P6_3n I1_I1942_P6_5 XI1_I1942_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I100_XP_MN1 (XI1_I1942_I100_XP_n1 I1_I1942_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I100_XP_MN0 (I1_I1942_P4_1n I1_I1942_P4_3 XI1_I1942_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I7_MN1 (XI1_I1988_I7_n1 I1_b31_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I7_MN0 (I1_I1988_gn7 I1_p30_6 XI1_I1988_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I5_MN1 (XI1_I1988_I5_n1 I1_b31_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I5_MN0 (I1_I1988_gn5 I1_p30_4 XI1_I1988_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I6_MN1 (XI1_I1988_I6_n1 I1_b31_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I6_MN0 (I1_I1988_gn6 I1_p30_5 XI1_I1988_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2010_MN1 (XI1_I2010_n1 I1_p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2010_MN0 (I1_dmn4 I1_dd4_b3_5 XI1_I2010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I100_XP_MN1 (XI1_I1988_I100_XP_n1 I1_I1988_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I100_XP_MN0 (I1_I1988_P4_1n I1_I1988_P4_3 XI1_I1988_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I2_MN1 (XI1_I2066_I2_n1 I1_dm2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I2_MN0 (I1_I2066_gn2 I1_p31_2 XI1_I2066_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I1_MN1 (XI1_I2066_I1_n1 I1_dm1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I1_MN0 (I1_I2066_gn1 I1_p31_1 XI1_I2066_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I1_MN1 (XI0_I1660_I1_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I1_MN0 (I0_I1660_gn1 I0_pp0_1 XI0_I1660_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I4_MN1 (XI0_I1660_I4_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I4_MN0 (I0_I1660_gn4 I0_fa209_0 XI0_I1660_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I203_XP_MN1 (XI0_I1660_I203_XP_n1 I0_I1660_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I203_XP_MN0 (I0_I1660_P11_8n I0_I1660_P11_10 XI0_I1660_I203_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I205_XP_MN1 (XI0_I1660_I205_XP_n1 I0_I1660_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I205_XP_MN0 (I0_I1660_P13_10n I0_I1660_P13_12 XI0_I1660_I205_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I211_XP_MN1 (XI0_I1660_I211_XP_n1 I0_I1660_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I211_XP_MN0 (I0_I1660_P19_16n I0_I1660_P19_18 XI0_I1660_I211_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I213_XP_MN1 (XI0_I1660_I213_XP_n1 I0_I1660_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I213_XP_MN0 (I0_I1660_P21_18n I0_I1660_P21_20 XI0_I1660_I213_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I215_XP_MN1 (XI0_I1660_I215_XP_n1 I0_I1660_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I215_XP_MN0 (I0_I1660_P23_20n I0_I1660_P23_22 XI0_I1660_I215_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I217_XP_MN1 (XI0_I1660_I217_XP_n1 I0_I1660_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I217_XP_MN0 (I0_I1660_P25_22n I0_I1660_P25_24 XI0_I1660_I217_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I219_XP_MN1 (XI0_I1660_I219_XP_n1 I0_I1660_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I219_XP_MN0 (I0_I1660_P27_24n I0_I1660_P27_26 XI0_I1660_I219_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I103_XP_MN1 (XI1_I1804_I103_XP_n1 I1_I1804_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I103_XP_MN0 (I1_I1804_P7_4n I1_I1804_P7_6 XI1_I1804_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I101_XP_MN1 (XI1_I1804_I101_XP_n1 I1_I1804_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I101_XP_MN0 (I1_I1804_P5_2n I1_I1804_P5_4 XI1_I1804_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I5_MN1 (XI1_I1850_I5_n1 I1_b28_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I5_MN0 (I1_I1850_gn5 I1_p27_4 XI1_I1850_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I5_MN1 (XI1_I1896_I5_n1 I1_b29_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I5_MN0 (I1_I1896_gn5 I1_p28_4 XI1_I1896_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I101_XP_MN1 (XI1_I1896_I101_XP_n1 I1_I1896_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I101_XP_MN0 (I1_I1896_P5_2n I1_I1896_P5_4 XI1_I1896_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I100_XP_MN1 (XI1_I1896_I100_XP_n1 I1_I1896_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I100_XP_MN0 (I1_I1896_P4_1n I1_I1896_P4_3 XI1_I1896_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I7_MN1 (XI1_I1942_I7_n1 I1_b30_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I7_MN0 (I1_I1942_gn7 I1_p29_6 XI1_I1942_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I103_XP_MN1 (XI1_I1942_I103_XP_n1 I1_I1942_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I103_XP_MN0 (I1_I1942_P7_4n I1_I1942_P7_6 XI1_I1942_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I104_XP_MN1 (XI1_I1942_I104_XP_n1 I1_I1942_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I104_XP_MN0 (I1_I1942_P8_5n I1_I1942_P8_7 XI1_I1942_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I167_XP_MN1 (XI1_I1942_I167_XP_n1 I1_I1942_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I167_XP_MN0 (I1_I1942_P16_1n I1_I1942_P16_9 XI1_I1942_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2014_MN1 (XI1_I2014_n1 I1_p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2014_MN0 (I1_dmn6 I1_dd6_b3_5 XI1_I2014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2012_MN1 (XI1_I2012_n1 I1_p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2012_MN0 (I1_dmn5 I1_dd5_b3_5 XI1_I2012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I105_XP_MN1 (XI1_I1988_I105_XP_n1 I1_I1988_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I105_XP_MN0 (I1_I1988_P9_6n I1_I1988_P9_8 XI1_I1988_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I103_XP_MN1 (XI1_I1988_I103_XP_n1 I1_I1988_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I103_XP_MN0 (I1_I1988_P7_4n I1_I1988_P7_6 XI1_I1988_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I101_XP_MN1 (XI1_I1988_I101_XP_n1 I1_I1988_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I101_XP_MN0 (I1_I1988_P5_2n I1_I1988_P5_4 XI1_I1988_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I102_XP_MN1 (XI1_I1988_I102_XP_n1 I1_I1988_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I102_XP_MN0 (I1_I1988_P6_3n I1_I1988_P6_5 XI1_I1988_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I104_XP_MN1 (XI1_I1988_I104_XP_n1 I1_I1988_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I104_XP_MN0 (I1_I1988_P8_5n I1_I1988_P8_7 XI1_I1988_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I4_MN1 (XI1_I2066_I4_n1 I1_dm4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I4_MN0 (I1_I2066_gn4 I1_p31_4 XI1_I2066_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I3_MN1 (XI1_I2066_I3_n1 I1_dm3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I3_MN0 (I1_I2066_gn3 I1_p31_3 XI1_I2066_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I2_MN1 (XI0_I1660_I2_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I2_MN0 (I0_I1660_gn2 I0_fa1_0 XI0_I1660_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I3_MN1 (XI0_I1660_I3_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I3_MN0 (I0_I1660_gn3 I0_fa137_0 XI0_I1660_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I199_XP_MN1 (XI0_I1660_I199_XP_n1 I0_I1660_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I199_XP_MN0 (I0_I1660_P7_4n I0_I1660_P7_6 XI0_I1660_I199_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I197_XP_MN1 (XI0_I1660_I197_XP_n1 I0_I1660_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I197_XP_MN0 (I0_I1660_P5_2n I0_I1660_P5_4 XI0_I1660_I197_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I201_XP_MN1 (XI0_I1660_I201_XP_n1 I0_I1660_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I201_XP_MN0 (I0_I1660_P9_6n I0_I1660_P9_8 XI0_I1660_I201_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I207_XP_MN1 (XI0_I1660_I207_XP_n1 I0_I1660_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I207_XP_MN0 (I0_I1660_P15_12n I0_I1660_P15_14 XI0_I1660_I207_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I209_XP_MN1 (XI0_I1660_I209_XP_n1 I0_I1660_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I209_XP_MN0 (I0_I1660_P17_14n I0_I1660_P17_16 XI0_I1660_I209_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I330_XP_MN1 (XI0_I1660_I330_XP_n1 I0_I1660_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I330_XP_MN0 (I0_I1660_P19_4n I0_I1660_P19_12 XI0_I1660_I330_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I334_XP_MN1 (XI0_I1660_I334_XP_n1 I0_I1660_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I334_XP_MN0 (I0_I1660_P23_8n I0_I1660_P23_16 XI0_I1660_I334_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I446_MN1 (XI2_I3_I446_n1 MULP_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I446_MN0 (I2_I3_n30_4 I2_I3_SEL_MUL_b3_5 XI2_I3_I446_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I221_XP_MN1 (XI0_I1660_I221_XP_n1 I0_I1660_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I221_XP_MN0 (I0_I1660_P29_26n I0_I1660_P29_28 XI0_I1660_I221_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I223_XP_MN1 (XI0_I1660_I223_XP_n1 I0_I1660_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I223_XP_MN0 (I0_I1660_P31_28n I0_I1660_P31_30 XI0_I1660_I223_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I29_MN1 (XI0_I1660_I29_n1 I0_ha273_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I29_MN0 (I0_I1660_gn29 I0_ha272_1 XI0_I1660_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I30_MN1 (XI0_I1660_I30_n1 I0_ha274_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I30_MN0 (I0_I1660_gn30 I0_ha273_1 XI0_I1660_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I127_XP_MN1 (XI1_I1804_I127_XP_n1 I1_I1804_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I127_XP_MN0 (I1_I1804_P31_28n I1_I1804_P31_30 XI1_I1804_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I125_XP_MN1 (XI1_I1804_I125_XP_n1 I1_I1804_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I125_XP_MN0 (I1_I1804_P29_26n I1_I1804_P29_28 XI1_I1804_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I123_XP_MN1 (XI1_I1804_I123_XP_n1 I1_I1804_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I123_XP_MN0 (I1_I1804_P27_24n I1_I1804_P27_26 XI1_I1804_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I121_XP_MN1 (XI1_I1804_I121_XP_n1 I1_I1804_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I121_XP_MN0 (I1_I1804_P25_22n I1_I1804_P25_24 XI1_I1804_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I119_XP_MN1 (XI1_I1804_I119_XP_n1 I1_I1804_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I119_XP_MN0 (I1_I1804_P23_20n I1_I1804_P23_22 XI1_I1804_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I117_XP_MN1 (XI1_I1804_I117_XP_n1 I1_I1804_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I117_XP_MN0 (I1_I1804_P21_18n I1_I1804_P21_20 XI1_I1804_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I176_XP_MN1 (XI1_I1804_I176_XP_n1 I1_I1804_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I176_XP_MN0 (I1_I1804_P25_10n I1_I1804_P25_18 XI1_I1804_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I115_XP_MN1 (XI1_I1804_I115_XP_n1 I1_I1804_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I115_XP_MN0 (I1_I1804_P19_16n I1_I1804_P19_18 XI1_I1804_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I113_XP_MN1 (XI1_I1804_I113_XP_n1 I1_I1804_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I113_XP_MN0 (I1_I1804_P17_14n I1_I1804_P17_16 XI1_I1804_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I111_XP_MN1 (XI1_I1804_I111_XP_n1 I1_I1804_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I111_XP_MN0 (I1_I1804_P15_12n I1_I1804_P15_14 XI1_I1804_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I109_XP_MN1 (XI1_I1804_I109_XP_n1 I1_I1804_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I109_XP_MN0 (I1_I1804_P13_10n I1_I1804_P13_12 XI1_I1804_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I107_XP_MN1 (XI1_I1804_I107_XP_n1 I1_I1804_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I107_XP_MN0 (I1_I1804_P11_8n I1_I1804_P11_10 XI1_I1804_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I168_XP_MN1 (XI1_I1804_I168_XP_n1 I1_I1804_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I168_XP_MN0 (I1_I1804_P17_2n I1_I1804_P17_10 XI1_I1804_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I105_XP_MN1 (XI1_I1804_I105_XP_n1 I1_I1804_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I105_XP_MN0 (I1_I1804_P9_6n I1_I1804_P9_8 XI1_I1804_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I7_MN1 (XI1_I1850_I7_n1 I1_b28_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I7_MN0 (I1_I1850_gn7 I1_p27_6 XI1_I1850_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I6_MN1 (XI1_I1850_I6_n1 I1_b28_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I6_MN0 (I1_I1850_gn6 I1_p27_5 XI1_I1850_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I6_MN1 (XI1_I1896_I6_n1 I1_b29_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I6_MN0 (I1_I1896_gn6 I1_p28_5 XI1_I1896_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I103_XP_MN1 (XI1_I1896_I103_XP_n1 I1_I1896_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I103_XP_MN0 (I1_I1896_P7_4n I1_I1896_P7_6 XI1_I1896_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I102_XP_MN1 (XI1_I1896_I102_XP_n1 I1_I1896_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I102_XP_MN0 (I1_I1896_P6_3n I1_I1896_P6_5 XI1_I1896_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I8_MN1 (XI1_I1942_I8_n1 I1_b30_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I8_MN0 (I1_I1942_gn8 I1_p29_7 XI1_I1942_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I105_XP_MN1 (XI1_I1942_I105_XP_n1 I1_I1942_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I105_XP_MN0 (I1_I1942_P9_6n I1_I1942_P9_8 XI1_I1942_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I106_XP_MN1 (XI1_I1942_I106_XP_n1 I1_I1942_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I106_XP_MN0 (I1_I1942_P10_7n I1_I1942_P10_9 XI1_I1942_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I9_MN1 (XI1_I1988_I9_n1 I1_b31_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I9_MN0 (I1_I1988_gn9 I1_p30_8 XI1_I1988_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I10_MN1 (XI1_I1988_I10_n1 I1_b31_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I10_MN0 (I1_I1988_gn10 I1_p30_9 XI1_I1988_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2018_MN1 (XI1_I2018_n1 I1_p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2018_MN0 (I1_dmn8 I1_dd8_b3_5 XI1_I2018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I168_XP_MN1 (XI1_I1988_I168_XP_n1 I1_I1988_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I168_XP_MN0 (I1_I1988_P17_2n I1_I1988_P17_10 XI1_I1988_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I106_XP_MN1 (XI1_I1988_I106_XP_n1 I1_I1988_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I106_XP_MN0 (I1_I1988_P10_7n I1_I1988_P10_9 XI1_I1988_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I167_XP_MN1 (XI1_I1988_I167_XP_n1 I1_I1988_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I167_XP_MN0 (I1_I1988_P16_1n I1_I1988_P16_9 XI1_I1988_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I7_MN1 (XI1_I2066_I7_n1 I1_dm7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I7_MN0 (I1_I2066_gn7 I1_p31_7 XI1_I2066_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I6_MN1 (XI1_I2066_I6_n1 I1_dm6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I6_MN0 (I1_I2066_gn6 I1_p31_6 XI1_I2066_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I5_MN1 (XI1_I2066_I5_n1 I1_dm5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I5_MN0 (I1_I2066_gn5 I1_p31_5 XI1_I2066_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2170_MN1 (XI1_I2170_n1 DIVR_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2170_MN0 (I1_nrkn1 I1_A_31_b3_5 XI1_I2170_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I202_XP_MN1 (XI0_I1660_I202_XP_n1 I0_I1660_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I202_XP_MN0 (I0_I1660_P10_7n I0_I1660_P10_9 XI0_I1660_I202_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I204_XP_MN1 (XI0_I1660_I204_XP_n1 I0_I1660_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I204_XP_MN0 (I0_I1660_P12_9n I0_I1660_P12_11 XI0_I1660_I204_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I206_XP_MN1 (XI0_I1660_I206_XP_n1 I0_I1660_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I206_XP_MN0 (I0_I1660_P14_11n I0_I1660_P14_13 XI0_I1660_I206_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I208_XP_MN1 (XI0_I1660_I208_XP_n1 I0_I1660_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I208_XP_MN0 (I0_I1660_P16_13n I0_I1660_P16_15 XI0_I1660_I208_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I210_XP_MN1 (XI0_I1660_I210_XP_n1 I0_I1660_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I210_XP_MN0 (I0_I1660_P18_15n I0_I1660_P18_17 XI0_I1660_I210_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I328_XP_MN1 (XI0_I1660_I328_XP_n1 I0_I1660_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I328_XP_MN0 (I0_I1660_P17_2n I0_I1660_P17_10 XI0_I1660_I328_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I212_XP_MN1 (XI0_I1660_I212_XP_n1 I0_I1660_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I212_XP_MN0 (I0_I1660_P20_17n I0_I1660_P20_19 XI0_I1660_I212_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I214_XP_MN1 (XI0_I1660_I214_XP_n1 I0_I1660_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I214_XP_MN0 (I0_I1660_P22_19n I0_I1660_P22_21 XI0_I1660_I214_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I332_XP_MN1 (XI0_I1660_I332_XP_n1 I0_I1660_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I332_XP_MN0 (I0_I1660_P21_6n I0_I1660_P21_14 XI0_I1660_I332_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I216_XP_MN1 (XI0_I1660_I216_XP_n1 I0_I1660_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I216_XP_MN0 (I0_I1660_P24_21n I0_I1660_P24_23 XI0_I1660_I216_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I222_XP_MN1 (XI0_I1660_I222_XP_n1 I0_I1660_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I222_XP_MN0 (I0_I1660_P30_27n I0_I1660_P30_29 XI0_I1660_I222_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I336_XP_MN1 (XI0_I1660_I336_XP_n1 I0_I1660_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I336_XP_MN0 (I0_I1660_P25_10n I0_I1660_P25_18 XI0_I1660_I336_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I344_XP_MN1 (XI0_I1660_I344_XP_n1 I0_I1660_P25_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I344_XP_MN0 (I0_I1660_P33_18n I0_I1660_P33_26 XI0_I1660_I344_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I340_XP_MN1 (XI0_I1660_I340_XP_n1 I0_I1660_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I340_XP_MN0 (I0_I1660_P29_14n I0_I1660_P29_22 XI0_I1660_I340_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I338_XP_MN1 (XI0_I1660_I338_XP_n1 I0_I1660_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I338_XP_MN0 (I0_I1660_P27_12n I0_I1660_P27_20 XI0_I1660_I338_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I458_MN1 (XI2_I3_I458_n1 MULP_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I458_MN0 (I2_I3_n31_4 I2_I3_SEL_MUL_b3_5 XI2_I3_I458_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I342_XP_MN1 (XI0_I1660_I342_XP_n1 I0_I1660_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I342_XP_MN0 (I0_I1660_P31_16n I0_I1660_P31_24 XI0_I1660_I342_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I225_XP_MN1 (XI0_I1660_I225_XP_n1 I0_I1660_P31_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I225_XP_MN0 (I0_I1660_P33_30n I0_I1660_P33_32 XI0_I1660_I225_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I31_MN1 (XI0_I1660_I31_n1 I0_ha275_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I31_MN0 (I0_I1660_gn31 I0_ha274_1 XI0_I1660_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I33_MN1 (XI0_I1660_I33_n1 I0_ha277_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I33_MN0 (I0_I1660_gn33 I0_ha276_1 XI0_I1660_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I180_XP_MN1 (XI1_I1804_I180_XP_n1 I1_I1804_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I180_XP_MN0 (I1_I1804_P29_14n I1_I1804_P29_22 XI1_I1804_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I172_XP_MN1 (XI1_I1804_I172_XP_n1 I1_I1804_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I172_XP_MN0 (I1_I1804_P21_6n I1_I1804_P21_14 XI1_I1804_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I101_XP_MN1 (XI1_I1850_I101_XP_n1 I1_I1850_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I101_XP_MN0 (I1_I1850_P5_2n I1_I1850_P5_4 XI1_I1850_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I8_MN1 (XI1_I1850_I8_n1 I1_b28_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I8_MN0 (I1_I1850_gn8 I1_p27_7 XI1_I1850_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I100_XP_MN1 (XI1_I1850_I100_XP_n1 I1_I1850_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I100_XP_MN0 (I1_I1850_P4_1n I1_I1850_P4_3 XI1_I1850_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I8_MN1 (XI1_I1896_I8_n1 I1_b29_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I8_MN0 (I1_I1896_gn8 I1_p28_7 XI1_I1896_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I7_MN1 (XI1_I1896_I7_n1 I1_b29_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I7_MN0 (I1_I1896_gn7 I1_p28_6 XI1_I1896_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I105_XP_MN1 (XI1_I1896_I105_XP_n1 I1_I1896_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I105_XP_MN0 (I1_I1896_P9_6n I1_I1896_P9_8 XI1_I1896_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I104_XP_MN1 (XI1_I1896_I104_XP_n1 I1_I1896_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I104_XP_MN0 (I1_I1896_P8_5n I1_I1896_P8_7 XI1_I1896_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I167_XP_MN1 (XI1_I1896_I167_XP_n1 I1_I1896_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I167_XP_MN0 (I1_I1896_P16_1n I1_I1896_P16_9 XI1_I1896_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I10_MN1 (XI1_I1942_I10_n1 I1_b30_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I10_MN0 (I1_I1942_gn10 I1_p29_9 XI1_I1942_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I9_MN1 (XI1_I1942_I9_n1 I1_b30_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I9_MN0 (I1_I1942_gn9 I1_p29_8 XI1_I1942_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I107_XP_MN1 (XI1_I1942_I107_XP_n1 I1_I1942_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I107_XP_MN0 (I1_I1942_P11_8n I1_I1942_P11_10 XI1_I1942_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I168_XP_MN1 (XI1_I1942_I168_XP_n1 I1_I1942_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I168_XP_MN0 (I1_I1942_P17_2n I1_I1942_P17_10 XI1_I1942_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I169_XP_MN1 (XI1_I1942_I169_XP_n1 I1_I1942_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I169_XP_MN0 (I1_I1942_P18_3n I1_I1942_P18_11 XI1_I1942_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I11_MN1 (XI1_I1988_I11_n1 I1_b31_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I11_MN0 (I1_I1988_gn11 I1_p30_10 XI1_I1988_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2022_MN1 (XI1_I2022_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2022_MN0 (I1_dmn10 I1_dd10_b3_5 XI1_I2022_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2020_MN1 (XI1_I2020_n1 I1_p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2020_MN0 (I1_dmn9 I1_dd9_b3_5 XI1_I2020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I107_XP_MN1 (XI1_I1988_I107_XP_n1 I1_I1988_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I107_XP_MN0 (I1_I1988_P11_8n I1_I1988_P11_10 XI1_I1988_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I108_XP_MN1 (XI1_I1988_I108_XP_n1 I1_I1988_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I108_XP_MN0 (I1_I1988_P12_9n I1_I1988_P12_11 XI1_I1988_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I9_MN1 (XI1_I2066_I9_n1 I1_dm9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I9_MN0 (I1_I2066_gn9 I1_p31_9 XI1_I2066_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I8_MN1 (XI1_I2066_I8_n1 I1_dm8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I8_MN0 (I1_I2066_gn8 I1_p31_8 XI1_I2066_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I196_XP_MN1 (XI0_I1660_I196_XP_n1 I0_I1660_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I196_XP_MN0 (I0_I1660_P4_1n I0_I1660_P4_3 XI0_I1660_I196_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I198_XP_MN1 (XI0_I1660_I198_XP_n1 I0_I1660_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I198_XP_MN0 (I0_I1660_P6_3n I0_I1660_P6_5 XI0_I1660_I198_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I200_XP_MN1 (XI0_I1660_I200_XP_n1 I0_I1660_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I200_XP_MN0 (I0_I1660_P8_5n I0_I1660_P8_7 XI0_I1660_I200_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I467_MN1 (XI2_I3_I467_n1 DIVR_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I467_MN0 (I2_I3_hd32 I2_I3_SEL_DIV_b3_5 XI2_I3_I467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I468_MN1 (XI2_I3_I468_n1 I2_I3_hd32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I468_MN0 (Y_32 I2_I3_hm32 XI2_I3_I468_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I472_MN1 (XI2_I3_I472_n1 MULP_34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I472_MN0 (I2_I3_hm34 I2_I3_SEL_MUL_b3_5 XI2_I3_I472_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I469_MN1 (XI2_I3_I469_n1 MULP_33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I469_MN0 (I2_I3_hm33 I2_I3_SEL_MUL_b3_5 XI2_I3_I469_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I466_MN1 (XI2_I3_I466_n1 MULP_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I466_MN0 (I2_I3_hm32 I2_I3_SEL_MUL_b3_5 XI2_I3_I466_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I218_XP_MN1 (XI0_I1660_I218_XP_n1 I0_I1660_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I218_XP_MN0 (I0_I1660_P26_23n I0_I1660_P26_25 XI0_I1660_I218_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I220_XP_MN1 (XI0_I1660_I220_XP_n1 I0_I1660_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I220_XP_MN0 (I0_I1660_P28_25n I0_I1660_P28_27 XI0_I1660_I220_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I224_XP_MN1 (XI0_I1660_I224_XP_n1 I0_I1660_P30_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I224_XP_MN0 (I0_I1660_P32_29n I0_I1660_P32_31 XI0_I1660_I224_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I346_XP_MN1 (XI0_I1660_I346_XP_n1 I0_I1660_P27_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I346_XP_MN0 (I0_I1660_P35_20n I0_I1660_P35_28 XI0_I1660_I346_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I350_XP_MN1 (XI0_I1660_I350_XP_n1 I0_I1660_P31_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I350_XP_MN0 (I0_I1660_P39_24n I0_I1660_P39_32 XI0_I1660_I350_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I227_XP_MN1 (XI0_I1660_I227_XP_n1 I0_I1660_P33_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I227_XP_MN0 (I0_I1660_P35_32n I0_I1660_P35_34 XI0_I1660_I227_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I32_MN1 (XI0_I1660_I32_n1 I0_ha276_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I32_MN0 (I0_I1660_gn32 I0_ha275_1 XI0_I1660_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I34_MN1 (XI0_I1660_I34_n1 I0_ha278_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I34_MN0 (I0_I1660_gn34 I0_ha277_1 XI0_I1660_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I36_MN1 (XI0_I1660_I36_n1 I0_fa280_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I36_MN0 (I0_I1660_gn36 I0_ha279_1 XI0_I1660_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I37_MN1 (XI0_I1660_I37_n1 I0_fa281_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I37_MN0 (I0_I1660_gn37 I0_fa280_1 XI0_I1660_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I182_XP_MN1 (XI1_I1804_I182_XP_n1 I1_I1804_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I182_XP_MN0 (I1_I1804_P31_16n I1_I1804_P31_24 XI1_I1804_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I178_XP_MN1 (XI1_I1804_I178_XP_n1 I1_I1804_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I178_XP_MN0 (I1_I1804_P27_12n I1_I1804_P27_20 XI1_I1804_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I174_XP_MN1 (XI1_I1804_I174_XP_n1 I1_I1804_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I174_XP_MN0 (I1_I1804_P23_8n I1_I1804_P23_16 XI1_I1804_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1804_I170_XP_MN1 (XI1_I1804_I170_XP_n1 I1_I1804_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1804_I170_XP_MN0 (I1_I1804_P19_4n I1_I1804_P19_12 XI1_I1804_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I11_MN1 (XI1_I1850_I11_n1 I1_b28_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I11_MN0 (I1_I1850_gn11 I1_p27_10 XI1_I1850_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I10_MN1 (XI1_I1850_I10_n1 I1_b28_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I10_MN0 (I1_I1850_gn10 I1_p27_9 XI1_I1850_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I9_MN1 (XI1_I1850_I9_n1 I1_b28_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I9_MN0 (I1_I1850_gn9 I1_p27_8 XI1_I1850_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I168_XP_MN1 (XI1_I1896_I168_XP_n1 I1_I1896_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I168_XP_MN0 (I1_I1896_P17_2n I1_I1896_P17_10 XI1_I1896_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I106_XP_MN1 (XI1_I1896_I106_XP_n1 I1_I1896_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I106_XP_MN0 (I1_I1896_P10_7n I1_I1896_P10_9 XI1_I1896_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I11_MN1 (XI1_I1942_I11_n1 I1_b30_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I11_MN0 (I1_I1942_gn11 I1_p29_10 XI1_I1942_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I12_MN1 (XI1_I1942_I12_n1 I1_b30_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I12_MN0 (I1_I1942_gn12 I1_p29_11 XI1_I1942_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I109_XP_MN1 (XI1_I1942_I109_XP_n1 I1_I1942_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I109_XP_MN0 (I1_I1942_P13_10n I1_I1942_P13_12 XI1_I1942_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I170_XP_MN1 (XI1_I1942_I170_XP_n1 I1_I1942_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I170_XP_MN0 (I1_I1942_P19_4n I1_I1942_P19_12 XI1_I1942_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I108_XP_MN1 (XI1_I1942_I108_XP_n1 I1_I1942_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I108_XP_MN0 (I1_I1942_P12_9n I1_I1942_P12_11 XI1_I1942_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I175_XP_MN1 (XI1_I1942_I175_XP_n1 I1_I1942_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I175_XP_MN0 (I1_I1942_P24_9n I1_I1942_P24_17 XI1_I1942_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2024_MN1 (XI1_I2024_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2024_MN0 (I1_dmn11 I1_dd11_b3_5 XI1_I2024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2026_MN1 (XI1_I2026_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2026_MN0 (I1_dmn12 I1_dd12_b3_5 XI1_I2026_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I12_MN1 (XI1_I1988_I12_n1 I1_b31_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I12_MN0 (I1_I1988_gn12 I1_p30_11 XI1_I1988_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I109_XP_MN1 (XI1_I1988_I109_XP_n1 I1_I1988_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I109_XP_MN0 (I1_I1988_P13_10n I1_I1988_P13_12 XI1_I1988_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I175_XP_MN1 (XI1_I1988_I175_XP_n1 I1_I1988_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I175_XP_MN0 (I1_I1988_P24_9n I1_I1988_P24_17 XI1_I1988_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I169_XP_MN1 (XI1_I1988_I169_XP_n1 I1_I1988_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I169_XP_MN0 (I1_I1988_P18_3n I1_I1988_P18_11 XI1_I1988_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I10_MN1 (XI1_I2066_I10_n1 I1_dm10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I10_MN0 (I1_I2066_gn10 I1_p31_10 XI1_I2066_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I104_XP_MN1 (XI1_I2066_I104_XP_n1 I1_I2066_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I104_XP_MN0 (I1_I2066_P8_5n I1_I2066_P8_7 XI1_I2066_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I102_XP_MN1 (XI1_I2066_I102_XP_n1 I1_I2066_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I102_XP_MN0 (I1_I2066_P6_3n I1_I2066_P6_5 XI1_I2066_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I100_XP_MN1 (XI1_I2066_I100_XP_n1 I1_I2066_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I100_XP_MN0 (I1_I2066_P4_1n I1_I2066_P4_3 XI1_I2066_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I327_XP_MN1 (XI0_I1660_I327_XP_n1 I0_I1660_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I327_XP_MN0 (I0_I1660_P16_1n I0_I1660_P16_9 XI0_I1660_I327_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I473_MN1 (XI2_I3_I473_n1 DIVR_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I473_MN0 (I2_I3_hd34 I2_I3_SEL_DIV_b3_5 XI2_I3_I473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I470_MN1 (XI2_I3_I470_n1 DIVR_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I470_MN0 (I2_I3_hd33 I2_I3_SEL_DIV_b3_5 XI2_I3_I470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I474_MN1 (XI2_I3_I474_n1 I2_I3_hd34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I474_MN0 (Y_34 I2_I3_hm34 XI2_I3_I474_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I471_MN1 (XI2_I3_I471_n1 I2_I3_hd33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I471_MN0 (Y_33 I2_I3_hm33 XI2_I3_I471_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I331_XP_MN1 (XI0_I1660_I331_XP_n1 I0_I1660_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I331_XP_MN0 (I0_I1660_P20_5n I0_I1660_P20_13 XI0_I1660_I331_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I335_XP_MN1 (XI0_I1660_I335_XP_n1 I0_I1660_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I335_XP_MN0 (I0_I1660_P24_9n I0_I1660_P24_17 XI0_I1660_I335_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I343_XP_MN1 (XI0_I1660_I343_XP_n1 I0_I1660_P24_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I343_XP_MN0 (I0_I1660_P32_17n I0_I1660_P32_25 XI0_I1660_I343_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I339_XP_MN1 (XI0_I1660_I339_XP_n1 I0_I1660_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I339_XP_MN0 (I0_I1660_P28_13n I0_I1660_P28_21 XI0_I1660_I339_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I226_XP_MN1 (XI0_I1660_I226_XP_n1 I0_I1660_P32_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I226_XP_MN0 (I0_I1660_P34_31n I0_I1660_P34_33 XI0_I1660_I226_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I228_XP_MN1 (XI0_I1660_I228_XP_n1 I0_I1660_P34_33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I228_XP_MN0 (I0_I1660_P36_33n I0_I1660_P36_35 XI0_I1660_I228_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I348_XP_MN1 (XI0_I1660_I348_XP_n1 I0_I1660_P29_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I348_XP_MN0 (I0_I1660_P37_22n I0_I1660_P37_30 XI0_I1660_I348_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I354_XP_MN1 (XI0_I1660_I354_XP_n1 I0_I1660_P35_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I354_XP_MN0 (I0_I1660_P43_28n I0_I1660_P43_36 XI0_I1660_I354_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I362_XP_MN1 (XI0_I1660_I362_XP_n1 I0_I1660_P43_36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I362_XP_MN0 (I0_I1660_P51_36n I0_I1660_P51_44 XI0_I1660_I362_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I229_XP_MN1 (XI0_I1660_I229_XP_n1 I0_I1660_P35_34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I229_XP_MN0 (I0_I1660_P37_34n I0_I1660_P37_36 XI0_I1660_I229_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I231_XP_MN1 (XI0_I1660_I231_XP_n1 I0_I1660_P37_36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I231_XP_MN0 (I0_I1660_P39_36n I0_I1660_P39_38 XI0_I1660_I231_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I35_MN1 (XI0_I1660_I35_n1 I0_ha279_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I35_MN0 (I0_I1660_gn35 I0_ha278_1 XI0_I1660_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I107_XP_MN1 (XI1_I1850_I107_XP_n1 I1_I1850_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I107_XP_MN0 (I1_I1850_P11_8n I1_I1850_P11_10 XI1_I1850_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I105_XP_MN1 (XI1_I1850_I105_XP_n1 I1_I1850_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I105_XP_MN0 (I1_I1850_P9_6n I1_I1850_P9_8 XI1_I1850_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I103_XP_MN1 (XI1_I1850_I103_XP_n1 I1_I1850_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I103_XP_MN0 (I1_I1850_P7_4n I1_I1850_P7_6 XI1_I1850_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I13_MN1 (XI1_I1850_I13_n1 I1_b28_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I13_MN0 (I1_I1850_gn13 I1_p27_12 XI1_I1850_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I102_XP_MN1 (XI1_I1850_I102_XP_n1 I1_I1850_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I102_XP_MN0 (I1_I1850_P6_3n I1_I1850_P6_5 XI1_I1850_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I10_MN1 (XI1_I1896_I10_n1 I1_b29_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I10_MN0 (I1_I1896_gn10 I1_p28_9 XI1_I1896_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I11_MN1 (XI1_I1896_I11_n1 I1_b29_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I11_MN0 (I1_I1896_gn11 I1_p28_10 XI1_I1896_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I9_MN1 (XI1_I1896_I9_n1 I1_b29_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I9_MN0 (I1_I1896_gn9 I1_p28_8 XI1_I1896_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I107_XP_MN1 (XI1_I1896_I107_XP_n1 I1_I1896_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I107_XP_MN0 (I1_I1896_P11_8n I1_I1896_P11_10 XI1_I1896_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I169_XP_MN1 (XI1_I1896_I169_XP_n1 I1_I1896_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I169_XP_MN0 (I1_I1896_P18_3n I1_I1896_P18_11 XI1_I1896_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I13_MN1 (XI1_I1942_I13_n1 I1_b30_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I13_MN0 (I1_I1942_gn13 I1_p29_12 XI1_I1942_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I176_XP_MN1 (XI1_I1942_I176_XP_n1 I1_I1942_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I176_XP_MN0 (I1_I1942_P25_10n I1_I1942_P25_18 XI1_I1942_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I110_XP_MN1 (XI1_I1942_I110_XP_n1 I1_I1942_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I110_XP_MN0 (I1_I1942_P14_11n I1_I1942_P14_13 XI1_I1942_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I13_MN1 (XI1_I1988_I13_n1 I1_b31_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I13_MN0 (I1_I1988_gn13 I1_p30_12 XI1_I1988_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2028_MN1 (XI1_I2028_n1 I1_p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2028_MN0 (I1_dmn13 I1_dd13_b3_5 XI1_I2028_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I14_MN1 (XI1_I1988_I14_n1 I1_b31_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I14_MN0 (I1_I1988_gn14 I1_p30_13 XI1_I1988_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I176_XP_MN1 (XI1_I1988_I176_XP_n1 I1_I1988_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I176_XP_MN0 (I1_I1988_P25_10n I1_I1988_P25_18 XI1_I1988_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I110_XP_MN1 (XI1_I1988_I110_XP_n1 I1_I1988_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I110_XP_MN0 (I1_I1988_P14_11n I1_I1988_P14_13 XI1_I1988_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I112_XP_MN1 (XI1_I1988_I112_XP_n1 I1_I1988_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I112_XP_MN0 (I1_I1988_P16_13n I1_I1988_P16_15 XI1_I1988_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I12_MN1 (XI1_I2066_I12_n1 I1_dm12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I12_MN0 (I1_I2066_gn12 I1_p31_12 XI1_I2066_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I11_MN1 (XI1_I2066_I11_n1 I1_dm11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I11_MN0 (I1_I2066_gn11 I1_p31_11 XI1_I2066_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I108_XP_MN1 (XI1_I2066_I108_XP_n1 I1_I2066_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I108_XP_MN0 (I1_I2066_P12_9n I1_I2066_P12_11 XI1_I2066_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I106_XP_MN1 (XI1_I2066_I106_XP_n1 I1_I2066_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I106_XP_MN0 (I1_I2066_P10_7n I1_I2066_P10_9 XI1_I2066_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I167_XP_MN1 (XI1_I2066_I167_XP_n1 I1_I2066_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I167_XP_MN0 (I1_I2066_P16_1n I1_I2066_P16_9 XI1_I2066_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I105_XP_MN1 (XI1_I2066_I105_XP_n1 I1_I2066_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I105_XP_MN0 (I1_I2066_P9_6n I1_I2066_P9_8 XI1_I2066_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I101_XP_MN1 (XI1_I2066_I101_XP_n1 I1_I2066_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I101_XP_MN0 (I1_I2066_P5_2n I1_I2066_P5_4 XI1_I2066_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I103_XP_MN1 (XI1_I2066_I103_XP_n1 I1_I2066_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I103_XP_MN0 (I1_I2066_P7_4n I1_I2066_P7_6 XI1_I2066_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I329_XP_MN1 (XI0_I1660_I329_XP_n1 I0_I1660_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I329_XP_MN0 (I0_I1660_P18_3n I0_I1660_P18_11 XI0_I1660_I329_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I347_XP_MN1 (XI0_I1660_I347_XP_n1 I0_I1660_P28_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I347_XP_MN0 (I0_I1660_P36_21n I0_I1660_P36_29 XI0_I1660_I347_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I351_XP_MN1 (XI0_I1660_I351_XP_n1 I0_I1660_P32_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I351_XP_MN0 (I0_I1660_P40_25n I0_I1660_P40_33 XI0_I1660_I351_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I230_XP_MN1 (XI0_I1660_I230_XP_n1 I0_I1660_P36_35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I230_XP_MN0 (I0_I1660_P38_35n I0_I1660_P38_37 XI0_I1660_I230_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I352_XP_MN1 (XI0_I1660_I352_XP_n1 I0_I1660_P33_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I352_XP_MN0 (I0_I1660_P41_26n I0_I1660_P41_34 XI0_I1660_I352_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I360_XP_MN1 (XI0_I1660_I360_XP_n1 I0_I1660_P41_34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I360_XP_MN0 (I0_I1660_P49_34n I0_I1660_P49_42 XI0_I1660_I360_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I358_XP_MN1 (XI0_I1660_I358_XP_n1 I0_I1660_P39_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I358_XP_MN0 (I0_I1660_P47_32n I0_I1660_P47_40 XI0_I1660_I358_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I233_XP_MN1 (XI0_I1660_I233_XP_n1 I0_I1660_P39_38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I233_XP_MN0 (I0_I1660_P41_38n I0_I1660_P41_40 XI0_I1660_I233_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I38_MN1 (XI0_I1660_I38_n1 I0_ha282_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I38_MN0 (I0_I1660_gn38 I0_fa281_1 XI0_I1660_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I40_MN1 (XI0_I1660_I40_n1 I0_ha284_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I40_MN0 (I0_I1660_gn40 I0_fa283_1 XI0_I1660_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I39_MN1 (XI0_I1660_I39_n1 I0_fa283_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I39_MN0 (I0_I1660_gn39 I0_ha282_1 XI0_I1660_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I41_MN1 (XI0_I1660_I41_n1 I0_fa285_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I41_MN0 (I0_I1660_gn41 I0_ha284_1 XI0_I1660_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I42_MN1 (XI0_I1660_I42_n1 I0_ha286_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I42_MN0 (I0_I1660_gn42 I0_fa285_1 XI0_I1660_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I170_XP_MN1 (XI1_I1850_I170_XP_n1 I1_I1850_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I170_XP_MN0 (I1_I1850_P19_4n I1_I1850_P19_12 XI1_I1850_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I111_XP_MN1 (XI1_I1850_I111_XP_n1 I1_I1850_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I111_XP_MN0 (I1_I1850_P15_12n I1_I1850_P15_14 XI1_I1850_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I109_XP_MN1 (XI1_I1850_I109_XP_n1 I1_I1850_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I109_XP_MN0 (I1_I1850_P13_10n I1_I1850_P13_12 XI1_I1850_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I15_MN1 (XI1_I1850_I15_n1 I1_b28_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I15_MN0 (I1_I1850_gn15 I1_p27_14 XI1_I1850_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I14_MN1 (XI1_I1850_I14_n1 I1_b28_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I14_MN0 (I1_I1850_gn14 I1_p27_13 XI1_I1850_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I12_MN1 (XI1_I1850_I12_n1 I1_b28_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I12_MN0 (I1_I1850_gn12 I1_p27_11 XI1_I1850_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I104_XP_MN1 (XI1_I1850_I104_XP_n1 I1_I1850_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I104_XP_MN0 (I1_I1850_P8_5n I1_I1850_P8_7 XI1_I1850_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I12_MN1 (XI1_I1896_I12_n1 I1_b29_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I12_MN0 (I1_I1896_gn12 I1_p28_11 XI1_I1896_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I13_MN1 (XI1_I1896_I13_n1 I1_b29_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I13_MN0 (I1_I1896_gn13 I1_p28_12 XI1_I1896_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I109_XP_MN1 (XI1_I1896_I109_XP_n1 I1_I1896_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I109_XP_MN0 (I1_I1896_P13_10n I1_I1896_P13_12 XI1_I1896_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I108_XP_MN1 (XI1_I1896_I108_XP_n1 I1_I1896_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I108_XP_MN0 (I1_I1896_P12_9n I1_I1896_P12_11 XI1_I1896_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I14_MN1 (XI1_I1942_I14_n1 I1_b30_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I14_MN0 (I1_I1942_gn14 I1_p29_13 XI1_I1942_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I111_XP_MN1 (XI1_I1942_I111_XP_n1 I1_I1942_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I111_XP_MN0 (I1_I1942_P15_12n I1_I1942_P15_14 XI1_I1942_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I113_XP_MN1 (XI1_I1942_I113_XP_n1 I1_I1942_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I113_XP_MN0 (I1_I1942_P17_14n I1_I1942_P17_16 XI1_I1942_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I172_XP_MN1 (XI1_I1942_I172_XP_n1 I1_I1942_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I172_XP_MN0 (I1_I1942_P21_6n I1_I1942_P21_14 XI1_I1942_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I112_XP_MN1 (XI1_I1942_I112_XP_n1 I1_I1942_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I112_XP_MN0 (I1_I1942_P16_13n I1_I1942_P16_15 XI1_I1942_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I171_XP_MN1 (XI1_I1942_I171_XP_n1 I1_I1942_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I171_XP_MN0 (I1_I1942_P20_5n I1_I1942_P20_13 XI1_I1942_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I15_MN1 (XI1_I1988_I15_n1 I1_b31_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I15_MN0 (I1_I1988_gn15 I1_p30_14 XI1_I1988_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I111_XP_MN1 (XI1_I1988_I111_XP_n1 I1_I1988_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I111_XP_MN0 (I1_I1988_P15_12n I1_I1988_P15_14 XI1_I1988_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I113_XP_MN1 (XI1_I1988_I113_XP_n1 I1_I1988_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I113_XP_MN0 (I1_I1988_P17_14n I1_I1988_P17_16 XI1_I1988_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I170_XP_MN1 (XI1_I1988_I170_XP_n1 I1_I1988_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I170_XP_MN0 (I1_I1988_P19_4n I1_I1988_P19_12 XI1_I1988_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I114_XP_MN1 (XI1_I1988_I114_XP_n1 I1_I1988_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I114_XP_MN0 (I1_I1988_P18_15n I1_I1988_P18_17 XI1_I1988_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I171_XP_MN1 (XI1_I1988_I171_XP_n1 I1_I1988_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I171_XP_MN0 (I1_I1988_P20_5n I1_I1988_P20_13 XI1_I1988_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I13_MN1 (XI1_I2066_I13_n1 I1_dm13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I13_MN0 (I1_I2066_gn13 I1_p31_13 XI1_I2066_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I14_MN1 (XI1_I2066_I14_n1 I1_dm14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I14_MN0 (I1_I2066_gn14 I1_p31_14 XI1_I2066_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I175_XP_MN1 (XI1_I2066_I175_XP_n1 I1_I2066_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I175_XP_MN0 (I1_I2066_P24_9n I1_I2066_P24_17 XI1_I2066_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I107_XP_MN1 (XI1_I2066_I107_XP_n1 I1_I2066_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I107_XP_MN0 (I1_I2066_P11_8n I1_I2066_P11_10 XI1_I2066_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I482_MN1 (XI2_I3_I482_n1 DIVR_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I482_MN0 (I2_I3_hd37 I2_I3_SEL_DIV_b3_6 XI2_I3_I482_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I476_MN1 (XI2_I3_I476_n1 DIVR_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I476_MN0 (I2_I3_hd35 I2_I3_SEL_DIV_b3_6 XI2_I3_I476_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I477_MN1 (XI2_I3_I477_n1 I2_I3_hd35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I477_MN0 (Y_35 I2_I3_hm35 XI2_I3_I477_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I483_MN1 (XI2_I3_I483_n1 I2_I3_hd37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I483_MN0 (Y_37 I2_I3_hm37 XI2_I3_I483_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I481_MN1 (XI2_I3_I481_n1 MULP_37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I481_MN0 (I2_I3_hm37 I2_I3_SEL_MUL_b3_6 XI2_I3_I481_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I359_XP_MN1 (XI0_I1660_I359_XP_n1 I0_I1660_P40_33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I359_XP_MN0 (I0_I1660_P48_33n I0_I1660_P48_41 XI0_I1660_I359_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I355_XP_MN1 (XI0_I1660_I355_XP_n1 I0_I1660_P36_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I355_XP_MN0 (I0_I1660_P44_29n I0_I1660_P44_37 XI0_I1660_I355_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I232_XP_MN1 (XI0_I1660_I232_XP_n1 I0_I1660_P38_37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I232_XP_MN0 (I0_I1660_P40_37n I0_I1660_P40_39 XI0_I1660_I232_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I364_XP_MN1 (XI0_I1660_I364_XP_n1 I0_I1660_P45_38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I364_XP_MN0 (I0_I1660_P53_38n I0_I1660_P53_46 XI0_I1660_I364_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I366_XP_MN1 (XI0_I1660_I366_XP_n1 I0_I1660_P47_40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I366_XP_MN0 (I0_I1660_P55_40n I0_I1660_P55_48 XI0_I1660_I366_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I235_XP_MN1 (XI0_I1660_I235_XP_n1 I0_I1660_P41_40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I235_XP_MN0 (I0_I1660_P43_40n I0_I1660_P43_42 XI0_I1660_I235_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I45_MN1 (XI0_I1660_I45_n1 I0_fa289_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I45_MN0 (I0_I1660_gn45 I0_ha288_1 XI0_I1660_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I43_MN1 (XI0_I1660_I43_n1 I0_fa287_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I43_MN0 (I0_I1660_gn43 I0_ha286_1 XI0_I1660_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I113_XP_MN1 (XI1_I1850_I113_XP_n1 I1_I1850_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I113_XP_MN0 (I1_I1850_P17_14n I1_I1850_P17_16 XI1_I1850_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I168_XP_MN1 (XI1_I1850_I168_XP_n1 I1_I1850_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I168_XP_MN0 (I1_I1850_P17_2n I1_I1850_P17_10 XI1_I1850_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I17_MN1 (XI1_I1850_I17_n1 I1_b28_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I17_MN0 (I1_I1850_gn17 I1_p27_16 XI1_I1850_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I16_MN1 (XI1_I1850_I16_n1 I1_b28_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I16_MN0 (I1_I1850_gn16 I1_p27_15 XI1_I1850_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I108_XP_MN1 (XI1_I1850_I108_XP_n1 I1_I1850_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I108_XP_MN0 (I1_I1850_P12_9n I1_I1850_P12_11 XI1_I1850_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I106_XP_MN1 (XI1_I1850_I106_XP_n1 I1_I1850_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I106_XP_MN0 (I1_I1850_P10_7n I1_I1850_P10_9 XI1_I1850_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I15_MN1 (XI1_I1896_I15_n1 I1_b29_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I15_MN0 (I1_I1896_gn15 I1_p28_14 XI1_I1896_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I14_MN1 (XI1_I1896_I14_n1 I1_b29_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I14_MN0 (I1_I1896_gn14 I1_p28_13 XI1_I1896_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I170_XP_MN1 (XI1_I1896_I170_XP_n1 I1_I1896_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I170_XP_MN0 (I1_I1896_P19_4n I1_I1896_P19_12 XI1_I1896_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I110_XP_MN1 (XI1_I1896_I110_XP_n1 I1_I1896_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I110_XP_MN0 (I1_I1896_P14_11n I1_I1896_P14_13 XI1_I1896_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I15_MN1 (XI1_I1942_I15_n1 I1_b30_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I15_MN0 (I1_I1942_gn15 I1_p29_14 XI1_I1942_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I16_MN1 (XI1_I1942_I16_n1 I1_b30_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I16_MN0 (I1_I1942_gn16 I1_p29_15 XI1_I1942_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I114_XP_MN1 (XI1_I1942_I114_XP_n1 I1_I1942_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I114_XP_MN0 (I1_I1942_P18_15n I1_I1942_P18_17 XI1_I1942_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I17_MN1 (XI1_I1988_I17_n1 I1_b31_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I17_MN0 (I1_I1988_gn17 I1_p30_16 XI1_I1988_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I16_MN1 (XI1_I1988_I16_n1 I1_b31_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I16_MN0 (I1_I1988_gn16 I1_p30_15 XI1_I1988_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2036_MN1 (XI1_I2036_n1 I1_p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2036_MN0 (I1_dmn17 I1_dd17_b3_5 XI1_I2036_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2034_MN1 (XI1_I2034_n1 I1_p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2034_MN0 (I1_dmn16 I1_dd16_b3_5 XI1_I2034_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I115_XP_MN1 (XI1_I1988_I115_XP_n1 I1_I1988_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I115_XP_MN0 (I1_I1988_P19_16n I1_I1988_P19_18 XI1_I1988_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I172_XP_MN1 (XI1_I1988_I172_XP_n1 I1_I1988_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I172_XP_MN0 (I1_I1988_P21_6n I1_I1988_P21_14 XI1_I1988_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I116_XP_MN1 (XI1_I1988_I116_XP_n1 I1_I1988_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I116_XP_MN0 (I1_I1988_P20_17n I1_I1988_P20_19 XI1_I1988_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I15_MN1 (XI1_I2066_I15_n1 I1_dm15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I15_MN0 (I1_I2066_gn15 I1_p31_15 XI1_I2066_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I112_XP_MN1 (XI1_I2066_I112_XP_n1 I1_I2066_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I112_XP_MN0 (I1_I2066_P16_13n I1_I2066_P16_15 XI1_I2066_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I110_XP_MN1 (XI1_I2066_I110_XP_n1 I1_I2066_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I110_XP_MN0 (I1_I2066_P14_11n I1_I2066_P14_13 XI1_I2066_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I109_XP_MN1 (XI1_I2066_I109_XP_n1 I1_I2066_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I109_XP_MN0 (I1_I2066_P13_10n I1_I2066_P13_12 XI1_I2066_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I168_XP_MN1 (XI1_I2066_I168_XP_n1 I1_I2066_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I168_XP_MN0 (I1_I2066_P17_2n I1_I2066_P17_10 XI1_I2066_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I485_MN1 (XI2_I3_I485_n1 DIVR_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I485_MN0 (I2_I3_hd38 I2_I3_SEL_DIV_b3_6 XI2_I3_I485_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I479_MN1 (XI2_I3_I479_n1 DIVR_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I479_MN0 (I2_I3_hd36 I2_I3_SEL_DIV_b3_6 XI2_I3_I479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I488_MN1 (XI2_I3_I488_n1 DIVR_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I488_MN0 (I2_I3_hd39 I2_I3_SEL_DIV_b3_6 XI2_I3_I488_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I491_MN1 (XI2_I3_I491_n1 DIVR_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I491_MN0 (I2_I3_hd40 I2_I3_SEL_DIV_b3_6 XI2_I3_I491_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I486_MN1 (XI2_I3_I486_n1 I2_I3_hd38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I486_MN0 (Y_38 I2_I3_hm38 XI2_I3_I486_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I480_MN1 (XI2_I3_I480_n1 I2_I3_hd36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I480_MN0 (Y_36 I2_I3_hm36 XI2_I3_I480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I492_MN1 (XI2_I3_I492_n1 I2_I3_hd40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I492_MN0 (Y_40 I2_I3_hm40 XI2_I3_I492_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I475_MN1 (XI2_I3_I475_n1 MULP_35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I475_MN0 (I2_I3_hm35 I2_I3_SEL_MUL_b3_6 XI2_I3_I475_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I484_MN1 (XI2_I3_I484_n1 MULP_38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I484_MN0 (I2_I3_hm38 I2_I3_SEL_MUL_b3_6 XI2_I3_I484_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I333_XP_MN1 (XI0_I1660_I333_XP_n1 I0_I1660_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I333_XP_MN0 (I0_I1660_P22_7n I0_I1660_P22_15 XI0_I1660_I333_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I337_XP_MN1 (XI0_I1660_I337_XP_n1 I0_I1660_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I337_XP_MN0 (I0_I1660_P26_11n I0_I1660_P26_19 XI0_I1660_I337_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I345_XP_MN1 (XI0_I1660_I345_XP_n1 I0_I1660_P26_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I345_XP_MN0 (I0_I1660_P34_19n I0_I1660_P34_27 XI0_I1660_I345_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I363_XP_MN1 (XI0_I1660_I363_XP_n1 I0_I1660_P44_37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I363_XP_MN0 (I0_I1660_P52_37n I0_I1660_P52_45 XI0_I1660_I363_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I234_XP_MN1 (XI0_I1660_I234_XP_n1 I0_I1660_P40_39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I234_XP_MN0 (I0_I1660_P42_39n I0_I1660_P42_41 XI0_I1660_I234_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I356_XP_MN1 (XI0_I1660_I356_XP_n1 I0_I1660_P37_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I356_XP_MN0 (I0_I1660_P45_30n I0_I1660_P45_38 XI0_I1660_I356_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I370_XP_MN1 (XI0_I1660_I370_XP_n1 I0_I1660_P51_44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I370_XP_MN0 (I0_I1660_P59_44n I0_I1660_P59_52 XI0_I1660_I370_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I239_XP_MN1 (XI0_I1660_I239_XP_n1 I0_I1660_P45_44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I239_XP_MN0 (I0_I1660_P47_44n I0_I1660_P47_46 XI0_I1660_I239_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I237_XP_MN1 (XI0_I1660_I237_XP_n1 I0_I1660_P43_42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I237_XP_MN0 (I0_I1660_P45_42n I0_I1660_P45_44 XI0_I1660_I237_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I44_MN1 (XI0_I1660_I44_n1 I0_ha288_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I44_MN0 (I0_I1660_gn44 I0_fa287_1 XI0_I1660_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I174_XP_MN1 (XI1_I1850_I174_XP_n1 I1_I1850_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I174_XP_MN0 (I1_I1850_P23_8n I1_I1850_P23_16 XI1_I1850_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I115_XP_MN1 (XI1_I1850_I115_XP_n1 I1_I1850_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I115_XP_MN0 (I1_I1850_P19_16n I1_I1850_P19_18 XI1_I1850_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I172_XP_MN1 (XI1_I1850_I172_XP_n1 I1_I1850_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I172_XP_MN0 (I1_I1850_P21_6n I1_I1850_P21_14 XI1_I1850_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I112_XP_MN1 (XI1_I1850_I112_XP_n1 I1_I1850_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I112_XP_MN0 (I1_I1850_P16_13n I1_I1850_P16_15 XI1_I1850_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I110_XP_MN1 (XI1_I1850_I110_XP_n1 I1_I1850_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I110_XP_MN0 (I1_I1850_P14_11n I1_I1850_P14_13 XI1_I1850_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I167_XP_MN1 (XI1_I1850_I167_XP_n1 I1_I1850_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I167_XP_MN0 (I1_I1850_P16_1n I1_I1850_P16_9 XI1_I1850_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I17_MN1 (XI1_I1896_I17_n1 I1_b29_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I17_MN0 (I1_I1896_gn17 I1_p28_16 XI1_I1896_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I113_XP_MN1 (XI1_I1896_I113_XP_n1 I1_I1896_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I113_XP_MN0 (I1_I1896_P17_14n I1_I1896_P17_16 XI1_I1896_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I111_XP_MN1 (XI1_I1896_I111_XP_n1 I1_I1896_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I111_XP_MN0 (I1_I1896_P15_12n I1_I1896_P15_14 XI1_I1896_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I114_XP_MN1 (XI1_I1896_I114_XP_n1 I1_I1896_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I114_XP_MN0 (I1_I1896_P18_15n I1_I1896_P18_17 XI1_I1896_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I112_XP_MN1 (XI1_I1896_I112_XP_n1 I1_I1896_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I112_XP_MN0 (I1_I1896_P16_13n I1_I1896_P16_15 XI1_I1896_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I171_XP_MN1 (XI1_I1896_I171_XP_n1 I1_I1896_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I171_XP_MN0 (I1_I1896_P20_5n I1_I1896_P20_13 XI1_I1896_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I17_MN1 (XI1_I1942_I17_n1 I1_b30_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I17_MN0 (I1_I1942_gn17 I1_p29_16 XI1_I1942_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I18_MN1 (XI1_I1942_I18_n1 I1_b30_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I18_MN0 (I1_I1942_gn18 I1_p29_17 XI1_I1942_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I117_XP_MN1 (XI1_I1942_I117_XP_n1 I1_I1942_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I117_XP_MN0 (I1_I1942_P21_18n I1_I1942_P21_20 XI1_I1942_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I115_XP_MN1 (XI1_I1942_I115_XP_n1 I1_I1942_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I115_XP_MN0 (I1_I1942_P19_16n I1_I1942_P19_18 XI1_I1942_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I178_XP_MN1 (XI1_I1942_I178_XP_n1 I1_I1942_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I178_XP_MN0 (I1_I1942_P27_12n I1_I1942_P27_20 XI1_I1942_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I116_XP_MN1 (XI1_I1942_I116_XP_n1 I1_I1942_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I116_XP_MN0 (I1_I1942_P20_17n I1_I1942_P20_19 XI1_I1942_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I177_XP_MN1 (XI1_I1942_I177_XP_n1 I1_I1942_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I177_XP_MN0 (I1_I1942_P26_11n I1_I1942_P26_19 XI1_I1942_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I18_MN1 (XI1_I1988_I18_n1 I1_b31_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I18_MN0 (I1_I1988_gn18 I1_p30_17 XI1_I1988_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I19_MN1 (XI1_I1988_I19_n1 I1_b31_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I19_MN0 (I1_I1988_gn19 I1_p30_18 XI1_I1988_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I117_XP_MN1 (XI1_I1988_I117_XP_n1 I1_I1988_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I117_XP_MN0 (I1_I1988_P21_18n I1_I1988_P21_20 XI1_I1988_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I178_XP_MN1 (XI1_I1988_I178_XP_n1 I1_I1988_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I178_XP_MN0 (I1_I1988_P27_12n I1_I1988_P27_20 XI1_I1988_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I177_XP_MN1 (XI1_I1988_I177_XP_n1 I1_I1988_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I177_XP_MN0 (I1_I1988_P26_11n I1_I1988_P26_19 XI1_I1988_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I17_MN1 (XI1_I2066_I17_n1 I1_dm17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I17_MN0 (I1_I2066_gn17 I1_p31_17 XI1_I2066_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I16_MN1 (XI1_I2066_I16_n1 I1_dm16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I16_MN0 (I1_I2066_gn16 I1_p31_16 XI1_I2066_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I114_XP_MN1 (XI1_I2066_I114_XP_n1 I1_I2066_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I114_XP_MN0 (I1_I2066_P18_15n I1_I2066_P18_17 XI1_I2066_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I169_XP_MN1 (XI1_I2066_I169_XP_n1 I1_I2066_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I169_XP_MN0 (I1_I2066_P18_3n I1_I2066_P18_11 XI1_I2066_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I111_XP_MN1 (XI1_I2066_I111_XP_n1 I1_I2066_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I111_XP_MN0 (I1_I2066_P15_12n I1_I2066_P15_14 XI1_I2066_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I176_XP_MN1 (XI1_I2066_I176_XP_n1 I1_I2066_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I176_XP_MN0 (I1_I2066_P25_10n I1_I2066_P25_18 XI1_I2066_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I494_MN1 (XI2_I3_I494_n1 DIVR_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I494_MN0 (I2_I3_hd41 I2_I3_SEL_DIV_b3_7 XI2_I3_I494_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I489_MN1 (XI2_I3_I489_n1 I2_I3_hd39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I489_MN0 (Y_39 I2_I3_hm39 XI2_I3_I489_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I495_MN1 (XI2_I3_I495_n1 I2_I3_hd41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I495_MN0 (Y_41 I2_I3_hm41 XI2_I3_I495_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I487_MN1 (XI2_I3_I487_n1 MULP_39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I487_MN0 (I2_I3_hm39 I2_I3_SEL_MUL_b3_6 XI2_I3_I487_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I502_MN1 (XI2_I3_I502_n1 MULP_44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I502_MN0 (I2_I3_hm44 I2_I3_SEL_MUL_b3_7 XI2_I3_I502_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I493_MN1 (XI2_I3_I493_n1 MULP_41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I493_MN0 (I2_I3_hm41 I2_I3_SEL_MUL_b3_7 XI2_I3_I493_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I353_XP_MN1 (XI0_I1660_I353_XP_n1 I0_I1660_P34_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I353_XP_MN0 (I0_I1660_P42_27n I0_I1660_P42_35 XI0_I1660_I353_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I367_XP_MN1 (XI0_I1660_I367_XP_n1 I0_I1660_P48_41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I367_XP_MN0 (I0_I1660_P56_41n I0_I1660_P56_49 XI0_I1660_I367_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I236_XP_MN1 (XI0_I1660_I236_XP_n1 I0_I1660_P42_41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I236_XP_MN0 (I0_I1660_P44_41n I0_I1660_P44_43 XI0_I1660_I236_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I368_XP_MN1 (XI0_I1660_I368_XP_n1 I0_I1660_P49_42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I368_XP_MN0 (I0_I1660_P57_42n I0_I1660_P57_50 XI0_I1660_I368_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I374_XP_MN1 (XI0_I1660_I374_XP_n1 I0_I1660_P55_48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I374_XP_MN0 (I0_I1660_P63_48n I0_I1660_P63_56 XI0_I1660_I374_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I241_XP_MN1 (XI0_I1660_I241_XP_n1 I0_I1660_P47_46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I241_XP_MN0 (I0_I1660_P49_46n I0_I1660_P49_48 XI0_I1660_I241_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I46_MN1 (XI0_I1660_I46_n1 I0_ha290_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I46_MN0 (I0_I1660_gn46 I0_fa289_1 XI0_I1660_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I47_MN1 (XI0_I1660_I47_n1 I0_fa291_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I47_MN0 (I0_I1660_gn47 I0_ha290_1 XI0_I1660_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I182_XP_MN1 (XI1_I1850_I182_XP_n1 I1_I1850_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I182_XP_MN0 (I1_I1850_P31_16n I1_I1850_P31_24 XI1_I1850_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I117_XP_MN1 (XI1_I1850_I117_XP_n1 I1_I1850_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I117_XP_MN0 (I1_I1850_P21_18n I1_I1850_P21_20 XI1_I1850_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I176_XP_MN1 (XI1_I1850_I176_XP_n1 I1_I1850_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I176_XP_MN0 (I1_I1850_P25_10n I1_I1850_P25_18 XI1_I1850_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I18_MN1 (XI1_I1850_I18_n1 I1_b28_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I18_MN0 (I1_I1850_gn18 I1_p27_17 XI1_I1850_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I114_XP_MN1 (XI1_I1850_I114_XP_n1 I1_I1850_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I114_XP_MN0 (I1_I1850_P18_15n I1_I1850_P18_17 XI1_I1850_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I19_MN1 (XI1_I1850_I19_n1 I1_b28_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I19_MN0 (I1_I1850_gn19 I1_p27_18 XI1_I1850_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I169_XP_MN1 (XI1_I1850_I169_XP_n1 I1_I1850_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I169_XP_MN0 (I1_I1850_P18_3n I1_I1850_P18_11 XI1_I1850_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I18_MN1 (XI1_I1896_I18_n1 I1_b29_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I18_MN0 (I1_I1896_gn18 I1_p28_17 XI1_I1896_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I16_MN1 (XI1_I1896_I16_n1 I1_b29_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I16_MN0 (I1_I1896_gn16 I1_p28_15 XI1_I1896_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I115_XP_MN1 (XI1_I1896_I115_XP_n1 I1_I1896_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I115_XP_MN0 (I1_I1896_P19_16n I1_I1896_P19_18 XI1_I1896_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I172_XP_MN1 (XI1_I1896_I172_XP_n1 I1_I1896_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I172_XP_MN0 (I1_I1896_P21_6n I1_I1896_P21_14 XI1_I1896_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I19_MN1 (XI1_I1942_I19_n1 I1_b30_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I19_MN0 (I1_I1942_gn19 I1_p29_18 XI1_I1942_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I118_XP_MN1 (XI1_I1942_I118_XP_n1 I1_I1942_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I118_XP_MN0 (I1_I1942_P22_19n I1_I1942_P22_21 XI1_I1942_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I173_XP_MN1 (XI1_I1942_I173_XP_n1 I1_I1942_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I173_XP_MN0 (I1_I1942_P22_7n I1_I1942_P22_15 XI1_I1942_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2040_MN1 (XI1_I2040_n1 I1_p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2040_MN0 (I1_dmn19 I1_dd19_b3_5 XI1_I2040_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2038_MN1 (XI1_I2038_n1 I1_p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2038_MN0 (I1_dmn18 I1_dd18_b3_5 XI1_I2038_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I20_MN1 (XI1_I1988_I20_n1 I1_b31_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I20_MN0 (I1_I1988_gn20 I1_p30_19 XI1_I1988_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I119_XP_MN1 (XI1_I1988_I119_XP_n1 I1_I1988_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I119_XP_MN0 (I1_I1988_P23_20n I1_I1988_P23_22 XI1_I1988_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I174_XP_MN1 (XI1_I1988_I174_XP_n1 I1_I1988_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I174_XP_MN0 (I1_I1988_P23_8n I1_I1988_P23_16 XI1_I1988_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I118_XP_MN1 (XI1_I1988_I118_XP_n1 I1_I1988_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I118_XP_MN0 (I1_I1988_P22_19n I1_I1988_P22_21 XI1_I1988_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I173_XP_MN1 (XI1_I1988_I173_XP_n1 I1_I1988_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I173_XP_MN0 (I1_I1988_P22_7n I1_I1988_P22_15 XI1_I1988_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I18_MN1 (XI1_I2066_I18_n1 I1_dm18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I18_MN0 (I1_I2066_gn18 I1_p31_18 XI1_I2066_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I171_XP_MN1 (XI1_I2066_I171_XP_n1 I1_I2066_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I171_XP_MN0 (I1_I2066_P20_5n I1_I2066_P20_13 XI1_I2066_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I115_XP_MN1 (XI1_I2066_I115_XP_n1 I1_I2066_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I115_XP_MN0 (I1_I2066_P19_16n I1_I2066_P19_18 XI1_I2066_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I113_XP_MN1 (XI1_I2066_I113_XP_n1 I1_I2066_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I113_XP_MN0 (I1_I2066_P17_14n I1_I2066_P17_16 XI1_I2066_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I503_MN1 (XI2_I3_I503_n1 DIVR_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I503_MN0 (I2_I3_hd44 I2_I3_SEL_DIV_b3_7 XI2_I3_I503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I497_MN1 (XI2_I3_I497_n1 DIVR_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I497_MN0 (I2_I3_hd42 I2_I3_SEL_DIV_b3_7 XI2_I3_I497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I500_MN1 (XI2_I3_I500_n1 DIVR_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I500_MN0 (I2_I3_hd43 I2_I3_SEL_DIV_b3_7 XI2_I3_I500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I498_MN1 (XI2_I3_I498_n1 I2_I3_hd42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I498_MN0 (Y_42 I2_I3_hm42 XI2_I3_I498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I504_MN1 (XI2_I3_I504_n1 I2_I3_hd44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I504_MN0 (Y_44 I2_I3_hm44 XI2_I3_I504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I499_MN1 (XI2_I3_I499_n1 MULP_43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I499_MN0 (I2_I3_hm43 I2_I3_SEL_MUL_b3_7 XI2_I3_I499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I496_MN1 (XI2_I3_I496_n1 MULP_42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I496_MN0 (I2_I3_hm42 I2_I3_SEL_MUL_b3_7 XI2_I3_I496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I341_XP_MN1 (XI0_I1660_I341_XP_n1 I0_I1660_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I341_XP_MN0 (I0_I1660_P30_15n I0_I1660_P30_23 XI0_I1660_I341_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I349_XP_MN1 (XI0_I1660_I349_XP_n1 I0_I1660_P30_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I349_XP_MN0 (I0_I1660_P38_23n I0_I1660_P38_31 XI0_I1660_I349_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I361_XP_MN1 (XI0_I1660_I361_XP_n1 I0_I1660_P42_35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I361_XP_MN0 (I0_I1660_P50_35n I0_I1660_P50_43 XI0_I1660_I361_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I371_XP_MN1 (XI0_I1660_I371_XP_n1 I0_I1660_P52_45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I371_XP_MN0 (I0_I1660_P60_45n I0_I1660_P60_53 XI0_I1660_I371_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I240_XP_MN1 (XI0_I1660_I240_XP_n1 I0_I1660_P46_45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I240_XP_MN0 (I0_I1660_P48_45n I0_I1660_P48_47 XI0_I1660_I240_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I238_XP_MN1 (XI0_I1660_I238_XP_n1 I0_I1660_P44_43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I238_XP_MN0 (I0_I1660_P46_43n I0_I1660_P46_45 XI0_I1660_I238_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I372_XP_MN1 (XI0_I1660_I372_XP_n1 I0_I1660_P53_46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I372_XP_MN0 (I0_I1660_P61_46n I0_I1660_P61_54 XI0_I1660_I372_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I243_XP_MN1 (XI0_I1660_I243_XP_n1 I0_I1660_P49_48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I243_XP_MN0 (I0_I1660_P51_48n I0_I1660_P51_50 XI0_I1660_I243_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I48_MN1 (XI0_I1660_I48_n1 I0_ha292_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I48_MN0 (I0_I1660_gn48 I0_fa291_1 XI0_I1660_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I178_XP_MN1 (XI1_I1850_I178_XP_n1 I1_I1850_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I178_XP_MN0 (I1_I1850_P27_12n I1_I1850_P27_20 XI1_I1850_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I119_XP_MN1 (XI1_I1850_I119_XP_n1 I1_I1850_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I119_XP_MN0 (I1_I1850_P23_20n I1_I1850_P23_22 XI1_I1850_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I180_XP_MN1 (XI1_I1850_I180_XP_n1 I1_I1850_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I180_XP_MN0 (I1_I1850_P29_14n I1_I1850_P29_22 XI1_I1850_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I20_MN1 (XI1_I1850_I20_n1 I1_b28_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I20_MN0 (I1_I1850_gn20 I1_p27_19 XI1_I1850_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I116_XP_MN1 (XI1_I1850_I116_XP_n1 I1_I1850_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I116_XP_MN0 (I1_I1850_P20_17n I1_I1850_P20_19 XI1_I1850_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I171_XP_MN1 (XI1_I1850_I171_XP_n1 I1_I1850_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I171_XP_MN0 (I1_I1850_P20_5n I1_I1850_P20_13 XI1_I1850_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I175_XP_MN1 (XI1_I1850_I175_XP_n1 I1_I1850_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I175_XP_MN0 (I1_I1850_P24_9n I1_I1850_P24_17 XI1_I1850_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I19_MN1 (XI1_I1896_I19_n1 I1_b29_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I19_MN0 (I1_I1896_gn19 I1_p28_18 XI1_I1896_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I117_XP_MN1 (XI1_I1896_I117_XP_n1 I1_I1896_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I117_XP_MN0 (I1_I1896_P21_18n I1_I1896_P21_20 XI1_I1896_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I176_XP_MN1 (XI1_I1896_I176_XP_n1 I1_I1896_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I176_XP_MN0 (I1_I1896_P25_10n I1_I1896_P25_18 XI1_I1896_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I178_XP_MN1 (XI1_I1896_I178_XP_n1 I1_I1896_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I178_XP_MN0 (I1_I1896_P27_12n I1_I1896_P27_20 XI1_I1896_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I116_XP_MN1 (XI1_I1896_I116_XP_n1 I1_I1896_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I116_XP_MN0 (I1_I1896_P20_17n I1_I1896_P20_19 XI1_I1896_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I177_XP_MN1 (XI1_I1896_I177_XP_n1 I1_I1896_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I177_XP_MN0 (I1_I1896_P26_11n I1_I1896_P26_19 XI1_I1896_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I175_XP_MN1 (XI1_I1896_I175_XP_n1 I1_I1896_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I175_XP_MN0 (I1_I1896_P24_9n I1_I1896_P24_17 XI1_I1896_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I21_MN1 (XI1_I1942_I21_n1 I1_b30_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I21_MN0 (I1_I1942_gn21 I1_p29_20 XI1_I1942_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I20_MN1 (XI1_I1942_I20_n1 I1_b30_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I20_MN0 (I1_I1942_gn20 I1_p29_19 XI1_I1942_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I119_XP_MN1 (XI1_I1942_I119_XP_n1 I1_I1942_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I119_XP_MN0 (I1_I1942_P23_20n I1_I1942_P23_22 XI1_I1942_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I174_XP_MN1 (XI1_I1942_I174_XP_n1 I1_I1942_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I174_XP_MN0 (I1_I1942_P23_8n I1_I1942_P23_16 XI1_I1942_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I120_XP_MN1 (XI1_I1942_I120_XP_n1 I1_I1942_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I120_XP_MN0 (I1_I1942_P24_21n I1_I1942_P24_23 XI1_I1942_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I179_XP_MN1 (XI1_I1942_I179_XP_n1 I1_I1942_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I179_XP_MN0 (I1_I1942_P28_13n I1_I1942_P28_21 XI1_I1942_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I21_MN1 (XI1_I1988_I21_n1 I1_b31_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I21_MN0 (I1_I1988_gn21 I1_p30_20 XI1_I1988_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I180_XP_MN1 (XI1_I1988_I180_XP_n1 I1_I1988_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I180_XP_MN0 (I1_I1988_P29_14n I1_I1988_P29_22 XI1_I1988_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I120_XP_MN1 (XI1_I1988_I120_XP_n1 I1_I1988_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I120_XP_MN0 (I1_I1988_P24_21n I1_I1988_P24_23 XI1_I1988_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I179_XP_MN1 (XI1_I1988_I179_XP_n1 I1_I1988_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I179_XP_MN0 (I1_I1988_P28_13n I1_I1988_P28_21 XI1_I1988_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I20_MN1 (XI1_I2066_I20_n1 I1_dm20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I20_MN0 (I1_I2066_gn20 I1_p31_20 XI1_I2066_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I19_MN1 (XI1_I2066_I19_n1 I1_dm19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I19_MN0 (I1_I2066_gn19 I1_p31_19 XI1_I2066_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I116_XP_MN1 (XI1_I2066_I116_XP_n1 I1_I2066_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I116_XP_MN0 (I1_I2066_P20_17n I1_I2066_P20_19 XI1_I2066_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I179_XP_MN1 (XI1_I2066_I179_XP_n1 I1_I2066_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I179_XP_MN0 (I1_I2066_P28_13n I1_I2066_P28_21 XI1_I2066_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I117_XP_MN1 (XI1_I2066_I117_XP_n1 I1_I2066_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I117_XP_MN0 (I1_I2066_P21_18n I1_I2066_P21_20 XI1_I2066_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I170_XP_MN1 (XI1_I2066_I170_XP_n1 I1_I2066_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I170_XP_MN0 (I1_I2066_P19_4n I1_I2066_P19_12 XI1_I2066_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I506_MN1 (XI2_I3_I506_n1 DIVR_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I506_MN0 (I2_I3_hd45 I2_I3_SEL_DIV_b3_7 XI2_I3_I506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I507_MN1 (XI2_I3_I507_n1 I2_I3_hd45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I507_MN0 (Y_45 I2_I3_hm45 XI2_I3_I507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I510_MN1 (XI2_I3_I510_n1 I2_I3_hd46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I510_MN0 (Y_46 I2_I3_hm46 XI2_I3_I510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I505_MN1 (XI2_I3_I505_n1 MULP_45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I505_MN0 (I2_I3_hm45 I2_I3_SEL_MUL_b3_7 XI2_I3_I505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I508_MN1 (XI2_I3_I508_n1 MULP_46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I508_MN0 (I2_I3_hm46 I2_I3_SEL_MUL_b3_7 XI2_I3_I508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I357_XP_MN1 (XI0_I1660_I357_XP_n1 I0_I1660_P38_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I357_XP_MN0 (I0_I1660_P46_31n I0_I1660_P46_39 XI0_I1660_I357_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I369_XP_MN1 (XI0_I1660_I369_XP_n1 I0_I1660_P50_43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I369_XP_MN0 (I0_I1660_P58_43n I0_I1660_P58_51 XI0_I1660_I369_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I244_XP_MN1 (XI0_I1660_I244_XP_n1 I0_I1660_P50_49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I244_XP_MN0 (I0_I1660_P52_49n I0_I1660_P52_51 XI0_I1660_I244_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I242_XP_MN1 (XI0_I1660_I242_XP_n1 I0_I1660_P48_47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I242_XP_MN0 (I0_I1660_P50_47n I0_I1660_P50_49 XI0_I1660_I242_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I245_XP_MN1 (XI0_I1660_I245_XP_n1 I0_I1660_P51_50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I245_XP_MN0 (I0_I1660_P53_50n I0_I1660_P53_52 XI0_I1660_I245_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I123_XP_MN1 (XI1_I1850_I123_XP_n1 I1_I1850_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I123_XP_MN0 (I1_I1850_P27_24n I1_I1850_P27_26 XI1_I1850_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I121_XP_MN1 (XI1_I1850_I121_XP_n1 I1_I1850_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I121_XP_MN0 (I1_I1850_P25_22n I1_I1850_P25_24 XI1_I1850_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I21_MN1 (XI1_I1850_I21_n1 I1_b28_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I21_MN0 (I1_I1850_gn21 I1_p27_20 XI1_I1850_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I22_MN1 (XI1_I1850_I22_n1 I1_b28_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I22_MN0 (I1_I1850_gn22 I1_p27_21 XI1_I1850_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I118_XP_MN1 (XI1_I1850_I118_XP_n1 I1_I1850_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I118_XP_MN0 (I1_I1850_P22_19n I1_I1850_P22_21 XI1_I1850_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I173_XP_MN1 (XI1_I1850_I173_XP_n1 I1_I1850_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I173_XP_MN0 (I1_I1850_P22_7n I1_I1850_P22_15 XI1_I1850_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I21_MN1 (XI1_I1896_I21_n1 I1_b29_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I21_MN0 (I1_I1896_gn21 I1_p28_20 XI1_I1896_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I20_MN1 (XI1_I1896_I20_n1 I1_b29_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I20_MN0 (I1_I1896_gn20 I1_p28_19 XI1_I1896_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I119_XP_MN1 (XI1_I1896_I119_XP_n1 I1_I1896_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I119_XP_MN0 (I1_I1896_P23_20n I1_I1896_P23_22 XI1_I1896_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I174_XP_MN1 (XI1_I1896_I174_XP_n1 I1_I1896_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I174_XP_MN0 (I1_I1896_P23_8n I1_I1896_P23_16 XI1_I1896_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I118_XP_MN1 (XI1_I1896_I118_XP_n1 I1_I1896_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I118_XP_MN0 (I1_I1896_P22_19n I1_I1896_P22_21 XI1_I1896_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I173_XP_MN1 (XI1_I1896_I173_XP_n1 I1_I1896_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I173_XP_MN0 (I1_I1896_P22_7n I1_I1896_P22_15 XI1_I1896_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I22_MN1 (XI1_I1942_I22_n1 I1_b30_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I22_MN0 (I1_I1942_gn22 I1_p29_21 XI1_I1942_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I23_MN1 (XI1_I1942_I23_n1 I1_b30_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I23_MN0 (I1_I1942_gn23 I1_p29_22 XI1_I1942_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I121_XP_MN1 (XI1_I1942_I121_XP_n1 I1_I1942_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I121_XP_MN0 (I1_I1942_P25_22n I1_I1942_P25_24 XI1_I1942_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I180_XP_MN1 (XI1_I1942_I180_XP_n1 I1_I1942_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I180_XP_MN0 (I1_I1942_P29_14n I1_I1942_P29_22 XI1_I1942_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I181_XP_MN1 (XI1_I1942_I181_XP_n1 I1_I1942_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I181_XP_MN0 (I1_I1942_P30_15n I1_I1942_P30_23 XI1_I1942_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I23_MN1 (XI1_I1988_I23_n1 I1_b31_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I23_MN0 (I1_I1988_gn23 I1_p30_22 XI1_I1988_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2046_MN1 (XI1_I2046_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2046_MN0 (I1_dmn22 I1_dd22_b3_5 XI1_I2046_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2044_MN1 (XI1_I2044_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2044_MN0 (I1_dmn21 I1_dd21_b3_5 XI1_I2044_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I121_XP_MN1 (XI1_I1988_I121_XP_n1 I1_I1988_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I121_XP_MN0 (I1_I1988_P25_22n I1_I1988_P25_24 XI1_I1988_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I182_XP_MN1 (XI1_I1988_I182_XP_n1 I1_I1988_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I182_XP_MN0 (I1_I1988_P31_16n I1_I1988_P31_24 XI1_I1988_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I122_XP_MN1 (XI1_I1988_I122_XP_n1 I1_I1988_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I122_XP_MN0 (I1_I1988_P26_23n I1_I1988_P26_25 XI1_I1988_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I181_XP_MN1 (XI1_I1988_I181_XP_n1 I1_I1988_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I181_XP_MN0 (I1_I1988_P30_15n I1_I1988_P30_23 XI1_I1988_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I21_MN1 (XI1_I2066_I21_n1 I1_dm21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I21_MN0 (I1_I2066_gn21 I1_p31_21 XI1_I2066_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I118_XP_MN1 (XI1_I2066_I118_XP_n1 I1_I2066_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I118_XP_MN0 (I1_I2066_P22_19n I1_I2066_P22_21 XI1_I2066_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I120_XP_MN1 (XI1_I2066_I120_XP_n1 I1_I2066_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I120_XP_MN0 (I1_I2066_P24_21n I1_I2066_P24_23 XI1_I2066_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I177_XP_MN1 (XI1_I2066_I177_XP_n1 I1_I2066_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I177_XP_MN0 (I1_I2066_P26_11n I1_I2066_P26_19 XI1_I2066_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I172_XP_MN1 (XI1_I2066_I172_XP_n1 I1_I2066_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I172_XP_MN0 (I1_I2066_P21_6n I1_I2066_P21_14 XI1_I2066_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I524_MN1 (XI2_I3_I524_n1 DIVR_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I524_MN0 (I2_I3_hd51 I2_I3_SEL_DIV_b3_8 XI2_I3_I524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I518_MN1 (XI2_I3_I518_n1 DIVR_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I518_MN0 (I2_I3_hd49 I2_I3_SEL_DIV_b3_8 XI2_I3_I518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I521_MN1 (XI2_I3_I521_n1 DIVR_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I521_MN0 (I2_I3_hd50 I2_I3_SEL_DIV_b3_8 XI2_I3_I521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I42_MN1 (XI2_I4_I42_n1 I2_I4_z0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I42_MN0 (I2_I4_z1_10 I2_I4_z0_20 XI2_I4_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I522_MN1 (XI2_I3_I522_n1 I2_I3_hd50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I522_MN0 (Y_50 I2_I3_hm50 XI2_I3_I522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I523_MN1 (XI2_I3_I523_n1 MULP_51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I523_MN0 (I2_I3_hm51 I2_I3_SEL_MUL_b3_8 XI2_I3_I523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I520_MN1 (XI2_I3_I520_n1 MULP_50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I520_MN0 (I2_I3_hm50 I2_I3_SEL_MUL_b3_8 XI2_I3_I520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I365_XP_MN1 (XI0_I1660_I365_XP_n1 I0_I1660_P46_39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I365_XP_MN0 (I0_I1660_P54_39n I0_I1660_P54_47 XI0_I1660_I365_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I58_MN1 (XI0_I1660_I58_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I58_MN0 (I0_I1660_gn58 I0_fa298_0 XI0_I1660_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I253_XP_MN1 (XI0_I1660_I253_XP_n1 I0_I1660_P59_58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I253_XP_MN0 (I0_I1660_P61_58n I0_I1660_P61_60 XI0_I1660_I253_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I251_XP_MN1 (XI0_I1660_I251_XP_n1 I0_I1660_P57_56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I251_XP_MN0 (I0_I1660_P59_56n I0_I1660_P59_58 XI0_I1660_I251_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I249_XP_MN1 (XI0_I1660_I249_XP_n1 I0_I1660_P55_54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I249_XP_MN0 (I0_I1660_P57_54n I0_I1660_P57_56 XI0_I1660_I249_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I247_XP_MN1 (XI0_I1660_I247_XP_n1 I0_I1660_P53_52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I247_XP_MN0 (I0_I1660_P55_52n I0_I1660_P55_54 XI0_I1660_I247_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I49_MN1 (XI0_I1660_I49_n1 I0_fa293_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I49_MN0 (I0_I1660_gn49 I0_ha292_1 XI0_I1660_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I127_XP_MN1 (XI1_I1850_I127_XP_n1 I1_I1850_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I127_XP_MN0 (I1_I1850_P31_28n I1_I1850_P31_30 XI1_I1850_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I125_XP_MN1 (XI1_I1850_I125_XP_n1 I1_I1850_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I125_XP_MN0 (I1_I1850_P29_26n I1_I1850_P29_28 XI1_I1850_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I23_MN1 (XI1_I1850_I23_n1 I1_b28_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I23_MN0 (I1_I1850_gn23 I1_p27_22 XI1_I1850_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I120_XP_MN1 (XI1_I1850_I120_XP_n1 I1_I1850_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I120_XP_MN0 (I1_I1850_P24_21n I1_I1850_P24_23 XI1_I1850_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I177_XP_MN1 (XI1_I1850_I177_XP_n1 I1_I1850_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I177_XP_MN0 (I1_I1850_P26_11n I1_I1850_P26_19 XI1_I1850_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I22_MN1 (XI1_I1896_I22_n1 I1_b29_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I22_MN0 (I1_I1896_gn22 I1_p28_21 XI1_I1896_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I121_XP_MN1 (XI1_I1896_I121_XP_n1 I1_I1896_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I121_XP_MN0 (I1_I1896_P25_22n I1_I1896_P25_24 XI1_I1896_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I180_XP_MN1 (XI1_I1896_I180_XP_n1 I1_I1896_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I180_XP_MN0 (I1_I1896_P29_14n I1_I1896_P29_22 XI1_I1896_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I120_XP_MN1 (XI1_I1896_I120_XP_n1 I1_I1896_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I120_XP_MN0 (I1_I1896_P24_21n I1_I1896_P24_23 XI1_I1896_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I179_XP_MN1 (XI1_I1896_I179_XP_n1 I1_I1896_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I179_XP_MN0 (I1_I1896_P28_13n I1_I1896_P28_21 XI1_I1896_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I24_MN1 (XI1_I1942_I24_n1 I1_b30_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I24_MN0 (I1_I1942_gn24 I1_p29_23 XI1_I1942_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I123_XP_MN1 (XI1_I1942_I123_XP_n1 I1_I1942_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I123_XP_MN0 (I1_I1942_P27_24n I1_I1942_P27_26 XI1_I1942_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I182_XP_MN1 (XI1_I1942_I182_XP_n1 I1_I1942_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I182_XP_MN0 (I1_I1942_P31_16n I1_I1942_P31_24 XI1_I1942_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I122_XP_MN1 (XI1_I1942_I122_XP_n1 I1_I1942_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I122_XP_MN0 (I1_I1942_P26_23n I1_I1942_P26_25 XI1_I1942_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I24_MN1 (XI1_I1988_I24_n1 I1_b31_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I24_MN0 (I1_I1988_gn24 I1_p30_23 XI1_I1988_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I25_MN1 (XI1_I1988_I25_n1 I1_b31_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I25_MN0 (I1_I1988_gn25 I1_p30_24 XI1_I1988_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2048_MN1 (XI1_I2048_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2048_MN0 (I1_dmn23 I1_dd23_b3_5 XI1_I2048_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I123_XP_MN1 (XI1_I1988_I123_XP_n1 I1_I1988_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I123_XP_MN0 (I1_I1988_P27_24n I1_I1988_P27_26 XI1_I1988_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I124_XP_MN1 (XI1_I1988_I124_XP_n1 I1_I1988_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I124_XP_MN0 (I1_I1988_P28_25n I1_I1988_P28_27 XI1_I1988_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I23_MN1 (XI1_I2066_I23_n1 I1_dm23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I23_MN0 (I1_I2066_gn23 I1_p31_23 XI1_I2066_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I22_MN1 (XI1_I2066_I22_n1 I1_dm22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I22_MN0 (I1_I2066_gn22 I1_p31_22 XI1_I2066_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I173_XP_MN1 (XI1_I2066_I173_XP_n1 I1_I2066_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I173_XP_MN0 (I1_I2066_P22_7n I1_I2066_P22_15 XI1_I2066_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I119_XP_MN1 (XI1_I2066_I119_XP_n1 I1_I2066_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I119_XP_MN0 (I1_I2066_P23_20n I1_I2066_P23_22 XI1_I2066_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I178_XP_MN1 (XI1_I2066_I178_XP_n1 I1_I2066_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I178_XP_MN0 (I1_I2066_P27_12n I1_I2066_P27_20 XI1_I2066_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I174_XP_MN1 (XI1_I2066_I174_XP_n1 I1_I2066_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I174_XP_MN0 (I1_I2066_P23_8n I1_I2066_P23_16 XI1_I2066_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I530_MN1 (XI2_I3_I530_n1 DIVR_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I530_MN0 (I2_I3_hd53 I2_I3_SEL_DIV_b3_9 XI2_I3_I530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I515_MN1 (XI2_I3_I515_n1 DIVR_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I515_MN0 (I2_I3_hd48 I2_I3_SEL_DIV_b3_8 XI2_I3_I515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I512_MN1 (XI2_I3_I512_n1 DIVR_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I512_MN0 (I2_I3_hd47 I2_I3_SEL_DIV_b3_8 XI2_I3_I512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I513_MN1 (XI2_I3_I513_n1 I2_I3_hd47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I513_MN0 (Y_47 I2_I3_hm47 XI2_I3_I513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I516_MN1 (XI2_I3_I516_n1 I2_I3_hd48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I516_MN0 (Y_48 I2_I3_hm48 XI2_I3_I516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I528_MN1 (XI2_I3_I528_n1 I2_I3_hd52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I528_MN0 (Y_52 I2_I3_hm52 XI2_I3_I528_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I529_MN1 (XI2_I3_I529_n1 MULP_53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I529_MN0 (I2_I3_hm53 I2_I3_SEL_MUL_b3_9 XI2_I3_I529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I526_MN1 (XI2_I3_I526_n1 MULP_52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I526_MN0 (I2_I3_hm52 I2_I3_SEL_MUL_b3_8 XI2_I3_I526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I246_XP_MN1 (XI0_I1660_I246_XP_n1 I0_I1660_P52_51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I246_XP_MN0 (I0_I1660_P54_51n I0_I1660_P54_53 XI0_I1660_I246_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I248_XP_MN1 (XI0_I1660_I248_XP_n1 I0_I1660_P54_53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I248_XP_MN0 (I0_I1660_P56_53n I0_I1660_P56_55 XI0_I1660_I248_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I255_XP_MN1 (XI0_I1660_I255_XP_n1 I0_I1660_P61_60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I255_XP_MN0 (I0_I1660_P63_60n I0_I1660_P63_62 XI0_I1660_I255_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I50_MN1 (XI0_I1660_I50_n1 I0_ha294_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I50_MN0 (I0_I1660_gn50 I0_fa293_1 XI0_I1660_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I31_MN1 (XI1_I1850_I31_n1 I1_b28_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I31_MN0 (I1_I1850_gn31 I1_p27_30 XI1_I1850_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I30_MN1 (XI1_I1850_I30_n1 I1_b28_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I30_MN0 (I1_I1850_gn30 I1_p27_29 XI1_I1850_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I25_MN1 (XI1_I1850_I25_n1 I1_b28_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I25_MN0 (I1_I1850_gn25 I1_p27_24 XI1_I1850_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I24_MN1 (XI1_I1850_I24_n1 I1_b28_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I24_MN0 (I1_I1850_gn24 I1_p27_23 XI1_I1850_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I124_XP_MN1 (XI1_I1850_I124_XP_n1 I1_I1850_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I124_XP_MN0 (I1_I1850_P28_25n I1_I1850_P28_27 XI1_I1850_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I122_XP_MN1 (XI1_I1850_I122_XP_n1 I1_I1850_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I122_XP_MN0 (I1_I1850_P26_23n I1_I1850_P26_25 XI1_I1850_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I179_XP_MN1 (XI1_I1850_I179_XP_n1 I1_I1850_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I179_XP_MN0 (I1_I1850_P28_13n I1_I1850_P28_21 XI1_I1850_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I24_MN1 (XI1_I1896_I24_n1 I1_b29_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I24_MN0 (I1_I1896_gn24 I1_p28_23 XI1_I1896_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I25_MN1 (XI1_I1896_I25_n1 I1_b29_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I25_MN0 (I1_I1896_gn25 I1_p28_24 XI1_I1896_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I23_MN1 (XI1_I1896_I23_n1 I1_b29_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I23_MN0 (I1_I1896_gn23 I1_p28_22 XI1_I1896_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I123_XP_MN1 (XI1_I1896_I123_XP_n1 I1_I1896_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I123_XP_MN0 (I1_I1896_P27_24n I1_I1896_P27_26 XI1_I1896_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I182_XP_MN1 (XI1_I1896_I182_XP_n1 I1_I1896_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I182_XP_MN0 (I1_I1896_P31_16n I1_I1896_P31_24 XI1_I1896_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I122_XP_MN1 (XI1_I1896_I122_XP_n1 I1_I1896_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I122_XP_MN0 (I1_I1896_P26_23n I1_I1896_P26_25 XI1_I1896_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I181_XP_MN1 (XI1_I1896_I181_XP_n1 I1_I1896_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I181_XP_MN0 (I1_I1896_P30_15n I1_I1896_P30_23 XI1_I1896_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I25_MN1 (XI1_I1942_I25_n1 I1_b30_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I25_MN0 (I1_I1942_gn25 I1_p29_24 XI1_I1942_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I26_MN1 (XI1_I1942_I26_n1 I1_b30_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I26_MN0 (I1_I1942_gn26 I1_p29_25 XI1_I1942_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I124_XP_MN1 (XI1_I1942_I124_XP_n1 I1_I1942_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I124_XP_MN0 (I1_I1942_P28_25n I1_I1942_P28_27 XI1_I1942_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I126_XP_MN1 (XI1_I1942_I126_XP_n1 I1_I1942_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I126_XP_MN0 (I1_I1942_P30_27n I1_I1942_P30_29 XI1_I1942_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I26_MN1 (XI1_I1988_I26_n1 I1_b31_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I26_MN0 (I1_I1988_gn26 I1_p30_25 XI1_I1988_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2052_MN1 (XI1_I2052_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2052_MN0 (I1_dmn25 I1_dd25_b3_5 XI1_I2052_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2050_MN1 (XI1_I2050_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2050_MN0 (I1_dmn24 I1_dd24_b3_5 XI1_I2050_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2054_MN1 (XI1_I2054_n1 I1_p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2054_MN0 (I1_dmn26 I1_dd26_b3_5 XI1_I2054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I125_XP_MN1 (XI1_I1988_I125_XP_n1 I1_I1988_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I125_XP_MN0 (I1_I1988_P29_26n I1_I1988_P29_28 XI1_I1988_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I127_XP_MN1 (XI1_I1988_I127_XP_n1 I1_I1988_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I127_XP_MN0 (I1_I1988_P31_28n I1_I1988_P31_30 XI1_I1988_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I126_XP_MN1 (XI1_I1988_I126_XP_n1 I1_I1988_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I126_XP_MN0 (I1_I1988_P30_27n I1_I1988_P30_29 XI1_I1988_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I24_MN1 (XI1_I2066_I24_n1 I1_dm24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I24_MN0 (I1_I2066_gn24 I1_p31_24 XI1_I2066_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I25_MN1 (XI1_I2066_I25_n1 I1_dm25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I25_MN0 (I1_I2066_gn25 I1_p31_25 XI1_I2066_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I122_XP_MN1 (XI1_I2066_I122_XP_n1 I1_I2066_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I122_XP_MN0 (I1_I2066_P26_23n I1_I2066_P26_25 XI1_I2066_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I124_XP_MN1 (XI1_I2066_I124_XP_n1 I1_I2066_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I124_XP_MN0 (I1_I2066_P28_25n I1_I2066_P28_27 XI1_I2066_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I181_XP_MN1 (XI1_I2066_I181_XP_n1 I1_I2066_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I181_XP_MN0 (I1_I2066_P30_15n I1_I2066_P30_23 XI1_I2066_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I121_XP_MN1 (XI1_I2066_I121_XP_n1 I1_I2066_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I121_XP_MN0 (I1_I2066_P25_22n I1_I2066_P25_24 XI1_I2066_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I180_XP_MN1 (XI1_I2066_I180_XP_n1 I1_I2066_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I180_XP_MN0 (I1_I2066_P29_14n I1_I2066_P29_22 XI1_I2066_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I182_XP_MN1 (XI1_I2066_I182_XP_n1 I1_I2066_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I182_XP_MN0 (I1_I2066_P31_16n I1_I2066_P31_24 XI1_I2066_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I536_MN1 (XI2_I3_I536_n1 DIVR_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I536_MN0 (I2_I3_hd55 I2_I3_SEL_DIV_b3_9 XI2_I3_I536_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I539_MN1 (XI2_I3_I539_n1 DIVR_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I539_MN0 (I2_I3_hd56 I2_I3_SEL_DIV_b3_9 XI2_I3_I539_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I542_MN1 (XI2_I3_I542_n1 DIVR_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I542_MN0 (I2_I3_hd57 I2_I3_SEL_DIV_b3_9 XI2_I3_I542_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I43_MN1 (XI2_I4_I43_n1 I2_I4_z0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I43_MN0 (I2_I4_z1_11 I2_I4_z0_22 XI2_I4_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I531_MN1 (XI2_I3_I531_n1 I2_I3_hd53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I531_MN0 (Y_53 I2_I3_hm53 XI2_I3_I531_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I543_MN1 (XI2_I3_I543_n1 I2_I3_hd57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I543_MN0 (Y_57 I2_I3_hm57 XI2_I3_I543_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I540_MN1 (XI2_I3_I540_n1 I2_I3_hd56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I540_MN0 (Y_56 I2_I3_hm56 XI2_I3_I540_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I537_MN1 (XI2_I3_I537_n1 I2_I3_hd55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I537_MN0 (Y_55 I2_I3_hm55 XI2_I3_I537_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I535_MN1 (XI2_I3_I535_n1 MULP_55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I535_MN0 (I2_I3_hm55 I2_I3_SEL_MUL_b3_9 XI2_I3_I535_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I373_XP_MN1 (XI0_I1660_I373_XP_n1 I0_I1660_P54_47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I373_XP_MN0 (I0_I1660_P62_47n I0_I1660_P62_55 XI0_I1660_I373_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I252_XP_MN1 (XI0_I1660_I252_XP_n1 I0_I1660_P58_57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I252_XP_MN0 (I0_I1660_P60_57n I0_I1660_P60_59 XI0_I1660_I252_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I250_XP_MN1 (XI0_I1660_I250_XP_n1 I0_I1660_P56_55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I250_XP_MN0 (I0_I1660_P58_55n I0_I1660_P58_57 XI0_I1660_I250_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I56_MN1 (XI0_I1660_I56_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I56_MN0 (I0_I1660_gn56 I0_fa297_0 XI0_I1660_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I57_MN1 (XI0_I1660_I57_n1 I0_fa246_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I57_MN0 (I0_I1660_gn57 I0_fa297_1 XI0_I1660_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I59_MN1 (XI0_I1660_I59_n1 I0_fa207_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I59_MN0 (I0_I1660_gn59 I0_fa298_1 XI0_I1660_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I55_MN1 (XI0_I1660_I55_n1 I0_fa245_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I55_MN0 (I0_I1660_gn55 I0_fa296_1 XI0_I1660_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I29_MN1 (XI1_I1850_I29_n1 I1_b28_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I29_MN0 (I1_I1850_gn29 I1_p27_28 XI1_I1850_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I126_XP_MN1 (XI1_I1850_I126_XP_n1 I1_I1850_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I126_XP_MN0 (I1_I1850_P30_27n I1_I1850_P30_29 XI1_I1850_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I26_MN1 (XI1_I1850_I26_n1 I1_b28_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I26_MN0 (I1_I1850_gn26 I1_p27_25 XI1_I1850_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I181_XP_MN1 (XI1_I1850_I181_XP_n1 I1_I1850_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I181_XP_MN0 (I1_I1850_P30_15n I1_I1850_P30_23 XI1_I1850_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I26_MN1 (XI1_I1896_I26_n1 I1_b29_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I26_MN0 (I1_I1896_gn26 I1_p28_25 XI1_I1896_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I31_MN1 (XI1_I1896_I31_n1 I1_b29_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I31_MN0 (I1_I1896_gn31 I1_p28_30 XI1_I1896_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I125_XP_MN1 (XI1_I1896_I125_XP_n1 I1_I1896_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I125_XP_MN0 (I1_I1896_P29_26n I1_I1896_P29_28 XI1_I1896_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I124_XP_MN1 (XI1_I1896_I124_XP_n1 I1_I1896_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I124_XP_MN0 (I1_I1896_P28_25n I1_I1896_P28_27 XI1_I1896_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I27_MN1 (XI1_I1942_I27_n1 I1_b30_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I27_MN0 (I1_I1942_gn27 I1_p29_26 XI1_I1942_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I28_MN1 (XI1_I1942_I28_n1 I1_b30_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I28_MN0 (I1_I1942_gn28 I1_p29_27 XI1_I1942_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I27_MN1 (XI1_I1988_I27_n1 I1_b31_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I27_MN0 (I1_I1988_gn27 I1_p30_26 XI1_I1988_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I28_MN1 (XI1_I1988_I28_n1 I1_b31_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I28_MN0 (I1_I1988_gn28 I1_p30_27 XI1_I1988_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2056_MN1 (XI1_I2056_n1 I1_p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2056_MN0 (I1_dmn27 I1_dd27_b3_5 XI1_I2056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I28_MN1 (XI1_I2066_I28_n1 I1_dm28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I28_MN0 (I1_I2066_gn28 I1_p31_28 XI1_I2066_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I26_MN1 (XI1_I2066_I26_n1 I1_dm26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I26_MN0 (I1_I2066_gn26 I1_p31_26 XI1_I2066_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I27_MN1 (XI1_I2066_I27_n1 I1_dm27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I27_MN0 (I1_I2066_gn27 I1_p31_27 XI1_I2066_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I126_XP_MN1 (XI1_I2066_I126_XP_n1 I1_I2066_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I126_XP_MN0 (I1_I2066_P30_27n I1_I2066_P30_29 XI1_I2066_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I123_XP_MN1 (XI1_I2066_I123_XP_n1 I1_I2066_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I123_XP_MN0 (I1_I2066_P27_24n I1_I2066_P27_26 XI1_I2066_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I125_XP_MN1 (XI1_I2066_I125_XP_n1 I1_I2066_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I125_XP_MN0 (I1_I2066_P29_26n I1_I2066_P29_28 XI1_I2066_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I40_MN1 (XI2_I4_I40_n1 I2_I4_z0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I40_MN0 (I2_I4_z1_8 I2_I4_z0_16 XI2_I4_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I533_MN1 (XI2_I3_I533_n1 DIVR_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I533_MN0 (I2_I3_hd54 I2_I3_SEL_DIV_b3_9 XI2_I3_I533_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I545_MN1 (XI2_I3_I545_n1 DIVR_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I545_MN0 (I2_I3_hd58 I2_I3_SEL_DIV_b3_9 XI2_I3_I545_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I554_MN1 (XI2_I3_I554_n1 DIVR_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I554_MN0 (I2_I3_hd61 I2_I3_SEL_DIV_b3_10 XI2_I3_I554_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I58_MN1 (XI2_I4_I58_n1 I2_I4_z2_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I58_MN0 (I2_I4_z3_2 I2_I4_z2_4 XI2_I4_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I44_MN1 (XI2_I4_I44_n1 I2_I4_z0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I44_MN0 (I2_I4_z1_12 I2_I4_z0_24 XI2_I4_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I45_MN1 (XI2_I4_I45_n1 I2_I4_z0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I45_MN0 (I2_I4_z1_13 I2_I4_z0_26 XI2_I4_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I534_MN1 (XI2_I3_I534_n1 I2_I3_hd54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I534_MN0 (Y_54 I2_I3_hm54 XI2_I3_I534_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I546_MN1 (XI2_I3_I546_n1 I2_I3_hd58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I546_MN0 (Y_58 I2_I3_hm58 XI2_I3_I546_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I555_MN1 (XI2_I3_I555_n1 I2_I3_hd61 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I555_MN0 (Y_61 I2_I3_hm61 XI2_I3_I555_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I547_MN1 (XI2_I3_I547_n1 MULP_59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I547_MN0 (I2_I3_hm59 I2_I3_SEL_MUL_b3_10 XI2_I3_I547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I553_MN1 (XI2_I3_I553_n1 MULP_61 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I553_MN0 (I2_I3_hm61 I2_I3_SEL_MUL_b3_10 XI2_I3_I553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I254_XP_MN1 (XI0_I1660_I254_XP_n1 I0_I1660_P60_59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I254_XP_MN0 (I0_I1660_P62_59n I0_I1660_P62_61 XI0_I1660_I254_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I60_MN1 (XI0_I1660_I60_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I60_MN0 (I0_I1660_gn60 I0_fa247_0 XI0_I1660_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I54_MN1 (XI0_I1660_I54_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I54_MN0 (I0_I1660_gn54 I0_fa296_0 XI0_I1660_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I52_MN1 (XI0_I1660_I52_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I52_MN0 (I0_I1660_gn52 I0_fa295_0 XI0_I1660_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I51_MN1 (XI0_I1660_I51_n1 I0_fa243_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I51_MN0 (I0_I1660_gn51 I0_ha294_1 XI0_I1660_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I28_MN1 (XI1_I1850_I28_n1 I1_b28_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I28_MN0 (I1_I1850_gn28 I1_p27_27 XI1_I1850_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I27_MN1 (XI1_I1850_I27_n1 I1_b28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I27_MN0 (I1_I1850_gn27 I1_p27_26 XI1_I1850_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I27_MN1 (XI1_I1896_I27_n1 I1_b29_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I27_MN0 (I1_I1896_gn27 I1_p28_26 XI1_I1896_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I28_MN1 (XI1_I1896_I28_n1 I1_b29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I28_MN0 (I1_I1896_gn28 I1_p28_27 XI1_I1896_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I29_MN1 (XI1_I1896_I29_n1 I1_b29_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I29_MN0 (I1_I1896_gn29 I1_p28_28 XI1_I1896_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I30_MN1 (XI1_I1896_I30_n1 I1_b29_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I30_MN0 (I1_I1896_gn30 I1_p28_29 XI1_I1896_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I127_XP_MN1 (XI1_I1896_I127_XP_n1 I1_I1896_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I127_XP_MN0 (I1_I1896_P31_28n I1_I1896_P31_30 XI1_I1896_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I126_XP_MN1 (XI1_I1896_I126_XP_n1 I1_I1896_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I126_XP_MN0 (I1_I1896_P30_27n I1_I1896_P30_29 XI1_I1896_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I29_MN1 (XI1_I1942_I29_n1 I1_b30_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I29_MN0 (I1_I1942_gn29 I1_p29_28 XI1_I1942_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I31_MN1 (XI1_I1942_I31_n1 I1_b30_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I31_MN0 (I1_I1942_gn31 I1_p29_30 XI1_I1942_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I30_MN1 (XI1_I1942_I30_n1 I1_b30_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I30_MN0 (I1_I1942_gn30 I1_p29_29 XI1_I1942_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I29_MN1 (XI1_I1988_I29_n1 I1_b31_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I29_MN0 (I1_I1988_gn29 I1_p30_28 XI1_I1988_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I31_MN1 (XI1_I1988_I31_n1 I1_b31_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I31_MN0 (I1_I1988_gn31 I1_p30_30 XI1_I1988_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2058_MN1 (XI1_I2058_n1 I1_p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2058_MN0 (I1_dmn28 I1_dd28_b3_5 XI1_I2058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2060_MN1 (XI1_I2060_n1 I1_p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2060_MN0 (I1_dmn29 I1_dd29_b3_5 XI1_I2060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2064_MN1 (XI1_I2064_n1 I1_p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2064_MN0 (I1_dmn31 I1_dd31_b3_5 XI1_I2064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I30_MN1 (XI1_I2066_I30_n1 I1_dm30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I30_MN0 (I1_I2066_gn30 I1_p31_30 XI1_I2066_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I31_MN1 (XI1_I2066_I31_n1 I1_dm31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I31_MN0 (I1_I2066_gn31 I1_p31_31 XI1_I2066_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I29_MN1 (XI1_I2066_I29_n1 I1_dm29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I29_MN0 (I1_I2066_gn29 I1_p31_29 XI1_I2066_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I127_XP_MN1 (XI1_I2066_I127_XP_n1 I1_I2066_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I127_XP_MN0 (I1_I2066_P31_28n I1_I2066_P31_30 XI1_I2066_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I62_MN1 (XI2_I4_I62_n1 I2_I4_z4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I62_MN0 (I2_I4_z5_0 I2_I4_z4_0 XI2_I4_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I59_MN1 (XI2_I4_I59_n1 I2_I4_z2_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I59_MN0 (I2_I4_z3_3 I2_I4_z2_6 XI2_I4_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I46_MN1 (XI2_I4_I46_n1 I2_I4_z0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I46_MN0 (I2_I4_z1_14 I2_I4_z0_28 XI2_I4_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I549_MN1 (XI2_I3_I549_n1 I2_I3_hd59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I549_MN0 (Y_59 I2_I3_hm59 XI2_I3_I549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I558_MN1 (XI2_I3_I558_n1 I2_I3_hd62 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I558_MN0 (Y_62 I2_I3_hm62 XI2_I3_I558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I4_I47_MN1 (XI2_I4_I47_n1 I2_I4_z0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I4_I47_MN0 (I2_I4_z1_15 I2_I4_z0_30 XI2_I4_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I561_MN1 (XI2_I3_I561_n1 I2_I3_hd63 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I561_MN0 (Y_63 I2_I3_hm63 XI2_I3_I561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I552_MN1 (XI2_I3_I552_n1 I2_I3_hd60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I552_MN0 (Y_60 I2_I3_hm60 XI2_I3_I552_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I559_MN1 (XI2_I3_I559_n1 MULP_63 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I559_MN0 (I2_I3_hm63 I2_I3_SEL_MUL_b3_10 XI2_I3_I559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I550_MN1 (XI2_I3_I550_n1 MULP_60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I550_MN0 (I2_I3_hm60 I2_I3_SEL_MUL_b3_10 XI2_I3_I550_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI2_I3_I556_MN1 (XI2_I3_I556_n1 MULP_62 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI2_I3_I556_MN0 (I2_I3_hm62 I2_I3_SEL_MUL_b3_10 XI2_I3_I556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I62_MN1 (XI0_I1660_I62_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I62_MN0 (I0_I1660_gn62 I0_fa248_0 XI0_I1660_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I63_MN1 (XI0_I1660_I63_n1 I0_sn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I63_MN0 (I0_I1660_gn63 I0_fa248_1 XI0_I1660_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I53_MN1 (XI0_I1660_I53_n1 I0_fa244_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I53_MN0 (I0_I1660_gn53 I0_fa295_1 XI0_I1660_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I61_MN1 (XI0_I1660_I61_n1 I0_fa208_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I61_MN0 (I0_I1660_gn61 I0_fa247_1 XI0_I1660_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I97_XP_MN0 (I1_I1298_P31_30 I1_I1298_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I97_XP_MN1 (VSS I1_I1298_pn30 I1_I1298_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I95_XP_MN0 (I1_I1298_P29_28 I1_I1298_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I95_XP_MN1 (VSS I1_I1298_pn28 I1_I1298_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I96_XP_MN0 (I1_I1298_P30_29 I1_I1298_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I96_XP_MN1 (VSS I1_I1298_pn29 I1_I1298_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I94_XP_MN0 (I1_I1252_P28_27 I1_I1252_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I94_XP_MN1 (VSS I1_I1252_pn27 I1_I1252_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I96_XP_MN0 (I1_I1252_P30_29 I1_I1252_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I96_XP_MN1 (VSS I1_I1252_pn29 I1_I1252_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I97_XP_MN0 (I1_I1252_P31_30 I1_I1252_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I97_XP_MN1 (VSS I1_I1252_pn30 I1_I1252_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I95_XP_MN0 (I1_I1252_P29_28 I1_I1252_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I95_XP_MN1 (VSS I1_I1252_pn28 I1_I1252_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I95_XP_MN0 (I1_I1206_P29_28 I1_I1206_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I95_XP_MN1 (VSS I1_I1206_pn28 I1_I1206_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I94_XP_MN0 (I1_I1206_P28_27 I1_I1206_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I94_XP_MN1 (VSS I1_I1206_pn27 I1_I1206_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I97_XP_MN0 (I1_I838_P31_30 I1_I838_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I97_XP_MN1 (VSS I1_I838_pn30 I1_I838_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I156_XP_MN0 (I1_I838_P31_24 I1_I838_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I156_XP_MN1 (VSS I1_I838_P27_24n I1_I838_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I154_XP_MN0 (I1_I838_P29_22 I1_I838_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I154_XP_MN1 (VSS I1_I838_P25_22n I1_I838_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I152_XP_MN0 (I1_I838_P27_20 I1_I838_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I152_XP_MN1 (VSS I1_I838_P23_20n I1_I838_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I148_XP_MN0 (I1_I838_P23_16 I1_I838_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I148_XP_MN1 (VSS I1_I838_P19_16n I1_I838_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I144_XP_MN0 (I1_I838_P19_12 I1_I838_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I144_XP_MN1 (VSS I1_I838_P15_12n I1_I838_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I140_XP_MN0 (I1_I838_P15_8 I1_I838_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I140_XP_MN1 (VSS I1_I838_P11_8n I1_I838_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I136_XP_MN0 (I1_I838_P11_4 I1_I838_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I136_XP_MN1 (VSS I1_I838_P7_4n I1_I838_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I154_XP_MN0 (I1_I792_P29_22 I1_I792_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I154_XP_MN1 (VSS I1_I792_P25_22n I1_I792_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I152_XP_MN0 (I1_I792_P27_20 I1_I792_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I152_XP_MN1 (VSS I1_I792_P23_20n I1_I792_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I156_XP_MN0 (I1_I792_P31_24 I1_I792_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I156_XP_MN1 (VSS I1_I792_P27_24n I1_I792_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I95_XP_MN0 (I1_I792_P29_28 I1_I792_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I95_XP_MN1 (VSS I1_I792_pn28 I1_I792_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I97_XP_MN0 (I1_I792_P31_30 I1_I792_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I97_XP_MN1 (VSS I1_I792_pn30 I1_I792_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I155_XP_MN0 (I1_I792_P30_23 I1_I792_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I155_XP_MN1 (VSS I1_I792_P26_23n I1_I792_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I94_XP_MN0 (I1_I792_P28_27 I1_I792_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I94_XP_MN1 (VSS I1_I792_pn27 I1_I792_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I96_XP_MN0 (I1_I792_P30_29 I1_I792_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I96_XP_MN1 (VSS I1_I792_pn29 I1_I792_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I97_XP_MN0 (I1_I1344_P31_30 I1_I1344_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I97_XP_MN1 (VSS I1_I1344_pn30 I1_I1344_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I156_XP_MN0 (I1_I1344_P31_24 I1_I1344_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I156_XP_MN1 (VSS I1_I1344_P27_24n I1_I1344_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I152_XP_MN0 (I1_I1344_P27_20 I1_I1344_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I152_XP_MN1 (VSS I1_I1344_P23_20n I1_I1344_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I148_XP_MN0 (I1_I1344_P23_16 I1_I1344_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I148_XP_MN1 (VSS I1_I1344_P19_16n I1_I1344_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I156_XP_MN0 (I1_I1298_P31_24 I1_I1298_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I156_XP_MN1 (VSS I1_I1298_P27_24n I1_I1298_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I93_XP_MN0 (I1_I1298_P27_26 I1_I1298_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I93_XP_MN1 (VSS I1_I1298_pn26 I1_I1298_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I94_XP_MN0 (I1_I1298_P28_27 I1_I1298_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I94_XP_MN1 (VSS I1_I1298_pn27 I1_I1298_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I155_XP_MN0 (I1_I1252_P30_23 I1_I1252_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I155_XP_MN1 (VSS I1_I1252_P26_23n I1_I1252_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I92_XP_MN0 (I1_I1252_P26_25 I1_I1252_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I92_XP_MN1 (VSS I1_I1252_pn25 I1_I1252_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I93_XP_MN0 (I1_I1252_P27_26 I1_I1252_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I93_XP_MN1 (VSS I1_I1252_pn26 I1_I1252_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I97_XP_MN0 (I1_I1206_P31_30 I1_I1206_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I97_XP_MN1 (VSS I1_I1206_pn30 I1_I1206_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I96_XP_MN0 (I1_I1206_P30_29 I1_I1206_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I96_XP_MN1 (VSS I1_I1206_pn29 I1_I1206_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I93_XP_MN0 (I1_I1206_P27_26 I1_I1206_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I93_XP_MN1 (VSS I1_I1206_pn26 I1_I1206_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I93_XP_MN0 (I1_I838_P27_26 I1_I838_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I93_XP_MN1 (VSS I1_I838_pn26 I1_I838_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I91_XP_MN0 (I1_I838_P25_24 I1_I838_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I91_XP_MN1 (VSS I1_I838_pn24 I1_I838_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I89_XP_MN0 (I1_I838_P23_22 I1_I838_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I89_XP_MN1 (VSS I1_I838_pn22 I1_I838_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I87_XP_MN0 (I1_I838_P21_20 I1_I838_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I87_XP_MN1 (VSS I1_I838_pn20 I1_I838_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I150_XP_MN0 (I1_I838_P25_18 I1_I838_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I150_XP_MN1 (VSS I1_I838_P21_18n I1_I838_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I146_XP_MN0 (I1_I838_P21_14 I1_I838_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I146_XP_MN1 (VSS I1_I838_P17_14n I1_I838_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I142_XP_MN0 (I1_I838_P17_10 I1_I838_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I142_XP_MN1 (VSS I1_I838_P13_10n I1_I838_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I138_XP_MN0 (I1_I838_P13_6 I1_I838_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I138_XP_MN1 (VSS I1_I838_P9_6n I1_I838_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I134_XP_MN0 (I1_I838_P9_2 I1_I838_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I134_XP_MN1 (VSS I1_I838_P5_2n I1_I838_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I150_XP_MN0 (I1_I792_P25_18 I1_I792_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I150_XP_MN1 (VSS I1_I792_P21_18n I1_I792_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I148_XP_MN0 (I1_I792_P23_16 I1_I792_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I148_XP_MN1 (VSS I1_I792_P19_16n I1_I792_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I89_XP_MN0 (I1_I792_P23_22 I1_I792_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I89_XP_MN1 (VSS I1_I792_pn22 I1_I792_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I91_XP_MN0 (I1_I792_P25_24 I1_I792_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I91_XP_MN1 (VSS I1_I792_pn24 I1_I792_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I93_XP_MN0 (I1_I792_P27_26 I1_I792_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I93_XP_MN1 (VSS I1_I792_pn26 I1_I792_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I153_XP_MN0 (I1_I792_P28_21 I1_I792_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I153_XP_MN1 (VSS I1_I792_P24_21n I1_I792_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I90_XP_MN0 (I1_I792_P24_23 I1_I792_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I90_XP_MN1 (VSS I1_I792_pn23 I1_I792_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I92_XP_MN0 (I1_I792_P26_25 I1_I792_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I92_XP_MN1 (VSS I1_I792_pn25 I1_I792_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I95_XP_MN0 (I1_I1344_P29_28 I1_I1344_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I95_XP_MN1 (VSS I1_I1344_pn28 I1_I1344_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I94_XP_MN0 (I1_I1344_P28_27 I1_I1344_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I94_XP_MN1 (VSS I1_I1344_pn27 I1_I1344_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I96_XP_MN0 (I1_I1344_P30_29 I1_I1344_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I96_XP_MN1 (VSS I1_I1344_pn29 I1_I1344_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I154_XP_MN0 (I1_I1344_P29_22 I1_I1344_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I154_XP_MN1 (VSS I1_I1344_P25_22n I1_I1344_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I144_XP_MN0 (I1_I1344_P19_12 I1_I1344_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I144_XP_MN1 (VSS I1_I1344_P15_12n I1_I1344_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I140_XP_MN0 (I1_I1344_P15_8 I1_I1344_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I140_XP_MN1 (VSS I1_I1344_P11_8n I1_I1344_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I152_XP_MN0 (I1_I1298_P27_20 I1_I1298_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I152_XP_MN1 (VSS I1_I1298_P23_20n I1_I1298_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I154_XP_MN0 (I1_I1298_P29_22 I1_I1298_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I154_XP_MN1 (VSS I1_I1298_P25_22n I1_I1298_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I91_XP_MN0 (I1_I1298_P25_24 I1_I1298_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I91_XP_MN1 (VSS I1_I1298_pn24 I1_I1298_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I155_XP_MN0 (I1_I1298_P30_23 I1_I1298_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I155_XP_MN1 (VSS I1_I1298_P26_23n I1_I1298_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I92_XP_MN0 (I1_I1298_P26_25 I1_I1298_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I92_XP_MN1 (VSS I1_I1298_pn25 I1_I1298_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I90_XP_MN0 (I1_I1298_P24_23 I1_I1298_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I90_XP_MN1 (VSS I1_I1298_pn23 I1_I1298_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I153_XP_MN0 (I1_I1252_P28_21 I1_I1252_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I153_XP_MN1 (VSS I1_I1252_P24_21n I1_I1252_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I90_XP_MN0 (I1_I1252_P24_23 I1_I1252_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I90_XP_MN1 (VSS I1_I1252_pn23 I1_I1252_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I156_XP_MN0 (I1_I1252_P31_24 I1_I1252_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I156_XP_MN1 (VSS I1_I1252_P27_24n I1_I1252_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I91_XP_MN0 (I1_I1252_P25_24 I1_I1252_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I91_XP_MN1 (VSS I1_I1252_pn24 I1_I1252_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I156_XP_MN0 (I1_I1206_P31_24 I1_I1206_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I156_XP_MN1 (VSS I1_I1206_P27_24n I1_I1206_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I92_XP_MN0 (I1_I1206_P26_25 I1_I1206_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I92_XP_MN1 (VSS I1_I1206_pn25 I1_I1206_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I96_XP_MN0 (I1_I838_P30_29 I1_I838_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I96_XP_MN1 (VSS I1_I838_pn29 I1_I838_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I95_XP_MN0 (I1_I838_P29_28 I1_I838_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I95_XP_MN1 (VSS I1_I838_pn28 I1_I838_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I90_XP_MN0 (I1_I838_P24_23 I1_I838_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I90_XP_MN1 (VSS I1_I838_pn23 I1_I838_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I85_XP_MN0 (I1_I838_P19_18 I1_I838_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I85_XP_MN1 (VSS I1_I838_pn18 I1_I838_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I83_XP_MN0 (I1_I838_P17_16 I1_I838_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I83_XP_MN1 (VSS I1_I838_pn16 I1_I838_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I81_XP_MN0 (I1_I838_P15_14 I1_I838_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I81_XP_MN1 (VSS I1_I838_pn14 I1_I838_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I79_XP_MN0 (I1_I838_P13_12 I1_I838_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I79_XP_MN1 (VSS I1_I838_pn12 I1_I838_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I146_XP_MN0 (I1_I792_P21_14 I1_I792_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I146_XP_MN1 (VSS I1_I792_P17_14n I1_I792_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I144_XP_MN0 (I1_I792_P19_12 I1_I792_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I144_XP_MN1 (VSS I1_I792_P15_12n I1_I792_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I87_XP_MN0 (I1_I792_P21_20 I1_I792_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I87_XP_MN1 (VSS I1_I792_pn20 I1_I792_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I147_XP_MN0 (I1_I792_P22_15 I1_I792_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I147_XP_MN1 (VSS I1_I792_P18_15n I1_I792_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I149_XP_MN0 (I1_I792_P24_17 I1_I792_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I149_XP_MN1 (VSS I1_I792_P20_17n I1_I792_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I151_XP_MN0 (I1_I792_P26_19 I1_I792_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I151_XP_MN1 (VSS I1_I792_P22_19n I1_I792_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I88_XP_MN0 (I1_I792_P22_21 I1_I792_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I88_XP_MN1 (VSS I1_I792_pn21 I1_I792_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I94_XP_MN0 (I1_I746_P28_27 I1_I746_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I94_XP_MN1 (VSS I1_I746_pn27 I1_I746_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I93_XP_MN0 (I1_I1344_P27_26 I1_I1344_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I93_XP_MN1 (VSS I1_I1344_pn26 I1_I1344_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I91_XP_MN0 (I1_I1344_P25_24 I1_I1344_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I91_XP_MN1 (VSS I1_I1344_pn24 I1_I1344_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I89_XP_MN0 (I1_I1344_P23_22 I1_I1344_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I89_XP_MN1 (VSS I1_I1344_pn22 I1_I1344_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I150_XP_MN0 (I1_I1344_P25_18 I1_I1344_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I150_XP_MN1 (VSS I1_I1344_P21_18n I1_I1344_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I146_XP_MN0 (I1_I1344_P21_14 I1_I1344_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I146_XP_MN1 (VSS I1_I1344_P17_14n I1_I1344_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I136_XP_MN0 (I1_I1344_P11_4 I1_I1344_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I136_XP_MN1 (VSS I1_I1344_P7_4n I1_I1344_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I148_XP_MN0 (I1_I1298_P23_16 I1_I1298_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I148_XP_MN1 (VSS I1_I1298_P19_16n I1_I1298_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I150_XP_MN0 (I1_I1298_P25_18 I1_I1298_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I150_XP_MN1 (VSS I1_I1298_P21_18n I1_I1298_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I89_XP_MN0 (I1_I1298_P23_22 I1_I1298_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I89_XP_MN1 (VSS I1_I1298_pn22 I1_I1298_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I153_XP_MN0 (I1_I1298_P28_21 I1_I1298_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I153_XP_MN1 (VSS I1_I1298_P24_21n I1_I1298_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I151_XP_MN0 (I1_I1252_P26_19 I1_I1252_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I151_XP_MN1 (VSS I1_I1252_P22_19n I1_I1252_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I88_XP_MN0 (I1_I1252_P22_21 I1_I1252_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I88_XP_MN1 (VSS I1_I1252_pn21 I1_I1252_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I154_XP_MN0 (I1_I1252_P29_22 I1_I1252_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I154_XP_MN1 (VSS I1_I1252_P25_22n I1_I1252_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I89_XP_MN0 (I1_I1252_P23_22 I1_I1252_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I89_XP_MN1 (VSS I1_I1252_pn22 I1_I1252_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I89_XP_MN0 (I1_I1206_P23_22 I1_I1206_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I89_XP_MN1 (VSS I1_I1206_pn22 I1_I1206_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I90_XP_MN0 (I1_I1206_P24_23 I1_I1206_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I90_XP_MN1 (VSS I1_I1206_pn23 I1_I1206_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I91_XP_MN0 (I1_I1206_P25_24 I1_I1206_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I91_XP_MN1 (VSS I1_I1206_pn24 I1_I1206_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I155_XP_MN0 (I1_I1206_P30_23 I1_I1206_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I155_XP_MN1 (VSS I1_I1206_P26_23n I1_I1206_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I153_XP_MN0 (I1_I1206_P28_21 I1_I1206_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I153_XP_MN1 (VSS I1_I1206_P24_21n I1_I1206_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I94_XP_MN0 (I1_I838_P28_27 I1_I838_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I94_XP_MN1 (VSS I1_I838_pn27 I1_I838_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I92_XP_MN0 (I1_I838_P26_25 I1_I838_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I92_XP_MN1 (VSS I1_I838_pn25 I1_I838_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I88_XP_MN0 (I1_I838_P22_21 I1_I838_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I88_XP_MN1 (VSS I1_I838_pn21 I1_I838_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I86_XP_MN0 (I1_I838_P20_19 I1_I838_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I86_XP_MN1 (VSS I1_I838_pn19 I1_I838_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I84_XP_MN0 (I1_I838_P18_17 I1_I838_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I84_XP_MN1 (VSS I1_I838_pn17 I1_I838_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I82_XP_MN0 (I1_I838_P16_15 I1_I838_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I82_XP_MN1 (VSS I1_I838_pn15 I1_I838_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I77_XP_MN0 (I1_I838_P11_10 I1_I838_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I77_XP_MN1 (VSS I1_I838_pn10 I1_I838_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I142_XP_MN0 (I1_I792_P17_10 I1_I792_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I142_XP_MN1 (VSS I1_I792_P13_10n I1_I792_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I140_XP_MN0 (I1_I792_P15_8 I1_I792_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I140_XP_MN1 (VSS I1_I792_P11_8n I1_I792_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I85_XP_MN0 (I1_I792_P19_18 I1_I792_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I85_XP_MN1 (VSS I1_I792_pn18 I1_I792_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I81_XP_MN0 (I1_I792_P15_14 I1_I792_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I81_XP_MN1 (VSS I1_I792_pn14 I1_I792_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I145_XP_MN0 (I1_I792_P20_13 I1_I792_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I145_XP_MN1 (VSS I1_I792_P16_13n I1_I792_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I86_XP_MN0 (I1_I792_P20_19 I1_I792_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I86_XP_MN1 (VSS I1_I792_pn19 I1_I792_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I151_XP_MN0 (I1_I746_P26_19 I1_I746_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I151_XP_MN1 (VSS I1_I746_P22_19n I1_I746_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I92_XP_MN0 (I1_I746_P26_25 I1_I746_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I92_XP_MN1 (VSS I1_I746_pn25 I1_I746_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I155_XP_MN0 (I1_I746_P30_23 I1_I746_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I155_XP_MN1 (VSS I1_I746_P26_23n I1_I746_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I96_XP_MN0 (I1_I746_P30_29 I1_I746_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I96_XP_MN1 (VSS I1_I746_pn29 I1_I746_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I93_XP_MN0 (I1_I746_P27_26 I1_I746_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I93_XP_MN1 (VSS I1_I746_pn26 I1_I746_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I90_XP_MN0 (I1_I1344_P24_23 I1_I1344_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I90_XP_MN1 (VSS I1_I1344_pn23 I1_I1344_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I87_XP_MN0 (I1_I1344_P21_20 I1_I1344_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I87_XP_MN1 (VSS I1_I1344_pn20 I1_I1344_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I142_XP_MN0 (I1_I1344_P17_10 I1_I1344_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I142_XP_MN1 (VSS I1_I1344_P13_10n I1_I1344_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I138_XP_MN0 (I1_I1344_P13_6 I1_I1344_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I138_XP_MN1 (VSS I1_I1344_P9_6n I1_I1344_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I87_XP_MN0 (I1_I1298_P21_20 I1_I1298_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I87_XP_MN1 (VSS I1_I1298_pn20 I1_I1298_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I151_XP_MN0 (I1_I1298_P26_19 I1_I1298_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I151_XP_MN1 (VSS I1_I1298_P22_19n I1_I1298_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I88_XP_MN0 (I1_I1298_P22_21 I1_I1298_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I88_XP_MN1 (VSS I1_I1298_pn21 I1_I1298_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I147_XP_MN0 (I1_I1252_P22_15 I1_I1252_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I147_XP_MN1 (VSS I1_I1252_P18_15n I1_I1252_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I86_XP_MN0 (I1_I1252_P20_19 I1_I1252_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I86_XP_MN1 (VSS I1_I1252_pn19 I1_I1252_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I148_XP_MN0 (I1_I1252_P23_16 I1_I1252_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I148_XP_MN1 (VSS I1_I1252_P19_16n I1_I1252_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I152_XP_MN0 (I1_I1252_P27_20 I1_I1252_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I152_XP_MN1 (VSS I1_I1252_P23_20n I1_I1252_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I87_XP_MN0 (I1_I1252_P21_20 I1_I1252_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I87_XP_MN1 (VSS I1_I1252_pn20 I1_I1252_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I87_XP_MN0 (I1_I1206_P21_20 I1_I1206_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I87_XP_MN1 (VSS I1_I1206_pn20 I1_I1206_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I88_XP_MN0 (I1_I1206_P22_21 I1_I1206_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I88_XP_MN1 (VSS I1_I1206_pn21 I1_I1206_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I152_XP_MN0 (I1_I1206_P27_20 I1_I1206_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I152_XP_MN1 (VSS I1_I1206_P23_20n I1_I1206_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I154_XP_MN0 (I1_I1206_P29_22 I1_I1206_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I154_XP_MN1 (VSS I1_I1206_P25_22n I1_I1206_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I151_XP_MN0 (I1_I1206_P26_19 I1_I1206_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I151_XP_MN1 (VSS I1_I1206_P22_19n I1_I1206_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I155_XP_MN0 (I1_I838_P30_23 I1_I838_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I155_XP_MN1 (VSS I1_I838_P26_23n I1_I838_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I153_XP_MN0 (I1_I838_P28_21 I1_I838_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I153_XP_MN1 (VSS I1_I838_P24_21n I1_I838_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I151_XP_MN0 (I1_I838_P26_19 I1_I838_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I151_XP_MN1 (VSS I1_I838_P22_19n I1_I838_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I147_XP_MN0 (I1_I838_P22_15 I1_I838_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I147_XP_MN1 (VSS I1_I838_P18_15n I1_I838_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I80_XP_MN0 (I1_I838_P14_13 I1_I838_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I80_XP_MN1 (VSS I1_I838_pn13 I1_I838_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I78_XP_MN0 (I1_I838_P12_11 I1_I838_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I78_XP_MN1 (VSS I1_I838_pn11 I1_I838_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I75_XP_MN0 (I1_I838_P9_8 I1_I838_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I75_XP_MN1 (VSS I1_I838_pn8 I1_I838_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I138_XP_MN0 (I1_I792_P13_6 I1_I792_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I138_XP_MN1 (VSS I1_I792_P9_6n I1_I792_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I136_XP_MN0 (I1_I792_P11_4 I1_I792_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I136_XP_MN1 (VSS I1_I792_P7_4n I1_I792_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I83_XP_MN0 (I1_I792_P17_16 I1_I792_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I83_XP_MN1 (VSS I1_I792_pn16 I1_I792_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I79_XP_MN0 (I1_I792_P13_12 I1_I792_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I79_XP_MN1 (VSS I1_I792_pn12 I1_I792_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I139_XP_MN0 (I1_I792_P14_7 I1_I792_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I139_XP_MN1 (VSS I1_I792_P10_7n I1_I792_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I143_XP_MN0 (I1_I792_P18_11 I1_I792_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I143_XP_MN1 (VSS I1_I792_P14_11n I1_I792_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I82_XP_MN0 (I1_I792_P16_15 I1_I792_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I82_XP_MN1 (VSS I1_I792_pn15 I1_I792_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I84_XP_MN0 (I1_I792_P18_17 I1_I792_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I84_XP_MN1 (VSS I1_I792_pn17 I1_I792_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I147_XP_MN0 (I1_I746_P22_15 I1_I746_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I147_XP_MN1 (VSS I1_I746_P18_15n I1_I746_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I153_XP_MN0 (I1_I746_P28_21 I1_I746_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I153_XP_MN1 (VSS I1_I746_P24_21n I1_I746_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I95_XP_MN0 (I1_I746_P29_28 I1_I746_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I95_XP_MN1 (VSS I1_I746_pn28 I1_I746_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I92_XP_MN0 (I1_I1344_P26_25 I1_I1344_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I92_XP_MN1 (VSS I1_I1344_pn25 I1_I1344_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I85_XP_MN0 (I1_I1344_P19_18 I1_I1344_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I85_XP_MN1 (VSS I1_I1344_pn18 I1_I1344_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I83_XP_MN0 (I1_I1344_P17_16 I1_I1344_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I83_XP_MN1 (VSS I1_I1344_pn16 I1_I1344_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I144_XP_MN0 (I1_I1298_P19_12 I1_I1298_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I144_XP_MN1 (VSS I1_I1298_P15_12n I1_I1298_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I146_XP_MN0 (I1_I1298_P21_14 I1_I1298_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I146_XP_MN1 (VSS I1_I1298_P17_14n I1_I1298_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I85_XP_MN0 (I1_I1298_P19_18 I1_I1298_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I85_XP_MN1 (VSS I1_I1298_pn18 I1_I1298_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I147_XP_MN0 (I1_I1298_P22_15 I1_I1298_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I147_XP_MN1 (VSS I1_I1298_P18_15n I1_I1298_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I149_XP_MN0 (I1_I1298_P24_17 I1_I1298_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I149_XP_MN1 (VSS I1_I1298_P20_17n I1_I1298_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I86_XP_MN0 (I1_I1298_P20_19 I1_I1298_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I86_XP_MN1 (VSS I1_I1298_pn19 I1_I1298_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I145_XP_MN0 (I1_I1252_P20_13 I1_I1252_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I145_XP_MN1 (VSS I1_I1252_P16_13n I1_I1252_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I149_XP_MN0 (I1_I1252_P24_17 I1_I1252_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I149_XP_MN1 (VSS I1_I1252_P20_17n I1_I1252_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I146_XP_MN0 (I1_I1252_P21_14 I1_I1252_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I146_XP_MN1 (VSS I1_I1252_P17_14n I1_I1252_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I150_XP_MN0 (I1_I1252_P25_18 I1_I1252_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I150_XP_MN1 (VSS I1_I1252_P21_18n I1_I1252_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I86_XP_MN0 (I1_I1206_P20_19 I1_I1206_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I86_XP_MN1 (VSS I1_I1206_pn19 I1_I1206_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I148_XP_MN0 (I1_I1206_P23_16 I1_I1206_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I148_XP_MN1 (VSS I1_I1206_P19_16n I1_I1206_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I147_XP_MN0 (I1_I1206_P22_15 I1_I1206_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I147_XP_MN1 (VSS I1_I1206_P18_15n I1_I1206_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I149_XP_MN0 (I1_I1206_P24_17 I1_I1206_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I149_XP_MN1 (VSS I1_I1206_P20_17n I1_I1206_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I149_XP_MN0 (I1_I838_P24_17 I1_I838_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I149_XP_MN1 (VSS I1_I838_P20_17n I1_I838_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I145_XP_MN0 (I1_I838_P20_13 I1_I838_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I145_XP_MN1 (VSS I1_I838_P16_13n I1_I838_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I143_XP_MN0 (I1_I838_P18_11 I1_I838_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I143_XP_MN1 (VSS I1_I838_P14_11n I1_I838_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I139_XP_MN0 (I1_I838_P14_7 I1_I838_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I139_XP_MN1 (VSS I1_I838_P10_7n I1_I838_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I141_XP_MN0 (I1_I838_P16_9 I1_I838_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I141_XP_MN1 (VSS I1_I838_P12_9n I1_I838_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I135_XP_MN0 (I1_I838_P10_3 I1_I838_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I135_XP_MN1 (VSS I1_I838_P6_3n I1_I838_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I76_XP_MN0 (I1_I838_P10_9 I1_I838_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I76_XP_MN1 (VSS I1_I838_pn9 I1_I838_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I74_XP_MN0 (I1_I838_P8_7 I1_I838_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I74_XP_MN1 (VSS I1_I838_pn7 I1_I838_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I134_XP_MN0 (I1_I792_P9_2 I1_I792_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I134_XP_MN1 (VSS I1_I792_P5_2n I1_I792_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I75_XP_MN0 (I1_I792_P9_8 I1_I792_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I75_XP_MN1 (VSS I1_I792_pn8 I1_I792_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I77_XP_MN0 (I1_I792_P11_10 I1_I792_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I77_XP_MN1 (VSS I1_I792_pn10 I1_I792_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I135_XP_MN0 (I1_I792_P10_3 I1_I792_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I135_XP_MN1 (VSS I1_I792_P6_3n I1_I792_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I141_XP_MN0 (I1_I792_P16_9 I1_I792_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I141_XP_MN1 (VSS I1_I792_P12_9n I1_I792_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I78_XP_MN0 (I1_I792_P12_11 I1_I792_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I78_XP_MN1 (VSS I1_I792_pn11 I1_I792_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I135_XP_MN0 (I1_I746_P10_3 I1_I746_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I135_XP_MN1 (VSS I1_I746_P6_3n I1_I746_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I139_XP_MN0 (I1_I746_P14_7 I1_I746_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I139_XP_MN1 (VSS I1_I746_P10_7n I1_I746_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I143_XP_MN0 (I1_I746_P18_11 I1_I746_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I143_XP_MN1 (VSS I1_I746_P14_11n I1_I746_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I149_XP_MN0 (I1_I746_P24_17 I1_I746_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I149_XP_MN1 (VSS I1_I746_P20_17n I1_I746_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I90_XP_MN0 (I1_I746_P24_23 I1_I746_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I90_XP_MN1 (VSS I1_I746_pn23 I1_I746_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I91_XP_MN0 (I1_I746_P25_24 I1_I746_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I91_XP_MN1 (VSS I1_I746_pn24 I1_I746_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I97_XP_MN0 (I1_I746_P31_30 I1_I746_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I97_XP_MN1 (VSS I1_I746_pn30 I1_I746_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I155_XP_MN0 (I1_I1344_P30_23 I1_I1344_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I155_XP_MN1 (VSS I1_I1344_P26_23n I1_I1344_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I153_XP_MN0 (I1_I1344_P28_21 I1_I1344_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I153_XP_MN1 (VSS I1_I1344_P24_21n I1_I1344_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I88_XP_MN0 (I1_I1344_P22_21 I1_I1344_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I88_XP_MN1 (VSS I1_I1344_pn21 I1_I1344_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I86_XP_MN0 (I1_I1344_P20_19 I1_I1344_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I86_XP_MN1 (VSS I1_I1344_pn19 I1_I1344_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I84_XP_MN0 (I1_I1344_P18_17 I1_I1344_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I84_XP_MN1 (VSS I1_I1344_pn17 I1_I1344_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I82_XP_MN0 (I1_I1344_P16_15 I1_I1344_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I82_XP_MN1 (VSS I1_I1344_pn15 I1_I1344_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I81_XP_MN0 (I1_I1344_P15_14 I1_I1344_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I81_XP_MN1 (VSS I1_I1344_pn14 I1_I1344_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I134_XP_MN0 (I1_I1344_P9_2 I1_I1344_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I134_XP_MN1 (VSS I1_I1344_P5_2n I1_I1344_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I140_XP_MN0 (I1_I1298_P15_8 I1_I1298_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I140_XP_MN1 (VSS I1_I1298_P11_8n I1_I1298_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I83_XP_MN0 (I1_I1298_P17_16 I1_I1298_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I83_XP_MN1 (VSS I1_I1298_pn16 I1_I1298_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I145_XP_MN0 (I1_I1298_P20_13 I1_I1298_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I145_XP_MN1 (VSS I1_I1298_P16_13n I1_I1298_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I84_XP_MN0 (I1_I1298_P18_17 I1_I1298_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I84_XP_MN1 (VSS I1_I1298_pn17 I1_I1298_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I84_XP_MN0 (I1_I1252_P18_17 I1_I1252_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I84_XP_MN1 (VSS I1_I1252_pn17 I1_I1252_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I144_XP_MN0 (I1_I1252_P19_12 I1_I1252_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I144_XP_MN1 (VSS I1_I1252_P15_12n I1_I1252_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I85_XP_MN0 (I1_I1252_P19_18 I1_I1252_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I85_XP_MN1 (VSS I1_I1252_pn18 I1_I1252_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I85_XP_MN0 (I1_I1206_P19_18 I1_I1206_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I85_XP_MN1 (VSS I1_I1206_pn18 I1_I1206_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I150_XP_MN0 (I1_I1206_P25_18 I1_I1206_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I150_XP_MN1 (VSS I1_I1206_P21_18n I1_I1206_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I146_XP_MN0 (I1_I1206_P21_14 I1_I1206_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I146_XP_MN1 (VSS I1_I1206_P17_14n I1_I1206_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I145_XP_MN0 (I1_I1206_P20_13 I1_I1206_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I145_XP_MN1 (VSS I1_I1206_P16_13n I1_I1206_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I137_XP_MN0 (I1_I838_P12_5 I1_I838_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I137_XP_MN1 (VSS I1_I838_P8_5n I1_I838_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I73_XP_MN0 (I1_I838_P7_6 I1_I838_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I73_XP_MN1 (VSS I1_I838_pn6 I1_I838_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I73_XP_MN0 (I1_I792_P7_6 I1_I792_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I73_XP_MN1 (VSS I1_I792_pn6 I1_I792_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I133_XP_MN0 (I1_I792_P8_1 I1_I792_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I133_XP_MN1 (VSS I1_I792_P4_1n I1_I792_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I74_XP_MN0 (I1_I792_P8_7 I1_I792_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I74_XP_MN1 (VSS I1_I792_pn7 I1_I792_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I76_XP_MN0 (I1_I792_P10_9 I1_I792_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I76_XP_MN1 (VSS I1_I792_pn9 I1_I792_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I137_XP_MN0 (I1_I792_P12_5 I1_I792_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I137_XP_MN1 (VSS I1_I792_P8_5n I1_I792_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I80_XP_MN0 (I1_I792_P14_13 I1_I792_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I80_XP_MN1 (VSS I1_I792_pn13 I1_I792_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I137_XP_MN0 (I1_I746_P12_5 I1_I746_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I137_XP_MN1 (VSS I1_I746_P8_5n I1_I746_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I141_XP_MN0 (I1_I746_P16_9 I1_I746_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I141_XP_MN1 (VSS I1_I746_P12_9n I1_I746_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I145_XP_MN0 (I1_I746_P20_13 I1_I746_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I145_XP_MN1 (VSS I1_I746_P16_13n I1_I746_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I84_XP_MN0 (I1_I746_P18_17 I1_I746_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I84_XP_MN1 (VSS I1_I746_pn17 I1_I746_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I86_XP_MN0 (I1_I746_P20_19 I1_I746_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I86_XP_MN1 (VSS I1_I746_pn19 I1_I746_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I88_XP_MN0 (I1_I746_P22_21 I1_I746_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I88_XP_MN1 (VSS I1_I746_pn21 I1_I746_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I154_XP_MN0 (I1_I746_P29_22 I1_I746_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I154_XP_MN1 (VSS I1_I746_P25_22n I1_I746_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I151_XP_MN0 (I1_I1344_P26_19 I1_I1344_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I151_XP_MN1 (VSS I1_I1344_P22_19n I1_I1344_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I147_XP_MN0 (I1_I1344_P22_15 I1_I1344_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I147_XP_MN1 (VSS I1_I1344_P18_15n I1_I1344_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I149_XP_MN0 (I1_I1344_P24_17 I1_I1344_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I149_XP_MN1 (VSS I1_I1344_P20_17n I1_I1344_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I80_XP_MN0 (I1_I1344_P14_13 I1_I1344_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I80_XP_MN1 (VSS I1_I1344_pn13 I1_I1344_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I138_XP_MN0 (I1_I1298_P13_6 I1_I1298_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I138_XP_MN1 (VSS I1_I1298_P9_6n I1_I1298_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I142_XP_MN0 (I1_I1298_P17_10 I1_I1298_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I142_XP_MN1 (VSS I1_I1298_P13_10n I1_I1298_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I81_XP_MN0 (I1_I1298_P15_14 I1_I1298_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I81_XP_MN1 (VSS I1_I1298_pn14 I1_I1298_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I143_XP_MN0 (I1_I1298_P18_11 I1_I1298_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I143_XP_MN1 (VSS I1_I1298_P14_11n I1_I1298_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I139_XP_MN0 (I1_I1298_P14_7 I1_I1298_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I139_XP_MN1 (VSS I1_I1298_P10_7n I1_I1298_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I82_XP_MN0 (I1_I1298_P16_15 I1_I1298_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I82_XP_MN1 (VSS I1_I1298_pn15 I1_I1298_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I143_XP_MN0 (I1_I1252_P18_11 I1_I1252_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I143_XP_MN1 (VSS I1_I1252_P14_11n I1_I1252_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I82_XP_MN0 (I1_I1252_P16_15 I1_I1252_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I82_XP_MN1 (VSS I1_I1252_pn15 I1_I1252_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I140_XP_MN0 (I1_I1252_P15_8 I1_I1252_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I140_XP_MN1 (VSS I1_I1252_P11_8n I1_I1252_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I83_XP_MN0 (I1_I1252_P17_16 I1_I1252_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I83_XP_MN1 (VSS I1_I1252_pn16 I1_I1252_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I83_XP_MN0 (I1_I1206_P17_16 I1_I1206_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I83_XP_MN1 (VSS I1_I1206_pn16 I1_I1206_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I84_XP_MN0 (I1_I1206_P18_17 I1_I1206_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I84_XP_MN1 (VSS I1_I1206_pn17 I1_I1206_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I144_XP_MN0 (I1_I1206_P19_12 I1_I1206_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I144_XP_MN1 (VSS I1_I1206_P15_12n I1_I1206_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I143_XP_MN0 (I1_I1206_P18_11 I1_I1206_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I143_XP_MN1 (VSS I1_I1206_P14_11n I1_I1206_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I133_XP_MN0 (I1_I838_P8_1 I1_I838_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I133_XP_MN1 (VSS I1_I838_P4_1n I1_I838_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I72_XP_MN0 (I1_I838_P6_5 I1_I838_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I72_XP_MN1 (VSS I1_I838_pn5 I1_I838_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I71_XP_MN0 (I1_I838_P5_4 I1_I838_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I71_XP_MN1 (VSS I1_I838_pn4 I1_I838_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I71_XP_MN0 (I1_I792_P5_4 I1_I792_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I71_XP_MN1 (VSS I1_I792_pn4 I1_I792_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I72_XP_MN0 (I1_I792_P6_5 I1_I792_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I72_XP_MN1 (VSS I1_I792_pn5 I1_I792_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I133_XP_MN0 (I1_I746_P8_1 I1_I746_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I133_XP_MN1 (VSS I1_I746_P4_1n I1_I746_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I76_XP_MN0 (I1_I746_P10_9 I1_I746_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I76_XP_MN1 (VSS I1_I746_pn9 I1_I746_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I78_XP_MN0 (I1_I746_P12_11 I1_I746_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I78_XP_MN1 (VSS I1_I746_pn11 I1_I746_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I80_XP_MN0 (I1_I746_P14_13 I1_I746_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I80_XP_MN1 (VSS I1_I746_pn13 I1_I746_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I82_XP_MN0 (I1_I746_P16_15 I1_I746_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I82_XP_MN1 (VSS I1_I746_pn15 I1_I746_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I89_XP_MN0 (I1_I746_P23_22 I1_I746_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I89_XP_MN1 (VSS I1_I746_pn22 I1_I746_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I145_XP_MN0 (I1_I1344_P20_13 I1_I1344_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I145_XP_MN1 (VSS I1_I1344_P16_13n I1_I1344_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I143_XP_MN0 (I1_I1344_P18_11 I1_I1344_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I143_XP_MN1 (VSS I1_I1344_P14_11n I1_I1344_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I141_XP_MN0 (I1_I1344_P16_9 I1_I1344_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I141_XP_MN1 (VSS I1_I1344_P12_9n I1_I1344_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I78_XP_MN0 (I1_I1344_P12_11 I1_I1344_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I78_XP_MN1 (VSS I1_I1344_pn11 I1_I1344_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I79_XP_MN0 (I1_I1344_P13_12 I1_I1344_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I79_XP_MN1 (VSS I1_I1344_pn12 I1_I1344_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I136_XP_MN0 (I1_I1298_P11_4 I1_I1298_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I136_XP_MN1 (VSS I1_I1298_P7_4n I1_I1298_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I79_XP_MN0 (I1_I1298_P13_12 I1_I1298_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I79_XP_MN1 (VSS I1_I1298_pn12 I1_I1298_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I141_XP_MN0 (I1_I1298_P16_9 I1_I1298_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I141_XP_MN1 (VSS I1_I1298_P12_9n I1_I1298_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I80_XP_MN0 (I1_I1298_P14_13 I1_I1298_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I80_XP_MN1 (VSS I1_I1298_pn13 I1_I1298_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I141_XP_MN0 (I1_I1252_P16_9 I1_I1252_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I141_XP_MN1 (VSS I1_I1252_P12_9n I1_I1252_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I139_XP_MN0 (I1_I1252_P14_7 I1_I1252_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I139_XP_MN1 (VSS I1_I1252_P10_7n I1_I1252_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I80_XP_MN0 (I1_I1252_P14_13 I1_I1252_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I80_XP_MN1 (VSS I1_I1252_pn13 I1_I1252_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I138_XP_MN0 (I1_I1252_P13_6 I1_I1252_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I138_XP_MN1 (VSS I1_I1252_P9_6n I1_I1252_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I142_XP_MN0 (I1_I1252_P17_10 I1_I1252_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I142_XP_MN1 (VSS I1_I1252_P13_10n I1_I1252_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I79_XP_MN0 (I1_I1252_P13_12 I1_I1252_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I79_XP_MN1 (VSS I1_I1252_pn12 I1_I1252_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I81_XP_MN0 (I1_I1252_P15_14 I1_I1252_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I81_XP_MN1 (VSS I1_I1252_pn14 I1_I1252_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I81_XP_MN0 (I1_I1206_P15_14 I1_I1206_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I81_XP_MN1 (VSS I1_I1206_pn14 I1_I1206_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I82_XP_MN0 (I1_I1206_P16_15 I1_I1206_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I82_XP_MN1 (VSS I1_I1206_pn15 I1_I1206_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I140_XP_MN0 (I1_I1206_P15_8 I1_I1206_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I140_XP_MN1 (VSS I1_I1206_P11_8n I1_I1206_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I142_XP_MN0 (I1_I1206_P17_10 I1_I1206_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I142_XP_MN1 (VSS I1_I1206_P13_10n I1_I1206_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I138_XP_MN0 (I1_I1206_P13_6 I1_I1206_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I138_XP_MN1 (VSS I1_I1206_P9_6n I1_I1206_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I139_XP_MN0 (I1_I1206_P14_7 I1_I1206_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I139_XP_MN1 (VSS I1_I1206_P10_7n I1_I1206_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I141_XP_MN0 (I1_I1206_P16_9 I1_I1206_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I141_XP_MN1 (VSS I1_I1206_P12_9n I1_I1206_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I95_XP_MN0 (I1_I884_P29_28 I1_I884_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I95_XP_MN1 (VSS I1_I884_pn28 I1_I884_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I93_XP_MN0 (I1_I884_P27_26 I1_I884_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I93_XP_MN1 (VSS I1_I884_pn26 I1_I884_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I91_XP_MN0 (I1_I884_P25_24 I1_I884_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I91_XP_MN1 (VSS I1_I884_pn24 I1_I884_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I87_XP_MN0 (I1_I884_P21_20 I1_I884_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I87_XP_MN1 (VSS I1_I884_pn20 I1_I884_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I70_XP_MN0 (I1_I838_P4_3 I1_I838_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I70_XP_MN1 (VSS I1_I838_pn3 I1_I838_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I69_XP_MN0 (I1_I838_P3_2 I1_I838_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I69_XP_MN1 (VSS I1_I838_pn2 I1_I838_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I70_XP_MN0 (I1_I792_P4_3 I1_I792_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I70_XP_MN1 (VSS I1_I792_pn3 I1_I792_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I74_XP_MN0 (I1_I746_P8_7 I1_I746_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I74_XP_MN1 (VSS I1_I746_pn7 I1_I746_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I134_XP_MN0 (I1_I746_P9_2 I1_I746_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I134_XP_MN1 (VSS I1_I746_P5_2n I1_I746_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I138_XP_MN0 (I1_I746_P13_6 I1_I746_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I138_XP_MN1 (VSS I1_I746_P9_6n I1_I746_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I81_XP_MN0 (I1_I746_P15_14 I1_I746_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I81_XP_MN1 (VSS I1_I746_pn14 I1_I746_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I142_XP_MN0 (I1_I746_P17_10 I1_I746_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I142_XP_MN1 (VSS I1_I746_P13_10n I1_I746_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I83_XP_MN0 (I1_I746_P17_16 I1_I746_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I83_XP_MN1 (VSS I1_I746_pn16 I1_I746_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I85_XP_MN0 (I1_I746_P19_18 I1_I746_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I85_XP_MN1 (VSS I1_I746_pn18 I1_I746_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I87_XP_MN0 (I1_I746_P21_20 I1_I746_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I87_XP_MN1 (VSS I1_I746_pn20 I1_I746_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I152_XP_MN0 (I1_I746_P27_20 I1_I746_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I152_XP_MN1 (VSS I1_I746_P23_20n I1_I746_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I156_XP_MN0 (I1_I746_P31_24 I1_I746_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I156_XP_MN1 (VSS I1_I746_P27_24n I1_I746_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I139_XP_MN0 (I1_I1344_P14_7 I1_I1344_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I139_XP_MN1 (VSS I1_I1344_P10_7n I1_I1344_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I137_XP_MN0 (I1_I1344_P12_5 I1_I1344_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I137_XP_MN1 (VSS I1_I1344_P8_5n I1_I1344_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I76_XP_MN0 (I1_I1344_P10_9 I1_I1344_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I76_XP_MN1 (VSS I1_I1344_pn9 I1_I1344_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I77_XP_MN0 (I1_I1344_P11_10 I1_I1344_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I77_XP_MN1 (VSS I1_I1344_pn10 I1_I1344_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I134_XP_MN0 (I1_I1298_P9_2 I1_I1298_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I134_XP_MN1 (VSS I1_I1298_P5_2n I1_I1298_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I77_XP_MN0 (I1_I1298_P11_10 I1_I1298_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I77_XP_MN1 (VSS I1_I1298_pn10 I1_I1298_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I137_XP_MN0 (I1_I1298_P12_5 I1_I1298_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I137_XP_MN1 (VSS I1_I1298_P8_5n I1_I1298_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I78_XP_MN0 (I1_I1298_P12_11 I1_I1298_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I78_XP_MN1 (VSS I1_I1298_pn11 I1_I1298_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I137_XP_MN0 (I1_I1252_P12_5 I1_I1252_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I137_XP_MN1 (VSS I1_I1252_P8_5n I1_I1252_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I78_XP_MN0 (I1_I1252_P12_11 I1_I1252_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I78_XP_MN1 (VSS I1_I1252_pn11 I1_I1252_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I136_XP_MN0 (I1_I1252_P11_4 I1_I1252_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I136_XP_MN1 (VSS I1_I1252_P7_4n I1_I1252_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I77_XP_MN0 (I1_I1252_P11_10 I1_I1252_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I77_XP_MN1 (VSS I1_I1252_pn10 I1_I1252_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I80_XP_MN0 (I1_I1206_P14_13 I1_I1206_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I80_XP_MN1 (VSS I1_I1206_pn13 I1_I1206_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I79_XP_MN0 (I1_I1206_P13_12 I1_I1206_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I79_XP_MN1 (VSS I1_I1206_pn12 I1_I1206_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I77_XP_MN0 (I1_I1206_P11_10 I1_I1206_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I77_XP_MN1 (VSS I1_I1206_pn10 I1_I1206_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I136_XP_MN0 (I1_I1206_P11_4 I1_I1206_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I136_XP_MN1 (VSS I1_I1206_P7_4n I1_I1206_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I134_XP_MN0 (I1_I1206_P9_2 I1_I1206_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I134_XP_MN1 (VSS I1_I1206_P5_2n I1_I1206_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I135_XP_MN0 (I1_I1206_P10_3 I1_I1206_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I135_XP_MN1 (VSS I1_I1206_P6_3n I1_I1206_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I137_XP_MN0 (I1_I1206_P12_5 I1_I1206_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I137_XP_MN1 (VSS I1_I1206_P8_5n I1_I1206_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I156_XP_MN0 (I1_I884_P31_24 I1_I884_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I156_XP_MN1 (VSS I1_I884_P27_24n I1_I884_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I154_XP_MN0 (I1_I884_P29_22 I1_I884_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I154_XP_MN1 (VSS I1_I884_P25_22n I1_I884_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I89_XP_MN0 (I1_I884_P23_22 I1_I884_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I89_XP_MN1 (VSS I1_I884_pn22 I1_I884_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I152_XP_MN0 (I1_I884_P27_20 I1_I884_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I152_XP_MN1 (VSS I1_I884_P23_20n I1_I884_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I150_XP_MN0 (I1_I884_P25_18 I1_I884_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I150_XP_MN1 (VSS I1_I884_P21_18n I1_I884_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I144_XP_MN0 (I1_I884_P19_12 I1_I884_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I144_XP_MN1 (VSS I1_I884_P15_12n I1_I884_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I85_XP_MN0 (I1_I884_P19_18 I1_I884_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I85_XP_MN1 (VSS I1_I884_pn18 I1_I884_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I83_XP_MN0 (I1_I884_P17_16 I1_I884_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I83_XP_MN1 (VSS I1_I884_pn16 I1_I884_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I81_XP_MN0 (I1_I884_P15_14 I1_I884_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I81_XP_MN1 (VSS I1_I884_pn14 I1_I884_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I68_XP_MN0 (I1_I838_P2_1 I1_I838_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I68_XP_MN1 (VSS I1_I838_pn1 I1_I838_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I69_XP_MN0 (I1_I792_P3_2 I1_I792_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I69_XP_MN1 (VSS I1_I792_pn2 I1_I792_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I68_XP_MN0 (I1_I792_P2_1 I1_I792_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I68_XP_MN1 (VSS I1_I792_pn1 I1_I792_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I72_XP_MN0 (I1_I746_P6_5 I1_I746_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I72_XP_MN1 (VSS I1_I746_pn5 I1_I746_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I73_XP_MN0 (I1_I746_P7_6 I1_I746_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I73_XP_MN1 (VSS I1_I746_pn6 I1_I746_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I75_XP_MN0 (I1_I746_P9_8 I1_I746_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I75_XP_MN1 (VSS I1_I746_pn8 I1_I746_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I77_XP_MN0 (I1_I746_P11_10 I1_I746_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I77_XP_MN1 (VSS I1_I746_pn10 I1_I746_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I136_XP_MN0 (I1_I746_P11_4 I1_I746_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I136_XP_MN1 (VSS I1_I746_P7_4n I1_I746_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I79_XP_MN0 (I1_I746_P13_12 I1_I746_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I79_XP_MN1 (VSS I1_I746_pn12 I1_I746_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I140_XP_MN0 (I1_I746_P15_8 I1_I746_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I140_XP_MN1 (VSS I1_I746_P11_8n I1_I746_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I144_XP_MN0 (I1_I746_P19_12 I1_I746_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I144_XP_MN1 (VSS I1_I746_P15_12n I1_I746_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I148_XP_MN0 (I1_I746_P23_16 I1_I746_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I148_XP_MN1 (VSS I1_I746_P19_16n I1_I746_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I135_XP_MN0 (I1_I1344_P10_3 I1_I1344_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I135_XP_MN1 (VSS I1_I1344_P6_3n I1_I1344_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I75_XP_MN0 (I1_I1344_P9_8 I1_I1344_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I75_XP_MN1 (VSS I1_I1344_pn8 I1_I1344_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I75_XP_MN0 (I1_I1298_P9_8 I1_I1298_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I75_XP_MN1 (VSS I1_I1298_pn8 I1_I1298_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I135_XP_MN0 (I1_I1298_P10_3 I1_I1298_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I135_XP_MN1 (VSS I1_I1298_P6_3n I1_I1298_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I74_XP_MN0 (I1_I1298_P8_7 I1_I1298_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I74_XP_MN1 (VSS I1_I1298_pn7 I1_I1298_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I76_XP_MN0 (I1_I1298_P10_9 I1_I1298_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I76_XP_MN1 (VSS I1_I1298_pn9 I1_I1298_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I135_XP_MN0 (I1_I1252_P10_3 I1_I1252_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I135_XP_MN1 (VSS I1_I1252_P6_3n I1_I1252_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I76_XP_MN0 (I1_I1252_P10_9 I1_I1252_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I76_XP_MN1 (VSS I1_I1252_pn9 I1_I1252_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I134_XP_MN0 (I1_I1252_P9_2 I1_I1252_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I134_XP_MN1 (VSS I1_I1252_P5_2n I1_I1252_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I75_XP_MN0 (I1_I1252_P9_8 I1_I1252_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I75_XP_MN1 (VSS I1_I1252_pn8 I1_I1252_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I78_XP_MN0 (I1_I1206_P12_11 I1_I1206_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I78_XP_MN1 (VSS I1_I1206_pn11 I1_I1206_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I76_XP_MN0 (I1_I1206_P10_9 I1_I1206_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I76_XP_MN1 (VSS I1_I1206_pn9 I1_I1206_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I75_XP_MN0 (I1_I1206_P9_8 I1_I1206_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I75_XP_MN1 (VSS I1_I1206_pn8 I1_I1206_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I97_XP_MN0 (I1_I884_P31_30 I1_I884_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I97_XP_MN1 (VSS I1_I884_pn30 I1_I884_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I94_XP_MN0 (I1_I884_P28_27 I1_I884_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I94_XP_MN1 (VSS I1_I884_pn27 I1_I884_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I148_XP_MN0 (I1_I884_P23_16 I1_I884_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I148_XP_MN1 (VSS I1_I884_P19_16n I1_I884_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I146_XP_MN0 (I1_I884_P21_14 I1_I884_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I146_XP_MN1 (VSS I1_I884_P17_14n I1_I884_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I140_XP_MN0 (I1_I884_P15_8 I1_I884_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I140_XP_MN1 (VSS I1_I884_P11_8n I1_I884_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I142_XP_MN0 (I1_I884_P17_10 I1_I884_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I142_XP_MN1 (VSS I1_I884_P13_10n I1_I884_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I138_XP_MN0 (I1_I884_P13_6 I1_I884_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I138_XP_MN1 (VSS I1_I884_P9_6n I1_I884_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I79_XP_MN0 (I1_I884_P13_12 I1_I884_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I79_XP_MN1 (VSS I1_I884_pn12 I1_I884_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I136_XP_MN0 (I1_I884_P11_4 I1_I884_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I136_XP_MN1 (VSS I1_I884_P7_4n I1_I884_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I77_XP_MN0 (I1_I884_P11_10 I1_I884_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I77_XP_MN1 (VSS I1_I884_pn10 I1_I884_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I75_XP_MN0 (I1_I884_P9_8 I1_I884_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I75_XP_MN1 (VSS I1_I884_pn8 I1_I884_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I68_XP_MN0 (I1_I746_P2_1 I1_I746_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I68_XP_MN1 (VSS I1_I746_pn1 I1_I746_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I69_XP_MN0 (I1_I746_P3_2 I1_I746_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I69_XP_MN1 (VSS I1_I746_pn2 I1_I746_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I70_XP_MN0 (I1_I746_P4_3 I1_I746_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I70_XP_MN1 (VSS I1_I746_pn3 I1_I746_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I746_I71_XP_MN0 (I1_I746_P5_4 I1_I746_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I746_I71_XP_MN1 (VSS I1_I746_pn4 I1_I746_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I133_XP_MN0 (I1_I1344_P8_1 I1_I1344_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I133_XP_MN1 (VSS I1_I1344_P4_1n I1_I1344_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I74_XP_MN0 (I1_I1344_P8_7 I1_I1344_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I74_XP_MN1 (VSS I1_I1344_pn7 I1_I1344_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I73_XP_MN0 (I1_I1344_P7_6 I1_I1344_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I73_XP_MN1 (VSS I1_I1344_pn6 I1_I1344_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I73_XP_MN0 (I1_I1298_P7_6 I1_I1298_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I73_XP_MN1 (VSS I1_I1298_pn6 I1_I1298_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I133_XP_MN0 (I1_I1298_P8_1 I1_I1298_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I133_XP_MN1 (VSS I1_I1298_P4_1n I1_I1298_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I133_XP_MN0 (I1_I1252_P8_1 I1_I1252_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I133_XP_MN1 (VSS I1_I1252_P4_1n I1_I1252_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I74_XP_MN0 (I1_I1252_P8_7 I1_I1252_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I74_XP_MN1 (VSS I1_I1252_pn7 I1_I1252_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I73_XP_MN0 (I1_I1252_P7_6 I1_I1252_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I73_XP_MN1 (VSS I1_I1252_pn6 I1_I1252_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I73_XP_MN0 (I1_I1206_P7_6 I1_I1206_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I73_XP_MN1 (VSS I1_I1206_pn6 I1_I1206_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I74_XP_MN0 (I1_I1206_P8_7 I1_I1206_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I74_XP_MN1 (VSS I1_I1206_pn7 I1_I1206_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I72_XP_MN0 (I1_I1206_P6_5 I1_I1206_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I72_XP_MN1 (VSS I1_I1206_pn5 I1_I1206_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I133_XP_MN0 (I1_I1206_P8_1 I1_I1206_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I133_XP_MN1 (VSS I1_I1206_P4_1n I1_I1206_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I96_XP_MN0 (I1_I884_P30_29 I1_I884_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I96_XP_MN1 (VSS I1_I884_pn29 I1_I884_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I92_XP_MN0 (I1_I884_P26_25 I1_I884_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I92_XP_MN1 (VSS I1_I884_pn25 I1_I884_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I90_XP_MN0 (I1_I884_P24_23 I1_I884_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I90_XP_MN1 (VSS I1_I884_pn23 I1_I884_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I88_XP_MN0 (I1_I884_P22_21 I1_I884_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I88_XP_MN1 (VSS I1_I884_pn21 I1_I884_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I86_XP_MN0 (I1_I884_P20_19 I1_I884_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I86_XP_MN1 (VSS I1_I884_pn19 I1_I884_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I84_XP_MN0 (I1_I884_P18_17 I1_I884_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I84_XP_MN1 (VSS I1_I884_pn17 I1_I884_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I82_XP_MN0 (I1_I884_P16_15 I1_I884_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I82_XP_MN1 (VSS I1_I884_pn15 I1_I884_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I80_XP_MN0 (I1_I884_P14_13 I1_I884_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I80_XP_MN1 (VSS I1_I884_pn13 I1_I884_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I134_XP_MN0 (I1_I884_P9_2 I1_I884_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I134_XP_MN1 (VSS I1_I884_P5_2n I1_I884_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I73_XP_MN0 (I1_I884_P7_6 I1_I884_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I73_XP_MN1 (VSS I1_I884_pn6 I1_I884_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I93_XP_MN0 (I1_I1390_P27_26 I1_I1390_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I93_XP_MN1 (VSS I1_I1390_pn26 I1_I1390_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I91_XP_MN0 (I1_I1390_P25_24 I1_I1390_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I91_XP_MN1 (VSS I1_I1390_pn24 I1_I1390_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I89_XP_MN0 (I1_I1390_P23_22 I1_I1390_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I89_XP_MN1 (VSS I1_I1390_pn22 I1_I1390_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I87_XP_MN0 (I1_I1390_P21_20 I1_I1390_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I87_XP_MN1 (VSS I1_I1390_pn20 I1_I1390_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I72_XP_MN0 (I1_I1344_P6_5 I1_I1344_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I72_XP_MN1 (VSS I1_I1344_pn5 I1_I1344_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I71_XP_MN0 (I1_I1344_P5_4 I1_I1344_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I71_XP_MN1 (VSS I1_I1344_pn4 I1_I1344_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I71_XP_MN0 (I1_I1298_P5_4 I1_I1298_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I71_XP_MN1 (VSS I1_I1298_pn4 I1_I1298_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I72_XP_MN0 (I1_I1298_P6_5 I1_I1298_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I72_XP_MN1 (VSS I1_I1298_pn5 I1_I1298_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I72_XP_MN0 (I1_I1252_P6_5 I1_I1252_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I72_XP_MN1 (VSS I1_I1252_pn5 I1_I1252_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I71_XP_MN0 (I1_I1206_P5_4 I1_I1206_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I71_XP_MN1 (VSS I1_I1206_pn4 I1_I1206_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I70_XP_MN0 (I1_I1206_P4_3 I1_I1206_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I70_XP_MN1 (VSS I1_I1206_pn3 I1_I1206_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I155_XP_MN0 (I1_I884_P30_23 I1_I884_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I155_XP_MN1 (VSS I1_I884_P26_23n I1_I884_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I153_XP_MN0 (I1_I884_P28_21 I1_I884_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I153_XP_MN1 (VSS I1_I884_P24_21n I1_I884_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I151_XP_MN0 (I1_I884_P26_19 I1_I884_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I151_XP_MN1 (VSS I1_I884_P22_19n I1_I884_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I147_XP_MN0 (I1_I884_P22_15 I1_I884_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I147_XP_MN1 (VSS I1_I884_P18_15n I1_I884_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I149_XP_MN0 (I1_I884_P24_17 I1_I884_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I149_XP_MN1 (VSS I1_I884_P20_17n I1_I884_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I145_XP_MN0 (I1_I884_P20_13 I1_I884_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I145_XP_MN1 (VSS I1_I884_P16_13n I1_I884_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I143_XP_MN0 (I1_I884_P18_11 I1_I884_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I143_XP_MN1 (VSS I1_I884_P14_11n I1_I884_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I139_XP_MN0 (I1_I884_P14_7 I1_I884_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I139_XP_MN1 (VSS I1_I884_P10_7n I1_I884_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I141_XP_MN0 (I1_I884_P16_9 I1_I884_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I141_XP_MN1 (VSS I1_I884_P12_9n I1_I884_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I78_XP_MN0 (I1_I884_P12_11 I1_I884_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I78_XP_MN1 (VSS I1_I884_pn11 I1_I884_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I76_XP_MN0 (I1_I884_P10_9 I1_I884_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I76_XP_MN1 (VSS I1_I884_pn9 I1_I884_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I74_XP_MN0 (I1_I884_P8_7 I1_I884_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I74_XP_MN1 (VSS I1_I884_pn7 I1_I884_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I72_XP_MN0 (I1_I884_P6_5 I1_I884_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I72_XP_MN1 (VSS I1_I884_pn5 I1_I884_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I71_XP_MN0 (I1_I884_P5_4 I1_I884_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I71_XP_MN1 (VSS I1_I884_pn4 I1_I884_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I136_XP_MN0 (I1_I700_P11_4 I1_I700_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I136_XP_MN1 (VSS I1_I700_P7_4n I1_I700_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I138_XP_MN0 (I1_I700_P13_6 I1_I700_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I138_XP_MN1 (VSS I1_I700_P9_6n I1_I700_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I140_XP_MN0 (I1_I700_P15_8 I1_I700_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I140_XP_MN1 (VSS I1_I700_P11_8n I1_I700_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I144_XP_MN0 (I1_I700_P19_12 I1_I700_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I144_XP_MN1 (VSS I1_I700_P15_12n I1_I700_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I148_XP_MN0 (I1_I700_P23_16 I1_I700_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I148_XP_MN1 (VSS I1_I700_P19_16n I1_I700_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I152_XP_MN0 (I1_I700_P27_20 I1_I700_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I152_XP_MN1 (VSS I1_I700_P23_20n I1_I700_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I156_XP_MN0 (I1_I700_P31_24 I1_I700_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I156_XP_MN1 (VSS I1_I700_P27_24n I1_I700_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I95_XP_MN0 (I1_I1390_P29_28 I1_I1390_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I95_XP_MN1 (VSS I1_I1390_pn28 I1_I1390_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I154_XP_MN0 (I1_I1390_P29_22 I1_I1390_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I154_XP_MN1 (VSS I1_I1390_P25_22n I1_I1390_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I85_XP_MN0 (I1_I1390_P19_18 I1_I1390_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I85_XP_MN1 (VSS I1_I1390_pn18 I1_I1390_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I83_XP_MN0 (I1_I1390_P17_16 I1_I1390_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I83_XP_MN1 (VSS I1_I1390_pn16 I1_I1390_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I70_XP_MN0 (I1_I1344_P4_3 I1_I1344_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I70_XP_MN1 (VSS I1_I1344_pn3 I1_I1344_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I70_XP_MN0 (I1_I1298_P4_3 I1_I1298_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I70_XP_MN1 (VSS I1_I1298_pn3 I1_I1298_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I68_XP_MN0 (I1_I1252_P2_1 I1_I1252_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I68_XP_MN1 (VSS I1_I1252_pn1 I1_I1252_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I70_XP_MN0 (I1_I1252_P4_3 I1_I1252_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I70_XP_MN1 (VSS I1_I1252_pn3 I1_I1252_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I69_XP_MN0 (I1_I1252_P3_2 I1_I1252_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I69_XP_MN1 (VSS I1_I1252_pn2 I1_I1252_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I71_XP_MN0 (I1_I1252_P5_4 I1_I1252_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I71_XP_MN1 (VSS I1_I1252_pn4 I1_I1252_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I144_XP_MN0 (I1_I1160_P19_12 I1_I1160_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I144_XP_MN1 (VSS I1_I1160_P15_12n I1_I1160_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I140_XP_MN0 (I1_I1160_P15_8 I1_I1160_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I140_XP_MN1 (VSS I1_I1160_P11_8n I1_I1160_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I136_XP_MN0 (I1_I1160_P11_4 I1_I1160_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I136_XP_MN1 (VSS I1_I1160_P7_4n I1_I1160_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I69_XP_MN0 (I1_I1206_P3_2 I1_I1206_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I69_XP_MN1 (VSS I1_I1206_pn2 I1_I1206_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I68_XP_MN0 (I1_I1206_P2_1 I1_I1206_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I68_XP_MN1 (VSS I1_I1206_pn1 I1_I1206_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I137_XP_MN0 (I1_I884_P12_5 I1_I884_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I137_XP_MN1 (VSS I1_I884_P8_5n I1_I884_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I135_XP_MN0 (I1_I884_P10_3 I1_I884_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I135_XP_MN1 (VSS I1_I884_P6_3n I1_I884_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I70_XP_MN0 (I1_I884_P4_3 I1_I884_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I70_XP_MN1 (VSS I1_I884_pn3 I1_I884_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I69_XP_MN0 (I1_I884_P3_2 I1_I884_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I69_XP_MN1 (VSS I1_I884_pn2 I1_I884_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I134_XP_MN0 (I1_I700_P9_2 I1_I700_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I134_XP_MN1 (VSS I1_I700_P5_2n I1_I700_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I142_XP_MN0 (I1_I700_P17_10 I1_I700_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I142_XP_MN1 (VSS I1_I700_P13_10n I1_I700_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I83_XP_MN0 (I1_I700_P17_16 I1_I700_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I83_XP_MN1 (VSS I1_I700_pn16 I1_I700_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I146_XP_MN0 (I1_I700_P21_14 I1_I700_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I146_XP_MN1 (VSS I1_I700_P17_14n I1_I700_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I150_XP_MN0 (I1_I700_P25_18 I1_I700_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I150_XP_MN1 (VSS I1_I700_P21_18n I1_I700_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I154_XP_MN0 (I1_I700_P29_22 I1_I700_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I154_XP_MN1 (VSS I1_I700_P25_22n I1_I700_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I97_XP_MN0 (I1_I1390_P31_30 I1_I1390_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I97_XP_MN1 (VSS I1_I1390_pn30 I1_I1390_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I96_XP_MN0 (I1_I1390_P30_29 I1_I1390_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I96_XP_MN1 (VSS I1_I1390_pn29 I1_I1390_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I156_XP_MN0 (I1_I1390_P31_24 I1_I1390_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I156_XP_MN1 (VSS I1_I1390_P27_24n I1_I1390_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I152_XP_MN0 (I1_I1390_P27_20 I1_I1390_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I152_XP_MN1 (VSS I1_I1390_P23_20n I1_I1390_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I148_XP_MN0 (I1_I1390_P23_16 I1_I1390_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I148_XP_MN1 (VSS I1_I1390_P19_16n I1_I1390_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I150_XP_MN0 (I1_I1390_P25_18 I1_I1390_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I150_XP_MN1 (VSS I1_I1390_P21_18n I1_I1390_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I146_XP_MN0 (I1_I1390_P21_14 I1_I1390_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I146_XP_MN1 (VSS I1_I1390_P17_14n I1_I1390_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I144_XP_MN0 (I1_I1390_P19_12 I1_I1390_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I144_XP_MN1 (VSS I1_I1390_P15_12n I1_I1390_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I81_XP_MN0 (I1_I1390_P15_14 I1_I1390_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I81_XP_MN1 (VSS I1_I1390_pn14 I1_I1390_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I79_XP_MN0 (I1_I1390_P13_12 I1_I1390_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I79_XP_MN1 (VSS I1_I1390_pn12 I1_I1390_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I68_XP_MN0 (I1_I1344_P2_1 I1_I1344_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I68_XP_MN1 (VSS I1_I1344_pn1 I1_I1344_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I69_XP_MN0 (I1_I1344_P3_2 I1_I1344_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I69_XP_MN1 (VSS I1_I1344_pn2 I1_I1344_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I69_XP_MN0 (I1_I1298_P3_2 I1_I1298_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I69_XP_MN1 (VSS I1_I1298_pn2 I1_I1298_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I68_XP_MN0 (I1_I1298_P2_1 I1_I1298_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I68_XP_MN1 (VSS I1_I1298_pn1 I1_I1298_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I156_XP_MN0 (I1_I1160_P31_24 I1_I1160_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I156_XP_MN1 (VSS I1_I1160_P27_24n I1_I1160_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I154_XP_MN0 (I1_I1160_P29_22 I1_I1160_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I154_XP_MN1 (VSS I1_I1160_P25_22n I1_I1160_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I152_XP_MN0 (I1_I1160_P27_20 I1_I1160_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I152_XP_MN1 (VSS I1_I1160_P23_20n I1_I1160_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I148_XP_MN0 (I1_I1160_P23_16 I1_I1160_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I148_XP_MN1 (VSS I1_I1160_P19_16n I1_I1160_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I150_XP_MN0 (I1_I1160_P25_18 I1_I1160_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I150_XP_MN1 (VSS I1_I1160_P21_18n I1_I1160_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I146_XP_MN0 (I1_I1160_P21_14 I1_I1160_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I146_XP_MN1 (VSS I1_I1160_P17_14n I1_I1160_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I142_XP_MN0 (I1_I1160_P17_10 I1_I1160_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I142_XP_MN1 (VSS I1_I1160_P13_10n I1_I1160_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I138_XP_MN0 (I1_I1160_P13_6 I1_I1160_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I138_XP_MN1 (VSS I1_I1160_P9_6n I1_I1160_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I134_XP_MN0 (I1_I1160_P9_2 I1_I1160_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I134_XP_MN1 (VSS I1_I1160_P5_2n I1_I1160_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I133_XP_MN0 (I1_I884_P8_1 I1_I884_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I133_XP_MN1 (VSS I1_I884_P4_1n I1_I884_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I884_I68_XP_MN0 (I1_I884_P2_1 I1_I884_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I884_I68_XP_MN1 (VSS I1_I884_pn1 I1_I884_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I69_XP_MN0 (I1_I700_P3_2 I1_I700_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I69_XP_MN1 (VSS I1_I700_pn2 I1_I700_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I71_XP_MN0 (I1_I700_P5_4 I1_I700_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I71_XP_MN1 (VSS I1_I700_pn4 I1_I700_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I73_XP_MN0 (I1_I700_P7_6 I1_I700_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I73_XP_MN1 (VSS I1_I700_pn6 I1_I700_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I75_XP_MN0 (I1_I700_P9_8 I1_I700_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I75_XP_MN1 (VSS I1_I700_pn8 I1_I700_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I77_XP_MN0 (I1_I700_P11_10 I1_I700_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I77_XP_MN1 (VSS I1_I700_pn10 I1_I700_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I79_XP_MN0 (I1_I700_P13_12 I1_I700_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I79_XP_MN1 (VSS I1_I700_pn12 I1_I700_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I81_XP_MN0 (I1_I700_P15_14 I1_I700_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I81_XP_MN1 (VSS I1_I700_pn14 I1_I700_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I85_XP_MN0 (I1_I700_P19_18 I1_I700_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I85_XP_MN1 (VSS I1_I700_pn18 I1_I700_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I87_XP_MN0 (I1_I700_P21_20 I1_I700_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I87_XP_MN1 (VSS I1_I700_pn20 I1_I700_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I89_XP_MN0 (I1_I700_P23_22 I1_I700_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I89_XP_MN1 (VSS I1_I700_pn22 I1_I700_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I91_XP_MN0 (I1_I700_P25_24 I1_I700_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I91_XP_MN1 (VSS I1_I700_pn24 I1_I700_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I93_XP_MN0 (I1_I700_P27_26 I1_I700_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I93_XP_MN1 (VSS I1_I700_pn26 I1_I700_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I95_XP_MN0 (I1_I700_P29_28 I1_I700_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I95_XP_MN1 (VSS I1_I700_pn28 I1_I700_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I97_XP_MN0 (I1_I700_P31_30 I1_I700_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I97_XP_MN1 (VSS I1_I700_pn30 I1_I700_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I94_XP_MN0 (I1_I1390_P28_27 I1_I1390_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I94_XP_MN1 (VSS I1_I1390_pn27 I1_I1390_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I90_XP_MN0 (I1_I1390_P24_23 I1_I1390_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I90_XP_MN1 (VSS I1_I1390_pn23 I1_I1390_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I140_XP_MN0 (I1_I1390_P15_8 I1_I1390_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I140_XP_MN1 (VSS I1_I1390_P11_8n I1_I1390_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I142_XP_MN0 (I1_I1390_P17_10 I1_I1390_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I142_XP_MN1 (VSS I1_I1390_P13_10n I1_I1390_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I138_XP_MN0 (I1_I1390_P13_6 I1_I1390_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I138_XP_MN1 (VSS I1_I1390_P9_6n I1_I1390_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I136_XP_MN0 (I1_I1390_P11_4 I1_I1390_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I136_XP_MN1 (VSS I1_I1390_P7_4n I1_I1390_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I77_XP_MN0 (I1_I1390_P11_10 I1_I1390_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I77_XP_MN1 (VSS I1_I1390_pn10 I1_I1390_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I75_XP_MN0 (I1_I1390_P9_8 I1_I1390_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I75_XP_MN1 (VSS I1_I1390_pn8 I1_I1390_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I97_XP_MN0 (I1_I1160_P31_30 I1_I1160_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I97_XP_MN1 (VSS I1_I1160_pn30 I1_I1160_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I95_XP_MN0 (I1_I1160_P29_28 I1_I1160_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I95_XP_MN1 (VSS I1_I1160_pn28 I1_I1160_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I87_XP_MN0 (I1_I1160_P21_20 I1_I1160_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I87_XP_MN1 (VSS I1_I1160_pn20 I1_I1160_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I85_XP_MN0 (I1_I1160_P19_18 I1_I1160_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I85_XP_MN1 (VSS I1_I1160_pn18 I1_I1160_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I79_XP_MN0 (I1_I1160_P13_12 I1_I1160_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I79_XP_MN1 (VSS I1_I1160_pn12 I1_I1160_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I75_XP_MN0 (I1_I1160_P9_8 I1_I1160_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I75_XP_MN1 (VSS I1_I1160_pn8 I1_I1160_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I73_XP_MN0 (I1_I1160_P7_6 I1_I1160_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I73_XP_MN1 (VSS I1_I1160_pn6 I1_I1160_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I71_XP_MN0 (I1_I1160_P5_4 I1_I1160_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I71_XP_MN1 (VSS I1_I1160_pn4 I1_I1160_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I133_XP_MN0 (I1_I700_P8_1 I1_I700_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I133_XP_MN1 (VSS I1_I700_P4_1n I1_I700_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I135_XP_MN0 (I1_I700_P10_3 I1_I700_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I135_XP_MN1 (VSS I1_I700_P6_3n I1_I700_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I137_XP_MN0 (I1_I700_P12_5 I1_I700_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I137_XP_MN1 (VSS I1_I700_P8_5n I1_I700_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I141_XP_MN0 (I1_I700_P16_9 I1_I700_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I141_XP_MN1 (VSS I1_I700_P12_9n I1_I700_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I139_XP_MN0 (I1_I700_P14_7 I1_I700_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I139_XP_MN1 (VSS I1_I700_P10_7n I1_I700_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I147_XP_MN0 (I1_I700_P22_15 I1_I700_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I147_XP_MN1 (VSS I1_I700_P18_15n I1_I700_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I151_XP_MN0 (I1_I700_P26_19 I1_I700_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I151_XP_MN1 (VSS I1_I700_P22_19n I1_I700_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I155_XP_MN0 (I1_I700_P30_23 I1_I700_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I155_XP_MN1 (VSS I1_I700_P26_23n I1_I700_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I94_XP_MN0 (I1_I700_P28_27 I1_I700_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I94_XP_MN1 (VSS I1_I700_pn27 I1_I700_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I96_XP_MN0 (I1_I700_P30_29 I1_I700_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I96_XP_MN1 (VSS I1_I700_pn29 I1_I700_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I155_XP_MN0 (I1_I1390_P30_23 I1_I1390_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I155_XP_MN1 (VSS I1_I1390_P26_23n I1_I1390_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I92_XP_MN0 (I1_I1390_P26_25 I1_I1390_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I92_XP_MN1 (VSS I1_I1390_pn25 I1_I1390_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I88_XP_MN0 (I1_I1390_P22_21 I1_I1390_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I88_XP_MN1 (VSS I1_I1390_pn21 I1_I1390_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I86_XP_MN0 (I1_I1390_P20_19 I1_I1390_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I86_XP_MN1 (VSS I1_I1390_pn19 I1_I1390_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I84_XP_MN0 (I1_I1390_P18_17 I1_I1390_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I84_XP_MN1 (VSS I1_I1390_pn17 I1_I1390_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I82_XP_MN0 (I1_I1390_P16_15 I1_I1390_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I82_XP_MN1 (VSS I1_I1390_pn15 I1_I1390_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I80_XP_MN0 (I1_I1390_P14_13 I1_I1390_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I80_XP_MN1 (VSS I1_I1390_pn13 I1_I1390_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I134_XP_MN0 (I1_I1390_P9_2 I1_I1390_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I134_XP_MN1 (VSS I1_I1390_P5_2n I1_I1390_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I73_XP_MN0 (I1_I1390_P7_6 I1_I1390_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I73_XP_MN1 (VSS I1_I1390_pn6 I1_I1390_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I96_XP_MN0 (I1_I1160_P30_29 I1_I1160_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I96_XP_MN1 (VSS I1_I1160_pn29 I1_I1160_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I94_XP_MN0 (I1_I1160_P28_27 I1_I1160_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I94_XP_MN1 (VSS I1_I1160_pn27 I1_I1160_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I93_XP_MN0 (I1_I1160_P27_26 I1_I1160_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I93_XP_MN1 (VSS I1_I1160_pn26 I1_I1160_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I92_XP_MN0 (I1_I1160_P26_25 I1_I1160_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I92_XP_MN1 (VSS I1_I1160_pn25 I1_I1160_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I91_XP_MN0 (I1_I1160_P25_24 I1_I1160_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I91_XP_MN1 (VSS I1_I1160_pn24 I1_I1160_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I155_XP_MN0 (I1_I1160_P30_23 I1_I1160_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I155_XP_MN1 (VSS I1_I1160_P26_23n I1_I1160_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I89_XP_MN0 (I1_I1160_P23_22 I1_I1160_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I89_XP_MN1 (VSS I1_I1160_pn22 I1_I1160_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I83_XP_MN0 (I1_I1160_P17_16 I1_I1160_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I83_XP_MN1 (VSS I1_I1160_pn16 I1_I1160_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I81_XP_MN0 (I1_I1160_P15_14 I1_I1160_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I81_XP_MN1 (VSS I1_I1160_pn14 I1_I1160_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I77_XP_MN0 (I1_I1160_P11_10 I1_I1160_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I77_XP_MN1 (VSS I1_I1160_pn10 I1_I1160_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I69_XP_MN0 (I1_I1160_P3_2 I1_I1160_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I69_XP_MN1 (VSS I1_I1160_pn2 I1_I1160_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I95_XP_MN0 (I1_I930_P29_28 I1_I930_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I95_XP_MN1 (VSS I1_I930_pn28 I1_I930_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I93_XP_MN0 (I1_I930_P27_26 I1_I930_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I93_XP_MN1 (VSS I1_I930_pn26 I1_I930_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I91_XP_MN0 (I1_I930_P25_24 I1_I930_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I91_XP_MN1 (VSS I1_I930_pn24 I1_I930_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I89_XP_MN0 (I1_I930_P23_22 I1_I930_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I89_XP_MN1 (VSS I1_I930_pn22 I1_I930_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I87_XP_MN0 (I1_I930_P21_20 I1_I930_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I87_XP_MN1 (VSS I1_I930_pn20 I1_I930_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I85_XP_MN0 (I1_I930_P19_18 I1_I930_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I85_XP_MN1 (VSS I1_I930_pn18 I1_I930_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I83_XP_MN0 (I1_I930_P17_16 I1_I930_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I83_XP_MN1 (VSS I1_I930_pn16 I1_I930_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I81_XP_MN0 (I1_I930_P15_14 I1_I930_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I81_XP_MN1 (VSS I1_I930_pn14 I1_I930_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I79_XP_MN0 (I1_I930_P13_12 I1_I930_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I79_XP_MN1 (VSS I1_I930_pn12 I1_I930_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I77_XP_MN0 (I1_I930_P11_10 I1_I930_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I77_XP_MN1 (VSS I1_I930_pn10 I1_I930_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I68_XP_MN0 (I1_I700_P2_1 I1_I700_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I68_XP_MN1 (VSS I1_I700_pn1 I1_I700_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I70_XP_MN0 (I1_I700_P4_3 I1_I700_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I70_XP_MN1 (VSS I1_I700_pn3 I1_I700_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I72_XP_MN0 (I1_I700_P6_5 I1_I700_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I72_XP_MN1 (VSS I1_I700_pn5 I1_I700_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I74_XP_MN0 (I1_I700_P8_7 I1_I700_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I74_XP_MN1 (VSS I1_I700_pn7 I1_I700_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I76_XP_MN0 (I1_I700_P10_9 I1_I700_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I76_XP_MN1 (VSS I1_I700_pn9 I1_I700_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I80_XP_MN0 (I1_I700_P14_13 I1_I700_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I80_XP_MN1 (VSS I1_I700_pn13 I1_I700_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I149_XP_MN0 (I1_I700_P24_17 I1_I700_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I149_XP_MN1 (VSS I1_I700_P20_17n I1_I700_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I86_XP_MN0 (I1_I700_P20_19 I1_I700_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I86_XP_MN1 (VSS I1_I700_pn19 I1_I700_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I88_XP_MN0 (I1_I700_P22_21 I1_I700_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I88_XP_MN1 (VSS I1_I700_pn21 I1_I700_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I153_XP_MN0 (I1_I700_P28_21 I1_I700_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I153_XP_MN1 (VSS I1_I700_P24_21n I1_I700_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I90_XP_MN0 (I1_I700_P24_23 I1_I700_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I90_XP_MN1 (VSS I1_I700_pn23 I1_I700_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I92_XP_MN0 (I1_I700_P26_25 I1_I700_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I92_XP_MN1 (VSS I1_I700_pn25 I1_I700_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I153_XP_MN0 (I1_I1390_P28_21 I1_I1390_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I153_XP_MN1 (VSS I1_I1390_P24_21n I1_I1390_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I151_XP_MN0 (I1_I1390_P26_19 I1_I1390_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I151_XP_MN1 (VSS I1_I1390_P22_19n I1_I1390_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I147_XP_MN0 (I1_I1390_P22_15 I1_I1390_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I147_XP_MN1 (VSS I1_I1390_P18_15n I1_I1390_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I149_XP_MN0 (I1_I1390_P24_17 I1_I1390_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I149_XP_MN1 (VSS I1_I1390_P20_17n I1_I1390_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I145_XP_MN0 (I1_I1390_P20_13 I1_I1390_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I145_XP_MN1 (VSS I1_I1390_P16_13n I1_I1390_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I143_XP_MN0 (I1_I1390_P18_11 I1_I1390_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I143_XP_MN1 (VSS I1_I1390_P14_11n I1_I1390_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I78_XP_MN0 (I1_I1390_P12_11 I1_I1390_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I78_XP_MN1 (VSS I1_I1390_pn11 I1_I1390_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I76_XP_MN0 (I1_I1390_P10_9 I1_I1390_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I76_XP_MN1 (VSS I1_I1390_pn9 I1_I1390_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I74_XP_MN0 (I1_I1390_P8_7 I1_I1390_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I74_XP_MN1 (VSS I1_I1390_pn7 I1_I1390_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I71_XP_MN0 (I1_I1390_P5_4 I1_I1390_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I71_XP_MN1 (VSS I1_I1390_pn4 I1_I1390_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I153_XP_MN0 (I1_I1160_P28_21 I1_I1160_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I153_XP_MN1 (VSS I1_I1160_P24_21n I1_I1160_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I151_XP_MN0 (I1_I1160_P26_19 I1_I1160_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I151_XP_MN1 (VSS I1_I1160_P22_19n I1_I1160_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I135_XP_MN0 (I1_I1160_P10_3 I1_I1160_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I135_XP_MN1 (VSS I1_I1160_P6_3n I1_I1160_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I137_XP_MN0 (I1_I1160_P12_5 I1_I1160_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I137_XP_MN1 (VSS I1_I1160_P8_5n I1_I1160_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I133_XP_MN0 (I1_I1160_P8_1 I1_I1160_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I133_XP_MN1 (VSS I1_I1160_P4_1n I1_I1160_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I68_XP_MN0 (I1_I1160_P2_1 I1_I1160_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I68_XP_MN1 (VSS I1_I1160_pn1 I1_I1160_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I97_XP_MN0 (I1_I930_P31_30 I1_I930_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I97_XP_MN1 (VSS I1_I930_pn30 I1_I930_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I156_XP_MN0 (I1_I930_P31_24 I1_I930_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I156_XP_MN1 (VSS I1_I930_P27_24n I1_I930_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I154_XP_MN0 (I1_I930_P29_22 I1_I930_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I154_XP_MN1 (VSS I1_I930_P25_22n I1_I930_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I152_XP_MN0 (I1_I930_P27_20 I1_I930_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I152_XP_MN1 (VSS I1_I930_P23_20n I1_I930_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I148_XP_MN0 (I1_I930_P23_16 I1_I930_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I148_XP_MN1 (VSS I1_I930_P19_16n I1_I930_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I150_XP_MN0 (I1_I930_P25_18 I1_I930_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I150_XP_MN1 (VSS I1_I930_P21_18n I1_I930_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I146_XP_MN0 (I1_I930_P21_14 I1_I930_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I146_XP_MN1 (VSS I1_I930_P17_14n I1_I930_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I144_XP_MN0 (I1_I930_P19_12 I1_I930_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I144_XP_MN1 (VSS I1_I930_P15_12n I1_I930_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I140_XP_MN0 (I1_I930_P15_8 I1_I930_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I140_XP_MN1 (VSS I1_I930_P11_8n I1_I930_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I142_XP_MN0 (I1_I930_P17_10 I1_I930_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I142_XP_MN1 (VSS I1_I930_P13_10n I1_I930_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I138_XP_MN0 (I1_I930_P13_6 I1_I930_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I138_XP_MN1 (VSS I1_I930_P9_6n I1_I930_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I136_XP_MN0 (I1_I930_P11_4 I1_I930_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I136_XP_MN1 (VSS I1_I930_P7_4n I1_I930_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I75_XP_MN0 (I1_I930_P9_8 I1_I930_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I75_XP_MN1 (VSS I1_I930_pn8 I1_I930_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I73_XP_MN0 (I1_I930_P7_6 I1_I930_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I73_XP_MN1 (VSS I1_I930_pn6 I1_I930_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I78_XP_MN0 (I1_I700_P12_11 I1_I700_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I78_XP_MN1 (VSS I1_I700_pn11 I1_I700_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I82_XP_MN0 (I1_I700_P16_15 I1_I700_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I82_XP_MN1 (VSS I1_I700_pn15 I1_I700_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I700_I84_XP_MN0 (I1_I700_P18_17 I1_I700_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I700_I84_XP_MN1 (VSS I1_I700_pn17 I1_I700_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I139_XP_MN0 (I1_I1390_P14_7 I1_I1390_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I139_XP_MN1 (VSS I1_I1390_P10_7n I1_I1390_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I141_XP_MN0 (I1_I1390_P16_9 I1_I1390_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I141_XP_MN1 (VSS I1_I1390_P12_9n I1_I1390_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I137_XP_MN0 (I1_I1390_P12_5 I1_I1390_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I137_XP_MN1 (VSS I1_I1390_P8_5n I1_I1390_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I135_XP_MN0 (I1_I1390_P10_3 I1_I1390_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I135_XP_MN1 (VSS I1_I1390_P6_3n I1_I1390_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I72_XP_MN0 (I1_I1390_P6_5 I1_I1390_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I72_XP_MN1 (VSS I1_I1390_pn5 I1_I1390_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I70_XP_MN0 (I1_I1390_P4_3 I1_I1390_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I70_XP_MN1 (VSS I1_I1390_pn3 I1_I1390_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I90_XP_MN0 (I1_I1160_P24_23 I1_I1160_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I90_XP_MN1 (VSS I1_I1160_pn23 I1_I1160_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I88_XP_MN0 (I1_I1160_P22_21 I1_I1160_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I88_XP_MN1 (VSS I1_I1160_pn21 I1_I1160_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I86_XP_MN0 (I1_I1160_P20_19 I1_I1160_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I86_XP_MN1 (VSS I1_I1160_pn19 I1_I1160_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I147_XP_MN0 (I1_I1160_P22_15 I1_I1160_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I147_XP_MN1 (VSS I1_I1160_P18_15n I1_I1160_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I149_XP_MN0 (I1_I1160_P24_17 I1_I1160_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I149_XP_MN1 (VSS I1_I1160_P20_17n I1_I1160_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I145_XP_MN0 (I1_I1160_P20_13 I1_I1160_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I145_XP_MN1 (VSS I1_I1160_P16_13n I1_I1160_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I143_XP_MN0 (I1_I1160_P18_11 I1_I1160_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I143_XP_MN1 (VSS I1_I1160_P14_11n I1_I1160_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I139_XP_MN0 (I1_I1160_P14_7 I1_I1160_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I139_XP_MN1 (VSS I1_I1160_P10_7n I1_I1160_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I74_XP_MN0 (I1_I1160_P8_7 I1_I1160_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I74_XP_MN1 (VSS I1_I1160_pn7 I1_I1160_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I141_XP_MN0 (I1_I1160_P16_9 I1_I1160_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I141_XP_MN1 (VSS I1_I1160_P12_9n I1_I1160_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I72_XP_MN0 (I1_I1160_P6_5 I1_I1160_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I72_XP_MN1 (VSS I1_I1160_pn5 I1_I1160_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I70_XP_MN0 (I1_I1160_P4_3 I1_I1160_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I70_XP_MN1 (VSS I1_I1160_pn3 I1_I1160_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I96_XP_MN0 (I1_I930_P30_29 I1_I930_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I96_XP_MN1 (VSS I1_I930_pn29 I1_I930_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I94_XP_MN0 (I1_I930_P28_27 I1_I930_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I94_XP_MN1 (VSS I1_I930_pn27 I1_I930_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I92_XP_MN0 (I1_I930_P26_25 I1_I930_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I92_XP_MN1 (VSS I1_I930_pn25 I1_I930_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I90_XP_MN0 (I1_I930_P24_23 I1_I930_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I90_XP_MN1 (VSS I1_I930_pn23 I1_I930_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I88_XP_MN0 (I1_I930_P22_21 I1_I930_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I88_XP_MN1 (VSS I1_I930_pn21 I1_I930_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I84_XP_MN0 (I1_I930_P18_17 I1_I930_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I84_XP_MN1 (VSS I1_I930_pn17 I1_I930_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I82_XP_MN0 (I1_I930_P16_15 I1_I930_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I82_XP_MN1 (VSS I1_I930_pn15 I1_I930_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I80_XP_MN0 (I1_I930_P14_13 I1_I930_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I80_XP_MN1 (VSS I1_I930_pn13 I1_I930_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I78_XP_MN0 (I1_I930_P12_11 I1_I930_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I78_XP_MN1 (VSS I1_I930_pn11 I1_I930_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I134_XP_MN0 (I1_I930_P9_2 I1_I930_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I134_XP_MN1 (VSS I1_I930_P5_2n I1_I930_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I71_XP_MN0 (I1_I930_P5_4 I1_I930_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I71_XP_MN1 (VSS I1_I930_pn4 I1_I930_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I133_XP_MN0 (I1_I1390_P8_1 I1_I1390_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I133_XP_MN1 (VSS I1_I1390_P4_1n I1_I1390_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I69_XP_MN0 (I1_I1390_P3_2 I1_I1390_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I69_XP_MN1 (VSS I1_I1390_pn2 I1_I1390_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1390_I68_XP_MN0 (I1_I1390_P2_1 I1_I1390_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1390_I68_XP_MN1 (VSS I1_I1390_pn1 I1_I1390_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I84_XP_MN0 (I1_I1160_P18_17 I1_I1160_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I84_XP_MN1 (VSS I1_I1160_pn17 I1_I1160_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I82_XP_MN0 (I1_I1160_P16_15 I1_I1160_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I82_XP_MN1 (VSS I1_I1160_pn15 I1_I1160_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I80_XP_MN0 (I1_I1160_P14_13 I1_I1160_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I80_XP_MN1 (VSS I1_I1160_pn13 I1_I1160_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I78_XP_MN0 (I1_I1160_P12_11 I1_I1160_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I78_XP_MN1 (VSS I1_I1160_pn11 I1_I1160_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1160_I76_XP_MN0 (I1_I1160_P10_9 I1_I1160_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1160_I76_XP_MN1 (VSS I1_I1160_pn9 I1_I1160_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I155_XP_MN0 (I1_I930_P30_23 I1_I930_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I155_XP_MN1 (VSS I1_I930_P26_23n I1_I930_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I153_XP_MN0 (I1_I930_P28_21 I1_I930_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I153_XP_MN1 (VSS I1_I930_P24_21n I1_I930_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I151_XP_MN0 (I1_I930_P26_19 I1_I930_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I151_XP_MN1 (VSS I1_I930_P22_19n I1_I930_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I147_XP_MN0 (I1_I930_P22_15 I1_I930_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I147_XP_MN1 (VSS I1_I930_P18_15n I1_I930_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I86_XP_MN0 (I1_I930_P20_19 I1_I930_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I86_XP_MN1 (VSS I1_I930_pn19 I1_I930_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I143_XP_MN0 (I1_I930_P18_11 I1_I930_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I143_XP_MN1 (VSS I1_I930_P14_11n I1_I930_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I76_XP_MN0 (I1_I930_P10_9 I1_I930_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I76_XP_MN1 (VSS I1_I930_pn9 I1_I930_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I74_XP_MN0 (I1_I930_P8_7 I1_I930_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I74_XP_MN1 (VSS I1_I930_pn7 I1_I930_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I72_XP_MN0 (I1_I930_P6_5 I1_I930_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I72_XP_MN1 (VSS I1_I930_pn5 I1_I930_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I136_XP_MN0 (I1_I654_P11_4 I1_I654_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I136_XP_MN1 (VSS I1_I654_P7_4n I1_I654_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I140_XP_MN0 (I1_I654_P15_8 I1_I654_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I140_XP_MN1 (VSS I1_I654_P11_8n I1_I654_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I95_XP_MN0 (I1_I1114_P29_28 I1_I1114_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I95_XP_MN1 (VSS I1_I1114_pn28 I1_I1114_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1114_I96_XP_MN0 (I1_I1114_P30_29 I1_I1114_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1114_I96_XP_MN1 (VSS I1_I1114_pn29 I1_I1114_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I149_XP_MN0 (I1_I930_P24_17 I1_I930_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I149_XP_MN1 (VSS I1_I930_P20_17n I1_I930_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I145_XP_MN0 (I1_I930_P20_13 I1_I930_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I145_XP_MN1 (VSS I1_I930_P16_13n I1_I930_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I139_XP_MN0 (I1_I930_P14_7 I1_I930_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I139_XP_MN1 (VSS I1_I930_P10_7n I1_I930_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I141_XP_MN0 (I1_I930_P16_9 I1_I930_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I141_XP_MN1 (VSS I1_I930_P12_9n I1_I930_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I137_XP_MN0 (I1_I930_P12_5 I1_I930_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I137_XP_MN1 (VSS I1_I930_P8_5n I1_I930_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I135_XP_MN0 (I1_I930_P10_3 I1_I930_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I135_XP_MN1 (VSS I1_I930_P6_3n I1_I930_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I70_XP_MN0 (I1_I930_P4_3 I1_I930_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I70_XP_MN1 (VSS I1_I930_pn3 I1_I930_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I930_I69_XP_MN0 (I1_I930_P3_2 I1_I930_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I930_I69_XP_MN1 (VSS I1_I930_pn2 I1_I930_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I69_XP_MN0 (I1_I654_P3_2 I1_I654_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I69_XP_MN1 (VSS I1_I654_pn2 I1_I654_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I71_XP_MN0 (I1_I654_P5_4 I1_I654_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I71_XP_MN1 (VSS I1_I654_pn4 I1_I654_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I134_XP_MN0 (I1_I654_P9_2 I1_I654_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I134_XP_MN1 (VSS I1_I654_P5_2n I1_I654_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I138_XP_MN0 (I1_I654_P13_6 I1_I654_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I138_XP_MN1 (VSS I1_I654_P9_6n I1_I654_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I142_XP_MN0 (I1_I654_P17_10 I1_I654_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I142_XP_MN1 (VSS I1_I654_P13_10n I1_I654_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I144_XP_MN0 (I1_I654_P19_12 I1_I654_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I144_XP_MN1 (VSS I1_I654_P15_12n I1_I654_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I146_XP_MN0 (I1_I654_P21_14 I1_I654_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I146_XP_MN1 (VSS I1_I654_P17_14n I1_I654_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I150_XP_MN0 (I1_I654_P25_18 I1_I654_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I150_XP_MN1 (VSS I1_I654_P21_18n I1_I654_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I148_XP_MN0 (I1_I654_P23_16 I1_I654_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I148_XP_MN1 (VSS I1_I654_P19_16n I1_I654_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I654_I156_XP_MN0 (I1_I654_P31_24 I1_I654_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I654_I156_XP_MN1 (VSS I1_I654_P27_24n I1_I654_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I86_XP_MN0 (I1_I1436_P20_19 I1_I1436_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I86_XP_MN1 (VSS I1_I1436_pn19 I1_I1436_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
    I_MXI1_I1436_I84_XP_MN0 (I1_I1436_P18_17 I1_I1436_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04078p as=0.06958p pd=0.67999u ps=1.15999u
    I_MXI1_I1436_I84_XP_MN1 (VSS I1_I1436_pn17 I1_I1436_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04078p pd=1.15999u ps=0.67999u
