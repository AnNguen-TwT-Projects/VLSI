    I_MXI2_I1_I42_I52_MN1 (XI2_I1_I42_I52_Bn I2_I1_bx20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I52_MN5 (XI2_I1_I42_I52_n2 I2_I1_bx20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I52_MN4 (I2_I1_I42_pn20 XI2_I1_I42_I52_An XI2_I1_I42_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I52_MN2 (XI2_I1_I42_I52_n1 A_20 I2_I1_I42_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I52_MN3 (VSS XI2_I1_I42_I52_Bn XI2_I1_I42_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I52_MN0 (XI2_I1_I42_I52_An A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I428_MN1 (XI1_I428_Bn I1_nbkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I428_MN5 (XI1_I428_n2 I1_nbkn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I428_MN4 (I1_dd24 XI1_I428_An XI1_I428_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I428_MN2 (XI1_I428_n1 B_24 I1_dd24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I428_MN3 (VSS XI1_I428_Bn XI1_I428_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I428_MN0 (XI1_I428_An B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I441_MN1 (XI1_I441_Bn I1_nbkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I441_MN5 (XI1_I441_n2 I1_nbkn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I441_MN4 (I1_dd25 XI1_I441_An XI1_I441_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I441_MN2 (XI1_I441_n1 B_25 I1_dd25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I441_MN3 (VSS XI1_I441_Bn XI1_I441_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I441_MN0 (XI1_I441_An B_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I209_MN1 (XI1_I562_I209_Bn I1_I562_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I209_MN5 (XI1_I562_I209_n2 I1_I562_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I209_MN4 (I1_p0_6 XI1_I562_I209_An XI1_I562_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I209_MN2 (XI1_I562_I209_n1 I1_I562_pn6 I1_p0_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I209_MN3 (VSS XI1_I562_I209_Bn XI1_I562_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I209_MN0 (XI1_I562_I209_An I1_I562_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I211_MN1 (XI1_I562_I211_Bn I1_I562_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I211_MN5 (XI1_I562_I211_n2 I1_I562_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I211_MN4 (I1_p0_8 XI1_I562_I211_An XI1_I562_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I211_MN2 (XI1_I562_I211_n1 I1_I562_pn8 I1_p0_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I211_MN3 (VSS XI1_I562_I211_Bn XI1_I562_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I211_MN0 (XI1_I562_I211_An I1_I562_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I44_MN1 (XI1_I562_I44_Bn I1_b0_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I44_MN5 (XI1_I562_I44_n2 I1_b0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I44_MN4 (I1_I562_pn12 XI1_I562_I44_An XI1_I562_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I44_MN2 (XI1_I562_I44_n1 VSS I1_I562_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I44_MN3 (VSS XI1_I562_I44_Bn XI1_I562_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I44_MN0 (XI1_I562_I44_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I46_MN1 (XI1_I562_I46_Bn I1_b0_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I46_MN5 (XI1_I562_I46_n2 I1_b0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I46_MN4 (I1_I562_pn14 XI1_I562_I46_An XI1_I562_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I46_MN2 (XI1_I562_I46_n1 VSS I1_I562_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I46_MN3 (VSS XI1_I562_I46_Bn XI1_I562_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I46_MN0 (XI1_I562_I46_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I48_MN1 (XI1_I562_I48_Bn I1_b0_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I48_MN5 (XI1_I562_I48_n2 I1_b0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I48_MN4 (I1_I562_pn16 XI1_I562_I48_An XI1_I562_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I48_MN2 (XI1_I562_I48_n1 VSS I1_I562_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I48_MN3 (VSS XI1_I562_I48_Bn XI1_I562_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I48_MN0 (XI1_I562_I48_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I50_MN1 (XI1_I562_I50_Bn I1_b0_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I50_MN5 (XI1_I562_I50_n2 I1_b0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I50_MN4 (I1_I562_pn18 XI1_I562_I50_An XI1_I562_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I50_MN2 (XI1_I562_I50_n1 VSS I1_I562_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I50_MN3 (VSS XI1_I562_I50_Bn XI1_I562_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I50_MN0 (XI1_I562_I50_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I223_MN1 (XI1_I562_I223_Bn I1_I562_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I223_MN5 (XI1_I562_I223_n2 I1_I562_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I223_MN4 (I1_p0_20 XI1_I562_I223_An XI1_I562_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I223_MN2 (XI1_I562_I223_n1 I1_I562_pn20 I1_p0_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I223_MN3 (VSS XI1_I562_I223_Bn XI1_I562_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I223_MN0 (XI1_I562_I223_An I1_I562_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I52_MN1 (XI1_I562_I52_Bn I1_b0_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I52_MN5 (XI1_I562_I52_n2 I1_b0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I52_MN4 (I1_I562_pn20 XI1_I562_I52_An XI1_I562_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I52_MN2 (XI1_I562_I52_n1 VSS I1_I562_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I52_MN3 (VSS XI1_I562_I52_Bn XI1_I562_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I52_MN0 (XI1_I562_I52_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I54_MN1 (XI1_I562_I54_Bn I1_b0_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I54_MN5 (XI1_I562_I54_n2 I1_b0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I54_MN4 (I1_I562_pn22 XI1_I562_I54_An XI1_I562_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I54_MN2 (XI1_I562_I54_n1 VSS I1_I562_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I54_MN3 (VSS XI1_I562_I54_Bn XI1_I562_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I54_MN0 (XI1_I562_I54_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I229_MN1 (XI1_I562_I229_Bn I1_I562_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I229_MN5 (XI1_I562_I229_n2 I1_I562_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I229_MN4 (I1_p0_26 XI1_I562_I229_An XI1_I562_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I229_MN2 (XI1_I562_I229_n1 I1_I562_pn26 I1_p0_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I229_MN3 (VSS XI1_I562_I229_Bn XI1_I562_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I229_MN0 (XI1_I562_I229_An I1_I562_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I60_MN1 (XI1_I562_I60_Bn I1_b0_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I60_MN5 (XI1_I562_I60_n2 I1_b0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I60_MN4 (I1_I562_pn28 XI1_I562_I60_An XI1_I562_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I60_MN2 (XI1_I562_I60_n1 VSS I1_I562_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I60_MN3 (VSS XI1_I562_I60_Bn XI1_I562_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I60_MN0 (XI1_I562_I60_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I231_MN1 (XI1_I562_I231_Bn I1_I562_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I231_MN5 (XI1_I562_I231_n2 I1_I562_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I231_MN4 (I1_p0_28 XI1_I562_I231_An XI1_I562_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I231_MN2 (XI1_I562_I231_n1 I1_I562_pn28 I1_p0_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I231_MN3 (VSS XI1_I562_I231_Bn XI1_I562_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I231_MN0 (XI1_I562_I231_An I1_I562_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I231_MN1 (XI1_I1712_I231_Bn I1_I1712_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I231_MN5 (XI1_I1712_I231_n2 I1_I1712_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I231_MN4 (I1_p25_28 XI1_I1712_I231_An XI1_I1712_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I231_MN2 (XI1_I1712_I231_n1 I1_I1712_pn28 I1_p25_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I231_MN3 (VSS XI1_I1712_I231_Bn XI1_I1712_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I231_MN0 (XI1_I1712_I231_An I1_I1712_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I229_MN1 (XI1_I1528_I229_Bn I1_I1528_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I229_MN5 (XI1_I1528_I229_n2 I1_I1528_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I229_MN4 (I1_p21_26 XI1_I1528_I229_An XI1_I1528_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I229_MN2 (XI1_I1528_I229_n1 I1_I1528_pn26 I1_p21_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I229_MN3 (VSS XI1_I1528_I229_Bn XI1_I1528_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I229_MN0 (XI1_I1528_I229_An I1_I1528_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I221_MN1 (XI1_I1528_I221_Bn I1_I1528_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I221_MN5 (XI1_I1528_I221_n2 I1_I1528_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I221_MN4 (I1_p21_18 XI1_I1528_I221_An XI1_I1528_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I221_MN2 (XI1_I1528_I221_n1 I1_I1528_pn18 I1_p21_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I221_MN3 (VSS XI1_I1528_I221_Bn XI1_I1528_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I221_MN0 (XI1_I1528_I221_An I1_I1528_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I46_MN1 (XI1_I1574_I46_Bn I1_b22_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I46_MN5 (XI1_I1574_I46_n2 I1_b22_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I46_MN4 (I1_I1574_pn14 XI1_I1574_I46_An XI1_I1574_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I46_MN2 (XI1_I1574_I46_n1 I1_p21_13 I1_I1574_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I46_MN3 (VSS XI1_I1574_I46_Bn XI1_I1574_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I46_MN0 (XI1_I1574_I46_An I1_p21_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I45_MN1 (XI1_I1574_I45_Bn I1_b22_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I45_MN5 (XI1_I1574_I45_n2 I1_b22_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I45_MN4 (I1_I1574_pn13 XI1_I1574_I45_An XI1_I1574_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I45_MN2 (XI1_I1574_I45_n1 I1_p21_12 I1_I1574_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I45_MN3 (VSS XI1_I1574_I45_Bn XI1_I1574_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I45_MN0 (XI1_I1574_I45_An I1_p21_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I211_MN1 (XI1_I1574_I211_Bn I1_I1574_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I211_MN5 (XI1_I1574_I211_n2 I1_I1574_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I211_MN4 (I1_p22_8 XI1_I1574_I211_An XI1_I1574_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I211_MN2 (XI1_I1574_I211_n1 I1_I1574_pn8 I1_p22_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I211_MN3 (VSS XI1_I1574_I211_Bn XI1_I1574_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I211_MN0 (XI1_I1574_I211_An I1_I1574_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I37_MN1 (XI1_I1574_I37_Bn I1_b22_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I37_MN5 (XI1_I1574_I37_n2 I1_b22_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I37_MN4 (I1_I1574_pn5 XI1_I1574_I37_An XI1_I1574_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I37_MN2 (XI1_I1574_I37_n1 I1_p21_4 I1_I1574_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I37_MN3 (VSS XI1_I1574_I37_Bn XI1_I1574_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I37_MN0 (XI1_I1574_I37_An I1_p21_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I67_MN1 (XI1_I67_Bn I1_nakn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I67_MN5 (XI1_I67_n2 I1_nakn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I67_MN4 (I1_aa11 XI1_I67_An XI1_I67_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I67_MN2 (XI1_I67_n1 A_11 I1_aa11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I67_MN3 (VSS XI1_I67_Bn XI1_I67_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I67_MN0 (XI1_I67_An A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2112_MN1 (XI1_I2112_Bn I1_nqkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2112_MN5 (XI1_I2112_n2 I1_nqkn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2112_MN4 (DIVQ_12 XI1_I2112_An XI1_I2112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2112_MN2 (XI1_I2112_n1 I1_qu12_b3_5 DIVQ_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2112_MN3 (VSS XI1_I2112_Bn XI1_I2112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2112_MN0 (XI1_I2112_An I1_qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2109_MN1 (XI1_I2109_Bn I1_nqkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2109_MN5 (XI1_I2109_n2 I1_nqkn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2109_MN4 (DIVQ_11 XI1_I2109_An XI1_I2109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2109_MN2 (XI1_I2109_n1 I1_qu11_b3_5 DIVQ_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2109_MN3 (VSS XI1_I2109_Bn XI1_I2109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2109_MN0 (XI1_I2109_An I1_qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I233_MN1 (XI1_I233_Bn I1_nbkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I233_MN5 (XI1_I233_n2 I1_nbkn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I233_MN4 (I1_dd9 XI1_I233_An XI1_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I233_MN2 (XI1_I233_n1 B_9 I1_dd9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I233_MN3 (VSS XI1_I233_Bn XI1_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I233_MN0 (XI1_I233_An B_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I207_MN1 (XI1_I207_Bn I1_nbkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I207_MN5 (XI1_I207_n2 I1_nbkn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I207_MN4 (I1_dd7 XI1_I207_An XI1_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I207_MN2 (XI1_I207_n1 B_7 I1_dd7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I207_MN3 (VSS XI1_I207_Bn XI1_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I207_MN0 (XI1_I207_An B_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I47_MN1 (XI2_I1_I42_I47_Bn I2_I1_bx15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I47_MN5 (XI2_I1_I42_I47_n2 I2_I1_bx15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I47_MN4 (I2_I1_I42_pn15 XI2_I1_I42_I47_An XI2_I1_I42_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I47_MN2 (XI2_I1_I42_I47_n1 A_15 I2_I1_I42_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I47_MN3 (VSS XI2_I1_I42_I47_Bn XI2_I1_I42_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I47_MN0 (XI2_I1_I42_I47_An A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I220_MN1 (XI2_I1_I42_I220_Bn I2_I1_I42_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I220_MN5 (XI2_I1_I42_I220_n2 I2_I1_I42_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I220_MN4 (I2_S_17 XI2_I1_I42_I220_An XI2_I1_I42_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I220_MN2 (XI2_I1_I42_I220_n1 I2_I1_I42_pn17 I2_S_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I220_MN3 (VSS XI2_I1_I42_I220_Bn XI2_I1_I42_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I220_MN0 (XI2_I1_I42_I220_An I2_I1_I42_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I221_MN1 (XI2_I1_I42_I221_Bn I2_I1_I42_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I221_MN5 (XI2_I1_I42_I221_n2 I2_I1_I42_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I221_MN4 (I2_S_18 XI2_I1_I42_I221_An XI2_I1_I42_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I221_MN2 (XI2_I1_I42_I221_n1 I2_I1_I42_pn18 I2_S_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I221_MN3 (VSS XI2_I1_I42_I221_Bn XI2_I1_I42_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I221_MN0 (XI2_I1_I42_I221_An I2_I1_I42_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I50_MN1 (XI2_I1_I42_I50_Bn I2_I1_bx18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I50_MN5 (XI2_I1_I42_I50_n2 I2_I1_bx18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I50_MN4 (I2_I1_I42_pn18 XI2_I1_I42_I50_An XI2_I1_I42_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I50_MN2 (XI2_I1_I42_I50_n1 A_18 I2_I1_I42_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I50_MN3 (VSS XI2_I1_I42_I50_Bn XI2_I1_I42_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I50_MN0 (XI2_I1_I42_I50_An A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I51_MN1 (XI2_I1_I42_I51_Bn I2_I1_bx19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I51_MN5 (XI2_I1_I42_I51_n2 I2_I1_bx19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I51_MN4 (I2_I1_I42_pn19 XI2_I1_I42_I51_An XI2_I1_I42_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I51_MN2 (XI2_I1_I42_I51_n1 A_19 I2_I1_I42_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I51_MN3 (VSS XI2_I1_I42_I51_Bn XI2_I1_I42_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I51_MN0 (XI2_I1_I42_I51_An A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I224_MN1 (XI2_I1_I42_I224_Bn I2_I1_I42_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I224_MN5 (XI2_I1_I42_I224_n2 I2_I1_I42_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I224_MN4 (I2_S_21 XI2_I1_I42_I224_An XI2_I1_I42_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I224_MN2 (XI2_I1_I42_I224_n1 I2_I1_I42_pn21 I2_S_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I224_MN3 (VSS XI2_I1_I42_I224_Bn XI2_I1_I42_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I224_MN0 (XI2_I1_I42_I224_An I2_I1_I42_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I53_MN1 (XI2_I1_I42_I53_Bn I2_I1_bx21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I53_MN5 (XI2_I1_I42_I53_n2 I2_I1_bx21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I53_MN4 (I2_I1_I42_pn21 XI2_I1_I42_I53_An XI2_I1_I42_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I53_MN2 (XI2_I1_I42_I53_n1 A_21 I2_I1_I42_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I53_MN3 (VSS XI2_I1_I42_I53_Bn XI2_I1_I42_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I53_MN0 (XI2_I1_I42_I53_An A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I226_MN1 (XI2_I1_I42_I226_Bn I2_I1_I42_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I226_MN5 (XI2_I1_I42_I226_n2 I2_I1_I42_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I226_MN4 (I2_S_23 XI2_I1_I42_I226_An XI2_I1_I42_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I226_MN2 (XI2_I1_I42_I226_n1 I2_I1_I42_pn23 I2_S_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I226_MN3 (VSS XI2_I1_I42_I226_Bn XI2_I1_I42_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I226_MN0 (XI2_I1_I42_I226_An I2_I1_I42_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I55_MN1 (XI2_I1_I42_I55_Bn I2_I1_bx23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I55_MN5 (XI2_I1_I42_I55_n2 I2_I1_bx23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I55_MN4 (I2_I1_I42_pn23 XI2_I1_I42_I55_An XI2_I1_I42_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I55_MN2 (XI2_I1_I42_I55_n1 A_23 I2_I1_I42_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I55_MN3 (VSS XI2_I1_I42_I55_Bn XI2_I1_I42_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I55_MN0 (XI2_I1_I42_I55_An A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I221_MN1 (XI1_I562_I221_Bn I1_I562_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I221_MN5 (XI1_I562_I221_n2 I1_I562_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I221_MN4 (I1_p0_18 XI1_I562_I221_An XI1_I562_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I221_MN2 (XI1_I562_I221_n1 I1_I562_pn18 I1_p0_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I221_MN3 (VSS XI1_I562_I221_Bn XI1_I562_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I221_MN0 (XI1_I562_I221_An I1_I562_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I225_MN1 (XI1_I562_I225_Bn I1_I562_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I225_MN5 (XI1_I562_I225_n2 I1_I562_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I225_MN4 (I1_p0_22 XI1_I562_I225_An XI1_I562_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I225_MN2 (XI1_I562_I225_n1 I1_I562_pn22 I1_p0_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I225_MN3 (VSS XI1_I562_I225_Bn XI1_I562_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I225_MN0 (XI1_I562_I225_An I1_I562_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I58_MN1 (XI1_I562_I58_Bn I1_b0_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I58_MN5 (XI1_I562_I58_n2 I1_b0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I58_MN4 (I1_I562_pn26 XI1_I562_I58_An XI1_I562_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I58_MN2 (XI1_I562_I58_n1 VSS I1_I562_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I58_MN3 (VSS XI1_I562_I58_Bn XI1_I562_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I58_MN0 (XI1_I562_I58_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I227_MN1 (XI1_I1528_I227_Bn I1_I1528_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I227_MN5 (XI1_I1528_I227_n2 I1_I1528_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I227_MN4 (I1_p21_24 XI1_I1528_I227_An XI1_I1528_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I227_MN2 (XI1_I1528_I227_n1 I1_I1528_pn24 I1_p21_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I227_MN3 (VSS XI1_I1528_I227_Bn XI1_I1528_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I227_MN0 (XI1_I1528_I227_An I1_I1528_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I231_MN1 (XI1_I1528_I231_Bn I1_I1528_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I231_MN5 (XI1_I1528_I231_n2 I1_I1528_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I231_MN4 (I1_p21_28 XI1_I1528_I231_An XI1_I1528_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I231_MN2 (XI1_I1528_I231_n1 I1_I1528_pn28 I1_p21_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I231_MN3 (VSS XI1_I1528_I231_Bn XI1_I1528_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I231_MN0 (XI1_I1528_I231_An I1_I1528_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I223_MN1 (XI1_I1528_I223_Bn I1_I1528_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I223_MN5 (XI1_I1528_I223_n2 I1_I1528_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I223_MN4 (I1_p21_20 XI1_I1528_I223_An XI1_I1528_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I223_MN2 (XI1_I1528_I223_n1 I1_I1528_pn20 I1_p21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I223_MN3 (VSS XI1_I1528_I223_Bn XI1_I1528_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I223_MN0 (XI1_I1528_I223_An I1_I1528_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I36_MN1 (XI1_I1574_I36_Bn I1_b22_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I36_MN5 (XI1_I1574_I36_n2 I1_b22_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I36_MN4 (I1_I1574_pn4 XI1_I1574_I36_An XI1_I1574_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I36_MN2 (XI1_I1574_I36_n1 I1_p21_3 I1_I1574_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I36_MN3 (VSS XI1_I1574_I36_Bn XI1_I1574_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I36_MN0 (XI1_I1574_I36_An I1_p21_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I35_MN1 (XI1_I1574_I35_Bn I1_b22_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I35_MN5 (XI1_I1574_I35_n2 I1_b22_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I35_MN4 (I1_I1574_pn3 XI1_I1574_I35_An XI1_I1574_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I35_MN2 (XI1_I1574_I35_n1 I1_p21_2 I1_I1574_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I35_MN3 (VSS XI1_I1574_I35_Bn XI1_I1574_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I35_MN0 (XI1_I1574_I35_An I1_p21_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I194_MN1 (XI1_I194_Bn I1_nbkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I194_MN5 (XI1_I194_n2 I1_nbkn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I194_MN4 (I1_dd6 XI1_I194_An XI1_I194_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I194_MN2 (XI1_I194_n1 B_6 I1_dd6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I194_MN3 (VSS XI1_I194_Bn XI1_I194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I194_MN0 (XI1_I194_An B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I46_MN1 (XI2_I1_I42_I46_Bn I2_I1_bx14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I46_MN5 (XI2_I1_I42_I46_n2 I2_I1_bx14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I46_MN4 (I2_I1_I42_pn14 XI2_I1_I42_I46_An XI2_I1_I42_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I46_MN2 (XI2_I1_I42_I46_n1 A_14 I2_I1_I42_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I46_MN3 (VSS XI2_I1_I42_I46_Bn XI2_I1_I42_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I46_MN0 (XI2_I1_I42_I46_An A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I222_MN1 (XI2_I1_I42_I222_Bn I2_I1_I42_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I222_MN5 (XI2_I1_I42_I222_n2 I2_I1_I42_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I222_MN4 (I2_S_19 XI2_I1_I42_I222_An XI2_I1_I42_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I222_MN2 (XI2_I1_I42_I222_n1 I2_I1_I42_pn19 I2_S_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I222_MN3 (VSS XI2_I1_I42_I222_Bn XI2_I1_I42_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I222_MN0 (XI2_I1_I42_I222_An I2_I1_I42_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I225_MN1 (XI2_I1_I42_I225_Bn I2_I1_I42_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I225_MN5 (XI2_I1_I42_I225_n2 I2_I1_I42_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I225_MN4 (I2_S_22 XI2_I1_I42_I225_An XI2_I1_I42_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I225_MN2 (XI2_I1_I42_I225_n1 I2_I1_I42_pn22 I2_S_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I225_MN3 (VSS XI2_I1_I42_I225_Bn XI2_I1_I42_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I225_MN0 (XI2_I1_I42_I225_An I2_I1_I42_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I54_MN1 (XI2_I1_I42_I54_Bn I2_I1_bx22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I54_MN5 (XI2_I1_I42_I54_n2 I2_I1_bx22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I54_MN4 (I2_I1_I42_pn22 XI2_I1_I42_I54_An XI2_I1_I42_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I54_MN2 (XI2_I1_I42_I54_n1 A_22 I2_I1_I42_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I54_MN3 (VSS XI2_I1_I42_I54_Bn XI2_I1_I42_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I54_MN0 (XI2_I1_I42_I54_An A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I56_MN1 (XI2_I1_I42_I56_Bn I2_I1_bx24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I56_MN5 (XI2_I1_I42_I56_n2 I2_I1_bx24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I56_MN4 (I2_I1_I42_pn24 XI2_I1_I42_I56_An XI2_I1_I42_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I56_MN2 (XI2_I1_I42_I56_n1 A_24 I2_I1_I42_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I56_MN3 (VSS XI2_I1_I42_I56_Bn XI2_I1_I42_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I56_MN0 (XI2_I1_I42_I56_An A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I57_MN1 (XI2_I1_I42_I57_Bn I2_I1_bx25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I57_MN5 (XI2_I1_I42_I57_n2 I2_I1_bx25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I57_MN4 (I2_I1_I42_pn25 XI2_I1_I42_I57_An XI2_I1_I42_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I57_MN2 (XI2_I1_I42_I57_n1 A_25 I2_I1_I42_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I57_MN3 (VSS XI2_I1_I42_I57_Bn XI2_I1_I42_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I57_MN0 (XI2_I1_I42_I57_An A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I233_MN1 (XI1_I1712_I233_Bn I1_I1712_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I233_MN5 (XI1_I1712_I233_n2 I1_I1712_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I233_MN4 (I1_p25_30 XI1_I1712_I233_An XI1_I1712_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I233_MN2 (XI1_I1712_I233_n1 I1_I1712_pn30 I1_p25_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I233_MN3 (VSS XI1_I1712_I233_Bn XI1_I1712_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I233_MN0 (XI1_I1712_I233_An I1_I1712_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I229_MN1 (XI1_I1712_I229_Bn I1_I1712_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I229_MN5 (XI1_I1712_I229_n2 I1_I1712_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I229_MN4 (I1_p25_26 XI1_I1712_I229_An XI1_I1712_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I229_MN2 (XI1_I1712_I229_n1 I1_I1712_pn26 I1_p25_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I229_MN3 (VSS XI1_I1712_I229_Bn XI1_I1712_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I229_MN0 (XI1_I1712_I229_An I1_I1712_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I209_MN1 (XI1_I1712_I209_Bn I1_I1712_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I209_MN5 (XI1_I1712_I209_n2 I1_I1712_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I209_MN4 (I1_p25_6 XI1_I1712_I209_An XI1_I1712_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I209_MN2 (XI1_I1712_I209_n1 I1_I1712_pn6 I1_p25_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I209_MN3 (VSS XI1_I1712_I209_Bn XI1_I1712_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I209_MN0 (XI1_I1712_I209_An I1_I1712_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I36_MN1 (XI1_I1712_I36_Bn I1_b25_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I36_MN5 (XI1_I1712_I36_n2 I1_b25_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I36_MN4 (I1_I1712_pn4 XI1_I1712_I36_An XI1_I1712_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I36_MN2 (XI1_I1712_I36_n1 I1_p24_3 I1_I1712_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I36_MN3 (VSS XI1_I1712_I36_Bn XI1_I1712_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I36_MN0 (XI1_I1712_I36_An I1_p24_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I233_MN1 (XI1_I1528_I233_Bn I1_I1528_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I233_MN5 (XI1_I1528_I233_n2 I1_I1528_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I233_MN4 (I1_p21_30 XI1_I1528_I233_An XI1_I1528_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I233_MN2 (XI1_I1528_I233_n1 I1_I1528_pn30 I1_p21_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I233_MN3 (VSS XI1_I1528_I233_Bn XI1_I1528_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I233_MN0 (XI1_I1528_I233_An I1_I1528_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I225_MN1 (XI1_I1528_I225_Bn I1_I1528_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1528_I225_MN5 (XI1_I1528_I225_n2 I1_I1528_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1528_I225_MN4 (I1_p21_22 XI1_I1528_I225_An XI1_I1528_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I225_MN2 (XI1_I1528_I225_n1 I1_I1528_pn22 I1_p21_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1528_I225_MN3 (VSS XI1_I1528_I225_Bn XI1_I1528_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1528_I225_MN0 (XI1_I1528_I225_An I1_I1528_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I63_MN1 (XI1_I1574_I63_Bn I1_b22_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I63_MN5 (XI1_I1574_I63_n2 I1_b22_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I63_MN4 (I1_I1574_pn31 XI1_I1574_I63_An XI1_I1574_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I63_MN2 (XI1_I1574_I63_n1 I1_p21_30 I1_I1574_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I63_MN3 (VSS XI1_I1574_I63_Bn XI1_I1574_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I63_MN0 (XI1_I1574_I63_An I1_p21_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I61_MN1 (XI1_I1574_I61_Bn I1_b22_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I61_MN5 (XI1_I1574_I61_n2 I1_b22_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I61_MN4 (I1_I1574_pn29 XI1_I1574_I61_An XI1_I1574_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I61_MN2 (XI1_I1574_I61_n1 I1_p21_28 I1_I1574_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I61_MN3 (VSS XI1_I1574_I61_Bn XI1_I1574_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I61_MN0 (XI1_I1574_I61_An I1_p21_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I48_MN1 (XI1_I1574_I48_Bn I1_b22_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I48_MN5 (XI1_I1574_I48_n2 I1_b22_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I48_MN4 (I1_I1574_pn16 XI1_I1574_I48_An XI1_I1574_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I48_MN2 (XI1_I1574_I48_n1 I1_p21_15 I1_I1574_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I48_MN3 (VSS XI1_I1574_I48_Bn XI1_I1574_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I48_MN0 (XI1_I1574_I48_An I1_p21_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I47_MN1 (XI1_I1574_I47_Bn I1_b22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I47_MN5 (XI1_I1574_I47_n2 I1_b22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I47_MN4 (I1_I1574_pn15 XI1_I1574_I47_An XI1_I1574_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I47_MN2 (XI1_I1574_I47_n1 I1_p21_14 I1_I1574_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I47_MN3 (VSS XI1_I1574_I47_Bn XI1_I1574_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I47_MN0 (XI1_I1574_I47_An I1_p21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I209_MN1 (XI1_I1574_I209_Bn I1_I1574_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I209_MN5 (XI1_I1574_I209_n2 I1_I1574_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I209_MN4 (I1_p22_6 XI1_I1574_I209_An XI1_I1574_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I209_MN2 (XI1_I1574_I209_n1 I1_I1574_pn6 I1_p22_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I209_MN3 (VSS XI1_I1574_I209_Bn XI1_I1574_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I209_MN0 (XI1_I1574_I209_An I1_I1574_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I64_MN1 (XI1_I64_Bn I1_nakn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I64_MN5 (XI1_I64_n2 I1_nakn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I64_MN4 (I1_aa10 XI1_I64_An XI1_I64_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I64_MN2 (XI1_I64_n1 A_10 I1_aa10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I64_MN3 (VSS XI1_I64_Bn XI1_I64_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I64_MN0 (XI1_I64_An A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I45_MN1 (XI2_I1_I42_I45_Bn I2_I1_bx13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I45_MN5 (XI2_I1_I42_I45_n2 I2_I1_bx13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I45_MN4 (I2_I1_I42_pn13 XI2_I1_I42_I45_An XI2_I1_I42_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I45_MN2 (XI2_I1_I42_I45_n1 A_13 I2_I1_I42_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I45_MN3 (VSS XI2_I1_I42_I45_Bn XI2_I1_I42_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I45_MN0 (XI2_I1_I42_I45_An A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I228_MN1 (XI2_I1_I42_I228_Bn I2_I1_I42_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I228_MN5 (XI2_I1_I42_I228_n2 I2_I1_I42_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I228_MN4 (I2_S_25 XI2_I1_I42_I228_An XI2_I1_I42_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I228_MN2 (XI2_I1_I42_I228_n1 I2_I1_I42_pn25 I2_S_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I228_MN3 (VSS XI2_I1_I42_I228_Bn XI2_I1_I42_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I228_MN0 (XI2_I1_I42_I228_An I2_I1_I42_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I58_MN1 (XI2_I1_I42_I58_Bn I2_I1_bx26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I58_MN5 (XI2_I1_I42_I58_n2 I2_I1_bx26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I58_MN4 (I2_I1_I42_pn26 XI2_I1_I42_I58_An XI2_I1_I42_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I58_MN2 (XI2_I1_I42_I58_n1 A_26 I2_I1_I42_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I58_MN3 (VSS XI2_I1_I42_I58_Bn XI2_I1_I42_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I58_MN0 (XI2_I1_I42_I58_An A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I59_MN1 (XI2_I1_I42_I59_Bn I2_I1_bx27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I59_MN5 (XI2_I1_I42_I59_n2 I2_I1_bx27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I59_MN4 (I2_I1_I42_pn27 XI2_I1_I42_I59_An XI2_I1_I42_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I59_MN2 (XI2_I1_I42_I59_n1 A_27 I2_I1_I42_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I59_MN3 (VSS XI2_I1_I42_I59_Bn XI2_I1_I42_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I59_MN0 (XI2_I1_I42_I59_An A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I232_MN1 (XI2_I1_I42_I232_Bn I2_I1_I42_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I232_MN5 (XI2_I1_I42_I232_n2 I2_I1_I42_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I232_MN4 (I2_S_29 XI2_I1_I42_I232_An XI2_I1_I42_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I232_MN2 (XI2_I1_I42_I232_n1 I2_I1_I42_pn29 I2_S_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I232_MN3 (VSS XI2_I1_I42_I232_Bn XI2_I1_I42_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I232_MN0 (XI2_I1_I42_I232_An I2_I1_I42_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I56_MN1 (XI1_I562_I56_Bn I1_b0_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I56_MN5 (XI1_I562_I56_n2 I1_b0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I56_MN4 (I1_I562_pn24 XI1_I562_I56_An XI1_I562_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I56_MN2 (XI1_I562_I56_n1 VSS I1_I562_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I56_MN3 (VSS XI1_I562_I56_Bn XI1_I562_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I56_MN0 (XI1_I562_I56_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I60_MN1 (XI1_I1712_I60_Bn I1_b25_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I60_MN5 (XI1_I1712_I60_n2 I1_b25_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I60_MN4 (I1_I1712_pn28 XI1_I1712_I60_An XI1_I1712_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I60_MN2 (XI1_I1712_I60_n1 I1_p24_27 I1_I1712_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I60_MN3 (VSS XI1_I1712_I60_Bn XI1_I1712_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I60_MN0 (XI1_I1712_I60_An I1_p24_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I232_MN1 (XI1_I1712_I232_Bn I1_I1712_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I232_MN5 (XI1_I1712_I232_n2 I1_I1712_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I232_MN4 (I1_p25_29 XI1_I1712_I232_An XI1_I1712_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I232_MN2 (XI1_I1712_I232_n1 I1_I1712_pn29 I1_p25_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I232_MN3 (VSS XI1_I1712_I232_Bn XI1_I1712_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I232_MN0 (XI1_I1712_I232_An I1_I1712_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I227_MN1 (XI1_I1712_I227_Bn I1_I1712_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I227_MN5 (XI1_I1712_I227_n2 I1_I1712_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I227_MN4 (I1_p25_24 XI1_I1712_I227_An XI1_I1712_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I227_MN2 (XI1_I1712_I227_n1 I1_I1712_pn24 I1_p25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I227_MN3 (VSS XI1_I1712_I227_Bn XI1_I1712_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I227_MN0 (XI1_I1712_I227_An I1_I1712_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I211_MN1 (XI1_I1712_I211_Bn I1_I1712_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I211_MN5 (XI1_I1712_I211_n2 I1_I1712_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I211_MN4 (I1_p25_8 XI1_I1712_I211_An XI1_I1712_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I211_MN2 (XI1_I1712_I211_n1 I1_I1712_pn8 I1_p25_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I211_MN3 (VSS XI1_I1712_I211_Bn XI1_I1712_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I211_MN0 (XI1_I1712_I211_An I1_I1712_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I208_MN1 (XI1_I1712_I208_Bn I1_I1712_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I208_MN5 (XI1_I1712_I208_n2 I1_I1712_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I208_MN4 (I1_p25_5 XI1_I1712_I208_An XI1_I1712_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I208_MN2 (XI1_I1712_I208_n1 I1_I1712_pn5 I1_p25_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I208_MN3 (VSS XI1_I1712_I208_Bn XI1_I1712_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I208_MN0 (XI1_I1712_I208_An I1_I1712_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I35_MN1 (XI1_I1712_I35_Bn I1_b25_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I35_MN5 (XI1_I1712_I35_n2 I1_b25_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I35_MN4 (I1_I1712_pn3 XI1_I1712_I35_An XI1_I1712_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I35_MN2 (XI1_I1712_I35_n1 I1_p24_2 I1_I1712_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I35_MN3 (VSS XI1_I1712_I35_Bn XI1_I1712_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I35_MN0 (XI1_I1712_I35_An I1_p24_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I37_MN1 (XI1_I1712_I37_Bn I1_b25_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I37_MN5 (XI1_I1712_I37_n2 I1_b25_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I37_MN4 (I1_I1712_pn5 XI1_I1712_I37_An XI1_I1712_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I37_MN2 (XI1_I1712_I37_n1 I1_p24_4 I1_I1712_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I37_MN3 (VSS XI1_I1712_I37_Bn XI1_I1712_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I37_MN0 (XI1_I1712_I37_An I1_p24_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I62_MN1 (XI1_I1574_I62_Bn I1_b22_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I62_MN5 (XI1_I1574_I62_n2 I1_b22_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I62_MN4 (I1_I1574_pn30 XI1_I1574_I62_An XI1_I1574_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I62_MN2 (XI1_I1574_I62_n1 I1_p21_29 I1_I1574_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I62_MN3 (VSS XI1_I1574_I62_Bn XI1_I1574_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I62_MN0 (XI1_I1574_I62_An I1_p21_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I60_MN1 (XI1_I1574_I60_Bn I1_b22_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I60_MN5 (XI1_I1574_I60_n2 I1_b22_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I60_MN4 (I1_I1574_pn28 XI1_I1574_I60_An XI1_I1574_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I60_MN2 (XI1_I1574_I60_n1 I1_p21_27 I1_I1574_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I60_MN3 (VSS XI1_I1574_I60_Bn XI1_I1574_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I60_MN0 (XI1_I1574_I60_An I1_p21_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I231_MN1 (XI1_I1574_I231_Bn I1_I1574_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I231_MN5 (XI1_I1574_I231_n2 I1_I1574_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I231_MN4 (I1_p22_28 XI1_I1574_I231_An XI1_I1574_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I231_MN2 (XI1_I1574_I231_n1 I1_I1574_pn28 I1_p22_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I231_MN3 (VSS XI1_I1574_I231_Bn XI1_I1574_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I231_MN0 (XI1_I1574_I231_An I1_I1574_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I50_MN1 (XI1_I1574_I50_Bn I1_b22_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I50_MN5 (XI1_I1574_I50_n2 I1_b22_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I50_MN4 (I1_I1574_pn18 XI1_I1574_I50_An XI1_I1574_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I50_MN2 (XI1_I1574_I50_n1 I1_p21_17 I1_I1574_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I50_MN3 (VSS XI1_I1574_I50_Bn XI1_I1574_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I50_MN0 (XI1_I1574_I50_An I1_p21_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I233_MN1 (XI1_I1574_I233_Bn I1_I1574_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I233_MN5 (XI1_I1574_I233_n2 I1_I1574_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I233_MN4 (I1_p22_30 XI1_I1574_I233_An XI1_I1574_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I233_MN2 (XI1_I1574_I233_n1 I1_I1574_pn30 I1_p22_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I233_MN3 (VSS XI1_I1574_I233_Bn XI1_I1574_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I233_MN0 (XI1_I1574_I233_An I1_I1574_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I49_MN1 (XI1_I1574_I49_Bn I1_b22_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I49_MN5 (XI1_I1574_I49_n2 I1_b22_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I49_MN4 (I1_I1574_pn17 XI1_I1574_I49_An XI1_I1574_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I49_MN2 (XI1_I1574_I49_n1 I1_p21_16 I1_I1574_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I49_MN3 (VSS XI1_I1574_I49_Bn XI1_I1574_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I49_MN0 (XI1_I1574_I49_An I1_p21_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I229_MN1 (XI1_I1574_I229_Bn I1_I1574_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I229_MN5 (XI1_I1574_I229_n2 I1_I1574_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I229_MN4 (I1_p22_26 XI1_I1574_I229_An XI1_I1574_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I229_MN2 (XI1_I1574_I229_n1 I1_I1574_pn26 I1_p22_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I229_MN3 (VSS XI1_I1574_I229_Bn XI1_I1574_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I229_MN0 (XI1_I1574_I229_An I1_I1574_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I34_MN1 (XI1_I1574_I34_Bn I1_b22_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I34_MN5 (XI1_I1574_I34_n2 I1_b22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I34_MN4 (I1_I1574_pn2 XI1_I1574_I34_An XI1_I1574_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I34_MN2 (XI1_I1574_I34_n1 I1_p21_1 I1_I1574_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I34_MN3 (VSS XI1_I1574_I34_Bn XI1_I1574_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I34_MN0 (XI1_I1574_I34_An I1_p21_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I44_MN1 (XI2_I1_I42_I44_Bn I2_I1_bx12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I44_MN5 (XI2_I1_I42_I44_n2 I2_I1_bx12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I44_MN4 (I2_I1_I42_pn12 XI2_I1_I42_I44_An XI2_I1_I42_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I44_MN2 (XI2_I1_I42_I44_n1 A_12 I2_I1_I42_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I44_MN3 (VSS XI2_I1_I42_I44_Bn XI2_I1_I42_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I44_MN0 (XI2_I1_I42_I44_An A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I227_MN1 (XI2_I1_I42_I227_Bn I2_I1_I42_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I227_MN5 (XI2_I1_I42_I227_n2 I2_I1_I42_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I227_MN4 (I2_S_24 XI2_I1_I42_I227_An XI2_I1_I42_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I227_MN2 (XI2_I1_I42_I227_n1 I2_I1_I42_pn24 I2_S_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I227_MN3 (VSS XI2_I1_I42_I227_Bn XI2_I1_I42_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I227_MN0 (XI2_I1_I42_I227_An I2_I1_I42_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I229_MN1 (XI2_I1_I42_I229_Bn I2_I1_I42_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I229_MN5 (XI2_I1_I42_I229_n2 I2_I1_I42_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I229_MN4 (I2_S_26 XI2_I1_I42_I229_An XI2_I1_I42_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I229_MN2 (XI2_I1_I42_I229_n1 I2_I1_I42_pn26 I2_S_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I229_MN3 (VSS XI2_I1_I42_I229_Bn XI2_I1_I42_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I229_MN0 (XI2_I1_I42_I229_An I2_I1_I42_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I231_MN1 (XI2_I1_I42_I231_Bn I2_I1_I42_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I231_MN5 (XI2_I1_I42_I231_n2 I2_I1_I42_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I231_MN4 (I2_S_28 XI2_I1_I42_I231_An XI2_I1_I42_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I231_MN2 (XI2_I1_I42_I231_n1 I2_I1_I42_pn28 I2_S_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I231_MN3 (VSS XI2_I1_I42_I231_Bn XI2_I1_I42_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I231_MN0 (XI2_I1_I42_I231_An I2_I1_I42_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I60_MN1 (XI2_I1_I42_I60_Bn I2_I1_bx28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I60_MN5 (XI2_I1_I42_I60_n2 I2_I1_bx28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I60_MN4 (I2_I1_I42_pn28 XI2_I1_I42_I60_An XI2_I1_I42_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I60_MN2 (XI2_I1_I42_I60_n1 A_28 I2_I1_I42_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I60_MN3 (VSS XI2_I1_I42_I60_Bn XI2_I1_I42_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I60_MN0 (XI2_I1_I42_I60_An A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I230_MN1 (XI2_I1_I42_I230_Bn I2_I1_I42_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I230_MN5 (XI2_I1_I42_I230_n2 I2_I1_I42_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I230_MN4 (I2_S_27 XI2_I1_I42_I230_An XI2_I1_I42_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I230_MN2 (XI2_I1_I42_I230_n1 I2_I1_I42_pn27 I2_S_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I230_MN3 (VSS XI2_I1_I42_I230_Bn XI2_I1_I42_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I230_MN0 (XI2_I1_I42_I230_An I2_I1_I42_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I61_MN1 (XI2_I1_I42_I61_Bn I2_I1_bx29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I61_MN5 (XI2_I1_I42_I61_n2 I2_I1_bx29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I61_MN4 (I2_I1_I42_pn29 XI2_I1_I42_I61_An XI2_I1_I42_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I61_MN2 (XI2_I1_I42_I61_n1 A_29 I2_I1_I42_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I61_MN3 (VSS XI2_I1_I42_I61_Bn XI2_I1_I42_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I61_MN0 (XI2_I1_I42_I61_An A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I227_MN1 (XI1_I562_I227_Bn I1_I562_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I562_I227_MN5 (XI1_I562_I227_n2 I1_I562_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I562_I227_MN4 (I1_p0_24 XI1_I562_I227_An XI1_I562_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I227_MN2 (XI1_I562_I227_n1 I1_I562_pn24 I1_p0_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I562_I227_MN3 (VSS XI1_I562_I227_Bn XI1_I562_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I562_I227_MN0 (XI1_I562_I227_An I1_I562_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I59_MN1 (XI1_I1712_I59_Bn I1_b25_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I59_MN5 (XI1_I1712_I59_n2 I1_b25_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I59_MN4 (I1_I1712_pn27 XI1_I1712_I59_An XI1_I1712_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I59_MN2 (XI1_I1712_I59_n1 I1_p24_26 I1_I1712_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I59_MN3 (VSS XI1_I1712_I59_Bn XI1_I1712_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I59_MN0 (XI1_I1712_I59_An I1_p24_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I205_MN1 (XI1_I1712_I205_Bn I1_I1712_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I205_MN5 (XI1_I1712_I205_n2 I1_I1712_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I205_MN4 (I1_p25_2 XI1_I1712_I205_An XI1_I1712_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I205_MN2 (XI1_I1712_I205_n1 I1_I1712_pn2 I1_p25_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I205_MN3 (VSS XI1_I1712_I205_Bn XI1_I1712_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I205_MN0 (XI1_I1712_I205_An I1_I1712_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I34_MN1 (XI1_I1712_I34_Bn I1_b25_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I34_MN5 (XI1_I1712_I34_n2 I1_b25_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I34_MN4 (I1_I1712_pn2 XI1_I1712_I34_An XI1_I1712_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I34_MN2 (XI1_I1712_I34_n1 I1_p24_1 I1_I1712_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I34_MN3 (VSS XI1_I1712_I34_Bn XI1_I1712_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I34_MN0 (XI1_I1712_I34_An I1_p24_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I59_MN1 (XI1_I1574_I59_Bn I1_b22_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I59_MN5 (XI1_I1574_I59_n2 I1_b22_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I59_MN4 (I1_I1574_pn27 XI1_I1574_I59_An XI1_I1574_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I59_MN2 (XI1_I1574_I59_n1 I1_p21_26 I1_I1574_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I59_MN3 (VSS XI1_I1574_I59_Bn XI1_I1574_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I59_MN0 (XI1_I1574_I59_An I1_p21_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I57_MN1 (XI1_I1574_I57_Bn I1_b22_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I57_MN5 (XI1_I1574_I57_n2 I1_b22_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I57_MN4 (I1_I1574_pn25 XI1_I1574_I57_An XI1_I1574_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I57_MN2 (XI1_I1574_I57_n1 I1_p21_24 I1_I1574_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I57_MN3 (VSS XI1_I1574_I57_Bn XI1_I1574_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I57_MN0 (XI1_I1574_I57_An I1_p21_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I58_MN1 (XI1_I1574_I58_Bn I1_b22_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I58_MN5 (XI1_I1574_I58_n2 I1_b22_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I58_MN4 (I1_I1574_pn26 XI1_I1574_I58_An XI1_I1574_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I58_MN2 (XI1_I1574_I58_n1 I1_p21_25 I1_I1574_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I58_MN3 (VSS XI1_I1574_I58_Bn XI1_I1574_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I58_MN0 (XI1_I1574_I58_An I1_p21_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I232_MN1 (XI1_I1574_I232_Bn I1_I1574_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I232_MN5 (XI1_I1574_I232_n2 I1_I1574_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I232_MN4 (I1_p22_29 XI1_I1574_I232_An XI1_I1574_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I232_MN2 (XI1_I1574_I232_n1 I1_I1574_pn29 I1_p22_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I232_MN3 (VSS XI1_I1574_I232_Bn XI1_I1574_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I232_MN0 (XI1_I1574_I232_An I1_I1574_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I221_MN1 (XI1_I1574_I221_Bn I1_I1574_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I221_MN5 (XI1_I1574_I221_n2 I1_I1574_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I221_MN4 (I1_p22_18 XI1_I1574_I221_An XI1_I1574_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I221_MN2 (XI1_I1574_I221_n1 I1_I1574_pn18 I1_p22_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I221_MN3 (VSS XI1_I1574_I221_Bn XI1_I1574_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I221_MN0 (XI1_I1574_I221_An I1_I1574_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I43_MN1 (XI2_I1_I42_I43_Bn I2_I1_bx11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I43_MN5 (XI2_I1_I42_I43_n2 I2_I1_bx11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I43_MN4 (I2_I1_I42_pn11 XI2_I1_I42_I43_An XI2_I1_I42_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I43_MN2 (XI2_I1_I42_I43_n1 A_11 I2_I1_I42_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I43_MN3 (VSS XI2_I1_I42_I43_Bn XI2_I1_I42_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I43_MN0 (XI2_I1_I42_I43_An A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I62_MN1 (XI2_I1_I42_I62_Bn I2_I1_bx30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I62_MN5 (XI2_I1_I42_I62_n2 I2_I1_bx30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I62_MN4 (I2_I1_I42_pn30 XI2_I1_I42_I62_An XI2_I1_I42_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I62_MN2 (XI2_I1_I42_I62_n1 A_30 I2_I1_I42_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I62_MN3 (VSS XI2_I1_I42_I62_Bn XI2_I1_I42_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I62_MN0 (XI2_I1_I42_I62_An A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I234_MN1 (XI2_I1_I42_I234_Bn I2_CM VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I234_MN5 (XI2_I1_I42_I234_n2 I2_CM VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I234_MN4 (I2_S_31 XI2_I1_I42_I234_An XI2_I1_I42_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I234_MN2 (XI2_I1_I42_I234_n1 I2_I1_I42_pn31 I2_S_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I234_MN3 (VSS XI2_I1_I42_I234_Bn XI2_I1_I42_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I234_MN0 (XI2_I1_I42_I234_An I2_I1_I42_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I61_MN1 (XI1_I1712_I61_Bn I1_b25_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I61_MN5 (XI1_I1712_I61_n2 I1_b25_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I61_MN4 (I1_I1712_pn29 XI1_I1712_I61_An XI1_I1712_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I61_MN2 (XI1_I1712_I61_n1 I1_p24_28 I1_I1712_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I61_MN3 (VSS XI1_I1712_I61_Bn XI1_I1712_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I61_MN0 (XI1_I1712_I61_An I1_p24_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I230_MN1 (XI1_I1712_I230_Bn I1_I1712_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I230_MN5 (XI1_I1712_I230_n2 I1_I1712_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I230_MN4 (I1_p25_27 XI1_I1712_I230_An XI1_I1712_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I230_MN2 (XI1_I1712_I230_n1 I1_I1712_pn27 I1_p25_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I230_MN3 (VSS XI1_I1712_I230_Bn XI1_I1712_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I230_MN0 (XI1_I1712_I230_An I1_I1712_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I56_MN1 (XI1_I1712_I56_Bn I1_b25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I56_MN5 (XI1_I1712_I56_n2 I1_b25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I56_MN4 (I1_I1712_pn24 XI1_I1712_I56_An XI1_I1712_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I56_MN2 (XI1_I1712_I56_n1 I1_p24_23 I1_I1712_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I56_MN3 (VSS XI1_I1712_I56_Bn XI1_I1712_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I56_MN0 (XI1_I1712_I56_An I1_p24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I38_MN1 (XI1_I1712_I38_Bn I1_b25_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I38_MN5 (XI1_I1712_I38_n2 I1_b25_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I38_MN4 (I1_I1712_pn6 XI1_I1712_I38_An XI1_I1712_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I38_MN2 (XI1_I1712_I38_n1 I1_p24_5 I1_I1712_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I38_MN3 (VSS XI1_I1712_I38_Bn XI1_I1712_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I38_MN0 (XI1_I1712_I38_An I1_p24_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I33_MN1 (XI1_I1712_I33_Bn I1_b25_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I33_MN5 (XI1_I1712_I33_n2 I1_b25_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I33_MN4 (I1_I1712_pn1 XI1_I1712_I33_An XI1_I1712_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I33_MN2 (XI1_I1712_I33_n1 I1_p24_0 I1_I1712_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I33_MN3 (VSS XI1_I1712_I33_Bn XI1_I1712_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I33_MN0 (XI1_I1712_I33_An I1_p24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I204_MN1 (XI1_I1666_I204_Bn I1_I1666_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I204_MN5 (XI1_I1666_I204_n2 I1_I1666_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I204_MN4 (I1_p24_1 XI1_I1666_I204_An XI1_I1666_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I204_MN2 (XI1_I1666_I204_n1 I1_I1666_pn1 I1_p24_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I204_MN3 (VSS XI1_I1666_I204_Bn XI1_I1666_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I204_MN0 (XI1_I1666_I204_An I1_I1666_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I32_MN1 (XI1_I1666_I32_Bn I1_b24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I32_MN5 (XI1_I1666_I32_n2 I1_b24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I32_MN4 (I1_I1666_pn0 XI1_I1666_I32_An XI1_I1666_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I32_MN2 (XI1_I1666_I32_n1 I1_aa7 I1_I1666_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I32_MN3 (VSS XI1_I1666_I32_Bn XI1_I1666_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I32_MN0 (XI1_I1666_I32_An I1_aa7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I203_MN1 (XI1_I1666_I203_Bn I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I203_MN5 (XI1_I1666_I203_n2 I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I203_MN4 (I1_p24_0 XI1_I1666_I203_An XI1_I1666_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I203_MN2 (XI1_I1666_I203_n1 I1_I1666_pn0 I1_p24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I203_MN3 (VSS XI1_I1666_I203_Bn XI1_I1666_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I203_MN0 (XI1_I1666_I203_An I1_I1666_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I56_MN1 (XI1_I1574_I56_Bn I1_b22_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I56_MN5 (XI1_I1574_I56_n2 I1_b22_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I56_MN4 (I1_I1574_pn24 XI1_I1574_I56_An XI1_I1574_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I56_MN2 (XI1_I1574_I56_n1 I1_p21_23 I1_I1574_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I56_MN3 (VSS XI1_I1574_I56_Bn XI1_I1574_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I56_MN0 (XI1_I1574_I56_An I1_p21_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I227_MN1 (XI1_I1574_I227_Bn I1_I1574_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I227_MN5 (XI1_I1574_I227_n2 I1_I1574_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I227_MN4 (I1_p22_24 XI1_I1574_I227_An XI1_I1574_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I227_MN2 (XI1_I1574_I227_n1 I1_I1574_pn24 I1_p22_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I227_MN3 (VSS XI1_I1574_I227_Bn XI1_I1574_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I227_MN0 (XI1_I1574_I227_An I1_I1574_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I225_MN1 (XI1_I1574_I225_Bn I1_I1574_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I225_MN5 (XI1_I1574_I225_n2 I1_I1574_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I225_MN4 (I1_p22_22 XI1_I1574_I225_An XI1_I1574_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I225_MN2 (XI1_I1574_I225_n1 I1_I1574_pn22 I1_p22_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I225_MN3 (VSS XI1_I1574_I225_Bn XI1_I1574_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I225_MN0 (XI1_I1574_I225_An I1_I1574_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I228_MN1 (XI1_I1574_I228_Bn I1_I1574_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I228_MN5 (XI1_I1574_I228_n2 I1_I1574_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I228_MN4 (I1_p22_25 XI1_I1574_I228_An XI1_I1574_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I228_MN2 (XI1_I1574_I228_n1 I1_I1574_pn25 I1_p22_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I228_MN3 (VSS XI1_I1574_I228_Bn XI1_I1574_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I228_MN0 (XI1_I1574_I228_An I1_I1574_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I220_MN1 (XI1_I1574_I220_Bn I1_I1574_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I220_MN5 (XI1_I1574_I220_n2 I1_I1574_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I220_MN4 (I1_p22_17 XI1_I1574_I220_An XI1_I1574_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I220_MN2 (XI1_I1574_I220_n1 I1_I1574_pn17 I1_p22_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I220_MN3 (VSS XI1_I1574_I220_Bn XI1_I1574_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I220_MN0 (XI1_I1574_I220_An I1_I1574_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I208_MN1 (XI1_I1574_I208_Bn I1_I1574_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I208_MN5 (XI1_I1574_I208_n2 I1_I1574_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I208_MN4 (I1_p22_5 XI1_I1574_I208_An XI1_I1574_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I208_MN2 (XI1_I1574_I208_n1 I1_I1574_pn5 I1_p22_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I208_MN3 (VSS XI1_I1574_I208_Bn XI1_I1574_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I208_MN0 (XI1_I1574_I208_An I1_I1574_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I205_MN1 (XI1_I1574_I205_Bn I1_I1574_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I205_MN5 (XI1_I1574_I205_n2 I1_I1574_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I205_MN4 (I1_p22_2 XI1_I1574_I205_An XI1_I1574_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I205_MN2 (XI1_I1574_I205_n1 I1_I1574_pn2 I1_p22_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I205_MN3 (VSS XI1_I1574_I205_Bn XI1_I1574_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I205_MN0 (XI1_I1574_I205_An I1_I1574_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I33_MN1 (XI1_I1574_I33_Bn I1_b22_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I33_MN5 (XI1_I1574_I33_n2 I1_b22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I33_MN4 (I1_I1574_pn1 XI1_I1574_I33_An XI1_I1574_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I33_MN2 (XI1_I1574_I33_n1 I1_p21_0 I1_I1574_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I33_MN3 (VSS XI1_I1574_I33_Bn XI1_I1574_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I33_MN0 (XI1_I1574_I33_An I1_p21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I233_MN1 (XI2_I1_I42_I233_Bn I2_I1_I42_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I233_MN5 (XI2_I1_I42_I233_n2 I2_I1_I42_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I233_MN4 (I2_S_30 XI2_I1_I42_I233_An XI2_I1_I42_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I233_MN2 (XI2_I1_I42_I233_n1 I2_I1_I42_pn30 I2_S_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I233_MN3 (VSS XI2_I1_I42_I233_Bn XI2_I1_I42_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I233_MN0 (XI2_I1_I42_I233_An I2_I1_I42_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I63_MN1 (XI2_I1_I42_I63_Bn I2_I1_bx31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I63_MN5 (XI2_I1_I42_I63_n2 I2_I1_bx31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I63_MN4 (I2_I1_I42_pn31 XI2_I1_I42_I63_An XI2_I1_I42_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I63_MN2 (XI2_I1_I42_I63_n1 A_31 I2_I1_I42_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I63_MN3 (VSS XI2_I1_I42_I63_Bn XI2_I1_I42_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I63_MN0 (XI2_I1_I42_I63_An A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I62_MN1 (XI1_I1712_I62_Bn I1_b25_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I62_MN5 (XI1_I1712_I62_n2 I1_b25_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I62_MN4 (I1_I1712_pn30 XI1_I1712_I62_An XI1_I1712_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I62_MN2 (XI1_I1712_I62_n1 I1_p24_29 I1_I1712_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I62_MN3 (VSS XI1_I1712_I62_Bn XI1_I1712_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I62_MN0 (XI1_I1712_I62_An I1_p24_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I58_MN1 (XI1_I1712_I58_Bn I1_b25_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I58_MN5 (XI1_I1712_I58_n2 I1_b25_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I58_MN4 (I1_I1712_pn26 XI1_I1712_I58_An XI1_I1712_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I58_MN2 (XI1_I1712_I58_n1 I1_p24_25 I1_I1712_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I58_MN3 (VSS XI1_I1712_I58_Bn XI1_I1712_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I58_MN0 (XI1_I1712_I58_An I1_p24_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I210_MN1 (XI1_I1712_I210_Bn I1_I1712_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I210_MN5 (XI1_I1712_I210_n2 I1_I1712_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I210_MN4 (I1_p25_7 XI1_I1712_I210_An XI1_I1712_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I210_MN2 (XI1_I1712_I210_n1 I1_I1712_pn7 I1_p25_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I210_MN3 (VSS XI1_I1712_I210_Bn XI1_I1712_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I210_MN0 (XI1_I1712_I210_An I1_I1712_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I39_MN1 (XI1_I1712_I39_Bn I1_b25_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I39_MN5 (XI1_I1712_I39_n2 I1_b25_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I39_MN4 (I1_I1712_pn7 XI1_I1712_I39_An XI1_I1712_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I39_MN2 (XI1_I1712_I39_n1 I1_p24_6 I1_I1712_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I39_MN3 (VSS XI1_I1712_I39_Bn XI1_I1712_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I39_MN0 (XI1_I1712_I39_An I1_p24_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I40_MN1 (XI1_I1712_I40_Bn I1_b25_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I40_MN5 (XI1_I1712_I40_n2 I1_b25_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I40_MN4 (I1_I1712_pn8 XI1_I1712_I40_An XI1_I1712_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I40_MN2 (XI1_I1712_I40_n1 I1_p24_7 I1_I1712_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I40_MN3 (VSS XI1_I1712_I40_Bn XI1_I1712_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I40_MN0 (XI1_I1712_I40_An I1_p24_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I204_MN1 (XI1_I1712_I204_Bn I1_I1712_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I204_MN5 (XI1_I1712_I204_n2 I1_I1712_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I204_MN4 (I1_p25_1 XI1_I1712_I204_An XI1_I1712_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I204_MN2 (XI1_I1712_I204_n1 I1_I1712_pn1 I1_p25_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I204_MN3 (VSS XI1_I1712_I204_Bn XI1_I1712_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I204_MN0 (XI1_I1712_I204_An I1_I1712_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I205_MN1 (XI1_I1666_I205_Bn I1_I1666_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I205_MN5 (XI1_I1666_I205_n2 I1_I1666_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I205_MN4 (I1_p24_2 XI1_I1666_I205_An XI1_I1666_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I205_MN2 (XI1_I1666_I205_n1 I1_I1666_pn2 I1_p24_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I205_MN3 (VSS XI1_I1666_I205_Bn XI1_I1666_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I205_MN0 (XI1_I1666_I205_An I1_I1666_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I33_MN1 (XI1_I1666_I33_Bn I1_b24_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I33_MN5 (XI1_I1666_I33_n2 I1_b24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I33_MN4 (I1_I1666_pn1 XI1_I1666_I33_An XI1_I1666_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I33_MN2 (XI1_I1666_I33_n1 I1_p23_0 I1_I1666_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I33_MN3 (VSS XI1_I1666_I33_Bn XI1_I1666_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I33_MN0 (XI1_I1666_I33_An I1_p23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I55_MN1 (XI1_I1574_I55_Bn I1_b22_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I55_MN5 (XI1_I1574_I55_n2 I1_b22_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I55_MN4 (I1_I1574_pn23 XI1_I1574_I55_An XI1_I1574_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I55_MN2 (XI1_I1574_I55_n1 I1_p21_22 I1_I1574_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I55_MN3 (VSS XI1_I1574_I55_Bn XI1_I1574_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I55_MN0 (XI1_I1574_I55_An I1_p21_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I53_MN1 (XI1_I1574_I53_Bn I1_b22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I53_MN5 (XI1_I1574_I53_n2 I1_b22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I53_MN4 (I1_I1574_pn21 XI1_I1574_I53_An XI1_I1574_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I53_MN2 (XI1_I1574_I53_n1 I1_p21_20 I1_I1574_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I53_MN3 (VSS XI1_I1574_I53_Bn XI1_I1574_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I53_MN0 (XI1_I1574_I53_An I1_p21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I54_MN1 (XI1_I1574_I54_Bn I1_b22_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I54_MN5 (XI1_I1574_I54_n2 I1_b22_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I54_MN4 (I1_I1574_pn22 XI1_I1574_I54_An XI1_I1574_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I54_MN2 (XI1_I1574_I54_n1 I1_p21_21 I1_I1574_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I54_MN3 (VSS XI1_I1574_I54_Bn XI1_I1574_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I54_MN0 (XI1_I1574_I54_An I1_p21_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I224_MN1 (XI1_I1574_I224_Bn I1_I1574_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I224_MN5 (XI1_I1574_I224_n2 I1_I1574_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I224_MN4 (I1_p22_21 XI1_I1574_I224_An XI1_I1574_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I224_MN2 (XI1_I1574_I224_n1 I1_I1574_pn21 I1_p22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I224_MN3 (VSS XI1_I1574_I224_Bn XI1_I1574_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I224_MN0 (XI1_I1574_I224_An I1_I1574_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I210_MN1 (XI1_I1574_I210_Bn I1_I1574_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I210_MN5 (XI1_I1574_I210_n2 I1_I1574_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I210_MN4 (I1_p22_7 XI1_I1574_I210_An XI1_I1574_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I210_MN2 (XI1_I1574_I210_n1 I1_I1574_pn7 I1_p22_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I210_MN3 (VSS XI1_I1574_I210_Bn XI1_I1574_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I210_MN0 (XI1_I1574_I210_An I1_I1574_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I36_MN1 (XI1_I1620_I36_Bn I1_b23_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I36_MN5 (XI1_I1620_I36_n2 I1_b23_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I36_MN4 (I1_I1620_pn4 XI1_I1620_I36_An XI1_I1620_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I36_MN2 (XI1_I1620_I36_n1 I1_p22_3 I1_I1620_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I36_MN3 (VSS XI1_I1620_I36_Bn XI1_I1620_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I36_MN0 (XI1_I1620_I36_An I1_p22_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I204_MN1 (XI1_I1574_I204_Bn I1_I1574_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I204_MN5 (XI1_I1574_I204_n2 I1_I1574_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I204_MN4 (I1_p22_1 XI1_I1574_I204_An XI1_I1574_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I204_MN2 (XI1_I1574_I204_n1 I1_I1574_pn1 I1_p22_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I204_MN3 (VSS XI1_I1574_I204_Bn XI1_I1574_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I204_MN0 (XI1_I1574_I204_An I1_I1574_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I42_MN1 (XI2_I1_I42_I42_Bn I2_I1_bx10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I42_MN5 (XI2_I1_I42_I42_n2 I2_I1_bx10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I42_MN4 (I2_I1_I42_pn10 XI2_I1_I42_I42_An XI2_I1_I42_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I42_MN2 (XI2_I1_I42_I42_n1 A_10 I2_I1_I42_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I42_MN3 (VSS XI2_I1_I42_I42_Bn XI2_I1_I42_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I42_MN0 (XI2_I1_I42_I42_An A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I63_MN1 (XI1_I1712_I63_Bn I1_b25_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I63_MN5 (XI1_I1712_I63_n2 I1_b25_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I63_MN4 (I1_I1712_pn31 XI1_I1712_I63_An XI1_I1712_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I63_MN2 (XI1_I1712_I63_n1 I1_p24_30 I1_I1712_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I63_MN3 (VSS XI1_I1712_I63_Bn XI1_I1712_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I63_MN0 (XI1_I1712_I63_An I1_p24_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I234_MN1 (XI1_I1712_I234_Bn I1_c25_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I234_MN5 (XI1_I1712_I234_n2 I1_c25_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I234_MN4 (I1_p25_31 XI1_I1712_I234_An XI1_I1712_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I234_MN2 (XI1_I1712_I234_n1 I1_I1712_pn31 I1_p25_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I234_MN3 (VSS XI1_I1712_I234_Bn XI1_I1712_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I234_MN0 (XI1_I1712_I234_An I1_I1712_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I57_MN1 (XI1_I1712_I57_Bn I1_b25_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I57_MN5 (XI1_I1712_I57_n2 I1_b25_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I57_MN4 (I1_I1712_pn25 XI1_I1712_I57_An XI1_I1712_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I57_MN2 (XI1_I1712_I57_n1 I1_p24_24 I1_I1712_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I57_MN3 (VSS XI1_I1712_I57_Bn XI1_I1712_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I57_MN0 (XI1_I1712_I57_An I1_p24_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I228_MN1 (XI1_I1712_I228_Bn I1_I1712_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I228_MN5 (XI1_I1712_I228_n2 I1_I1712_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I228_MN4 (I1_p25_25 XI1_I1712_I228_An XI1_I1712_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I228_MN2 (XI1_I1712_I228_n1 I1_I1712_pn25 I1_p25_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I228_MN3 (VSS XI1_I1712_I228_Bn XI1_I1712_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I228_MN0 (XI1_I1712_I228_An I1_I1712_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I225_MN1 (XI1_I1712_I225_Bn I1_I1712_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I225_MN5 (XI1_I1712_I225_n2 I1_I1712_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I225_MN4 (I1_p25_22 XI1_I1712_I225_An XI1_I1712_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I225_MN2 (XI1_I1712_I225_n1 I1_I1712_pn22 I1_p25_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I225_MN3 (VSS XI1_I1712_I225_Bn XI1_I1712_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I225_MN0 (XI1_I1712_I225_An I1_I1712_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I54_MN1 (XI1_I1712_I54_Bn I1_b25_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I54_MN5 (XI1_I1712_I54_n2 I1_b25_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I54_MN4 (I1_I1712_pn22 XI1_I1712_I54_An XI1_I1712_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I54_MN2 (XI1_I1712_I54_n1 I1_p24_21 I1_I1712_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I54_MN3 (VSS XI1_I1712_I54_Bn XI1_I1712_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I54_MN0 (XI1_I1712_I54_An I1_p24_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I223_MN1 (XI1_I1712_I223_Bn I1_I1712_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I223_MN5 (XI1_I1712_I223_n2 I1_I1712_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I223_MN4 (I1_p25_20 XI1_I1712_I223_An XI1_I1712_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I223_MN2 (XI1_I1712_I223_n1 I1_I1712_pn20 I1_p25_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I223_MN3 (VSS XI1_I1712_I223_Bn XI1_I1712_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I223_MN0 (XI1_I1712_I223_An I1_I1712_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I222_MN1 (XI1_I1712_I222_Bn I1_I1712_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I222_MN5 (XI1_I1712_I222_n2 I1_I1712_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I222_MN4 (I1_p25_19 XI1_I1712_I222_An XI1_I1712_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I222_MN2 (XI1_I1712_I222_n1 I1_I1712_pn19 I1_p25_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I222_MN3 (VSS XI1_I1712_I222_Bn XI1_I1712_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I222_MN0 (XI1_I1712_I222_An I1_I1712_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I221_MN1 (XI1_I1712_I221_Bn I1_I1712_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I221_MN5 (XI1_I1712_I221_n2 I1_I1712_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I221_MN4 (I1_p25_18 XI1_I1712_I221_An XI1_I1712_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I221_MN2 (XI1_I1712_I221_n1 I1_I1712_pn18 I1_p25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I221_MN3 (VSS XI1_I1712_I221_Bn XI1_I1712_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I221_MN0 (XI1_I1712_I221_An I1_I1712_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I42_MN1 (XI1_I1712_I42_Bn I1_b25_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I42_MN5 (XI1_I1712_I42_n2 I1_b25_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I42_MN4 (I1_I1712_pn10 XI1_I1712_I42_An XI1_I1712_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I42_MN2 (XI1_I1712_I42_n1 I1_p24_9 I1_I1712_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I42_MN3 (VSS XI1_I1712_I42_Bn XI1_I1712_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I42_MN0 (XI1_I1712_I42_An I1_p24_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I41_MN1 (XI1_I1712_I41_Bn I1_b25_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I41_MN5 (XI1_I1712_I41_n2 I1_b25_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I41_MN4 (I1_I1712_pn9 XI1_I1712_I41_An XI1_I1712_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I41_MN2 (XI1_I1712_I41_n1 I1_p24_8 I1_I1712_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I41_MN3 (VSS XI1_I1712_I41_Bn XI1_I1712_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I41_MN0 (XI1_I1712_I41_An I1_p24_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I203_MN1 (XI1_I1712_I203_Bn I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I203_MN5 (XI1_I1712_I203_n2 I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I203_MN4 (I1_p25_0 XI1_I1712_I203_An XI1_I1712_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I203_MN2 (XI1_I1712_I203_n1 I1_I1712_pn0 I1_p25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I203_MN3 (VSS XI1_I1712_I203_Bn XI1_I1712_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I203_MN0 (XI1_I1712_I203_An I1_I1712_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I32_MN1 (XI1_I1712_I32_Bn I1_b25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I32_MN5 (XI1_I1712_I32_n2 I1_b25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I32_MN4 (I1_I1712_pn0 XI1_I1712_I32_An XI1_I1712_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I32_MN2 (XI1_I1712_I32_n1 I1_aa6 I1_I1712_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I32_MN3 (VSS XI1_I1712_I32_Bn XI1_I1712_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I32_MN0 (XI1_I1712_I32_An I1_aa6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I34_MN1 (XI1_I1666_I34_Bn I1_b24_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I34_MN5 (XI1_I1666_I34_n2 I1_b24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I34_MN4 (I1_I1666_pn2 XI1_I1666_I34_An XI1_I1666_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I34_MN2 (XI1_I1666_I34_n1 I1_p23_1 I1_I1666_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I34_MN3 (VSS XI1_I1666_I34_Bn XI1_I1666_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I34_MN0 (XI1_I1666_I34_An I1_p23_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I35_MN1 (XI1_I1666_I35_Bn I1_b24_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I35_MN5 (XI1_I1666_I35_n2 I1_b24_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I35_MN4 (I1_I1666_pn3 XI1_I1666_I35_An XI1_I1666_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I35_MN2 (XI1_I1666_I35_n1 I1_p23_2 I1_I1666_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I35_MN3 (VSS XI1_I1666_I35_Bn XI1_I1666_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I35_MN0 (XI1_I1666_I35_An I1_p23_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I36_MN1 (XI1_I1666_I36_Bn I1_b24_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I36_MN5 (XI1_I1666_I36_n2 I1_b24_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I36_MN4 (I1_I1666_pn4 XI1_I1666_I36_An XI1_I1666_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I36_MN2 (XI1_I1666_I36_n1 I1_p23_3 I1_I1666_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I36_MN3 (VSS XI1_I1666_I36_Bn XI1_I1666_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I36_MN0 (XI1_I1666_I36_An I1_p23_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I52_MN1 (XI1_I1574_I52_Bn I1_b22_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I52_MN5 (XI1_I1574_I52_n2 I1_b22_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I52_MN4 (I1_I1574_pn20 XI1_I1574_I52_An XI1_I1574_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I52_MN2 (XI1_I1574_I52_n1 I1_p21_19 I1_I1574_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I52_MN3 (VSS XI1_I1574_I52_Bn XI1_I1574_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I52_MN0 (XI1_I1574_I52_An I1_p21_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I230_MN1 (XI1_I1574_I230_Bn I1_I1574_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I230_MN5 (XI1_I1574_I230_n2 I1_I1574_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I230_MN4 (I1_p22_27 XI1_I1574_I230_An XI1_I1574_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I230_MN2 (XI1_I1574_I230_n1 I1_I1574_pn27 I1_p22_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I230_MN3 (VSS XI1_I1574_I230_Bn XI1_I1574_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I230_MN0 (XI1_I1574_I230_An I1_I1574_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I51_MN1 (XI1_I1574_I51_Bn I1_b22_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I51_MN5 (XI1_I1574_I51_n2 I1_b22_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I51_MN4 (I1_I1574_pn19 XI1_I1574_I51_An XI1_I1574_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I51_MN2 (XI1_I1574_I51_n1 I1_p21_18 I1_I1574_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I51_MN3 (VSS XI1_I1574_I51_Bn XI1_I1574_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I51_MN0 (XI1_I1574_I51_An I1_p21_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I223_MN1 (XI1_I1574_I223_Bn I1_I1574_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I223_MN5 (XI1_I1574_I223_n2 I1_I1574_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I223_MN4 (I1_p22_20 XI1_I1574_I223_An XI1_I1574_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I223_MN2 (XI1_I1574_I223_n1 I1_I1574_pn20 I1_p22_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I223_MN3 (VSS XI1_I1574_I223_Bn XI1_I1574_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I223_MN0 (XI1_I1574_I223_An I1_I1574_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I222_MN1 (XI1_I1574_I222_Bn I1_I1574_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I222_MN5 (XI1_I1574_I222_n2 I1_I1574_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I222_MN4 (I1_p22_19 XI1_I1574_I222_An XI1_I1574_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I222_MN2 (XI1_I1574_I222_n1 I1_I1574_pn19 I1_p22_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I222_MN3 (VSS XI1_I1574_I222_Bn XI1_I1574_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I222_MN0 (XI1_I1574_I222_An I1_I1574_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I234_MN1 (XI1_I1574_I234_Bn I1_c22_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I234_MN5 (XI1_I1574_I234_n2 I1_c22_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I234_MN4 (I1_p22_31 XI1_I1574_I234_An XI1_I1574_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I234_MN2 (XI1_I1574_I234_n1 I1_I1574_pn31 I1_p22_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I234_MN3 (VSS XI1_I1574_I234_Bn XI1_I1574_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I234_MN0 (XI1_I1574_I234_An I1_I1574_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I32_MN1 (XI1_I1574_I32_Bn I1_b22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I32_MN5 (XI1_I1574_I32_n2 I1_b22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I32_MN4 (I1_I1574_pn0 XI1_I1574_I32_An XI1_I1574_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I32_MN2 (XI1_I1574_I32_n1 I1_aa9 I1_I1574_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I32_MN3 (VSS XI1_I1574_I32_Bn XI1_I1574_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I32_MN0 (XI1_I1574_I32_An I1_aa9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I61_MN1 (XI1_I61_Bn I1_nakn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I61_MN5 (XI1_I61_n2 I1_nakn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I61_MN4 (I1_aa9 XI1_I61_An XI1_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I61_MN2 (XI1_I61_n1 A_9 I1_aa9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I61_MN3 (VSS XI1_I61_Bn XI1_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I61_MN0 (XI1_I61_An A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I41_MN1 (XI2_I1_I42_I41_Bn I2_I1_bx9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I41_MN5 (XI2_I1_I42_I41_n2 I2_I1_bx9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I41_MN4 (I2_I1_I42_pn9 XI2_I1_I42_I41_An XI2_I1_I42_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I41_MN2 (XI2_I1_I42_I41_n1 A_9 I2_I1_I42_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I41_MN3 (VSS XI2_I1_I42_I41_Bn XI2_I1_I42_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I41_MN0 (XI2_I1_I42_I41_An A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I40_MN1 (XI2_I1_I42_I40_Bn I2_I1_bx8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I40_MN5 (XI2_I1_I42_I40_n2 I2_I1_bx8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I40_MN4 (I2_I1_I42_pn8 XI2_I1_I42_I40_An XI2_I1_I42_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I40_MN2 (XI2_I1_I42_I40_n1 A_8 I2_I1_I42_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I40_MN3 (VSS XI2_I1_I42_I40_Bn XI2_I1_I42_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I40_MN0 (XI2_I1_I42_I40_An A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I211_MN1 (XI2_I1_I42_I211_Bn I2_I1_I42_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I211_MN5 (XI2_I1_I42_I211_n2 I2_I1_I42_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I211_MN4 (I2_S_8 XI2_I1_I42_I211_An XI2_I1_I42_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I211_MN2 (XI2_I1_I42_I211_n1 I2_I1_I42_pn8 I2_S_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I211_MN3 (VSS XI2_I1_I42_I211_Bn XI2_I1_I42_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I211_MN0 (XI2_I1_I42_I211_An I2_I1_I42_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I59_MN1 (XI1_I1758_I59_Bn I1_b26_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I59_MN5 (XI1_I1758_I59_n2 I1_b26_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I59_MN4 (I1_I1758_pn27 XI1_I1758_I59_An XI1_I1758_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I59_MN2 (XI1_I1758_I59_n1 I1_p25_26 I1_I1758_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I59_MN3 (VSS XI1_I1758_I59_Bn XI1_I1758_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I59_MN0 (XI1_I1758_I59_An I1_p25_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I226_MN1 (XI1_I1712_I226_Bn I1_I1712_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I226_MN5 (XI1_I1712_I226_n2 I1_I1712_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I226_MN4 (I1_p25_23 XI1_I1712_I226_An XI1_I1712_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I226_MN2 (XI1_I1712_I226_n1 I1_I1712_pn23 I1_p25_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I226_MN3 (VSS XI1_I1712_I226_Bn XI1_I1712_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I226_MN0 (XI1_I1712_I226_An I1_I1712_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I52_MN1 (XI1_I1712_I52_Bn I1_b25_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I52_MN5 (XI1_I1712_I52_n2 I1_b25_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I52_MN4 (I1_I1712_pn20 XI1_I1712_I52_An XI1_I1712_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I52_MN2 (XI1_I1712_I52_n1 I1_p24_19 I1_I1712_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I52_MN3 (VSS XI1_I1712_I52_Bn XI1_I1712_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I52_MN0 (XI1_I1712_I52_An I1_p24_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I224_MN1 (XI1_I1712_I224_Bn I1_I1712_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I224_MN5 (XI1_I1712_I224_n2 I1_I1712_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I224_MN4 (I1_p25_21 XI1_I1712_I224_An XI1_I1712_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I224_MN2 (XI1_I1712_I224_n1 I1_I1712_pn21 I1_p25_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I224_MN3 (VSS XI1_I1712_I224_Bn XI1_I1712_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I224_MN0 (XI1_I1712_I224_An I1_I1712_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I50_MN1 (XI1_I1712_I50_Bn I1_b25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I50_MN5 (XI1_I1712_I50_n2 I1_b25_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I50_MN4 (I1_I1712_pn18 XI1_I1712_I50_An XI1_I1712_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I50_MN2 (XI1_I1712_I50_n1 I1_p24_17 I1_I1712_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I50_MN3 (VSS XI1_I1712_I50_Bn XI1_I1712_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I50_MN0 (XI1_I1712_I50_An I1_p24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I47_MN1 (XI1_I1712_I47_Bn I1_b25_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I47_MN5 (XI1_I1712_I47_n2 I1_b25_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I47_MN4 (I1_I1712_pn15 XI1_I1712_I47_An XI1_I1712_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I47_MN2 (XI1_I1712_I47_n1 I1_p24_14 I1_I1712_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I47_MN3 (VSS XI1_I1712_I47_Bn XI1_I1712_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I47_MN0 (XI1_I1712_I47_An I1_p24_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I44_MN1 (XI1_I1712_I44_Bn I1_b25_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I44_MN5 (XI1_I1712_I44_n2 I1_b25_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I44_MN4 (I1_I1712_pn12 XI1_I1712_I44_An XI1_I1712_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I44_MN2 (XI1_I1712_I44_n1 I1_p24_11 I1_I1712_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I44_MN3 (VSS XI1_I1712_I44_Bn XI1_I1712_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I44_MN0 (XI1_I1712_I44_An I1_p24_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I43_MN1 (XI1_I1712_I43_Bn I1_b25_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I43_MN5 (XI1_I1712_I43_n2 I1_b25_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I43_MN4 (I1_I1712_pn11 XI1_I1712_I43_An XI1_I1712_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I43_MN2 (XI1_I1712_I43_n1 I1_p24_10 I1_I1712_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I43_MN3 (VSS XI1_I1712_I43_Bn XI1_I1712_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I43_MN0 (XI1_I1712_I43_An I1_p24_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I208_MN1 (XI1_I1666_I208_Bn I1_I1666_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I208_MN5 (XI1_I1666_I208_n2 I1_I1666_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I208_MN4 (I1_p24_5 XI1_I1666_I208_An XI1_I1666_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I208_MN2 (XI1_I1666_I208_n1 I1_I1666_pn5 I1_p24_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I208_MN3 (VSS XI1_I1666_I208_Bn XI1_I1666_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I208_MN0 (XI1_I1666_I208_An I1_I1666_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I220_MN1 (XI1_I1666_I220_Bn I1_I1666_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I220_MN5 (XI1_I1666_I220_n2 I1_I1666_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I220_MN4 (I1_p24_17 XI1_I1666_I220_An XI1_I1666_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I220_MN2 (XI1_I1666_I220_n1 I1_I1666_pn17 I1_p24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I220_MN3 (VSS XI1_I1666_I220_Bn XI1_I1666_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I220_MN0 (XI1_I1666_I220_An I1_I1666_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I209_MN1 (XI1_I1666_I209_Bn I1_I1666_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I209_MN5 (XI1_I1666_I209_n2 I1_I1666_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I209_MN4 (I1_p24_6 XI1_I1666_I209_An XI1_I1666_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I209_MN2 (XI1_I1666_I209_n1 I1_I1666_pn6 I1_p24_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I209_MN3 (VSS XI1_I1666_I209_Bn XI1_I1666_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I209_MN0 (XI1_I1666_I209_An I1_I1666_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I37_MN1 (XI1_I1666_I37_Bn I1_b24_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I37_MN5 (XI1_I1666_I37_n2 I1_b24_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I37_MN4 (I1_I1666_pn5 XI1_I1666_I37_An XI1_I1666_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I37_MN2 (XI1_I1666_I37_n1 I1_p23_4 I1_I1666_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I37_MN3 (VSS XI1_I1666_I37_Bn XI1_I1666_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I37_MN0 (XI1_I1666_I37_An I1_p23_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I38_MN1 (XI1_I1666_I38_Bn I1_b24_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I38_MN5 (XI1_I1666_I38_n2 I1_b24_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I38_MN4 (I1_I1666_pn6 XI1_I1666_I38_An XI1_I1666_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I38_MN2 (XI1_I1666_I38_n1 I1_p23_5 I1_I1666_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I38_MN3 (VSS XI1_I1666_I38_Bn XI1_I1666_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I38_MN0 (XI1_I1666_I38_An I1_p23_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I226_MN1 (XI1_I1574_I226_Bn I1_I1574_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I226_MN5 (XI1_I1574_I226_n2 I1_I1574_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I226_MN4 (I1_p22_23 XI1_I1574_I226_An XI1_I1574_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I226_MN2 (XI1_I1574_I226_n1 I1_I1574_pn23 I1_p22_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I226_MN3 (VSS XI1_I1574_I226_Bn XI1_I1574_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I226_MN0 (XI1_I1574_I226_An I1_I1574_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I40_MN1 (XI1_I1620_I40_Bn I1_b23_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I40_MN5 (XI1_I1620_I40_n2 I1_b23_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I40_MN4 (I1_I1620_pn8 XI1_I1620_I40_An XI1_I1620_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I40_MN2 (XI1_I1620_I40_n1 I1_p22_7 I1_I1620_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I40_MN3 (VSS XI1_I1620_I40_Bn XI1_I1620_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I40_MN0 (XI1_I1620_I40_An I1_p22_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I37_MN1 (XI1_I1620_I37_Bn I1_b23_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I37_MN5 (XI1_I1620_I37_n2 I1_b23_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I37_MN4 (I1_I1620_pn5 XI1_I1620_I37_An XI1_I1620_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I37_MN2 (XI1_I1620_I37_n1 I1_p22_4 I1_I1620_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I37_MN3 (VSS XI1_I1620_I37_Bn XI1_I1620_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I37_MN0 (XI1_I1620_I37_An I1_p22_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I52_MN1 (XI1_I52_Bn I1_nakn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I52_MN5 (XI1_I52_n2 I1_nakn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I52_MN4 (I1_aa6 XI1_I52_An XI1_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I52_MN2 (XI1_I52_n1 A_6 I1_aa6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I52_MN3 (VSS XI1_I52_Bn XI1_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I52_MN0 (XI1_I52_An A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I35_MN1 (XI1_I1620_I35_Bn I1_b23_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I35_MN5 (XI1_I1620_I35_n2 I1_b23_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I35_MN4 (I1_I1620_pn3 XI1_I1620_I35_An XI1_I1620_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I35_MN2 (XI1_I1620_I35_n1 I1_p22_2 I1_I1620_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I35_MN3 (VSS XI1_I1620_I35_Bn XI1_I1620_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I35_MN0 (XI1_I1620_I35_An I1_p22_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I203_MN1 (XI1_I1574_I203_Bn I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1574_I203_MN5 (XI1_I1574_I203_n2 I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1574_I203_MN4 (I1_p22_0 XI1_I1574_I203_An XI1_I1574_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I203_MN2 (XI1_I1574_I203_n1 I1_I1574_pn0 I1_p22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1574_I203_MN3 (VSS XI1_I1574_I203_Bn XI1_I1574_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1574_I203_MN0 (XI1_I1574_I203_An I1_I1574_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I55_MN1 (XI1_I55_Bn I1_nakn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I55_MN5 (XI1_I55_n2 I1_nakn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I55_MN4 (I1_aa7 XI1_I55_An XI1_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I55_MN2 (XI1_I55_n1 A_7 I1_aa7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I55_MN3 (VSS XI1_I55_Bn XI1_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I55_MN0 (XI1_I55_An A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I39_MN1 (XI2_I1_I42_I39_Bn I2_I1_bx7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I39_MN5 (XI2_I1_I42_I39_n2 I2_I1_bx7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I39_MN4 (I2_I1_I42_pn7 XI2_I1_I42_I39_An XI2_I1_I42_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I39_MN2 (XI2_I1_I42_I39_n1 A_7 I2_I1_I42_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I39_MN3 (VSS XI2_I1_I42_I39_Bn XI2_I1_I42_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I39_MN0 (XI2_I1_I42_I39_An A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I210_MN1 (XI2_I1_I42_I210_Bn I2_I1_I42_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I210_MN5 (XI2_I1_I42_I210_n2 I2_I1_I42_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I210_MN4 (I2_S_7 XI2_I1_I42_I210_An XI2_I1_I42_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I210_MN2 (XI2_I1_I42_I210_n1 I2_I1_I42_pn7 I2_S_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I210_MN3 (VSS XI2_I1_I42_I210_Bn XI2_I1_I42_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I210_MN0 (XI2_I1_I42_I210_An I2_I1_I42_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I61_MN1 (XI1_I1758_I61_Bn I1_b26_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I61_MN5 (XI1_I1758_I61_n2 I1_b26_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I61_MN4 (I1_I1758_pn29 XI1_I1758_I61_An XI1_I1758_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I61_MN2 (XI1_I1758_I61_n1 I1_p25_28 I1_I1758_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I61_MN3 (VSS XI1_I1758_I61_Bn XI1_I1758_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I61_MN0 (XI1_I1758_I61_An I1_p25_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I60_MN1 (XI1_I1758_I60_Bn I1_b26_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I60_MN5 (XI1_I1758_I60_n2 I1_b26_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I60_MN4 (I1_I1758_pn28 XI1_I1758_I60_An XI1_I1758_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I60_MN2 (XI1_I1758_I60_n1 I1_p25_27 I1_I1758_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I60_MN3 (VSS XI1_I1758_I60_Bn XI1_I1758_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I60_MN0 (XI1_I1758_I60_An I1_p25_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I57_MN1 (XI1_I1758_I57_Bn I1_b26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I57_MN5 (XI1_I1758_I57_n2 I1_b26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I57_MN4 (I1_I1758_pn25 XI1_I1758_I57_An XI1_I1758_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I57_MN2 (XI1_I1758_I57_n1 I1_p25_24 I1_I1758_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I57_MN3 (VSS XI1_I1758_I57_Bn XI1_I1758_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I57_MN0 (XI1_I1758_I57_An I1_p25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I53_MN1 (XI1_I1712_I53_Bn I1_b25_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I53_MN5 (XI1_I1712_I53_n2 I1_b25_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I53_MN4 (I1_I1712_pn21 XI1_I1712_I53_An XI1_I1712_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I53_MN2 (XI1_I1712_I53_n1 I1_p24_20 I1_I1712_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I53_MN3 (VSS XI1_I1712_I53_Bn XI1_I1712_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I53_MN0 (XI1_I1712_I53_An I1_p24_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I55_MN1 (XI1_I1712_I55_Bn I1_b25_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I55_MN5 (XI1_I1712_I55_n2 I1_b25_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I55_MN4 (I1_I1712_pn23 XI1_I1712_I55_An XI1_I1712_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I55_MN2 (XI1_I1712_I55_n1 I1_p24_22 I1_I1712_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I55_MN3 (VSS XI1_I1712_I55_Bn XI1_I1712_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I55_MN0 (XI1_I1712_I55_An I1_p24_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I51_MN1 (XI1_I1712_I51_Bn I1_b25_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I51_MN5 (XI1_I1712_I51_n2 I1_b25_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I51_MN4 (I1_I1712_pn19 XI1_I1712_I51_An XI1_I1712_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I51_MN2 (XI1_I1712_I51_n1 I1_p24_18 I1_I1712_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I51_MN3 (VSS XI1_I1712_I51_Bn XI1_I1712_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I51_MN0 (XI1_I1712_I51_An I1_p24_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I48_MN1 (XI1_I1712_I48_Bn I1_b25_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I48_MN5 (XI1_I1712_I48_n2 I1_b25_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I48_MN4 (I1_I1712_pn16 XI1_I1712_I48_An XI1_I1712_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I48_MN2 (XI1_I1712_I48_n1 I1_p24_15 I1_I1712_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I48_MN3 (VSS XI1_I1712_I48_Bn XI1_I1712_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I48_MN0 (XI1_I1712_I48_An I1_p24_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I46_MN1 (XI1_I1712_I46_Bn I1_b25_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I46_MN5 (XI1_I1712_I46_n2 I1_b25_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I46_MN4 (I1_I1712_pn14 XI1_I1712_I46_An XI1_I1712_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I46_MN2 (XI1_I1712_I46_n1 I1_p24_13 I1_I1712_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I46_MN3 (VSS XI1_I1712_I46_Bn XI1_I1712_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I46_MN0 (XI1_I1712_I46_An I1_p24_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I45_MN1 (XI1_I1712_I45_Bn I1_b25_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I45_MN5 (XI1_I1712_I45_n2 I1_b25_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I45_MN4 (I1_I1712_pn13 XI1_I1712_I45_An XI1_I1712_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I45_MN2 (XI1_I1712_I45_n1 I1_p24_12 I1_I1712_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I45_MN3 (VSS XI1_I1712_I45_Bn XI1_I1712_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I45_MN0 (XI1_I1712_I45_An I1_p24_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I210_MN1 (XI1_I1666_I210_Bn I1_I1666_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I210_MN5 (XI1_I1666_I210_n2 I1_I1666_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I210_MN4 (I1_p24_7 XI1_I1666_I210_An XI1_I1666_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I210_MN2 (XI1_I1666_I210_n1 I1_I1666_pn7 I1_p24_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I210_MN3 (VSS XI1_I1666_I210_Bn XI1_I1666_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I210_MN0 (XI1_I1666_I210_An I1_I1666_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I222_MN1 (XI1_I1666_I222_Bn I1_I1666_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I222_MN5 (XI1_I1666_I222_n2 I1_I1666_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I222_MN4 (I1_p24_19 XI1_I1666_I222_An XI1_I1666_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I222_MN2 (XI1_I1666_I222_n1 I1_I1666_pn19 I1_p24_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I222_MN3 (VSS XI1_I1666_I222_Bn XI1_I1666_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I222_MN0 (XI1_I1666_I222_An I1_I1666_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I211_MN1 (XI1_I1666_I211_Bn I1_I1666_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I211_MN5 (XI1_I1666_I211_n2 I1_I1666_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I211_MN4 (I1_p24_8 XI1_I1666_I211_An XI1_I1666_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I211_MN2 (XI1_I1666_I211_n1 I1_I1666_pn8 I1_p24_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I211_MN3 (VSS XI1_I1666_I211_Bn XI1_I1666_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I211_MN0 (XI1_I1666_I211_An I1_I1666_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I39_MN1 (XI1_I1666_I39_Bn I1_b24_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I39_MN5 (XI1_I1666_I39_n2 I1_b24_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I39_MN4 (I1_I1666_pn7 XI1_I1666_I39_An XI1_I1666_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I39_MN2 (XI1_I1666_I39_n1 I1_p23_6 I1_I1666_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I39_MN3 (VSS XI1_I1666_I39_Bn XI1_I1666_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I39_MN0 (XI1_I1666_I39_An I1_p23_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I40_MN1 (XI1_I1666_I40_Bn I1_b24_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I40_MN5 (XI1_I1666_I40_n2 I1_b24_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I40_MN4 (I1_I1666_pn8 XI1_I1666_I40_An XI1_I1666_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I40_MN2 (XI1_I1666_I40_n1 I1_p23_7 I1_I1666_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I40_MN3 (VSS XI1_I1666_I40_Bn XI1_I1666_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I40_MN0 (XI1_I1666_I40_An I1_p23_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I203_MN1 (XI1_I1620_I203_Bn I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I203_MN5 (XI1_I1620_I203_n2 I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I203_MN4 (I1_p23_0 XI1_I1620_I203_An XI1_I1620_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I203_MN2 (XI1_I1620_I203_n1 I1_I1620_pn0 I1_p23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I203_MN3 (VSS XI1_I1620_I203_Bn XI1_I1620_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I203_MN0 (XI1_I1620_I203_An I1_I1620_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I210_MN1 (XI1_I1620_I210_Bn I1_I1620_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I210_MN5 (XI1_I1620_I210_n2 I1_I1620_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I210_MN4 (I1_p23_7 XI1_I1620_I210_An XI1_I1620_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I210_MN2 (XI1_I1620_I210_n1 I1_I1620_pn7 I1_p23_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I210_MN3 (VSS XI1_I1620_I210_Bn XI1_I1620_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I210_MN0 (XI1_I1620_I210_An I1_I1620_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I41_MN1 (XI1_I1620_I41_Bn I1_b23_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I41_MN5 (XI1_I1620_I41_n2 I1_b23_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I41_MN4 (I1_I1620_pn9 XI1_I1620_I41_An XI1_I1620_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I41_MN2 (XI1_I1620_I41_n1 I1_p22_8 I1_I1620_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I41_MN3 (VSS XI1_I1620_I41_Bn XI1_I1620_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I41_MN0 (XI1_I1620_I41_An I1_p22_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I39_MN1 (XI1_I1620_I39_Bn I1_b23_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I39_MN5 (XI1_I1620_I39_n2 I1_b23_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I39_MN4 (I1_I1620_pn7 XI1_I1620_I39_An XI1_I1620_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I39_MN2 (XI1_I1620_I39_n1 I1_p22_6 I1_I1620_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I39_MN3 (VSS XI1_I1620_I39_Bn XI1_I1620_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I39_MN0 (XI1_I1620_I39_An I1_p22_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I208_MN1 (XI1_I1620_I208_Bn I1_I1620_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I208_MN5 (XI1_I1620_I208_n2 I1_I1620_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I208_MN4 (I1_p23_5 XI1_I1620_I208_An XI1_I1620_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I208_MN2 (XI1_I1620_I208_n1 I1_I1620_pn5 I1_p23_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I208_MN3 (VSS XI1_I1620_I208_Bn XI1_I1620_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I208_MN0 (XI1_I1620_I208_An I1_I1620_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I34_MN1 (XI1_I1620_I34_Bn I1_b23_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I34_MN5 (XI1_I1620_I34_n2 I1_b23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I34_MN4 (I1_I1620_pn2 XI1_I1620_I34_An XI1_I1620_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I34_MN2 (XI1_I1620_I34_n1 I1_p22_1 I1_I1620_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I34_MN3 (VSS XI1_I1620_I34_Bn XI1_I1620_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I34_MN0 (XI1_I1620_I34_An I1_p22_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I204_MN1 (XI1_I1620_I204_Bn I1_I1620_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I204_MN5 (XI1_I1620_I204_n2 I1_I1620_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I204_MN4 (I1_p23_1 XI1_I1620_I204_An XI1_I1620_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I204_MN2 (XI1_I1620_I204_n1 I1_I1620_pn1 I1_p23_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I204_MN3 (VSS XI1_I1620_I204_Bn XI1_I1620_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I204_MN0 (XI1_I1620_I204_An I1_I1620_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I32_MN1 (XI1_I1620_I32_Bn I1_b23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I32_MN5 (XI1_I1620_I32_n2 I1_b23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I32_MN4 (I1_I1620_pn0 XI1_I1620_I32_An XI1_I1620_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I32_MN2 (XI1_I1620_I32_n1 I1_aa8 I1_I1620_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I32_MN3 (VSS XI1_I1620_I32_Bn XI1_I1620_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I32_MN0 (XI1_I1620_I32_An I1_aa8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I58_MN1 (XI1_I58_Bn I1_nakn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I58_MN5 (XI1_I58_n2 I1_nakn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I58_MN4 (I1_aa8 XI1_I58_An XI1_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I58_MN2 (XI1_I58_n1 A_8 I1_aa8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I58_MN3 (VSS XI1_I58_Bn XI1_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I58_MN0 (XI1_I58_An A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I38_MN1 (XI2_I1_I42_I38_Bn I2_I1_bx6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I38_MN5 (XI2_I1_I42_I38_n2 I2_I1_bx6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I38_MN4 (I2_I1_I42_pn6 XI2_I1_I42_I38_An XI2_I1_I42_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I38_MN2 (XI2_I1_I42_I38_n1 A_6 I2_I1_I42_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I38_MN3 (VSS XI2_I1_I42_I38_Bn XI2_I1_I42_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I38_MN0 (XI2_I1_I42_I38_An A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I209_MN1 (XI2_I1_I42_I209_Bn I2_I1_I42_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I209_MN5 (XI2_I1_I42_I209_n2 I2_I1_I42_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I209_MN4 (I2_S_6 XI2_I1_I42_I209_An XI2_I1_I42_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I209_MN2 (XI2_I1_I42_I209_n1 I2_I1_I42_pn6 I2_S_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I209_MN3 (VSS XI2_I1_I42_I209_Bn XI2_I1_I42_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I209_MN0 (XI2_I1_I42_I209_An I2_I1_I42_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I208_MN1 (XI2_I1_I42_I208_Bn I2_I1_I42_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I208_MN5 (XI2_I1_I42_I208_n2 I2_I1_I42_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I208_MN4 (I2_S_5 XI2_I1_I42_I208_An XI2_I1_I42_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I208_MN2 (XI2_I1_I42_I208_n1 I2_I1_I42_pn5 I2_S_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I208_MN3 (VSS XI2_I1_I42_I208_Bn XI2_I1_I42_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I208_MN0 (XI2_I1_I42_I208_An I2_I1_I42_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I56_MN1 (XI1_I1758_I56_Bn I1_b26_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I56_MN5 (XI1_I1758_I56_n2 I1_b26_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I56_MN4 (I1_I1758_pn24 XI1_I1758_I56_An XI1_I1758_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I56_MN2 (XI1_I1758_I56_n1 I1_p25_23 I1_I1758_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I56_MN3 (VSS XI1_I1758_I56_Bn XI1_I1758_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I56_MN0 (XI1_I1758_I56_An I1_p25_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I53_MN1 (XI1_I1758_I53_Bn I1_b26_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I53_MN5 (XI1_I1758_I53_n2 I1_b26_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I53_MN4 (I1_I1758_pn21 XI1_I1758_I53_An XI1_I1758_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I53_MN2 (XI1_I1758_I53_n1 I1_p25_20 I1_I1758_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I53_MN3 (VSS XI1_I1758_I53_Bn XI1_I1758_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I53_MN0 (XI1_I1758_I53_An I1_p25_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I220_MN1 (XI1_I1712_I220_Bn I1_I1712_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I220_MN5 (XI1_I1712_I220_n2 I1_I1712_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I220_MN4 (I1_p25_17 XI1_I1712_I220_An XI1_I1712_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I220_MN2 (XI1_I1712_I220_n1 I1_I1712_pn17 I1_p25_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I220_MN3 (VSS XI1_I1712_I220_Bn XI1_I1712_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I220_MN0 (XI1_I1712_I220_An I1_I1712_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I47_MN1 (XI1_I1758_I47_Bn I1_b26_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I47_MN5 (XI1_I1758_I47_n2 I1_b26_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I47_MN4 (I1_I1758_pn15 XI1_I1758_I47_An XI1_I1758_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I47_MN2 (XI1_I1758_I47_n1 I1_p25_14 I1_I1758_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I47_MN3 (VSS XI1_I1758_I47_Bn XI1_I1758_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I47_MN0 (XI1_I1758_I47_An I1_p25_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I49_MN1 (XI1_I1712_I49_Bn I1_b25_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1712_I49_MN5 (XI1_I1712_I49_n2 I1_b25_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1712_I49_MN4 (I1_I1712_pn17 XI1_I1712_I49_An XI1_I1712_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I49_MN2 (XI1_I1712_I49_n1 I1_p24_16 I1_I1712_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1712_I49_MN3 (VSS XI1_I1712_I49_Bn XI1_I1712_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1712_I49_MN0 (XI1_I1712_I49_An I1_p24_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I228_MN1 (XI1_I1666_I228_Bn I1_I1666_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I228_MN5 (XI1_I1666_I228_n2 I1_I1666_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I228_MN4 (I1_p24_25 XI1_I1666_I228_An XI1_I1666_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I228_MN2 (XI1_I1666_I228_n1 I1_I1666_pn25 I1_p24_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I228_MN3 (VSS XI1_I1666_I228_Bn XI1_I1666_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I228_MN0 (XI1_I1666_I228_An I1_I1666_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I221_MN1 (XI1_I1666_I221_Bn I1_I1666_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I221_MN5 (XI1_I1666_I221_n2 I1_I1666_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I221_MN4 (I1_p24_18 XI1_I1666_I221_An XI1_I1666_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I221_MN2 (XI1_I1666_I221_n1 I1_I1666_pn18 I1_p24_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I221_MN3 (VSS XI1_I1666_I221_Bn XI1_I1666_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I221_MN0 (XI1_I1666_I221_An I1_I1666_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I43_MN1 (XI1_I1666_I43_Bn I1_b24_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I43_MN5 (XI1_I1666_I43_n2 I1_b24_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I43_MN4 (I1_I1666_pn11 XI1_I1666_I43_An XI1_I1666_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I43_MN2 (XI1_I1666_I43_n1 I1_p23_10 I1_I1666_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I43_MN3 (VSS XI1_I1666_I43_Bn XI1_I1666_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I43_MN0 (XI1_I1666_I43_An I1_p23_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I42_MN1 (XI1_I1666_I42_Bn I1_b24_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I42_MN5 (XI1_I1666_I42_n2 I1_b24_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I42_MN4 (I1_I1666_pn10 XI1_I1666_I42_An XI1_I1666_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I42_MN2 (XI1_I1666_I42_n1 I1_p23_9 I1_I1666_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I42_MN3 (VSS XI1_I1666_I42_Bn XI1_I1666_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I42_MN0 (XI1_I1666_I42_An I1_p23_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I41_MN1 (XI1_I1666_I41_Bn I1_b24_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I41_MN5 (XI1_I1666_I41_n2 I1_b24_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I41_MN4 (I1_I1666_pn9 XI1_I1666_I41_An XI1_I1666_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I41_MN2 (XI1_I1666_I41_n1 I1_p23_8 I1_I1666_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I41_MN3 (VSS XI1_I1666_I41_Bn XI1_I1666_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I41_MN0 (XI1_I1666_I41_An I1_p23_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I45_MN1 (XI1_I1620_I45_Bn I1_b23_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I45_MN5 (XI1_I1620_I45_n2 I1_b23_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I45_MN4 (I1_I1620_pn13 XI1_I1620_I45_An XI1_I1620_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I45_MN2 (XI1_I1620_I45_n1 I1_p22_12 I1_I1620_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I45_MN3 (VSS XI1_I1620_I45_Bn XI1_I1620_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I45_MN0 (XI1_I1620_I45_An I1_p22_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I46_MN1 (XI1_I1620_I46_Bn I1_b23_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I46_MN5 (XI1_I1620_I46_n2 I1_b23_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I46_MN4 (I1_I1620_pn14 XI1_I1620_I46_An XI1_I1620_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I46_MN2 (XI1_I1620_I46_n1 I1_p22_13 I1_I1620_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I46_MN3 (VSS XI1_I1620_I46_Bn XI1_I1620_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I46_MN0 (XI1_I1620_I46_An I1_p22_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I44_MN1 (XI1_I1620_I44_Bn I1_b23_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I44_MN5 (XI1_I1620_I44_n2 I1_b23_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I44_MN4 (I1_I1620_pn12 XI1_I1620_I44_An XI1_I1620_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I44_MN2 (XI1_I1620_I44_n1 I1_p22_11 I1_I1620_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I44_MN3 (VSS XI1_I1620_I44_Bn XI1_I1620_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I44_MN0 (XI1_I1620_I44_An I1_p22_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I43_MN1 (XI1_I1620_I43_Bn I1_b23_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I43_MN5 (XI1_I1620_I43_n2 I1_b23_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I43_MN4 (I1_I1620_pn11 XI1_I1620_I43_An XI1_I1620_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I43_MN2 (XI1_I1620_I43_n1 I1_p22_10 I1_I1620_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I43_MN3 (VSS XI1_I1620_I43_Bn XI1_I1620_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I43_MN0 (XI1_I1620_I43_An I1_p22_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I42_MN1 (XI1_I1620_I42_Bn I1_b23_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I42_MN5 (XI1_I1620_I42_n2 I1_b23_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I42_MN4 (I1_I1620_pn10 XI1_I1620_I42_An XI1_I1620_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I42_MN2 (XI1_I1620_I42_n1 I1_p22_9 I1_I1620_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I42_MN3 (VSS XI1_I1620_I42_Bn XI1_I1620_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I42_MN0 (XI1_I1620_I42_An I1_p22_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I38_MN1 (XI1_I1620_I38_Bn I1_b23_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I38_MN5 (XI1_I1620_I38_n2 I1_b23_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I38_MN4 (I1_I1620_pn6 XI1_I1620_I38_An XI1_I1620_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I38_MN2 (XI1_I1620_I38_n1 I1_p22_5 I1_I1620_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I38_MN3 (VSS XI1_I1620_I38_Bn XI1_I1620_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I38_MN0 (XI1_I1620_I38_An I1_p22_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I205_MN1 (XI1_I1620_I205_Bn I1_I1620_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I205_MN5 (XI1_I1620_I205_n2 I1_I1620_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I205_MN4 (I1_p23_2 XI1_I1620_I205_An XI1_I1620_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I205_MN2 (XI1_I1620_I205_n1 I1_I1620_pn2 I1_p23_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I205_MN3 (VSS XI1_I1620_I205_Bn XI1_I1620_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I205_MN0 (XI1_I1620_I205_An I1_I1620_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I33_MN1 (XI1_I1620_I33_Bn I1_b23_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I33_MN5 (XI1_I1620_I33_n2 I1_b23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I33_MN4 (I1_I1620_pn1 XI1_I1620_I33_An XI1_I1620_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I33_MN2 (XI1_I1620_I33_n1 I1_p22_0 I1_I1620_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I33_MN3 (VSS XI1_I1620_I33_Bn XI1_I1620_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I33_MN0 (XI1_I1620_I33_An I1_p22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I37_MN1 (XI2_I1_I42_I37_Bn I2_I1_bx5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I37_MN5 (XI2_I1_I42_I37_n2 I2_I1_bx5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I37_MN4 (I2_I1_I42_pn5 XI2_I1_I42_I37_An XI2_I1_I42_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I37_MN2 (XI2_I1_I42_I37_n1 A_5 I2_I1_I42_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I37_MN3 (VSS XI2_I1_I42_I37_Bn XI2_I1_I42_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I37_MN0 (XI2_I1_I42_I37_An A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I58_MN1 (XI1_I1758_I58_Bn I1_b26_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I58_MN5 (XI1_I1758_I58_n2 I1_b26_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I58_MN4 (I1_I1758_pn26 XI1_I1758_I58_An XI1_I1758_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I58_MN2 (XI1_I1758_I58_n1 I1_p25_25 I1_I1758_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I58_MN3 (VSS XI1_I1758_I58_Bn XI1_I1758_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I58_MN0 (XI1_I1758_I58_An I1_p25_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I55_MN1 (XI1_I1758_I55_Bn I1_b26_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I55_MN5 (XI1_I1758_I55_n2 I1_b26_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I55_MN4 (I1_I1758_pn23 XI1_I1758_I55_An XI1_I1758_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I55_MN2 (XI1_I1758_I55_n1 I1_p25_22 I1_I1758_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I55_MN3 (VSS XI1_I1758_I55_Bn XI1_I1758_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I55_MN0 (XI1_I1758_I55_An I1_p25_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I50_MN1 (XI1_I1758_I50_Bn I1_b26_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I50_MN5 (XI1_I1758_I50_n2 I1_b26_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I50_MN4 (I1_I1758_pn18 XI1_I1758_I50_An XI1_I1758_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I50_MN2 (XI1_I1758_I50_n1 I1_p25_17 I1_I1758_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I50_MN3 (VSS XI1_I1758_I50_Bn XI1_I1758_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I50_MN0 (XI1_I1758_I50_An I1_p25_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I49_MN1 (XI1_I1758_I49_Bn I1_b26_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I49_MN5 (XI1_I1758_I49_n2 I1_b26_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I49_MN4 (I1_I1758_pn17 XI1_I1758_I49_An XI1_I1758_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I49_MN2 (XI1_I1758_I49_n1 I1_p25_16 I1_I1758_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I49_MN3 (VSS XI1_I1758_I49_Bn XI1_I1758_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I49_MN0 (XI1_I1758_I49_An I1_p25_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I48_MN1 (XI1_I1758_I48_Bn I1_b26_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I48_MN5 (XI1_I1758_I48_n2 I1_b26_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I48_MN4 (I1_I1758_pn16 XI1_I1758_I48_An XI1_I1758_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I48_MN2 (XI1_I1758_I48_n1 I1_p25_15 I1_I1758_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I48_MN3 (VSS XI1_I1758_I48_Bn XI1_I1758_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I48_MN0 (XI1_I1758_I48_An I1_p25_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I45_MN1 (XI1_I1758_I45_Bn I1_b26_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I45_MN5 (XI1_I1758_I45_n2 I1_b26_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I45_MN4 (I1_I1758_pn13 XI1_I1758_I45_An XI1_I1758_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I45_MN2 (XI1_I1758_I45_n1 I1_p25_12 I1_I1758_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I45_MN3 (VSS XI1_I1758_I45_Bn XI1_I1758_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I45_MN0 (XI1_I1758_I45_An I1_p25_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I224_MN1 (XI1_I1666_I224_Bn I1_I1666_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I224_MN5 (XI1_I1666_I224_n2 I1_I1666_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I224_MN4 (I1_p24_21 XI1_I1666_I224_An XI1_I1666_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I224_MN2 (XI1_I1666_I224_n1 I1_I1666_pn21 I1_p24_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I224_MN3 (VSS XI1_I1666_I224_Bn XI1_I1666_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I224_MN0 (XI1_I1666_I224_An I1_I1666_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I230_MN1 (XI1_I1666_I230_Bn I1_I1666_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I230_MN5 (XI1_I1666_I230_n2 I1_I1666_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I230_MN4 (I1_p24_27 XI1_I1666_I230_An XI1_I1666_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I230_MN2 (XI1_I1666_I230_n1 I1_I1666_pn27 I1_p24_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I230_MN3 (VSS XI1_I1666_I230_Bn XI1_I1666_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I230_MN0 (XI1_I1666_I230_An I1_I1666_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I223_MN1 (XI1_I1666_I223_Bn I1_I1666_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I223_MN5 (XI1_I1666_I223_n2 I1_I1666_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I223_MN4 (I1_p24_20 XI1_I1666_I223_An XI1_I1666_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I223_MN2 (XI1_I1666_I223_n1 I1_I1666_pn20 I1_p24_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I223_MN3 (VSS XI1_I1666_I223_Bn XI1_I1666_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I223_MN0 (XI1_I1666_I223_An I1_I1666_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I44_MN1 (XI1_I1666_I44_Bn I1_b24_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I44_MN5 (XI1_I1666_I44_n2 I1_b24_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I44_MN4 (I1_I1666_pn12 XI1_I1666_I44_An XI1_I1666_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I44_MN2 (XI1_I1666_I44_n1 I1_p23_11 I1_I1666_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I44_MN3 (VSS XI1_I1666_I44_Bn XI1_I1666_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I44_MN0 (XI1_I1666_I44_An I1_p23_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I48_MN1 (XI1_I1620_I48_Bn I1_b23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I48_MN5 (XI1_I1620_I48_n2 I1_b23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I48_MN4 (I1_I1620_pn16 XI1_I1620_I48_An XI1_I1620_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I48_MN2 (XI1_I1620_I48_n1 I1_p22_15 I1_I1620_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I48_MN3 (VSS XI1_I1620_I48_Bn XI1_I1620_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I48_MN0 (XI1_I1620_I48_An I1_p22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I211_MN1 (XI1_I1620_I211_Bn I1_I1620_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I211_MN5 (XI1_I1620_I211_n2 I1_I1620_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I211_MN4 (I1_p23_8 XI1_I1620_I211_An XI1_I1620_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I211_MN2 (XI1_I1620_I211_n1 I1_I1620_pn8 I1_p23_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I211_MN3 (VSS XI1_I1620_I211_Bn XI1_I1620_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I211_MN0 (XI1_I1620_I211_An I1_I1620_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I209_MN1 (XI1_I1620_I209_Bn I1_I1620_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I209_MN5 (XI1_I1620_I209_n2 I1_I1620_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I209_MN4 (I1_p23_6 XI1_I1620_I209_An XI1_I1620_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I209_MN2 (XI1_I1620_I209_n1 I1_I1620_pn6 I1_p23_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I209_MN3 (VSS XI1_I1620_I209_Bn XI1_I1620_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I209_MN0 (XI1_I1620_I209_An I1_I1620_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I36_MN1 (XI2_I1_I42_I36_Bn I2_I1_bx4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I36_MN5 (XI2_I1_I42_I36_n2 I2_I1_bx4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I36_MN4 (I2_I1_I42_pn4 XI2_I1_I42_I36_An XI2_I1_I42_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I36_MN2 (XI2_I1_I42_I36_n1 A_4 I2_I1_I42_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I36_MN3 (VSS XI2_I1_I42_I36_Bn XI2_I1_I42_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I36_MN0 (XI2_I1_I42_I36_An A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I35_MN1 (XI2_I1_I42_I35_Bn I2_I1_bx3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I35_MN5 (XI2_I1_I42_I35_n2 I2_I1_bx3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I35_MN4 (I2_I1_I42_pn3 XI2_I1_I42_I35_An XI2_I1_I42_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I35_MN2 (XI2_I1_I42_I35_n1 A_3 I2_I1_I42_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I35_MN3 (VSS XI2_I1_I42_I35_Bn XI2_I1_I42_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I35_MN0 (XI2_I1_I42_I35_An A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I63_MN1 (XI1_I1758_I63_Bn I1_b26_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I63_MN5 (XI1_I1758_I63_n2 I1_b26_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I63_MN4 (I1_I1758_pn31 XI1_I1758_I63_An XI1_I1758_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I63_MN2 (XI1_I1758_I63_n1 I1_p25_30 I1_I1758_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I63_MN3 (VSS XI1_I1758_I63_Bn XI1_I1758_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I63_MN0 (XI1_I1758_I63_An I1_p25_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I62_MN1 (XI1_I1758_I62_Bn I1_b26_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I62_MN5 (XI1_I1758_I62_n2 I1_b26_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I62_MN4 (I1_I1758_pn30 XI1_I1758_I62_An XI1_I1758_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I62_MN2 (XI1_I1758_I62_n1 I1_p25_29 I1_I1758_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I62_MN3 (VSS XI1_I1758_I62_Bn XI1_I1758_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I62_MN0 (XI1_I1758_I62_An I1_p25_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I54_MN1 (XI1_I1758_I54_Bn I1_b26_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I54_MN5 (XI1_I1758_I54_n2 I1_b26_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I54_MN4 (I1_I1758_pn22 XI1_I1758_I54_An XI1_I1758_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I54_MN2 (XI1_I1758_I54_n1 I1_p25_21 I1_I1758_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I54_MN3 (VSS XI1_I1758_I54_Bn XI1_I1758_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I54_MN0 (XI1_I1758_I54_An I1_p25_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I52_MN1 (XI1_I1758_I52_Bn I1_b26_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I52_MN5 (XI1_I1758_I52_n2 I1_b26_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I52_MN4 (I1_I1758_pn20 XI1_I1758_I52_An XI1_I1758_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I52_MN2 (XI1_I1758_I52_n1 I1_p25_19 I1_I1758_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I52_MN3 (VSS XI1_I1758_I52_Bn XI1_I1758_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I52_MN0 (XI1_I1758_I52_An I1_p25_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I51_MN1 (XI1_I1758_I51_Bn I1_b26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I51_MN5 (XI1_I1758_I51_n2 I1_b26_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I51_MN4 (I1_I1758_pn19 XI1_I1758_I51_An XI1_I1758_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I51_MN2 (XI1_I1758_I51_n1 I1_p25_18 I1_I1758_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I51_MN3 (VSS XI1_I1758_I51_Bn XI1_I1758_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I51_MN0 (XI1_I1758_I51_An I1_p25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I46_MN1 (XI1_I1758_I46_Bn I1_b26_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I46_MN5 (XI1_I1758_I46_n2 I1_b26_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I46_MN4 (I1_I1758_pn14 XI1_I1758_I46_An XI1_I1758_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I46_MN2 (XI1_I1758_I46_n1 I1_p25_13 I1_I1758_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I46_MN3 (VSS XI1_I1758_I46_Bn XI1_I1758_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I46_MN0 (XI1_I1758_I46_An I1_p25_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I43_MN1 (XI1_I1758_I43_Bn I1_b26_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I43_MN5 (XI1_I1758_I43_n2 I1_b26_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I43_MN4 (I1_I1758_pn11 XI1_I1758_I43_An XI1_I1758_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I43_MN2 (XI1_I1758_I43_n1 I1_p25_10 I1_I1758_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I43_MN3 (VSS XI1_I1758_I43_Bn XI1_I1758_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I43_MN0 (XI1_I1758_I43_An I1_p25_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I44_MN1 (XI1_I1758_I44_Bn I1_b26_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I44_MN5 (XI1_I1758_I44_n2 I1_b26_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I44_MN4 (I1_I1758_pn12 XI1_I1758_I44_An XI1_I1758_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I44_MN2 (XI1_I1758_I44_n1 I1_p25_11 I1_I1758_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I44_MN3 (VSS XI1_I1758_I44_Bn XI1_I1758_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I44_MN0 (XI1_I1758_I44_An I1_p25_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I229_MN1 (XI1_I1666_I229_Bn I1_I1666_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I229_MN5 (XI1_I1666_I229_n2 I1_I1666_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I229_MN4 (I1_p24_26 XI1_I1666_I229_An XI1_I1666_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I229_MN2 (XI1_I1666_I229_n1 I1_I1666_pn26 I1_p24_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I229_MN3 (VSS XI1_I1666_I229_Bn XI1_I1666_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I229_MN0 (XI1_I1666_I229_An I1_I1666_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I46_MN1 (XI1_I1666_I46_Bn I1_b24_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I46_MN5 (XI1_I1666_I46_n2 I1_b24_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I46_MN4 (I1_I1666_pn14 XI1_I1666_I46_An XI1_I1666_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I46_MN2 (XI1_I1666_I46_n1 I1_p23_13 I1_I1666_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I46_MN3 (VSS XI1_I1666_I46_Bn XI1_I1666_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I46_MN0 (XI1_I1666_I46_An I1_p23_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I45_MN1 (XI1_I1666_I45_Bn I1_b24_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I45_MN5 (XI1_I1666_I45_n2 I1_b24_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I45_MN4 (I1_I1666_pn13 XI1_I1666_I45_An XI1_I1666_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I45_MN2 (XI1_I1666_I45_n1 I1_p23_12 I1_I1666_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I45_MN3 (VSS XI1_I1666_I45_Bn XI1_I1666_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I45_MN0 (XI1_I1666_I45_An I1_p23_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I49_MN1 (XI1_I1620_I49_Bn I1_b23_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I49_MN5 (XI1_I1620_I49_n2 I1_b23_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I49_MN4 (I1_I1620_pn17 XI1_I1620_I49_An XI1_I1620_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I49_MN2 (XI1_I1620_I49_n1 I1_p22_16 I1_I1620_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I49_MN3 (VSS XI1_I1620_I49_Bn XI1_I1620_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I49_MN0 (XI1_I1620_I49_An I1_p22_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I47_MN1 (XI1_I1620_I47_Bn I1_b23_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I47_MN5 (XI1_I1620_I47_n2 I1_b23_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I47_MN4 (I1_I1620_pn15 XI1_I1620_I47_An XI1_I1620_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I47_MN2 (XI1_I1620_I47_n1 I1_p22_14 I1_I1620_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I47_MN3 (VSS XI1_I1620_I47_Bn XI1_I1620_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I47_MN0 (XI1_I1620_I47_An I1_p22_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I34_MN1 (XI2_I1_I42_I34_Bn I2_I1_bx2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I34_MN5 (XI2_I1_I42_I34_n2 I2_I1_bx2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I34_MN4 (I2_I1_I42_pn2 XI2_I1_I42_I34_An XI2_I1_I42_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I34_MN2 (XI2_I1_I42_I34_n1 A_2 I2_I1_I42_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I34_MN3 (VSS XI2_I1_I42_I34_Bn XI2_I1_I42_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I34_MN0 (XI2_I1_I42_I34_An A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I205_MN1 (XI2_I1_I42_I205_Bn I2_I1_I42_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I205_MN5 (XI2_I1_I42_I205_n2 I2_I1_I42_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I205_MN4 (I2_S_2 XI2_I1_I42_I205_An XI2_I1_I42_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I205_MN2 (XI2_I1_I42_I205_n1 I2_I1_I42_pn2 I2_S_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I205_MN3 (VSS XI2_I1_I42_I205_Bn XI2_I1_I42_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I205_MN0 (XI2_I1_I42_I205_An I2_I1_I42_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I42_MN1 (XI1_I1758_I42_Bn I1_b26_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I42_MN5 (XI1_I1758_I42_n2 I1_b26_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I42_MN4 (I1_I1758_pn10 XI1_I1758_I42_An XI1_I1758_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I42_MN2 (XI1_I1758_I42_n1 I1_p25_9 I1_I1758_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I42_MN3 (VSS XI1_I1758_I42_Bn XI1_I1758_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I42_MN0 (XI1_I1758_I42_An I1_p25_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I40_MN1 (XI1_I1758_I40_Bn I1_b26_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I40_MN5 (XI1_I1758_I40_n2 I1_b26_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I40_MN4 (I1_I1758_pn8 XI1_I1758_I40_An XI1_I1758_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I40_MN2 (XI1_I1758_I40_n1 I1_p25_7 I1_I1758_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I40_MN3 (VSS XI1_I1758_I40_Bn XI1_I1758_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I40_MN0 (XI1_I1758_I40_An I1_p25_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I232_MN1 (XI1_I1666_I232_Bn I1_I1666_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I232_MN5 (XI1_I1666_I232_n2 I1_I1666_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I232_MN4 (I1_p24_29 XI1_I1666_I232_An XI1_I1666_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I232_MN2 (XI1_I1666_I232_n1 I1_I1666_pn29 I1_p24_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I232_MN3 (VSS XI1_I1666_I232_Bn XI1_I1666_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I232_MN0 (XI1_I1666_I232_An I1_I1666_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I225_MN1 (XI1_I1666_I225_Bn I1_I1666_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I225_MN5 (XI1_I1666_I225_n2 I1_I1666_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I225_MN4 (I1_p24_22 XI1_I1666_I225_An XI1_I1666_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I225_MN2 (XI1_I1666_I225_n1 I1_I1666_pn22 I1_p24_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I225_MN3 (VSS XI1_I1666_I225_Bn XI1_I1666_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I225_MN0 (XI1_I1666_I225_An I1_I1666_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I47_MN1 (XI1_I1666_I47_Bn I1_b24_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I47_MN5 (XI1_I1666_I47_n2 I1_b24_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I47_MN4 (I1_I1666_pn15 XI1_I1666_I47_An XI1_I1666_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I47_MN2 (XI1_I1666_I47_n1 I1_p23_14 I1_I1666_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I47_MN3 (VSS XI1_I1666_I47_Bn XI1_I1666_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I47_MN0 (XI1_I1666_I47_An I1_p23_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I48_MN1 (XI1_I1666_I48_Bn I1_b24_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I48_MN5 (XI1_I1666_I48_n2 I1_b24_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I48_MN4 (I1_I1666_pn16 XI1_I1666_I48_An XI1_I1666_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I48_MN2 (XI1_I1666_I48_n1 I1_p23_15 I1_I1666_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I48_MN3 (VSS XI1_I1666_I48_Bn XI1_I1666_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I48_MN0 (XI1_I1666_I48_An I1_p23_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I204_MN1 (XI2_I1_I42_I204_Bn I2_I1_I42_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I204_MN5 (XI2_I1_I42_I204_n2 I2_I1_I42_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I204_MN4 (I2_S_1 XI2_I1_I42_I204_An XI2_I1_I42_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I204_MN2 (XI2_I1_I42_I204_n1 I2_I1_I42_pn1 I2_S_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I204_MN3 (VSS XI2_I1_I42_I204_Bn XI2_I1_I42_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I204_MN0 (XI2_I1_I42_I204_An I2_I1_I42_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I33_MN1 (XI2_I1_I42_I33_Bn I2_I1_bx1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I33_MN5 (XI2_I1_I42_I33_n2 I2_I1_bx1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I33_MN4 (I2_I1_I42_pn1 XI2_I1_I42_I33_An XI2_I1_I42_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I33_MN2 (XI2_I1_I42_I33_n1 A_1 I2_I1_I42_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I33_MN3 (VSS XI2_I1_I42_I33_Bn XI2_I1_I42_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I33_MN0 (XI2_I1_I42_I33_An A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I41_MN1 (XI1_I1758_I41_Bn I1_b26_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I41_MN5 (XI1_I1758_I41_n2 I1_b26_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I41_MN4 (I1_I1758_pn9 XI1_I1758_I41_An XI1_I1758_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I41_MN2 (XI1_I1758_I41_n1 I1_p25_8 I1_I1758_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I41_MN3 (VSS XI1_I1758_I41_Bn XI1_I1758_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I41_MN0 (XI1_I1758_I41_An I1_p25_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I39_MN1 (XI1_I1758_I39_Bn I1_b26_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I39_MN5 (XI1_I1758_I39_n2 I1_b26_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I39_MN4 (I1_I1758_pn7 XI1_I1758_I39_An XI1_I1758_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I39_MN2 (XI1_I1758_I39_n1 I1_p25_6 I1_I1758_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I39_MN3 (VSS XI1_I1758_I39_Bn XI1_I1758_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I39_MN0 (XI1_I1758_I39_An I1_p25_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I231_MN1 (XI1_I1666_I231_Bn I1_I1666_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I231_MN5 (XI1_I1666_I231_n2 I1_I1666_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I231_MN4 (I1_p24_28 XI1_I1666_I231_An XI1_I1666_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I231_MN2 (XI1_I1666_I231_n1 I1_I1666_pn28 I1_p24_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I231_MN3 (VSS XI1_I1666_I231_Bn XI1_I1666_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I231_MN0 (XI1_I1666_I231_An I1_I1666_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I50_MN1 (XI1_I1666_I50_Bn I1_b24_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I50_MN5 (XI1_I1666_I50_n2 I1_b24_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I50_MN4 (I1_I1666_pn18 XI1_I1666_I50_An XI1_I1666_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I50_MN2 (XI1_I1666_I50_n1 I1_p23_17 I1_I1666_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I50_MN3 (VSS XI1_I1666_I50_Bn XI1_I1666_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I50_MN0 (XI1_I1666_I50_An I1_p23_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I220_MN1 (XI1_I1620_I220_Bn I1_I1620_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I220_MN5 (XI1_I1620_I220_n2 I1_I1620_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I220_MN4 (I1_p23_17 XI1_I1620_I220_An XI1_I1620_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I220_MN2 (XI1_I1620_I220_n1 I1_I1620_pn17 I1_p23_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I220_MN3 (VSS XI1_I1620_I220_Bn XI1_I1620_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I220_MN0 (XI1_I1620_I220_An I1_I1620_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2106_MN1 (XI1_I2106_Bn I1_nqkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2106_MN5 (XI1_I2106_n2 I1_nqkn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2106_MN4 (DIVQ_10 XI1_I2106_An XI1_I2106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2106_MN2 (XI1_I2106_n1 I1_qu10_b3_5 DIVQ_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2106_MN3 (VSS XI1_I2106_Bn XI1_I2106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2106_MN0 (XI1_I2106_An I1_qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I32_MN1 (XI2_I1_I42_I32_Bn I2_I1_bx0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I32_MN5 (XI2_I1_I42_I32_n2 I2_I1_bx0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I32_MN4 (I2_I1_I42_pn0 XI2_I1_I42_I32_An XI2_I1_I42_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I32_MN2 (XI2_I1_I42_I32_n1 A_0 I2_I1_I42_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I32_MN3 (VSS XI2_I1_I42_I32_Bn XI2_I1_I42_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I32_MN0 (XI2_I1_I42_I32_An A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I233_MN1 (XI1_I1758_I233_Bn I1_I1758_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I233_MN5 (XI1_I1758_I233_n2 I1_I1758_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I233_MN4 (I1_p26_30 XI1_I1758_I233_An XI1_I1758_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I233_MN2 (XI1_I1758_I233_n1 I1_I1758_pn30 I1_p26_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I233_MN3 (VSS XI1_I1758_I233_Bn XI1_I1758_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I233_MN0 (XI1_I1758_I233_An I1_I1758_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I229_MN1 (XI1_I1758_I229_Bn I1_I1758_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I229_MN5 (XI1_I1758_I229_n2 I1_I1758_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I229_MN4 (I1_p26_26 XI1_I1758_I229_An XI1_I1758_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I229_MN2 (XI1_I1758_I229_n1 I1_I1758_pn26 I1_p26_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I229_MN3 (VSS XI1_I1758_I229_Bn XI1_I1758_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I229_MN0 (XI1_I1758_I229_An I1_I1758_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I227_MN1 (XI1_I1758_I227_Bn I1_I1758_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I227_MN5 (XI1_I1758_I227_n2 I1_I1758_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I227_MN4 (I1_p26_24 XI1_I1758_I227_An XI1_I1758_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I227_MN2 (XI1_I1758_I227_n1 I1_I1758_pn24 I1_p26_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I227_MN3 (VSS XI1_I1758_I227_Bn XI1_I1758_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I227_MN0 (XI1_I1758_I227_An I1_I1758_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I38_MN1 (XI1_I1758_I38_Bn I1_b26_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I38_MN5 (XI1_I1758_I38_n2 I1_b26_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I38_MN4 (I1_I1758_pn6 XI1_I1758_I38_An XI1_I1758_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I38_MN2 (XI1_I1758_I38_n1 I1_p25_5 I1_I1758_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I38_MN3 (VSS XI1_I1758_I38_Bn XI1_I1758_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I38_MN0 (XI1_I1758_I38_An I1_p25_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I226_MN1 (XI1_I1666_I226_Bn I1_I1666_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I226_MN5 (XI1_I1666_I226_n2 I1_I1666_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I226_MN4 (I1_p24_23 XI1_I1666_I226_An XI1_I1666_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I226_MN2 (XI1_I1666_I226_n1 I1_I1666_pn23 I1_p24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I226_MN3 (VSS XI1_I1666_I226_Bn XI1_I1666_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I226_MN0 (XI1_I1666_I226_An I1_I1666_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I227_MN1 (XI1_I1666_I227_Bn I1_I1666_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I227_MN5 (XI1_I1666_I227_n2 I1_I1666_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I227_MN4 (I1_p24_24 XI1_I1666_I227_An XI1_I1666_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I227_MN2 (XI1_I1666_I227_n1 I1_I1666_pn24 I1_p24_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I227_MN3 (VSS XI1_I1666_I227_Bn XI1_I1666_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I227_MN0 (XI1_I1666_I227_An I1_I1666_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I233_MN1 (XI1_I1666_I233_Bn I1_I1666_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I233_MN5 (XI1_I1666_I233_n2 I1_I1666_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I233_MN4 (I1_p24_30 XI1_I1666_I233_An XI1_I1666_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I233_MN2 (XI1_I1666_I233_n1 I1_I1666_pn30 I1_p24_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I233_MN3 (VSS XI1_I1666_I233_Bn XI1_I1666_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I233_MN0 (XI1_I1666_I233_An I1_I1666_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I52_MN1 (XI1_I1666_I52_Bn I1_b24_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I52_MN5 (XI1_I1666_I52_n2 I1_b24_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I52_MN4 (I1_I1666_pn20 XI1_I1666_I52_An XI1_I1666_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I52_MN2 (XI1_I1666_I52_n1 I1_p23_19 I1_I1666_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I52_MN3 (VSS XI1_I1666_I52_Bn XI1_I1666_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I52_MN0 (XI1_I1666_I52_An I1_p23_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I51_MN1 (XI1_I1666_I51_Bn I1_b24_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I51_MN5 (XI1_I1666_I51_n2 I1_b24_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I51_MN4 (I1_I1666_pn19 XI1_I1666_I51_An XI1_I1666_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I51_MN2 (XI1_I1666_I51_n1 I1_p23_18 I1_I1666_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I51_MN3 (VSS XI1_I1666_I51_Bn XI1_I1666_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I51_MN0 (XI1_I1666_I51_An I1_p23_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I49_MN1 (XI1_I1666_I49_Bn I1_b24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I49_MN5 (XI1_I1666_I49_n2 I1_b24_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I49_MN4 (I1_I1666_pn17 XI1_I1666_I49_An XI1_I1666_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I49_MN2 (XI1_I1666_I49_n1 I1_p23_16 I1_I1666_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I49_MN3 (VSS XI1_I1666_I49_Bn XI1_I1666_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I49_MN0 (XI1_I1666_I49_An I1_p23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I222_MN1 (XI1_I1620_I222_Bn I1_I1620_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I222_MN5 (XI1_I1620_I222_n2 I1_I1620_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I222_MN4 (I1_p23_19 XI1_I1620_I222_An XI1_I1620_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I222_MN2 (XI1_I1620_I222_n1 I1_I1620_pn19 I1_p23_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I222_MN3 (VSS XI1_I1620_I222_Bn XI1_I1620_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I222_MN0 (XI1_I1620_I222_An I1_I1620_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I221_MN1 (XI1_I1620_I221_Bn I1_I1620_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I221_MN5 (XI1_I1620_I221_n2 I1_I1620_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I221_MN4 (I1_p23_18 XI1_I1620_I221_An XI1_I1620_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I221_MN2 (XI1_I1620_I221_n1 I1_I1620_pn18 I1_p23_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I221_MN3 (VSS XI1_I1620_I221_Bn XI1_I1620_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I221_MN0 (XI1_I1620_I221_An I1_I1620_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I203_MN1 (XI2_I1_I42_I203_Bn I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI2_I1_I42_I203_MN5 (XI2_I1_I42_I203_n2 I2_I1_SUB_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I203_MN4 (I2_S_0 XI2_I1_I42_I203_An XI2_I1_I42_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I203_MN2 (XI2_I1_I42_I203_n1 I2_I1_I42_pn0 I2_S_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI2_I1_I42_I203_MN3 (VSS XI2_I1_I42_I203_Bn XI2_I1_I42_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I203_MN0 (XI2_I1_I42_I203_An I2_I1_I42_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I231_MN1 (XI1_I1758_I231_Bn I1_I1758_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I231_MN5 (XI1_I1758_I231_n2 I1_I1758_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I231_MN4 (I1_p26_28 XI1_I1758_I231_An XI1_I1758_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I231_MN2 (XI1_I1758_I231_n1 I1_I1758_pn28 I1_p26_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I231_MN3 (VSS XI1_I1758_I231_Bn XI1_I1758_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I231_MN0 (XI1_I1758_I231_An I1_I1758_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I225_MN1 (XI1_I1758_I225_Bn I1_I1758_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I225_MN5 (XI1_I1758_I225_n2 I1_I1758_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I225_MN4 (I1_p26_22 XI1_I1758_I225_An XI1_I1758_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I225_MN2 (XI1_I1758_I225_n1 I1_I1758_pn22 I1_p26_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I225_MN3 (VSS XI1_I1758_I225_Bn XI1_I1758_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I225_MN0 (XI1_I1758_I225_An I1_I1758_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I223_MN1 (XI1_I1758_I223_Bn I1_I1758_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I223_MN5 (XI1_I1758_I223_n2 I1_I1758_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I223_MN4 (I1_p26_20 XI1_I1758_I223_An XI1_I1758_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I223_MN2 (XI1_I1758_I223_n1 I1_I1758_pn20 I1_p26_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I223_MN3 (VSS XI1_I1758_I223_Bn XI1_I1758_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I223_MN0 (XI1_I1758_I223_An I1_I1758_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I234_MN1 (XI1_I1666_I234_Bn I1_c24_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I234_MN5 (XI1_I1666_I234_n2 I1_c24_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I234_MN4 (I1_p24_31 XI1_I1666_I234_An XI1_I1666_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I234_MN2 (XI1_I1666_I234_n1 I1_I1666_pn31 I1_p24_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I234_MN3 (VSS XI1_I1666_I234_Bn XI1_I1666_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I234_MN0 (XI1_I1666_I234_An I1_I1666_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I37_MN1 (XI1_I1758_I37_Bn I1_b26_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I37_MN5 (XI1_I1758_I37_n2 I1_b26_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I37_MN4 (I1_I1758_pn5 XI1_I1758_I37_An XI1_I1758_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I37_MN2 (XI1_I1758_I37_n1 I1_p25_4 I1_I1758_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I37_MN3 (VSS XI1_I1758_I37_Bn XI1_I1758_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I37_MN0 (XI1_I1758_I37_An I1_p25_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I54_MN1 (XI1_I1666_I54_Bn I1_b24_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I54_MN5 (XI1_I1666_I54_n2 I1_b24_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I54_MN4 (I1_I1666_pn22 XI1_I1666_I54_An XI1_I1666_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I54_MN2 (XI1_I1666_I54_n1 I1_p23_21 I1_I1666_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I54_MN3 (VSS XI1_I1666_I54_Bn XI1_I1666_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I54_MN0 (XI1_I1666_I54_An I1_p23_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I53_MN1 (XI1_I1666_I53_Bn I1_b24_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I53_MN5 (XI1_I1666_I53_n2 I1_b24_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I53_MN4 (I1_I1666_pn21 XI1_I1666_I53_An XI1_I1666_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I53_MN2 (XI1_I1666_I53_n1 I1_p23_20 I1_I1666_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I53_MN3 (VSS XI1_I1666_I53_Bn XI1_I1666_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I53_MN0 (XI1_I1666_I53_An I1_p23_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I52_MN1 (XI1_I1620_I52_Bn I1_b23_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I52_MN5 (XI1_I1620_I52_n2 I1_b23_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I52_MN4 (I1_I1620_pn20 XI1_I1620_I52_An XI1_I1620_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I52_MN2 (XI1_I1620_I52_n1 I1_p22_19 I1_I1620_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I52_MN3 (VSS XI1_I1620_I52_Bn XI1_I1620_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I52_MN0 (XI1_I1620_I52_An I1_p22_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I51_MN1 (XI1_I1620_I51_Bn I1_b23_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I51_MN5 (XI1_I1620_I51_n2 I1_b23_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I51_MN4 (I1_I1620_pn19 XI1_I1620_I51_An XI1_I1620_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I51_MN2 (XI1_I1620_I51_n1 I1_p22_18 I1_I1620_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I51_MN3 (VSS XI1_I1620_I51_Bn XI1_I1620_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I51_MN0 (XI1_I1620_I51_An I1_p22_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I50_MN1 (XI1_I1620_I50_Bn I1_b23_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I50_MN5 (XI1_I1620_I50_n2 I1_b23_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I50_MN4 (I1_I1620_pn18 XI1_I1620_I50_An XI1_I1620_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I50_MN2 (XI1_I1620_I50_n1 I1_p22_17 I1_I1620_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I50_MN3 (VSS XI1_I1620_I50_Bn XI1_I1620_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I50_MN0 (XI1_I1620_I50_An I1_p22_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2103_MN1 (XI1_I2103_Bn I1_nqkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2103_MN5 (XI1_I2103_n2 I1_nqkn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2103_MN4 (DIVQ_9 XI1_I2103_An XI1_I2103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2103_MN2 (XI1_I2103_n1 I1_qu9_b3_5 DIVQ_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2103_MN3 (VSS XI1_I2103_Bn XI1_I2103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2103_MN0 (XI1_I2103_An I1_qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2097_MN1 (XI1_I2097_Bn I1_nqkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2097_MN5 (XI1_I2097_n2 I1_nqkn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2097_MN4 (DIVQ_7 XI1_I2097_An XI1_I2097_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2097_MN2 (XI1_I2097_n1 I1_qu7_b3_5 DIVQ_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2097_MN3 (VSS XI1_I2097_Bn XI1_I2097_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2097_MN0 (XI1_I2097_An I1_qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I221_MN1 (XI1_I1758_I221_Bn I1_I1758_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I221_MN5 (XI1_I1758_I221_n2 I1_I1758_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I221_MN4 (I1_p26_18 XI1_I1758_I221_An XI1_I1758_I221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I221_MN2 (XI1_I1758_I221_n1 I1_I1758_pn18 I1_p26_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I221_MN3 (VSS XI1_I1758_I221_Bn XI1_I1758_I221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I221_MN0 (XI1_I1758_I221_An I1_I1758_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I211_MN1 (XI1_I1758_I211_Bn I1_I1758_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I211_MN5 (XI1_I1758_I211_n2 I1_I1758_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I211_MN4 (I1_p26_8 XI1_I1758_I211_An XI1_I1758_I211_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I211_MN2 (XI1_I1758_I211_n1 I1_I1758_pn8 I1_p26_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I211_MN3 (VSS XI1_I1758_I211_Bn XI1_I1758_I211_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I211_MN0 (XI1_I1758_I211_An I1_I1758_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I36_MN1 (XI1_I1758_I36_Bn I1_b26_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I36_MN5 (XI1_I1758_I36_n2 I1_b26_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I36_MN4 (I1_I1758_pn4 XI1_I1758_I36_An XI1_I1758_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I36_MN2 (XI1_I1758_I36_n1 I1_p25_3 I1_I1758_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I36_MN3 (VSS XI1_I1758_I36_Bn XI1_I1758_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I36_MN0 (XI1_I1758_I36_An I1_p25_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I55_MN1 (XI1_I1666_I55_Bn I1_b24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I55_MN5 (XI1_I1666_I55_n2 I1_b24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I55_MN4 (I1_I1666_pn23 XI1_I1666_I55_An XI1_I1666_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I55_MN2 (XI1_I1666_I55_n1 I1_p23_22 I1_I1666_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I55_MN3 (VSS XI1_I1666_I55_Bn XI1_I1666_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I55_MN0 (XI1_I1666_I55_An I1_p23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I53_MN1 (XI1_I1620_I53_Bn I1_b23_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I53_MN5 (XI1_I1620_I53_n2 I1_b23_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I53_MN4 (I1_I1620_pn21 XI1_I1620_I53_An XI1_I1620_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I53_MN2 (XI1_I1620_I53_n1 I1_p22_20 I1_I1620_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I53_MN3 (VSS XI1_I1620_I53_Bn XI1_I1620_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I53_MN0 (XI1_I1620_I53_An I1_p22_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I224_MN1 (XI1_I1620_I224_Bn I1_I1620_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I224_MN5 (XI1_I1620_I224_n2 I1_I1620_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I224_MN4 (I1_p23_21 XI1_I1620_I224_An XI1_I1620_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I224_MN2 (XI1_I1620_I224_n1 I1_I1620_pn21 I1_p23_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I224_MN3 (VSS XI1_I1620_I224_Bn XI1_I1620_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I224_MN0 (XI1_I1620_I224_An I1_I1620_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I223_MN1 (XI1_I1620_I223_Bn I1_I1620_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I223_MN5 (XI1_I1620_I223_n2 I1_I1620_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I223_MN4 (I1_p23_20 XI1_I1620_I223_An XI1_I1620_I223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I223_MN2 (XI1_I1620_I223_n1 I1_I1620_pn20 I1_p23_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I223_MN3 (VSS XI1_I1620_I223_Bn XI1_I1620_I223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I223_MN0 (XI1_I1620_I223_An I1_I1620_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2100_MN1 (XI1_I2100_Bn I1_nqkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2100_MN5 (XI1_I2100_n2 I1_nqkn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2100_MN4 (DIVQ_8 XI1_I2100_An XI1_I2100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2100_MN2 (XI1_I2100_n1 I1_qu8_b3_5 DIVQ_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2100_MN3 (VSS XI1_I2100_Bn XI1_I2100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2100_MN0 (XI1_I2100_An I1_qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I234_MN1 (XI1_I1758_I234_Bn I1_c26_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I234_MN5 (XI1_I1758_I234_n2 I1_c26_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I234_MN4 (I1_p26_31 XI1_I1758_I234_An XI1_I1758_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I234_MN2 (XI1_I1758_I234_n1 I1_I1758_pn31 I1_p26_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I234_MN3 (VSS XI1_I1758_I234_Bn XI1_I1758_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I234_MN0 (XI1_I1758_I234_An I1_I1758_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I232_MN1 (XI1_I1758_I232_Bn I1_I1758_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I232_MN5 (XI1_I1758_I232_n2 I1_I1758_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I232_MN4 (I1_p26_29 XI1_I1758_I232_An XI1_I1758_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I232_MN2 (XI1_I1758_I232_n1 I1_I1758_pn29 I1_p26_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I232_MN3 (VSS XI1_I1758_I232_Bn XI1_I1758_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I232_MN0 (XI1_I1758_I232_An I1_I1758_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I209_MN1 (XI1_I1758_I209_Bn I1_I1758_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I209_MN5 (XI1_I1758_I209_n2 I1_I1758_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I209_MN4 (I1_p26_6 XI1_I1758_I209_An XI1_I1758_I209_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I209_MN2 (XI1_I1758_I209_n1 I1_I1758_pn6 I1_p26_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I209_MN3 (VSS XI1_I1758_I209_Bn XI1_I1758_I209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I209_MN0 (XI1_I1758_I209_An I1_I1758_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I210_MN1 (XI1_I1758_I210_Bn I1_I1758_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I210_MN5 (XI1_I1758_I210_n2 I1_I1758_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I210_MN4 (I1_p26_7 XI1_I1758_I210_An XI1_I1758_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I210_MN2 (XI1_I1758_I210_n1 I1_I1758_pn7 I1_p26_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I210_MN3 (VSS XI1_I1758_I210_Bn XI1_I1758_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I210_MN0 (XI1_I1758_I210_An I1_I1758_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I35_MN1 (XI1_I1758_I35_Bn I1_b26_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I35_MN5 (XI1_I1758_I35_n2 I1_b26_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I35_MN4 (I1_I1758_pn3 XI1_I1758_I35_An XI1_I1758_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I35_MN2 (XI1_I1758_I35_n1 I1_p25_2 I1_I1758_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I35_MN3 (VSS XI1_I1758_I35_Bn XI1_I1758_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I35_MN0 (XI1_I1758_I35_An I1_p25_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I56_MN1 (XI1_I1666_I56_Bn I1_b24_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I56_MN5 (XI1_I1666_I56_n2 I1_b24_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I56_MN4 (I1_I1666_pn24 XI1_I1666_I56_An XI1_I1666_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I56_MN2 (XI1_I1666_I56_n1 I1_p23_23 I1_I1666_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I56_MN3 (VSS XI1_I1666_I56_Bn XI1_I1666_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I56_MN0 (XI1_I1666_I56_An I1_p23_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I234_MN1 (XI1_I1620_I234_Bn I1_c23_m VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I234_MN5 (XI1_I1620_I234_n2 I1_c23_m VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I234_MN4 (I1_p23_31 XI1_I1620_I234_An XI1_I1620_I234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I234_MN2 (XI1_I1620_I234_n1 I1_I1620_pn31 I1_p23_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I234_MN3 (VSS XI1_I1620_I234_Bn XI1_I1620_I234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I234_MN0 (XI1_I1620_I234_An I1_I1620_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I226_MN1 (XI1_I1620_I226_Bn I1_I1620_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I226_MN5 (XI1_I1620_I226_n2 I1_I1620_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I226_MN4 (I1_p23_23 XI1_I1620_I226_An XI1_I1620_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I226_MN2 (XI1_I1620_I226_n1 I1_I1620_pn23 I1_p23_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I226_MN3 (VSS XI1_I1620_I226_Bn XI1_I1620_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I226_MN0 (XI1_I1620_I226_An I1_I1620_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I54_MN1 (XI1_I1620_I54_Bn I1_b23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I54_MN5 (XI1_I1620_I54_n2 I1_b23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I54_MN4 (I1_I1620_pn22 XI1_I1620_I54_An XI1_I1620_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I54_MN2 (XI1_I1620_I54_n1 I1_p22_21 I1_I1620_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I54_MN3 (VSS XI1_I1620_I54_Bn XI1_I1620_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I54_MN0 (XI1_I1620_I54_An I1_p22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I225_MN1 (XI1_I1620_I225_Bn I1_I1620_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I225_MN5 (XI1_I1620_I225_n2 I1_I1620_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I225_MN4 (I1_p23_22 XI1_I1620_I225_An XI1_I1620_I225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I225_MN2 (XI1_I1620_I225_n1 I1_I1620_pn22 I1_p23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I225_MN3 (VSS XI1_I1620_I225_Bn XI1_I1620_I225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I225_MN0 (XI1_I1620_I225_An I1_I1620_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2094_MN1 (XI1_I2094_Bn I1_nqkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2094_MN5 (XI1_I2094_n2 I1_nqkn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2094_MN4 (DIVQ_6 XI1_I2094_An XI1_I2094_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2094_MN2 (XI1_I2094_n1 I1_qu6_b3_5 DIVQ_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2094_MN3 (VSS XI1_I2094_Bn XI1_I2094_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2094_MN0 (XI1_I2094_An I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I230_MN1 (XI1_I1758_I230_Bn I1_I1758_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I230_MN5 (XI1_I1758_I230_n2 I1_I1758_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I230_MN4 (I1_p26_27 XI1_I1758_I230_An XI1_I1758_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I230_MN2 (XI1_I1758_I230_n1 I1_I1758_pn27 I1_p26_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I230_MN3 (VSS XI1_I1758_I230_Bn XI1_I1758_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I230_MN0 (XI1_I1758_I230_An I1_I1758_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I228_MN1 (XI1_I1758_I228_Bn I1_I1758_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I228_MN5 (XI1_I1758_I228_n2 I1_I1758_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I228_MN4 (I1_p26_25 XI1_I1758_I228_An XI1_I1758_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I228_MN2 (XI1_I1758_I228_n1 I1_I1758_pn25 I1_p26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I228_MN3 (VSS XI1_I1758_I228_Bn XI1_I1758_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I228_MN0 (XI1_I1758_I228_An I1_I1758_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I226_MN1 (XI1_I1758_I226_Bn I1_I1758_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I226_MN5 (XI1_I1758_I226_n2 I1_I1758_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I226_MN4 (I1_p26_23 XI1_I1758_I226_An XI1_I1758_I226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I226_MN2 (XI1_I1758_I226_n1 I1_I1758_pn23 I1_p26_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I226_MN3 (VSS XI1_I1758_I226_Bn XI1_I1758_I226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I226_MN0 (XI1_I1758_I226_An I1_I1758_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I224_MN1 (XI1_I1758_I224_Bn I1_I1758_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I224_MN5 (XI1_I1758_I224_n2 I1_I1758_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I224_MN4 (I1_p26_21 XI1_I1758_I224_An XI1_I1758_I224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I224_MN2 (XI1_I1758_I224_n1 I1_I1758_pn21 I1_p26_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I224_MN3 (VSS XI1_I1758_I224_Bn XI1_I1758_I224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I224_MN0 (XI1_I1758_I224_An I1_I1758_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I222_MN1 (XI1_I1758_I222_Bn I1_I1758_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I222_MN5 (XI1_I1758_I222_n2 I1_I1758_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I222_MN4 (I1_p26_19 XI1_I1758_I222_An XI1_I1758_I222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I222_MN2 (XI1_I1758_I222_n1 I1_I1758_pn19 I1_p26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I222_MN3 (VSS XI1_I1758_I222_Bn XI1_I1758_I222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I222_MN0 (XI1_I1758_I222_An I1_I1758_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I33_MN1 (XI1_I1758_I33_Bn I1_b26_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I33_MN5 (XI1_I1758_I33_n2 I1_b26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I33_MN4 (I1_I1758_pn1 XI1_I1758_I33_An XI1_I1758_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I33_MN2 (XI1_I1758_I33_n1 I1_p25_0 I1_I1758_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I33_MN3 (VSS XI1_I1758_I33_Bn XI1_I1758_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I33_MN0 (XI1_I1758_I33_An I1_p25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I34_MN1 (XI1_I1758_I34_Bn I1_b26_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I34_MN5 (XI1_I1758_I34_n2 I1_b26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I34_MN4 (I1_I1758_pn2 XI1_I1758_I34_An XI1_I1758_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I34_MN2 (XI1_I1758_I34_n1 I1_p25_1 I1_I1758_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I34_MN3 (VSS XI1_I1758_I34_Bn XI1_I1758_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I34_MN0 (XI1_I1758_I34_An I1_p25_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I62_MN1 (XI1_I1666_I62_Bn I1_b24_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I62_MN5 (XI1_I1666_I62_n2 I1_b24_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I62_MN4 (I1_I1666_pn30 XI1_I1666_I62_An XI1_I1666_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I62_MN2 (XI1_I1666_I62_n1 I1_p23_29 I1_I1666_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I62_MN3 (VSS XI1_I1666_I62_Bn XI1_I1666_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I62_MN0 (XI1_I1666_I62_An I1_p23_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I58_MN1 (XI1_I1666_I58_Bn I1_b24_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I58_MN5 (XI1_I1666_I58_n2 I1_b24_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I58_MN4 (I1_I1666_pn26 XI1_I1666_I58_An XI1_I1666_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I58_MN2 (XI1_I1666_I58_n1 I1_p23_25 I1_I1666_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I58_MN3 (VSS XI1_I1666_I58_Bn XI1_I1666_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I58_MN0 (XI1_I1666_I58_An I1_p23_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I57_MN1 (XI1_I1666_I57_Bn I1_b24_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I57_MN5 (XI1_I1666_I57_n2 I1_b24_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I57_MN4 (I1_I1666_pn25 XI1_I1666_I57_An XI1_I1666_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I57_MN2 (XI1_I1666_I57_n1 I1_p23_24 I1_I1666_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I57_MN3 (VSS XI1_I1666_I57_Bn XI1_I1666_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I57_MN0 (XI1_I1666_I57_An I1_p23_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I63_MN1 (XI1_I1620_I63_Bn I1_b23_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I63_MN5 (XI1_I1620_I63_n2 I1_b23_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I63_MN4 (I1_I1620_pn31 XI1_I1620_I63_An XI1_I1620_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I63_MN2 (XI1_I1620_I63_n1 I1_p22_30 I1_I1620_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I63_MN3 (VSS XI1_I1620_I63_Bn XI1_I1620_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I63_MN0 (XI1_I1620_I63_An I1_p22_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I55_MN1 (XI1_I1620_I55_Bn I1_b23_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I55_MN5 (XI1_I1620_I55_n2 I1_b23_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I55_MN4 (I1_I1620_pn23 XI1_I1620_I55_An XI1_I1620_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I55_MN2 (XI1_I1620_I55_n1 I1_p22_22 I1_I1620_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I55_MN3 (VSS XI1_I1620_I55_Bn XI1_I1620_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I55_MN0 (XI1_I1620_I55_An I1_p22_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I232_MN1 (XI1_I1620_I232_Bn I1_I1620_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I232_MN5 (XI1_I1620_I232_n2 I1_I1620_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I232_MN4 (I1_p23_29 XI1_I1620_I232_An XI1_I1620_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I232_MN2 (XI1_I1620_I232_n1 I1_I1620_pn29 I1_p23_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I232_MN3 (VSS XI1_I1620_I232_Bn XI1_I1620_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I232_MN0 (XI1_I1620_I232_An I1_I1620_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I228_MN1 (XI1_I1620_I228_Bn I1_I1620_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I228_MN5 (XI1_I1620_I228_n2 I1_I1620_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I228_MN4 (I1_p23_25 XI1_I1620_I228_An XI1_I1620_I228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I228_MN2 (XI1_I1620_I228_n1 I1_I1620_pn25 I1_p23_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I228_MN3 (VSS XI1_I1620_I228_Bn XI1_I1620_I228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I228_MN0 (XI1_I1620_I228_An I1_I1620_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I227_MN1 (XI1_I1620_I227_Bn I1_I1620_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I227_MN5 (XI1_I1620_I227_n2 I1_I1620_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I227_MN4 (I1_p23_24 XI1_I1620_I227_An XI1_I1620_I227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I227_MN2 (XI1_I1620_I227_n1 I1_I1620_pn24 I1_p23_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I227_MN3 (VSS XI1_I1620_I227_Bn XI1_I1620_I227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I227_MN0 (XI1_I1620_I227_An I1_I1620_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I49_MN1 (XI1_I49_Bn I1_nakn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I49_MN5 (XI1_I49_n2 I1_nakn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I49_MN4 (I1_aa5 XI1_I49_An XI1_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I49_MN2 (XI1_I49_n1 A_5 I1_aa5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I49_MN3 (VSS XI1_I49_Bn XI1_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I49_MN0 (XI1_I49_An A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I50_MN1 (XI1_I1804_I50_Bn I1_b27_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I50_MN5 (XI1_I1804_I50_n2 I1_b27_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I50_MN4 (I1_I1804_pn18 XI1_I1804_I50_An XI1_I1804_I50_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I50_MN2 (XI1_I1804_I50_n1 I1_p26_17 I1_I1804_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I50_MN3 (VSS XI1_I1804_I50_Bn XI1_I1804_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I50_MN0 (XI1_I1804_I50_An I1_p26_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I220_MN1 (XI1_I1758_I220_Bn I1_I1758_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I220_MN5 (XI1_I1758_I220_n2 I1_I1758_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I220_MN4 (I1_p26_17 XI1_I1758_I220_An XI1_I1758_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I220_MN2 (XI1_I1758_I220_n1 I1_I1758_pn17 I1_p26_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I220_MN3 (VSS XI1_I1758_I220_Bn XI1_I1758_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I220_MN0 (XI1_I1758_I220_An I1_I1758_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I47_MN1 (XI1_I1804_I47_Bn I1_b27_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I47_MN5 (XI1_I1804_I47_n2 I1_b27_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I47_MN4 (I1_I1804_pn15 XI1_I1804_I47_An XI1_I1804_I47_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I47_MN2 (XI1_I1804_I47_n1 I1_p26_14 I1_I1804_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I47_MN3 (VSS XI1_I1804_I47_Bn XI1_I1804_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I47_MN0 (XI1_I1804_I47_An I1_p26_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I45_MN1 (XI1_I1804_I45_Bn I1_b27_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I45_MN5 (XI1_I1804_I45_n2 I1_b27_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I45_MN4 (I1_I1804_pn13 XI1_I1804_I45_An XI1_I1804_I45_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I45_MN2 (XI1_I1804_I45_n1 I1_p26_12 I1_I1804_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I45_MN3 (VSS XI1_I1804_I45_Bn XI1_I1804_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I45_MN0 (XI1_I1804_I45_An I1_p26_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I40_MN1 (XI1_I1804_I40_Bn I1_b27_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I40_MN5 (XI1_I1804_I40_n2 I1_b27_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I40_MN4 (I1_I1804_pn8 XI1_I1804_I40_An XI1_I1804_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I40_MN2 (XI1_I1804_I40_n1 I1_p26_7 I1_I1804_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I40_MN3 (VSS XI1_I1804_I40_Bn XI1_I1804_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I40_MN0 (XI1_I1804_I40_An I1_p26_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I208_MN1 (XI1_I1758_I208_Bn I1_I1758_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I208_MN5 (XI1_I1758_I208_n2 I1_I1758_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I208_MN4 (I1_p26_5 XI1_I1758_I208_An XI1_I1758_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I208_MN2 (XI1_I1758_I208_n1 I1_I1758_pn5 I1_p26_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I208_MN3 (VSS XI1_I1758_I208_Bn XI1_I1758_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I208_MN0 (XI1_I1758_I208_An I1_I1758_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I205_MN1 (XI1_I1758_I205_Bn I1_I1758_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I205_MN5 (XI1_I1758_I205_n2 I1_I1758_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I205_MN4 (I1_p26_2 XI1_I1758_I205_An XI1_I1758_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I205_MN2 (XI1_I1758_I205_n1 I1_I1758_pn2 I1_p26_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I205_MN3 (VSS XI1_I1758_I205_Bn XI1_I1758_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I205_MN0 (XI1_I1758_I205_An I1_I1758_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I204_MN1 (XI1_I1758_I204_Bn I1_I1758_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I204_MN5 (XI1_I1758_I204_n2 I1_I1758_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I204_MN4 (I1_p26_1 XI1_I1758_I204_An XI1_I1758_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I204_MN2 (XI1_I1758_I204_n1 I1_I1758_pn1 I1_p26_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I204_MN3 (VSS XI1_I1758_I204_Bn XI1_I1758_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I204_MN0 (XI1_I1758_I204_An I1_I1758_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I203_MN1 (XI1_I1758_I203_Bn I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I203_MN5 (XI1_I1758_I203_n2 I1_qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I203_MN4 (I1_p26_0 XI1_I1758_I203_An XI1_I1758_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I203_MN2 (XI1_I1758_I203_n1 I1_I1758_pn0 I1_p26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I203_MN3 (VSS XI1_I1758_I203_Bn XI1_I1758_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I203_MN0 (XI1_I1758_I203_An I1_I1758_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I63_MN1 (XI1_I1666_I63_Bn I1_b24_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I63_MN5 (XI1_I1666_I63_n2 I1_b24_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I63_MN4 (I1_I1666_pn31 XI1_I1666_I63_An XI1_I1666_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I63_MN2 (XI1_I1666_I63_n1 I1_p23_30 I1_I1666_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I63_MN3 (VSS XI1_I1666_I63_Bn XI1_I1666_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I63_MN0 (XI1_I1666_I63_An I1_p23_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I57_MN1 (XI1_I1620_I57_Bn I1_b23_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I57_MN5 (XI1_I1620_I57_n2 I1_b23_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I57_MN4 (I1_I1620_pn25 XI1_I1620_I57_An XI1_I1620_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I57_MN2 (XI1_I1620_I57_n1 I1_p22_24 I1_I1620_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I57_MN3 (VSS XI1_I1620_I57_Bn XI1_I1620_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I57_MN0 (XI1_I1620_I57_An I1_p22_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I233_MN1 (XI1_I1620_I233_Bn I1_I1620_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I233_MN5 (XI1_I1620_I233_n2 I1_I1620_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I233_MN4 (I1_p23_30 XI1_I1620_I233_An XI1_I1620_I233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I233_MN2 (XI1_I1620_I233_n1 I1_I1620_pn30 I1_p23_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I233_MN3 (VSS XI1_I1620_I233_Bn XI1_I1620_I233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I233_MN0 (XI1_I1620_I233_An I1_I1620_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I56_MN1 (XI1_I1620_I56_Bn I1_b23_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I56_MN5 (XI1_I1620_I56_n2 I1_b23_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I56_MN4 (I1_I1620_pn24 XI1_I1620_I56_An XI1_I1620_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I56_MN2 (XI1_I1620_I56_n1 I1_p22_23 I1_I1620_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I56_MN3 (VSS XI1_I1620_I56_Bn XI1_I1620_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I56_MN0 (XI1_I1620_I56_An I1_p22_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I64_MN1 (XI0_I1660_I64_Bn I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I64_MN5 (XI0_I1660_I64_n2 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I64_MN4 (I0_I1660_pn0 XI0_I1660_I64_An XI0_I1660_I64_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I64_MN2 (XI0_I1660_I64_n1 I0_pp0_0 I0_I1660_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I64_MN3 (VSS XI0_I1660_I64_Bn XI0_I1660_I64_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I64_MN0 (XI0_I1660_I64_An I0_pp0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I62_MN1 (XI1_I1804_I62_Bn I1_b27_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I62_MN5 (XI1_I1804_I62_n2 I1_b27_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I62_MN4 (I1_I1804_pn30 XI1_I1804_I62_An XI1_I1804_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I62_MN2 (XI1_I1804_I62_n1 I1_p26_29 I1_I1804_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I62_MN3 (VSS XI1_I1804_I62_Bn XI1_I1804_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I62_MN0 (XI1_I1804_I62_An I1_p26_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I58_MN1 (XI1_I1804_I58_Bn I1_b27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I58_MN5 (XI1_I1804_I58_n2 I1_b27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I58_MN4 (I1_I1804_pn26 XI1_I1804_I58_An XI1_I1804_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I58_MN2 (XI1_I1804_I58_n1 I1_p26_25 I1_I1804_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I58_MN3 (VSS XI1_I1804_I58_Bn XI1_I1804_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I58_MN0 (XI1_I1804_I58_An I1_p26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I56_MN1 (XI1_I1804_I56_Bn I1_b27_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I56_MN5 (XI1_I1804_I56_n2 I1_b27_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I56_MN4 (I1_I1804_pn24 XI1_I1804_I56_An XI1_I1804_I56_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I56_MN2 (XI1_I1804_I56_n1 I1_p26_23 I1_I1804_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I56_MN3 (VSS XI1_I1804_I56_Bn XI1_I1804_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I56_MN0 (XI1_I1804_I56_An I1_p26_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I55_MN1 (XI1_I1804_I55_Bn I1_b27_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I55_MN5 (XI1_I1804_I55_n2 I1_b27_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I55_MN4 (I1_I1804_pn23 XI1_I1804_I55_An XI1_I1804_I55_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I55_MN2 (XI1_I1804_I55_n1 I1_p26_22 I1_I1804_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I55_MN3 (VSS XI1_I1804_I55_Bn XI1_I1804_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I55_MN0 (XI1_I1804_I55_An I1_p26_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I53_MN1 (XI1_I1804_I53_Bn I1_b27_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I53_MN5 (XI1_I1804_I53_n2 I1_b27_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I53_MN4 (I1_I1804_pn21 XI1_I1804_I53_An XI1_I1804_I53_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I53_MN2 (XI1_I1804_I53_n1 I1_p26_20 I1_I1804_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I53_MN3 (VSS XI1_I1804_I53_Bn XI1_I1804_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I53_MN0 (XI1_I1804_I53_An I1_p26_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I51_MN1 (XI1_I1804_I51_Bn I1_b27_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I51_MN5 (XI1_I1804_I51_n2 I1_b27_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I51_MN4 (I1_I1804_pn19 XI1_I1804_I51_An XI1_I1804_I51_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I51_MN2 (XI1_I1804_I51_n1 I1_p26_18 I1_I1804_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I51_MN3 (VSS XI1_I1804_I51_Bn XI1_I1804_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I51_MN0 (XI1_I1804_I51_An I1_p26_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I49_MN1 (XI1_I1804_I49_Bn I1_b27_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I49_MN5 (XI1_I1804_I49_n2 I1_b27_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I49_MN4 (I1_I1804_pn17 XI1_I1804_I49_An XI1_I1804_I49_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I49_MN2 (XI1_I1804_I49_n1 I1_p26_16 I1_I1804_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I49_MN3 (VSS XI1_I1804_I49_Bn XI1_I1804_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I49_MN0 (XI1_I1804_I49_An I1_p26_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I48_MN1 (XI1_I1804_I48_Bn I1_b27_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I48_MN5 (XI1_I1804_I48_n2 I1_b27_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I48_MN4 (I1_I1804_pn16 XI1_I1804_I48_An XI1_I1804_I48_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I48_MN2 (XI1_I1804_I48_n1 I1_p26_15 I1_I1804_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I48_MN3 (VSS XI1_I1804_I48_Bn XI1_I1804_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I48_MN0 (XI1_I1804_I48_An I1_p26_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I46_MN1 (XI1_I1804_I46_Bn I1_b27_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I46_MN5 (XI1_I1804_I46_n2 I1_b27_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I46_MN4 (I1_I1804_pn14 XI1_I1804_I46_An XI1_I1804_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I46_MN2 (XI1_I1804_I46_n1 I1_p26_13 I1_I1804_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I46_MN3 (VSS XI1_I1804_I46_Bn XI1_I1804_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I46_MN0 (XI1_I1804_I46_An I1_p26_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I44_MN1 (XI1_I1804_I44_Bn I1_b27_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I44_MN5 (XI1_I1804_I44_n2 I1_b27_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I44_MN4 (I1_I1804_pn12 XI1_I1804_I44_An XI1_I1804_I44_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I44_MN2 (XI1_I1804_I44_n1 I1_p26_11 I1_I1804_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I44_MN3 (VSS XI1_I1804_I44_Bn XI1_I1804_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I44_MN0 (XI1_I1804_I44_An I1_p26_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I43_MN1 (XI1_I1804_I43_Bn I1_b27_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I43_MN5 (XI1_I1804_I43_n2 I1_b27_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I43_MN4 (I1_I1804_pn11 XI1_I1804_I43_An XI1_I1804_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I43_MN2 (XI1_I1804_I43_n1 I1_p26_10 I1_I1804_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I43_MN3 (VSS XI1_I1804_I43_Bn XI1_I1804_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I43_MN0 (XI1_I1804_I43_An I1_p26_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I42_MN1 (XI1_I1804_I42_Bn I1_b27_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I42_MN5 (XI1_I1804_I42_n2 I1_b27_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I42_MN4 (I1_I1804_pn10 XI1_I1804_I42_An XI1_I1804_I42_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I42_MN2 (XI1_I1804_I42_n1 I1_p26_9 I1_I1804_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I42_MN3 (VSS XI1_I1804_I42_Bn XI1_I1804_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I42_MN0 (XI1_I1804_I42_An I1_p26_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I41_MN1 (XI1_I1804_I41_Bn I1_b27_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I41_MN5 (XI1_I1804_I41_n2 I1_b27_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I41_MN4 (I1_I1804_pn9 XI1_I1804_I41_An XI1_I1804_I41_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I41_MN2 (XI1_I1804_I41_n1 I1_p26_8 I1_I1804_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I41_MN3 (VSS XI1_I1804_I41_Bn XI1_I1804_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I41_MN0 (XI1_I1804_I41_An I1_p26_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I38_MN1 (XI1_I1804_I38_Bn I1_b27_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I38_MN5 (XI1_I1804_I38_n2 I1_b27_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I38_MN4 (I1_I1804_pn6 XI1_I1804_I38_An XI1_I1804_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I38_MN2 (XI1_I1804_I38_n1 I1_p26_5 I1_I1804_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I38_MN3 (VSS XI1_I1804_I38_Bn XI1_I1804_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I38_MN0 (XI1_I1804_I38_An I1_p26_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I36_MN1 (XI1_I1804_I36_Bn I1_b27_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I36_MN5 (XI1_I1804_I36_n2 I1_b27_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I36_MN4 (I1_I1804_pn4 XI1_I1804_I36_An XI1_I1804_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I36_MN2 (XI1_I1804_I36_n1 I1_p26_3 I1_I1804_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I36_MN3 (VSS XI1_I1804_I36_Bn XI1_I1804_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I36_MN0 (XI1_I1804_I36_An I1_p26_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I32_MN1 (XI1_I1758_I32_Bn I1_b26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1758_I32_MN5 (XI1_I1758_I32_n2 I1_b26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1758_I32_MN4 (I1_I1758_pn0 XI1_I1758_I32_An XI1_I1758_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I32_MN2 (XI1_I1758_I32_n1 I1_aa5 I1_I1758_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1758_I32_MN3 (VSS XI1_I1758_I32_Bn XI1_I1758_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1758_I32_MN0 (XI1_I1758_I32_An I1_aa5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I60_MN1 (XI1_I1666_I60_Bn I1_b24_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I60_MN5 (XI1_I1666_I60_n2 I1_b24_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I60_MN4 (I1_I1666_pn28 XI1_I1666_I60_An XI1_I1666_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I60_MN2 (XI1_I1666_I60_n1 I1_p23_27 I1_I1666_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I60_MN3 (VSS XI1_I1666_I60_Bn XI1_I1666_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I60_MN0 (XI1_I1666_I60_An I1_p23_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I59_MN1 (XI1_I1666_I59_Bn I1_b24_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I59_MN5 (XI1_I1666_I59_n2 I1_b24_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I59_MN4 (I1_I1666_pn27 XI1_I1666_I59_An XI1_I1666_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I59_MN2 (XI1_I1666_I59_n1 I1_p23_26 I1_I1666_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I59_MN3 (VSS XI1_I1666_I59_Bn XI1_I1666_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I59_MN0 (XI1_I1666_I59_An I1_p23_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I61_MN1 (XI1_I1620_I61_Bn I1_b23_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I61_MN5 (XI1_I1620_I61_n2 I1_b23_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I61_MN4 (I1_I1620_pn29 XI1_I1620_I61_An XI1_I1620_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I61_MN2 (XI1_I1620_I61_n1 I1_p22_28 I1_I1620_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I61_MN3 (VSS XI1_I1620_I61_Bn XI1_I1620_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I61_MN0 (XI1_I1620_I61_An I1_p22_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I62_MN1 (XI1_I1620_I62_Bn I1_b23_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I62_MN5 (XI1_I1620_I62_n2 I1_b23_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I62_MN4 (I1_I1620_pn30 XI1_I1620_I62_An XI1_I1620_I62_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I62_MN2 (XI1_I1620_I62_n1 I1_p22_29 I1_I1620_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I62_MN3 (VSS XI1_I1620_I62_Bn XI1_I1620_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I62_MN0 (XI1_I1620_I62_An I1_p22_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I58_MN1 (XI1_I1620_I58_Bn I1_b23_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I58_MN5 (XI1_I1620_I58_n2 I1_b23_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I58_MN4 (I1_I1620_pn26 XI1_I1620_I58_An XI1_I1620_I58_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I58_MN2 (XI1_I1620_I58_n1 I1_p22_25 I1_I1620_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I58_MN3 (VSS XI1_I1620_I58_Bn XI1_I1620_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I58_MN0 (XI1_I1620_I58_An I1_p22_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I230_MN1 (XI1_I1620_I230_Bn I1_I1620_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I230_MN5 (XI1_I1620_I230_n2 I1_I1620_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I230_MN4 (I1_p23_27 XI1_I1620_I230_An XI1_I1620_I230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I230_MN2 (XI1_I1620_I230_n1 I1_I1620_pn27 I1_p23_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I230_MN3 (VSS XI1_I1620_I230_Bn XI1_I1620_I230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I230_MN0 (XI1_I1620_I230_An I1_I1620_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I229_MN1 (XI1_I1620_I229_Bn I1_I1620_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I229_MN5 (XI1_I1620_I229_n2 I1_I1620_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I229_MN4 (I1_p23_26 XI1_I1620_I229_An XI1_I1620_I229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I229_MN2 (XI1_I1620_I229_n1 I1_I1620_pn26 I1_p23_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I229_MN3 (VSS XI1_I1620_I229_Bn XI1_I1620_I229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I229_MN0 (XI1_I1620_I229_An I1_I1620_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I46_MN1 (XI1_I46_Bn I1_nakn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I46_MN5 (XI1_I46_n2 I1_nakn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I46_MN4 (I1_aa4 XI1_I46_An XI1_I46_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I46_MN2 (XI1_I46_n1 A_4 I1_aa4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I46_MN3 (VSS XI1_I46_Bn XI1_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I46_MN0 (XI1_I46_An A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2091_MN1 (XI1_I2091_Bn I1_nqkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2091_MN5 (XI1_I2091_n2 I1_nqkn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2091_MN4 (DIVQ_5 XI1_I2091_An XI1_I2091_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2091_MN2 (XI1_I2091_n1 I1_qu5_b3_5 DIVQ_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2091_MN3 (VSS XI1_I2091_Bn XI1_I2091_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2091_MN0 (XI1_I2091_An I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I63_MN1 (XI1_I1804_I63_Bn I1_b27_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I63_MN5 (XI1_I1804_I63_n2 I1_b27_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I63_MN4 (I1_I1804_pn31 XI1_I1804_I63_An XI1_I1804_I63_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I63_MN2 (XI1_I1804_I63_n1 I1_p26_30 I1_I1804_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I63_MN3 (VSS XI1_I1804_I63_Bn XI1_I1804_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I63_MN0 (XI1_I1804_I63_An I1_p26_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I59_MN1 (XI1_I1804_I59_Bn I1_b27_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I59_MN5 (XI1_I1804_I59_n2 I1_b27_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I59_MN4 (I1_I1804_pn27 XI1_I1804_I59_An XI1_I1804_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I59_MN2 (XI1_I1804_I59_n1 I1_p26_26 I1_I1804_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I59_MN3 (VSS XI1_I1804_I59_Bn XI1_I1804_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I59_MN0 (XI1_I1804_I59_An I1_p26_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I57_MN1 (XI1_I1804_I57_Bn I1_b27_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I57_MN5 (XI1_I1804_I57_n2 I1_b27_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I57_MN4 (I1_I1804_pn25 XI1_I1804_I57_An XI1_I1804_I57_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I57_MN2 (XI1_I1804_I57_n1 I1_p26_24 I1_I1804_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I57_MN3 (VSS XI1_I1804_I57_Bn XI1_I1804_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I57_MN0 (XI1_I1804_I57_An I1_p26_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I54_MN1 (XI1_I1804_I54_Bn I1_b27_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I54_MN5 (XI1_I1804_I54_n2 I1_b27_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I54_MN4 (I1_I1804_pn22 XI1_I1804_I54_An XI1_I1804_I54_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I54_MN2 (XI1_I1804_I54_n1 I1_p26_21 I1_I1804_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I54_MN3 (VSS XI1_I1804_I54_Bn XI1_I1804_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I54_MN0 (XI1_I1804_I54_An I1_p26_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I52_MN1 (XI1_I1804_I52_Bn I1_b27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I52_MN5 (XI1_I1804_I52_n2 I1_b27_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I52_MN4 (I1_I1804_pn20 XI1_I1804_I52_An XI1_I1804_I52_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I52_MN2 (XI1_I1804_I52_n1 I1_p26_19 I1_I1804_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I52_MN3 (VSS XI1_I1804_I52_Bn XI1_I1804_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I52_MN0 (XI1_I1804_I52_An I1_p26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I39_MN1 (XI1_I1804_I39_Bn I1_b27_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I39_MN5 (XI1_I1804_I39_n2 I1_b27_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I39_MN4 (I1_I1804_pn7 XI1_I1804_I39_An XI1_I1804_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I39_MN2 (XI1_I1804_I39_n1 I1_p26_6 I1_I1804_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I39_MN3 (VSS XI1_I1804_I39_Bn XI1_I1804_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I39_MN0 (XI1_I1804_I39_An I1_p26_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I37_MN1 (XI1_I1804_I37_Bn I1_b27_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I37_MN5 (XI1_I1804_I37_n2 I1_b27_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I37_MN4 (I1_I1804_pn5 XI1_I1804_I37_An XI1_I1804_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I37_MN2 (XI1_I1804_I37_n1 I1_p26_4 I1_I1804_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I37_MN3 (VSS XI1_I1804_I37_Bn XI1_I1804_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I37_MN0 (XI1_I1804_I37_An I1_p26_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I35_MN1 (XI1_I1804_I35_Bn I1_b27_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I35_MN5 (XI1_I1804_I35_n2 I1_b27_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I35_MN4 (I1_I1804_pn3 XI1_I1804_I35_An XI1_I1804_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I35_MN2 (XI1_I1804_I35_n1 I1_p26_2 I1_I1804_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I35_MN3 (VSS XI1_I1804_I35_Bn XI1_I1804_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I35_MN0 (XI1_I1804_I35_An I1_p26_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I34_MN1 (XI1_I1804_I34_Bn I1_b27_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I34_MN5 (XI1_I1804_I34_n2 I1_b27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I34_MN4 (I1_I1804_pn2 XI1_I1804_I34_An XI1_I1804_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I34_MN2 (XI1_I1804_I34_n1 I1_p26_1 I1_I1804_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I34_MN3 (VSS XI1_I1804_I34_Bn XI1_I1804_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I34_MN0 (XI1_I1804_I34_An I1_p26_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I32_MN1 (XI1_I1804_I32_Bn I1_b27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I32_MN5 (XI1_I1804_I32_n2 I1_b27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I32_MN4 (I1_I1804_pn0 XI1_I1804_I32_An XI1_I1804_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I32_MN2 (XI1_I1804_I32_n1 I1_aa4 I1_I1804_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I32_MN3 (VSS XI1_I1804_I32_Bn XI1_I1804_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I32_MN0 (XI1_I1804_I32_An I1_aa4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I203_MN1 (XI1_I1804_I203_Bn I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I203_MN5 (XI1_I1804_I203_n2 I1_qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I203_MN4 (I1_p27_0 XI1_I1804_I203_An XI1_I1804_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I203_MN2 (XI1_I1804_I203_n1 I1_I1804_pn0 I1_p27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I203_MN3 (VSS XI1_I1804_I203_Bn XI1_I1804_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I203_MN0 (XI1_I1804_I203_An I1_I1804_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I61_MN1 (XI1_I1666_I61_Bn I1_b24_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1666_I61_MN5 (XI1_I1666_I61_n2 I1_b24_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1666_I61_MN4 (I1_I1666_pn29 XI1_I1666_I61_An XI1_I1666_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I61_MN2 (XI1_I1666_I61_n1 I1_p23_28 I1_I1666_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1666_I61_MN3 (VSS XI1_I1666_I61_Bn XI1_I1666_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1666_I61_MN0 (XI1_I1666_I61_An I1_p23_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I32_MN1 (XI1_I1850_I32_Bn I1_b28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I32_MN5 (XI1_I1850_I32_n2 I1_b28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I32_MN4 (I1_I1850_pn0 XI1_I1850_I32_An XI1_I1850_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I32_MN2 (XI1_I1850_I32_n1 I1_aa3 I1_I1850_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I32_MN3 (VSS XI1_I1850_I32_Bn XI1_I1850_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I32_MN0 (XI1_I1850_I32_An I1_aa3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I60_MN1 (XI1_I1620_I60_Bn I1_b23_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I60_MN5 (XI1_I1620_I60_n2 I1_b23_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I60_MN4 (I1_I1620_pn28 XI1_I1620_I60_An XI1_I1620_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I60_MN2 (XI1_I1620_I60_n1 I1_p22_27 I1_I1620_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I60_MN3 (VSS XI1_I1620_I60_Bn XI1_I1620_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I60_MN0 (XI1_I1620_I60_An I1_p22_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I231_MN1 (XI1_I1620_I231_Bn I1_I1620_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I231_MN5 (XI1_I1620_I231_n2 I1_I1620_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I231_MN4 (I1_p23_28 XI1_I1620_I231_An XI1_I1620_I231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I231_MN2 (XI1_I1620_I231_n1 I1_I1620_pn28 I1_p23_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I231_MN3 (VSS XI1_I1620_I231_Bn XI1_I1620_I231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I231_MN0 (XI1_I1620_I231_An I1_I1620_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I59_MN1 (XI1_I1620_I59_Bn I1_b23_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1620_I59_MN5 (XI1_I1620_I59_n2 I1_b23_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1620_I59_MN4 (I1_I1620_pn27 XI1_I1620_I59_An XI1_I1620_I59_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I59_MN2 (XI1_I1620_I59_n1 I1_p22_26 I1_I1620_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1620_I59_MN3 (VSS XI1_I1620_I59_Bn XI1_I1620_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1620_I59_MN0 (XI1_I1620_I59_An I1_p22_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I32_MN1 (XI1_I1896_I32_Bn I1_b29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I32_MN5 (XI1_I1896_I32_n2 I1_b29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I32_MN4 (I1_I1896_pn0 XI1_I1896_I32_An XI1_I1896_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I32_MN2 (XI1_I1896_I32_n1 I1_aa2 I1_I1896_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I32_MN3 (VSS XI1_I1896_I32_Bn XI1_I1896_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I32_MN0 (XI1_I1896_I32_An I1_aa2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I40_MN1 (XI1_I40_Bn I1_nakn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I40_MN5 (XI1_I40_n2 I1_nakn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I40_MN4 (I1_aa2 XI1_I40_An XI1_I40_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I40_MN2 (XI1_I40_n1 A_2 I1_aa2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I40_MN3 (VSS XI1_I40_Bn XI1_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I40_MN0 (XI1_I40_An A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I32_MN1 (XI1_I1942_I32_Bn I1_b30_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I32_MN5 (XI1_I1942_I32_n2 I1_b30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I32_MN4 (I1_I1942_pn0 XI1_I1942_I32_An XI1_I1942_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I32_MN2 (XI1_I1942_I32_n1 I1_aa1 I1_I1942_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I32_MN3 (VSS XI1_I1942_I32_Bn XI1_I1942_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I32_MN0 (XI1_I1942_I32_An I1_aa1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I43_MN1 (XI1_I43_Bn I1_nakn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I43_MN5 (XI1_I43_n2 I1_nakn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I43_MN4 (I1_aa3 XI1_I43_An XI1_I43_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I43_MN2 (XI1_I43_n1 A_3 I1_aa3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I43_MN3 (VSS XI1_I43_Bn XI1_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I43_MN0 (XI1_I43_An A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I37_MN1 (XI1_I37_Bn I1_nakn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I37_MN5 (XI1_I37_n2 I1_nakn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I37_MN4 (I1_aa1 XI1_I37_An XI1_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I37_MN2 (XI1_I37_n1 A_1 I1_aa1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I37_MN3 (VSS XI1_I37_Bn XI1_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I37_MN0 (XI1_I37_An A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2082_MN1 (XI1_I2082_Bn I1_nqkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2082_MN5 (XI1_I2082_n2 I1_nqkn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2082_MN4 (DIVQ_2 XI1_I2082_An XI1_I2082_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2082_MN2 (XI1_I2082_n1 I1_qu2_b3_5 DIVQ_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2082_MN3 (VSS XI1_I2082_Bn XI1_I2082_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2082_MN0 (XI1_I2082_An I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I467_MN1 (XI0_I1660_I467_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I467_MN5 (XI0_I1660_I467_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I467_MN4 (MULP_0 XI0_I1660_I467_An XI0_I1660_I467_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I467_MN2 (XI0_I1660_I467_n1 I0_I1660_pn0 MULP_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I467_MN3 (VSS XI0_I1660_I467_Bn XI0_I1660_I467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I467_MN0 (XI0_I1660_I467_An I0_I1660_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I72_MN1 (XI0_I1660_I72_Bn I0_ha252_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I72_MN5 (XI0_I1660_I72_n2 I0_ha252_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I72_MN4 (I0_I1660_pn8 XI0_I1660_I72_An XI0_I1660_I72_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I72_MN2 (XI0_I1660_I72_n1 I0_ha251_1 I0_I1660_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I72_MN3 (VSS XI0_I1660_I72_Bn XI0_I1660_I72_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I72_MN0 (XI0_I1660_I72_An I0_ha251_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I73_MN1 (XI0_I1660_I73_Bn I0_ha253_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I73_MN5 (XI0_I1660_I73_n2 I0_ha253_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I73_MN4 (I0_I1660_pn9 XI0_I1660_I73_An XI0_I1660_I73_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I73_MN2 (XI0_I1660_I73_n1 I0_ha252_1 I0_I1660_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I73_MN3 (VSS XI0_I1660_I73_Bn XI0_I1660_I73_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I73_MN0 (XI0_I1660_I73_An I0_ha252_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I75_MN1 (XI0_I1660_I75_Bn I0_ha255_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I75_MN5 (XI0_I1660_I75_n2 I0_ha255_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I75_MN4 (I0_I1660_pn11 XI0_I1660_I75_An XI0_I1660_I75_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I75_MN2 (XI0_I1660_I75_n1 I0_ha254_1 I0_I1660_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I75_MN3 (VSS XI0_I1660_I75_Bn XI0_I1660_I75_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I75_MN0 (XI0_I1660_I75_An I0_ha254_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I78_MN1 (XI0_I1660_I78_Bn I0_ha258_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I78_MN5 (XI0_I1660_I78_n2 I0_ha258_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I78_MN4 (I0_I1660_pn14 XI0_I1660_I78_An XI0_I1660_I78_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I78_MN2 (XI0_I1660_I78_n1 I0_ha257_1 I0_I1660_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I78_MN3 (VSS XI0_I1660_I78_Bn XI0_I1660_I78_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I78_MN0 (XI0_I1660_I78_An I0_ha257_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I60_MN1 (XI1_I1804_I60_Bn I1_b27_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I60_MN5 (XI1_I1804_I60_n2 I1_b27_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I60_MN4 (I1_I1804_pn28 XI1_I1804_I60_An XI1_I1804_I60_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I60_MN2 (XI1_I1804_I60_n1 I1_p26_27 I1_I1804_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I60_MN3 (VSS XI1_I1804_I60_Bn XI1_I1804_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I60_MN0 (XI1_I1804_I60_An I1_p26_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I33_MN1 (XI1_I1804_I33_Bn I1_b27_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I33_MN5 (XI1_I1804_I33_n2 I1_b27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I33_MN4 (I1_I1804_pn1 XI1_I1804_I33_An XI1_I1804_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I33_MN2 (XI1_I1804_I33_n1 I1_p26_0 I1_I1804_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I33_MN3 (VSS XI1_I1804_I33_Bn XI1_I1804_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I33_MN0 (XI1_I1804_I33_An I1_p26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I204_MN1 (XI1_I1804_I204_Bn I1_I1804_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I204_MN5 (XI1_I1804_I204_n2 I1_I1804_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I204_MN4 (I1_p27_1 XI1_I1804_I204_An XI1_I1804_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I204_MN2 (XI1_I1804_I204_n1 I1_I1804_pn1 I1_p27_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I204_MN3 (VSS XI1_I1804_I204_Bn XI1_I1804_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I204_MN0 (XI1_I1804_I204_An I1_I1804_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I33_MN1 (XI1_I1850_I33_Bn I1_b28_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I33_MN5 (XI1_I1850_I33_n2 I1_b28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I33_MN4 (I1_I1850_pn1 XI1_I1850_I33_An XI1_I1850_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I33_MN2 (XI1_I1850_I33_n1 I1_p27_0 I1_I1850_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I33_MN3 (VSS XI1_I1850_I33_Bn XI1_I1850_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I33_MN0 (XI1_I1850_I33_An I1_p27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I203_MN1 (XI1_I1850_I203_Bn I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I203_MN5 (XI1_I1850_I203_n2 I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I203_MN4 (I1_p28_0 XI1_I1850_I203_An XI1_I1850_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I203_MN2 (XI1_I1850_I203_n1 I1_I1850_pn0 I1_p28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I203_MN3 (VSS XI1_I1850_I203_Bn XI1_I1850_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I203_MN0 (XI1_I1850_I203_An I1_I1850_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I33_MN1 (XI1_I1896_I33_Bn I1_b29_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I33_MN5 (XI1_I1896_I33_n2 I1_b29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I33_MN4 (I1_I1896_pn1 XI1_I1896_I33_An XI1_I1896_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I33_MN2 (XI1_I1896_I33_n1 I1_p28_0 I1_I1896_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I33_MN3 (VSS XI1_I1896_I33_Bn XI1_I1896_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I33_MN0 (XI1_I1896_I33_An I1_p28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I204_MN1 (XI1_I1896_I204_Bn I1_I1896_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I204_MN5 (XI1_I1896_I204_n2 I1_I1896_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I204_MN4 (I1_p29_1 XI1_I1896_I204_An XI1_I1896_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I204_MN2 (XI1_I1896_I204_n1 I1_I1896_pn1 I1_p29_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I204_MN3 (VSS XI1_I1896_I204_Bn XI1_I1896_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I204_MN0 (XI1_I1896_I204_An I1_I1896_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I35_MN1 (XI1_I1942_I35_Bn I1_b30_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I35_MN5 (XI1_I1942_I35_n2 I1_b30_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I35_MN4 (I1_I1942_pn3 XI1_I1942_I35_An XI1_I1942_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I35_MN2 (XI1_I1942_I35_n1 I1_p29_2 I1_I1942_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I35_MN3 (VSS XI1_I1942_I35_Bn XI1_I1942_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I35_MN0 (XI1_I1942_I35_An I1_p29_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I34_MN1 (XI1_I1942_I34_Bn I1_b30_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I34_MN5 (XI1_I1942_I34_n2 I1_b30_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I34_MN4 (I1_I1942_pn2 XI1_I1942_I34_An XI1_I1942_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I34_MN2 (XI1_I1942_I34_n1 I1_p29_1 I1_I1942_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I34_MN3 (VSS XI1_I1942_I34_Bn XI1_I1942_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I34_MN0 (XI1_I1942_I34_An I1_p29_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I33_MN1 (XI1_I1942_I33_Bn I1_b30_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I33_MN5 (XI1_I1942_I33_n2 I1_b30_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I33_MN4 (I1_I1942_pn1 XI1_I1942_I33_An XI1_I1942_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I33_MN2 (XI1_I1942_I33_n1 I1_p29_0 I1_I1942_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I33_MN3 (VSS XI1_I1942_I33_Bn XI1_I1942_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I33_MN0 (XI1_I1942_I33_An I1_p29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I203_MN1 (XI1_I1896_I203_Bn I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I203_MN5 (XI1_I1896_I203_n2 I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I203_MN4 (I1_p29_0 XI1_I1896_I203_An XI1_I1896_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I203_MN2 (XI1_I1896_I203_n1 I1_I1896_pn0 I1_p29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I203_MN3 (VSS XI1_I1896_I203_Bn XI1_I1896_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I203_MN0 (XI1_I1896_I203_An I1_I1896_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I203_MN1 (XI1_I1942_I203_Bn I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I203_MN5 (XI1_I1942_I203_n2 I1_qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I203_MN4 (I1_p30_0 XI1_I1942_I203_An XI1_I1942_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I203_MN2 (XI1_I1942_I203_n1 I1_I1942_pn0 I1_p30_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I203_MN3 (VSS XI1_I1942_I203_Bn XI1_I1942_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I203_MN0 (XI1_I1942_I203_An I1_I1942_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2088_MN1 (XI1_I2088_Bn I1_nqkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2088_MN5 (XI1_I2088_n2 I1_nqkn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2088_MN4 (DIVQ_4 XI1_I2088_An XI1_I2088_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2088_MN2 (XI1_I2088_n1 I1_qu4_b3_5 DIVQ_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2088_MN3 (VSS XI1_I2088_Bn XI1_I2088_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2088_MN0 (XI1_I2088_An I1_qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2085_MN1 (XI1_I2085_Bn I1_nqkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2085_MN5 (XI1_I2085_n2 I1_nqkn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2085_MN4 (DIVQ_3 XI1_I2085_An XI1_I2085_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2085_MN2 (XI1_I2085_n1 I1_qu3_b3_5 DIVQ_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2085_MN3 (VSS XI1_I2085_Bn XI1_I2085_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2085_MN0 (XI1_I2085_An I1_qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2079_MN1 (XI1_I2079_Bn I1_nqkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2079_MN5 (XI1_I2079_n2 I1_nqkn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2079_MN4 (DIVQ_1 XI1_I2079_An XI1_I2079_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2079_MN2 (XI1_I2079_n1 I1_qu1_b3_5 DIVQ_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2079_MN3 (VSS XI1_I2079_Bn XI1_I2079_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2079_MN0 (XI1_I2079_An I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I70_MN1 (XI0_I1660_I70_Bn I0_ha250_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I70_MN5 (XI0_I1660_I70_n2 I0_ha250_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I70_MN4 (I0_I1660_pn6 XI0_I1660_I70_An XI0_I1660_I70_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I70_MN2 (XI0_I1660_I70_n1 I0_fa249_1 I0_I1660_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I70_MN3 (VSS XI0_I1660_I70_Bn XI0_I1660_I70_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I70_MN0 (XI0_I1660_I70_An I0_fa249_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I71_MN1 (XI0_I1660_I71_Bn I0_ha251_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I71_MN5 (XI0_I1660_I71_n2 I0_ha251_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I71_MN4 (I0_I1660_pn7 XI0_I1660_I71_An XI0_I1660_I71_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I71_MN2 (XI0_I1660_I71_n1 I0_ha250_1 I0_I1660_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I71_MN3 (VSS XI0_I1660_I71_Bn XI0_I1660_I71_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I71_MN0 (XI0_I1660_I71_An I0_ha250_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I475_MN1 (XI0_I1660_I475_Bn I0_I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I475_MN5 (XI0_I1660_I475_n2 I0_I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I475_MN4 (MULP_8 XI0_I1660_I475_An XI0_I1660_I475_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I475_MN2 (XI0_I1660_I475_n1 I0_I1660_pn8 MULP_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I475_MN3 (VSS XI0_I1660_I475_Bn XI0_I1660_I475_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I475_MN0 (XI0_I1660_I475_An I0_I1660_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I74_MN1 (XI0_I1660_I74_Bn I0_ha254_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I74_MN5 (XI0_I1660_I74_n2 I0_ha254_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I74_MN4 (I0_I1660_pn10 XI0_I1660_I74_An XI0_I1660_I74_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I74_MN2 (XI0_I1660_I74_n1 I0_ha253_1 I0_I1660_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I74_MN3 (VSS XI0_I1660_I74_Bn XI0_I1660_I74_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I74_MN0 (XI0_I1660_I74_An I0_ha253_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I76_MN1 (XI0_I1660_I76_Bn I0_ha256_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I76_MN5 (XI0_I1660_I76_n2 I0_ha256_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I76_MN4 (I0_I1660_pn12 XI0_I1660_I76_An XI0_I1660_I76_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I76_MN2 (XI0_I1660_I76_n1 I0_ha255_1 I0_I1660_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I76_MN3 (VSS XI0_I1660_I76_Bn XI0_I1660_I76_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I76_MN0 (XI0_I1660_I76_An I0_ha255_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I77_MN1 (XI0_I1660_I77_Bn I0_ha257_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I77_MN5 (XI0_I1660_I77_n2 I0_ha257_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I77_MN4 (I0_I1660_pn13 XI0_I1660_I77_An XI0_I1660_I77_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I77_MN2 (XI0_I1660_I77_n1 I0_ha256_1 I0_I1660_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I77_MN3 (VSS XI0_I1660_I77_Bn XI0_I1660_I77_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I77_MN0 (XI0_I1660_I77_An I0_ha256_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I79_MN1 (XI0_I1660_I79_Bn I0_ha259_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I79_MN5 (XI0_I1660_I79_n2 I0_ha259_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I79_MN4 (I0_I1660_pn15 XI0_I1660_I79_An XI0_I1660_I79_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I79_MN2 (XI0_I1660_I79_n1 I0_ha258_1 I0_I1660_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I79_MN3 (VSS XI0_I1660_I79_Bn XI0_I1660_I79_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I79_MN0 (XI0_I1660_I79_An I0_ha258_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I80_MN1 (XI0_I1660_I80_Bn I0_ha260_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I80_MN5 (XI0_I1660_I80_n2 I0_ha260_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I80_MN4 (I0_I1660_pn16 XI0_I1660_I80_An XI0_I1660_I80_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I80_MN2 (XI0_I1660_I80_n1 I0_ha259_1 I0_I1660_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I80_MN3 (VSS XI0_I1660_I80_Bn XI0_I1660_I80_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I80_MN0 (XI0_I1660_I80_An I0_ha259_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I82_MN1 (XI0_I1660_I82_Bn I0_ha262_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I82_MN5 (XI0_I1660_I82_n2 I0_ha262_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I82_MN4 (I0_I1660_pn18 XI0_I1660_I82_An XI0_I1660_I82_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I82_MN2 (XI0_I1660_I82_n1 I0_ha261_1 I0_I1660_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I82_MN3 (VSS XI0_I1660_I82_Bn XI0_I1660_I82_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I82_MN0 (XI0_I1660_I82_An I0_ha261_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I83_MN1 (XI0_I1660_I83_Bn I0_ha263_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I83_MN5 (XI0_I1660_I83_n2 I0_ha263_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I83_MN4 (I0_I1660_pn19 XI0_I1660_I83_An XI0_I1660_I83_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I83_MN2 (XI0_I1660_I83_n1 I0_ha262_1 I0_I1660_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I83_MN3 (VSS XI0_I1660_I83_Bn XI0_I1660_I83_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I83_MN0 (XI0_I1660_I83_An I0_ha262_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I84_MN1 (XI0_I1660_I84_Bn I0_ha264_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I84_MN5 (XI0_I1660_I84_n2 I0_ha264_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I84_MN4 (I0_I1660_pn20 XI0_I1660_I84_An XI0_I1660_I84_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I84_MN2 (XI0_I1660_I84_n1 I0_ha263_1 I0_I1660_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I84_MN3 (VSS XI0_I1660_I84_Bn XI0_I1660_I84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I84_MN0 (XI0_I1660_I84_An I0_ha263_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I87_MN1 (XI0_I1660_I87_Bn I0_ha267_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I87_MN5 (XI0_I1660_I87_n2 I0_ha267_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I87_MN4 (I0_I1660_pn23 XI0_I1660_I87_An XI0_I1660_I87_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I87_MN2 (XI0_I1660_I87_n1 I0_ha266_1 I0_I1660_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I87_MN3 (VSS XI0_I1660_I87_Bn XI0_I1660_I87_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I87_MN0 (XI0_I1660_I87_An I0_ha266_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I88_MN1 (XI0_I1660_I88_Bn I0_ha268_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I88_MN5 (XI0_I1660_I88_n2 I0_ha268_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I88_MN4 (I0_I1660_pn24 XI0_I1660_I88_An XI0_I1660_I88_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I88_MN2 (XI0_I1660_I88_n1 I0_ha267_1 I0_I1660_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I88_MN3 (VSS XI0_I1660_I88_Bn XI0_I1660_I88_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I88_MN0 (XI0_I1660_I88_An I0_ha267_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I89_MN1 (XI0_I1660_I89_Bn I0_ha269_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I89_MN5 (XI0_I1660_I89_n2 I0_ha269_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I89_MN4 (I0_I1660_pn25 XI0_I1660_I89_An XI0_I1660_I89_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I89_MN2 (XI0_I1660_I89_n1 I0_ha268_1 I0_I1660_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I89_MN3 (VSS XI0_I1660_I89_Bn XI0_I1660_I89_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I89_MN0 (XI0_I1660_I89_An I0_ha268_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I61_MN1 (XI1_I1804_I61_Bn I1_b27_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I61_MN5 (XI1_I1804_I61_n2 I1_b27_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I61_MN4 (I1_I1804_pn29 XI1_I1804_I61_An XI1_I1804_I61_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I61_MN2 (XI1_I1804_I61_n1 I1_p26_28 I1_I1804_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I61_MN3 (VSS XI1_I1804_I61_Bn XI1_I1804_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I61_MN0 (XI1_I1804_I61_An I1_p26_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I205_MN1 (XI1_I1804_I205_Bn I1_I1804_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I205_MN5 (XI1_I1804_I205_n2 I1_I1804_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I205_MN4 (I1_p27_2 XI1_I1804_I205_An XI1_I1804_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I205_MN2 (XI1_I1804_I205_n1 I1_I1804_pn2 I1_p27_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I205_MN3 (VSS XI1_I1804_I205_Bn XI1_I1804_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I205_MN0 (XI1_I1804_I205_An I1_I1804_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I35_MN1 (XI1_I1850_I35_Bn I1_b28_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I35_MN5 (XI1_I1850_I35_n2 I1_b28_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I35_MN4 (I1_I1850_pn3 XI1_I1850_I35_An XI1_I1850_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I35_MN2 (XI1_I1850_I35_n1 I1_p27_2 I1_I1850_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I35_MN3 (VSS XI1_I1850_I35_Bn XI1_I1850_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I35_MN0 (XI1_I1850_I35_An I1_p27_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I34_MN1 (XI1_I1850_I34_Bn I1_b28_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I34_MN5 (XI1_I1850_I34_n2 I1_b28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I34_MN4 (I1_I1850_pn2 XI1_I1850_I34_An XI1_I1850_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I34_MN2 (XI1_I1850_I34_n1 I1_p27_1 I1_I1850_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I34_MN3 (VSS XI1_I1850_I34_Bn XI1_I1850_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I34_MN0 (XI1_I1850_I34_An I1_p27_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I204_MN1 (XI1_I1850_I204_Bn I1_I1850_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I204_MN5 (XI1_I1850_I204_n2 I1_I1850_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I204_MN4 (I1_p28_1 XI1_I1850_I204_An XI1_I1850_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I204_MN2 (XI1_I1850_I204_n1 I1_I1850_pn1 I1_p28_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I204_MN3 (VSS XI1_I1850_I204_Bn XI1_I1850_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I204_MN0 (XI1_I1850_I204_An I1_I1850_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I35_MN1 (XI1_I1896_I35_Bn I1_b29_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I35_MN5 (XI1_I1896_I35_n2 I1_b29_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I35_MN4 (I1_I1896_pn3 XI1_I1896_I35_An XI1_I1896_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I35_MN2 (XI1_I1896_I35_n1 I1_p28_2 I1_I1896_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I35_MN3 (VSS XI1_I1896_I35_Bn XI1_I1896_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I35_MN0 (XI1_I1896_I35_An I1_p28_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I34_MN1 (XI1_I1896_I34_Bn I1_b29_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I34_MN5 (XI1_I1896_I34_n2 I1_b29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I34_MN4 (I1_I1896_pn2 XI1_I1896_I34_An XI1_I1896_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I34_MN2 (XI1_I1896_I34_n1 I1_p28_1 I1_I1896_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I34_MN3 (VSS XI1_I1896_I34_Bn XI1_I1896_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I34_MN0 (XI1_I1896_I34_An I1_p28_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I205_MN1 (XI1_I1896_I205_Bn I1_I1896_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I205_MN5 (XI1_I1896_I205_n2 I1_I1896_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I205_MN4 (I1_p29_2 XI1_I1896_I205_An XI1_I1896_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I205_MN2 (XI1_I1896_I205_n1 I1_I1896_pn2 I1_p29_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I205_MN3 (VSS XI1_I1896_I205_Bn XI1_I1896_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I205_MN0 (XI1_I1896_I205_An I1_I1896_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I37_MN1 (XI1_I1942_I37_Bn I1_b30_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I37_MN5 (XI1_I1942_I37_n2 I1_b30_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I37_MN4 (I1_I1942_pn5 XI1_I1942_I37_An XI1_I1942_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I37_MN2 (XI1_I1942_I37_n1 I1_p29_4 I1_I1942_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I37_MN3 (VSS XI1_I1942_I37_Bn XI1_I1942_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I37_MN0 (XI1_I1942_I37_An I1_p29_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I36_MN1 (XI1_I1942_I36_Bn I1_b30_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I36_MN5 (XI1_I1942_I36_n2 I1_b30_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I36_MN4 (I1_I1942_pn4 XI1_I1942_I36_An XI1_I1942_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I36_MN2 (XI1_I1942_I36_n1 I1_p29_3 I1_I1942_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I36_MN3 (VSS XI1_I1942_I36_Bn XI1_I1942_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I36_MN0 (XI1_I1942_I36_An I1_p29_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I205_MN1 (XI1_I1942_I205_Bn I1_I1942_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I205_MN5 (XI1_I1942_I205_n2 I1_I1942_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I205_MN4 (I1_p30_2 XI1_I1942_I205_An XI1_I1942_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I205_MN2 (XI1_I1942_I205_n1 I1_I1942_pn2 I1_p30_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I205_MN3 (VSS XI1_I1942_I205_Bn XI1_I1942_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I205_MN0 (XI1_I1942_I205_An I1_I1942_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I204_MN1 (XI1_I1942_I204_Bn I1_I1942_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I204_MN5 (XI1_I1942_I204_n2 I1_I1942_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I204_MN4 (I1_p30_1 XI1_I1942_I204_An XI1_I1942_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I204_MN2 (XI1_I1942_I204_n1 I1_I1942_pn1 I1_p30_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I204_MN3 (VSS XI1_I1942_I204_Bn XI1_I1942_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I204_MN0 (XI1_I1942_I204_An I1_I1942_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I37_MN1 (XI1_I1988_I37_Bn I1_b31_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I37_MN5 (XI1_I1988_I37_n2 I1_b31_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I37_MN4 (I1_I1988_pn5 XI1_I1988_I37_An XI1_I1988_I37_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I37_MN2 (XI1_I1988_I37_n1 I1_p30_4 I1_I1988_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I37_MN3 (VSS XI1_I1988_I37_Bn XI1_I1988_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I37_MN0 (XI1_I1988_I37_An I1_p30_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I36_MN1 (XI1_I1988_I36_Bn I1_b31_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I36_MN5 (XI1_I1988_I36_n2 I1_b31_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I36_MN4 (I1_I1988_pn4 XI1_I1988_I36_An XI1_I1988_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I36_MN2 (XI1_I1988_I36_n1 I1_p30_3 I1_I1988_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I36_MN3 (VSS XI1_I1988_I36_Bn XI1_I1988_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I36_MN0 (XI1_I1988_I36_An I1_p30_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I35_MN1 (XI1_I1988_I35_Bn I1_b31_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I35_MN5 (XI1_I1988_I35_n2 I1_b31_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I35_MN4 (I1_I1988_pn3 XI1_I1988_I35_An XI1_I1988_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I35_MN2 (XI1_I1988_I35_n1 I1_p30_2 I1_I1988_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I35_MN3 (VSS XI1_I1988_I35_Bn XI1_I1988_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I35_MN0 (XI1_I1988_I35_An I1_p30_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I34_MN1 (XI1_I1988_I34_Bn I1_b31_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I34_MN5 (XI1_I1988_I34_n2 I1_b31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I34_MN4 (I1_I1988_pn2 XI1_I1988_I34_An XI1_I1988_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I34_MN2 (XI1_I1988_I34_n1 I1_p30_1 I1_I1988_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I34_MN3 (VSS XI1_I1988_I34_Bn XI1_I1988_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I34_MN0 (XI1_I1988_I34_An I1_p30_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I33_MN1 (XI1_I1988_I33_Bn I1_b31_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I33_MN5 (XI1_I1988_I33_n2 I1_b31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I33_MN4 (I1_I1988_pn1 XI1_I1988_I33_An XI1_I1988_I33_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I33_MN2 (XI1_I1988_I33_n1 I1_p30_0 I1_I1988_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I33_MN3 (VSS XI1_I1988_I33_Bn XI1_I1988_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I33_MN0 (XI1_I1988_I33_An I1_p30_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I205_MN1 (XI1_I1988_I205_Bn I1_I1988_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I205_MN5 (XI1_I1988_I205_n2 I1_I1988_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I205_MN4 (I1_p31_2 XI1_I1988_I205_An XI1_I1988_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I205_MN2 (XI1_I1988_I205_n1 I1_I1988_pn2 I1_p31_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I205_MN3 (VSS XI1_I1988_I205_Bn XI1_I1988_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I205_MN0 (XI1_I1988_I205_An I1_I1988_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I32_MN1 (XI1_I1988_I32_Bn I1_b31_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I32_MN5 (XI1_I1988_I32_n2 I1_b31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I32_MN4 (I1_I1988_pn0 XI1_I1988_I32_An XI1_I1988_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I32_MN2 (XI1_I1988_I32_n1 A_0 I1_I1988_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I32_MN3 (VSS XI1_I1988_I32_Bn XI1_I1988_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I32_MN0 (XI1_I1988_I32_An A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I203_MN1 (XI1_I1988_I203_Bn I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I203_MN5 (XI1_I1988_I203_n2 I1_qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I203_MN4 (I1_p31_0 XI1_I1988_I203_An XI1_I1988_I203_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I203_MN2 (XI1_I1988_I203_n1 I1_I1988_pn0 I1_p31_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I203_MN3 (VSS XI1_I1988_I203_Bn XI1_I1988_I203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I203_MN0 (XI1_I1988_I203_An I1_I1988_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I32_MN1 (XI1_I2066_I32_Bn I1_dm0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I32_MN5 (XI1_I2066_I32_n2 I1_dm0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I32_MN4 (I1_I2066_pn0 XI1_I2066_I32_An XI1_I2066_I32_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I32_MN2 (XI1_I2066_I32_n1 I1_p31_0 I1_I2066_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I32_MN3 (VSS XI1_I2066_I32_Bn XI1_I2066_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I32_MN0 (XI1_I2066_I32_An I1_p31_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I468_MN1 (XI0_I1660_I468_Bn I0_I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I468_MN5 (XI0_I1660_I468_n2 I0_I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I468_MN4 (MULP_1 XI0_I1660_I468_An XI0_I1660_I468_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I468_MN2 (XI0_I1660_I468_n1 I0_I1660_pn1 MULP_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I468_MN3 (VSS XI0_I1660_I468_Bn XI0_I1660_I468_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I468_MN0 (XI0_I1660_I468_An I0_I1660_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I65_MN1 (XI0_I1660_I65_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I65_MN5 (XI0_I1660_I65_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I65_MN4 (I0_I1660_pn1 XI0_I1660_I65_An XI0_I1660_I65_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I65_MN2 (XI0_I1660_I65_n1 I0_pp0_1 I0_I1660_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I65_MN3 (VSS XI0_I1660_I65_Bn XI0_I1660_I65_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I65_MN0 (XI0_I1660_I65_An I0_pp0_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I68_MN1 (XI0_I1660_I68_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I68_MN5 (XI0_I1660_I68_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I68_MN4 (I0_I1660_pn4 XI0_I1660_I68_An XI0_I1660_I68_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I68_MN2 (XI0_I1660_I68_n1 I0_fa209_0 I0_I1660_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I68_MN3 (VSS XI0_I1660_I68_Bn XI0_I1660_I68_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I68_MN0 (XI0_I1660_I68_An I0_fa209_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I69_MN1 (XI0_I1660_I69_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I69_MN5 (XI0_I1660_I69_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I69_MN4 (I0_I1660_pn5 XI0_I1660_I69_An XI0_I1660_I69_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I69_MN2 (XI0_I1660_I69_n1 I0_fa249_0 I0_I1660_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I69_MN3 (VSS XI0_I1660_I69_Bn XI0_I1660_I69_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I69_MN0 (XI0_I1660_I69_An I0_fa249_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I473_MN1 (XI0_I1660_I473_Bn I0_I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I473_MN5 (XI0_I1660_I473_n2 I0_I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I473_MN4 (MULP_6 XI0_I1660_I473_An XI0_I1660_I473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I473_MN2 (XI0_I1660_I473_n1 I0_I1660_pn6 MULP_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I473_MN3 (VSS XI0_I1660_I473_Bn XI0_I1660_I473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I473_MN0 (XI0_I1660_I473_An I0_I1660_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I474_MN1 (XI0_I1660_I474_Bn I0_I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I474_MN5 (XI0_I1660_I474_n2 I0_I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I474_MN4 (MULP_7 XI0_I1660_I474_An XI0_I1660_I474_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I474_MN2 (XI0_I1660_I474_n1 I0_I1660_pn7 MULP_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I474_MN3 (VSS XI0_I1660_I474_Bn XI0_I1660_I474_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I474_MN0 (XI0_I1660_I474_An I0_I1660_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I484_MN1 (XI0_I1660_I484_Bn I0_I1660_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I484_MN5 (XI0_I1660_I484_n2 I0_I1660_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I484_MN4 (MULP_17 XI0_I1660_I484_An XI0_I1660_I484_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I484_MN2 (XI0_I1660_I484_n1 I0_I1660_pn17 MULP_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I484_MN3 (VSS XI0_I1660_I484_Bn XI0_I1660_I484_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I484_MN0 (XI0_I1660_I484_An I0_I1660_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I486_MN1 (XI0_I1660_I486_Bn I0_I1660_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I486_MN5 (XI0_I1660_I486_n2 I0_I1660_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I486_MN4 (MULP_19 XI0_I1660_I486_An XI0_I1660_I486_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I486_MN2 (XI0_I1660_I486_n1 I0_I1660_pn19 MULP_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I486_MN3 (VSS XI0_I1660_I486_Bn XI0_I1660_I486_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I486_MN0 (XI0_I1660_I486_An I0_I1660_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I81_MN1 (XI0_I1660_I81_Bn I0_ha261_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I81_MN5 (XI0_I1660_I81_n2 I0_ha261_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I81_MN4 (I0_I1660_pn17 XI0_I1660_I81_An XI0_I1660_I81_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I81_MN2 (XI0_I1660_I81_n1 I0_ha260_1 I0_I1660_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I81_MN3 (VSS XI0_I1660_I81_Bn XI0_I1660_I81_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I81_MN0 (XI0_I1660_I81_An I0_ha260_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I487_MN1 (XI0_I1660_I487_Bn I0_I1660_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I487_MN5 (XI0_I1660_I487_n2 I0_I1660_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I487_MN4 (MULP_20 XI0_I1660_I487_An XI0_I1660_I487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I487_MN2 (XI0_I1660_I487_n1 I0_I1660_pn20 MULP_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I487_MN3 (VSS XI0_I1660_I487_Bn XI0_I1660_I487_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I487_MN0 (XI0_I1660_I487_An I0_I1660_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I490_MN1 (XI0_I1660_I490_Bn I0_I1660_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I490_MN5 (XI0_I1660_I490_n2 I0_I1660_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I490_MN4 (MULP_23 XI0_I1660_I490_An XI0_I1660_I490_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I490_MN2 (XI0_I1660_I490_n1 I0_I1660_pn23 MULP_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I490_MN3 (VSS XI0_I1660_I490_Bn XI0_I1660_I490_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I490_MN0 (XI0_I1660_I490_An I0_I1660_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I85_MN1 (XI0_I1660_I85_Bn I0_ha265_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I85_MN5 (XI0_I1660_I85_n2 I0_ha265_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I85_MN4 (I0_I1660_pn21 XI0_I1660_I85_An XI0_I1660_I85_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I85_MN2 (XI0_I1660_I85_n1 I0_ha264_1 I0_I1660_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I85_MN3 (VSS XI0_I1660_I85_Bn XI0_I1660_I85_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I85_MN0 (XI0_I1660_I85_An I0_ha264_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I86_MN1 (XI0_I1660_I86_Bn I0_ha266_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I86_MN5 (XI0_I1660_I86_n2 I0_ha266_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I86_MN4 (I0_I1660_pn22 XI0_I1660_I86_An XI0_I1660_I86_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I86_MN2 (XI0_I1660_I86_n1 I0_ha265_1 I0_I1660_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I86_MN3 (VSS XI0_I1660_I86_Bn XI0_I1660_I86_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I86_MN0 (XI0_I1660_I86_An I0_ha265_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I491_MN1 (XI0_I1660_I491_Bn I0_I1660_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I491_MN5 (XI0_I1660_I491_n2 I0_I1660_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I491_MN4 (MULP_24 XI0_I1660_I491_An XI0_I1660_I491_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I491_MN2 (XI0_I1660_I491_n1 I0_I1660_pn24 MULP_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I491_MN3 (VSS XI0_I1660_I491_Bn XI0_I1660_I491_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I491_MN0 (XI0_I1660_I491_An I0_I1660_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I90_MN1 (XI0_I1660_I90_Bn I0_ha270_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I90_MN5 (XI0_I1660_I90_n2 I0_ha270_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I90_MN4 (I0_I1660_pn26 XI0_I1660_I90_An XI0_I1660_I90_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I90_MN2 (XI0_I1660_I90_n1 I0_ha269_1 I0_I1660_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I90_MN3 (VSS XI0_I1660_I90_Bn XI0_I1660_I90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I90_MN0 (XI0_I1660_I90_An I0_ha269_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I91_MN1 (XI0_I1660_I91_Bn I0_ha271_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI0_I1660_I91_MN5 (XI0_I1660_I91_n2 I0_ha271_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1660_I91_MN4 (I0_I1660_pn27 XI0_I1660_I91_An XI0_I1660_I91_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I91_MN2 (XI0_I1660_I91_n1 I0_ha270_1 I0_I1660_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1660_I91_MN3 (VSS XI0_I1660_I91_Bn XI0_I1660_I91_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1660_I91_MN0 (XI0_I1660_I91_An I0_ha270_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I232_MN1 (XI1_I1804_I232_Bn I1_I1804_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I232_MN5 (XI1_I1804_I232_n2 I1_I1804_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I232_MN4 (I1_p27_29 XI1_I1804_I232_An XI1_I1804_I232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I232_MN2 (XI1_I1804_I232_n1 I1_I1804_pn29 I1_p27_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I232_MN3 (VSS XI1_I1804_I232_Bn XI1_I1804_I232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I232_MN0 (XI1_I1804_I232_An I1_I1804_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I220_MN1 (XI1_I1804_I220_Bn I1_I1804_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I220_MN5 (XI1_I1804_I220_n2 I1_I1804_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I220_MN4 (I1_p27_17 XI1_I1804_I220_An XI1_I1804_I220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I220_MN2 (XI1_I1804_I220_n1 I1_I1804_pn17 I1_p27_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I220_MN3 (VSS XI1_I1804_I220_Bn XI1_I1804_I220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I220_MN0 (XI1_I1804_I220_An I1_I1804_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I210_MN1 (XI1_I1804_I210_Bn I1_I1804_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I210_MN5 (XI1_I1804_I210_n2 I1_I1804_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I210_MN4 (I1_p27_7 XI1_I1804_I210_An XI1_I1804_I210_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I210_MN2 (XI1_I1804_I210_n1 I1_I1804_pn7 I1_p27_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I210_MN3 (VSS XI1_I1804_I210_Bn XI1_I1804_I210_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I210_MN0 (XI1_I1804_I210_An I1_I1804_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I208_MN1 (XI1_I1804_I208_Bn I1_I1804_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1804_I208_MN5 (XI1_I1804_I208_n2 I1_I1804_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1804_I208_MN4 (I1_p27_5 XI1_I1804_I208_An XI1_I1804_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I208_MN2 (XI1_I1804_I208_n1 I1_I1804_pn5 I1_p27_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1804_I208_MN3 (VSS XI1_I1804_I208_Bn XI1_I1804_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1804_I208_MN0 (XI1_I1804_I208_An I1_I1804_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I36_MN1 (XI1_I1850_I36_Bn I1_b28_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I36_MN5 (XI1_I1850_I36_n2 I1_b28_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I36_MN4 (I1_I1850_pn4 XI1_I1850_I36_An XI1_I1850_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I36_MN2 (XI1_I1850_I36_n1 I1_p27_3 I1_I1850_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I36_MN3 (VSS XI1_I1850_I36_Bn XI1_I1850_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I36_MN0 (XI1_I1850_I36_An I1_p27_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I205_MN1 (XI1_I1850_I205_Bn I1_I1850_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1850_I205_MN5 (XI1_I1850_I205_n2 I1_I1850_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1850_I205_MN4 (I1_p28_2 XI1_I1850_I205_An XI1_I1850_I205_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I205_MN2 (XI1_I1850_I205_n1 I1_I1850_pn2 I1_p28_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1850_I205_MN3 (VSS XI1_I1850_I205_Bn XI1_I1850_I205_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1850_I205_MN0 (XI1_I1850_I205_An I1_I1850_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I36_MN1 (XI1_I1896_I36_Bn I1_b29_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1896_I36_MN5 (XI1_I1896_I36_n2 I1_b29_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1896_I36_MN4 (I1_I1896_pn4 XI1_I1896_I36_An XI1_I1896_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I36_MN2 (XI1_I1896_I36_n1 I1_p28_3 I1_I1896_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1896_I36_MN3 (VSS XI1_I1896_I36_Bn XI1_I1896_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1896_I36_MN0 (XI1_I1896_I36_An I1_p28_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I38_MN1 (XI1_I1942_I38_Bn I1_b30_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I38_MN5 (XI1_I1942_I38_n2 I1_b30_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I38_MN4 (I1_I1942_pn6 XI1_I1942_I38_An XI1_I1942_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I38_MN2 (XI1_I1942_I38_n1 I1_p29_5 I1_I1942_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I38_MN3 (VSS XI1_I1942_I38_Bn XI1_I1942_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I38_MN0 (XI1_I1942_I38_An I1_p29_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I208_MN1 (XI1_I1942_I208_Bn I1_I1942_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1942_I208_MN5 (XI1_I1942_I208_n2 I1_I1942_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I208_MN4 (I1_p30_5 XI1_I1942_I208_An XI1_I1942_I208_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I208_MN2 (XI1_I1942_I208_n1 I1_I1942_pn5 I1_p30_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1942_I208_MN3 (VSS XI1_I1942_I208_Bn XI1_I1942_I208_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I208_MN0 (XI1_I1942_I208_An I1_I1942_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I39_MN1 (XI1_I1988_I39_Bn I1_b31_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I39_MN5 (XI1_I1988_I39_n2 I1_b31_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I39_MN4 (I1_I1988_pn7 XI1_I1988_I39_An XI1_I1988_I39_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I39_MN2 (XI1_I1988_I39_n1 I1_p30_6 I1_I1988_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I39_MN3 (VSS XI1_I1988_I39_Bn XI1_I1988_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I39_MN0 (XI1_I1988_I39_An I1_p30_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I38_MN1 (XI1_I1988_I38_Bn I1_b31_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I38_MN5 (XI1_I1988_I38_n2 I1_b31_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I38_MN4 (I1_I1988_pn6 XI1_I1988_I38_An XI1_I1988_I38_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I38_MN2 (XI1_I1988_I38_n1 I1_p30_5 I1_I1988_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I38_MN3 (VSS XI1_I1988_I38_Bn XI1_I1988_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I38_MN0 (XI1_I1988_I38_An I1_p30_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I204_MN1 (XI1_I1988_I204_Bn I1_I1988_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I1988_I204_MN5 (XI1_I1988_I204_n2 I1_I1988_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I204_MN4 (I1_p31_1 XI1_I1988_I204_An XI1_I1988_I204_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I204_MN2 (XI1_I1988_I204_n1 I1_I1988_pn1 I1_p31_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I1988_I204_MN3 (VSS XI1_I1988_I204_Bn XI1_I1988_I204_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I204_MN0 (XI1_I1988_I204_An I1_I1988_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I34_MN1 (XI1_I2066_I34_Bn I1_dm2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I34_MN5 (XI1_I2066_I34_n2 I1_dm2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I34_MN4 (I1_I2066_pn2 XI1_I2066_I34_An XI1_I2066_I34_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I34_MN2 (XI1_I2066_I34_n1 I1_p31_2 I1_I2066_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I34_MN3 (VSS XI1_I2066_I34_Bn XI1_I2066_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I34_MN0 (XI1_I2066_I34_An I1_p31_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I36_MN1 (XI1_I2066_I36_Bn I1_dm4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I36_MN5 (XI1_I2066_I36_n2 I1_dm4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I36_MN4 (I1_I2066_pn4 XI1_I2066_I36_An XI1_I2066_I36_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I36_MN2 (XI1_I2066_I36_n1 I1_p31_4 I1_I2066_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I36_MN3 (VSS XI1_I2066_I36_Bn XI1_I2066_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I36_MN0 (XI1_I2066_I36_An I1_p31_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I35_MN1 (XI1_I2066_I35_Bn I1_dm3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I35_MN5 (XI1_I2066_I35_n2 I1_dm3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2066_I35_MN4 (I1_I2066_pn3 XI1_I2066_I35_An XI1_I2066_I35_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I35_MN2 (XI1_I2066_I35_n1 I1_p31_3 I1_I2066_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1_I2066_I35_MN3 (VSS XI1_I2066_I35_Bn XI1_I2066_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2066_I35_MN0 (XI1_I2066_I35_An I1_p31_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I33_MN1 (XI1_I2066_I33_Bn I1_dm1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1_I2066_I33_MN5 (XI1_I2066_I33_n2 I1_dm1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
